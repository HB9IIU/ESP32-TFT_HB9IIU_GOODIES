#ifndef _NOTOSANS_EXTRACONDENSED_THIN66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xB6, 0xDB, 0x6D, 0xB6, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x20, 0x00, 0x00, 0x7F, 0xF8, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xA0, 0x34,
  0x06, 0x80, 0xD0, 0x1A, 0x03, 0x40, 0x60, 0x00, 0x20, 0x08, 0x00, 0x18,
  0x02, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00, 0x40, 0x10,
  0x00, 0x10, 0x04, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0x40, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xFC, 0x02, 0x00, 0xC0, 0x00,
  0x80, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x02, 0x00, 0x06, 0x00, 0x80,
  0x01, 0x80, 0x20, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x00, 0x60, 0x00, 0x40, 0x18, 0x00, 0x10, 0x06, 0x00, 0x0C,
  0x01, 0x00, 0x03, 0x00, 0x40, 0x00, 0xC0, 0x10, 0x0F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x20, 0x0C,
  0x00, 0x08, 0x03, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0x60,
  0x08, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x40, 0x18, 0x00, 0x10, 0x06, 0x00, 0x04, 0x01, 0x00, 0x03, 0x00, 0x40,
  0x00, 0xC0, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0xFF, 0xC0, 0x3C, 0x87, 0xC1, 0xC2, 0x03, 0x0C,
  0x08, 0x00, 0x70, 0x20, 0x01, 0x80, 0x80, 0x04, 0x02, 0x00, 0x30, 0x08,
  0x00, 0xC0, 0x20, 0x03, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x30, 0x08, 0x00,
  0xC0, 0x20, 0x03, 0x00, 0x80, 0x06, 0x02, 0x00, 0x18, 0x08, 0x00, 0x30,
  0x20, 0x00, 0xE0, 0x80, 0x01, 0xC2, 0x00, 0x03, 0x88, 0x00, 0x03, 0xA0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0B, 0x80, 0x00, 0x27, 0x80,
  0x00, 0x87, 0x00, 0x02, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x18, 0x00,
  0x80, 0x60, 0x02, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x20, 0x0C, 0x00, 0x80,
  0x30, 0x02, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x20,
  0x02, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x20, 0x73, 0x80, 0x83, 0x8F, 0xC2,
  0x7C, 0x07, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x30, 0x60, 0x03,
  0x00, 0x60, 0x20, 0x02, 0x00, 0x60, 0x30, 0x06, 0x00, 0x40, 0x30, 0x06,
  0x00, 0x40, 0x10, 0x04, 0x00, 0xC0, 0x10, 0x0C, 0x00, 0xC0, 0x10, 0x0C,
  0x00, 0xC0, 0x18, 0x08, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC0, 0x18, 0x18,
  0x00, 0xC0, 0x18, 0x10, 0x00, 0xC0, 0x18, 0x30, 0x00, 0xC0, 0x18, 0x30,
  0x00, 0xC0, 0x18, 0x20, 0x00, 0xC0, 0x18, 0x60, 0x00, 0xC0, 0x18, 0x60,
  0x00, 0xC0, 0x18, 0x41, 0xE0, 0xC0, 0x10, 0xC3, 0xB8, 0xC0, 0x10, 0xC6,
  0x0C, 0x40, 0x10, 0x84, 0x0C, 0x40, 0x31, 0x8C, 0x04, 0x60, 0x31, 0x8C,
  0x06, 0x60, 0x21, 0x08, 0x06, 0x30, 0x63, 0x08, 0x02, 0x38, 0xC3, 0x18,
  0x02, 0x1F, 0xC2, 0x18, 0x03, 0x07, 0x06, 0x18, 0x03, 0x00, 0x06, 0x18,
  0x03, 0x00, 0x04, 0x18, 0x03, 0x00, 0x0C, 0x18, 0x03, 0x00, 0x0C, 0x18,
  0x03, 0x00, 0x08, 0x18, 0x03, 0x00, 0x18, 0x18, 0x03, 0x00, 0x18, 0x18,
  0x03, 0x00, 0x10, 0x18, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0x30, 0x18,
  0x02, 0x00, 0x20, 0x18, 0x02, 0x00, 0x60, 0x08, 0x06, 0x00, 0x60, 0x08,
  0x06, 0x00, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x04, 0x04, 0x00, 0xC0, 0x06,
  0x0C, 0x00, 0xC0, 0x03, 0x18, 0x01, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0x40, 0x02, 0x00, 0x80, 0x04, 0x01, 0x80,
  0x08, 0x03, 0x00, 0x10, 0x06, 0x00, 0x20, 0x0C, 0x00, 0x40, 0x18, 0x00,
  0xC0, 0x20, 0x01, 0x80, 0x40, 0x03, 0x01, 0x80, 0x02, 0x03, 0x00, 0x06,
  0x04, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x13,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x40,
  0x00, 0x18, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x81, 0x80, 0x03, 0x01, 0x80,
  0x4C, 0x03, 0x00, 0x98, 0x03, 0x01, 0x20, 0x02, 0x06, 0xC0, 0x06, 0x0D,
  0x80, 0x04, 0x1B, 0x00, 0x0C, 0x26, 0x00, 0x0C, 0xCC, 0x00, 0x19, 0x98,
  0x00, 0x1A, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x60, 0x80,
  0x00, 0xE1, 0x80, 0x03, 0x43, 0x00, 0x0C, 0xC3, 0x00, 0x38, 0xC3, 0x00,
  0xE1, 0x87, 0x03, 0x81, 0x83, 0xFC, 0x03, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xD5, 0x55, 0x40, 0x00, 0x70, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x70, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x81,
  0xF0, 0x87, 0x1C, 0xBC, 0x07, 0xE0, 0x01, 0x80, 0x03, 0x40, 0x06, 0x20,
  0x04, 0x30, 0x08, 0x18, 0x18, 0x08, 0x30, 0x04, 0x20, 0x04, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xC6, 0x73,
  0x18, 0xC6, 0x63, 0x18, 0x8C, 0x62, 0x10, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F,
  0xF6, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0xC0, 0x07, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x81,
  0x80, 0x18, 0x10, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00,
  0x24, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x02,
  0x60, 0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x63, 0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0xC1, 0x80,
  0x18, 0x0C, 0x01, 0x80, 0xE0, 0x30, 0x07, 0x8E, 0x00, 0x1F, 0xC0, 0x00,
  0x60, 0x1C, 0x0F, 0x83, 0xB0, 0xE6, 0x38, 0xCE, 0x1B, 0x03, 0xC0, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x78, 0x0E, 0x06,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0x01, 0xC0,
  0xE0, 0x03, 0x8C, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x20, 0x00, 0xE1, 0xE0, 0x1C, 0x03, 0xFF, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04,
  0x40, 0x00, 0x0C, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18,
  0x40, 0x00, 0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x60, 0x40, 0x00, 0x60,
  0x40, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x40, 0x01, 0x80,
  0x40, 0x03, 0x00, 0x40, 0x03, 0x00, 0x40, 0x06, 0x00, 0x40, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x40, 0x0C, 0x00, 0x40, 0x18, 0x00, 0x40, 0x18, 0x00,
  0x40, 0x30, 0x00, 0x40, 0x30, 0x00, 0x40, 0x60, 0x00, 0x40, 0x60, 0x00,
  0x40, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0xFF, 0x80,
  0x7F, 0xFE, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0xC0, 0x07, 0x0F, 0x01, 0xE0, 0x3F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x04,
  0x00, 0x07, 0xFC, 0x01, 0xE0, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x0F, 0x80,
  0xC3, 0xFE, 0x0C, 0x60, 0x38, 0xCC, 0x01, 0x8D, 0x80, 0x0C, 0xD0, 0x00,
  0x4E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x23, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C,
  0x18, 0x00, 0xC0, 0xC0, 0x18, 0x0E, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x38, 0x03, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x10,
  0x80, 0x00, 0x66, 0x00, 0x01, 0x88, 0x00, 0x06, 0x20, 0x00, 0x10, 0xC0,
  0x00, 0x43, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x01,
  0x80, 0xC0, 0x0C, 0x01, 0xC0, 0x60, 0x03, 0x87, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xCC, 0x00, 0x0C, 0x1C, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x64, 0x00, 0x00, 0xB0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x90, 0x00,
  0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x70, 0x03, 0x00, 0xF0, 0x38, 0x00, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x0C, 0x0E, 0x01, 0x80, 0x30,
  0x30, 0x01, 0x86, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00,
  0x4C, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x68, 0x00,
  0x06, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x66,
  0x00, 0x0E, 0x60, 0x00, 0xA3, 0x00, 0x1A, 0x30, 0x03, 0x21, 0xC0, 0x62,
  0x0F, 0xFC, 0x20, 0x3F, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x20, 0x78, 0x03,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x6F, 0xFE, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0x60, 0x39,
  0xCE, 0x71, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x67, 0x31, 0x8C, 0x66, 0x31, 0x88,
  0xC6, 0x21, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xC3, 0x81, 0xC2, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x06, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x00, 0x63, 0x00, 0x07, 0x80, 0x31, 0x80, 0x0F, 0xF0,
  0x08, 0xC0, 0x1C, 0x18, 0x06, 0x40, 0x0C, 0x0C, 0x03, 0x60, 0x0C, 0x06,
  0x01, 0xB0, 0x06, 0x03, 0x00, 0xD8, 0x06, 0x01, 0x80, 0x6C, 0x03, 0x00,
  0xC0, 0x16, 0x01, 0x00, 0x60, 0x0B, 0x01, 0x80, 0x30, 0x05, 0x00, 0xC0,
  0x18, 0x02, 0x80, 0x60, 0x0C, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xA0, 0x18,
  0x03, 0x00, 0x50, 0x0C, 0x01, 0x00, 0x28, 0x06, 0x00, 0x80, 0x14, 0x03,
  0x00, 0xC0, 0x1A, 0x01, 0x80, 0x60, 0x0D, 0x00, 0xC0, 0x30, 0x06, 0xC0,
  0x60, 0x18, 0x03, 0x60, 0x30, 0x0C, 0x01, 0x30, 0x0C, 0x0F, 0x01, 0x98,
  0x06, 0x04, 0x80, 0xCC, 0x03, 0x06, 0x60, 0xC6, 0x00, 0xE7, 0x38, 0xE1,
  0x00, 0x3F, 0x0F, 0xE0, 0xC0, 0x04, 0x00, 0x80, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0x88, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0x40,
  0x00, 0x18, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x02, 0x02,
  0x00, 0x03, 0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x20, 0x08, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x01, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x01, 0x00, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x10, 0x00, 0x30, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x02, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x64, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x30, 0x00,
  0xE1, 0x80, 0x01, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98,
  0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x98, 0x00, 0x0C, 0xC0,
  0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x70,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x18, 0x00, 0xE0, 0xC0, 0x01, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x0B,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x39, 0x80, 0x03,
  0x8C, 0x00, 0x38, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0xE0, 0x02, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x10, 0x0F, 0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x58,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1B, 0x00, 0x00, 0x26, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00,
  0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x01,
  0xC3, 0x00, 0x07, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0xF0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0xFF, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x00, 0xE0, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0,
  0x3C, 0x01, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0xFF, 0x8C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC3,
  0xFE, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x83,
  0xBF, 0xC1, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0,
  0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x06, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0xF0, 0x00, 0xCF, 0x00,
  0x0D, 0x90, 0x00, 0xD1, 0x80, 0x0F, 0x08, 0x00, 0xE0, 0xC0, 0x0C, 0x04,
  0x00, 0xC0, 0x60, 0x0C, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0xC0,
  0x18, 0x0C, 0x00, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x40, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x80, 0x00, 0x00, 0x2F,
  0x60, 0x00, 0x00, 0x37, 0xB0, 0x00, 0x00, 0x1B, 0xC8, 0x00, 0x00, 0x09,
  0xE6, 0x00, 0x00, 0x0C, 0xF3, 0x00, 0x00, 0x06, 0x79, 0x80, 0x00, 0x03,
  0x3C, 0x60, 0x00, 0x03, 0x1E, 0x30, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x00,
  0xC7, 0x84, 0x00, 0x00, 0x43, 0xC3, 0x00, 0x00, 0x61, 0xE1, 0x80, 0x00,
  0x30, 0xF0, 0x40, 0x00, 0x10, 0x78, 0x30, 0x00, 0x18, 0x3C, 0x18, 0x00,
  0x0C, 0x1E, 0x0C, 0x00, 0x06, 0x0F, 0x03, 0x00, 0x06, 0x07, 0x81, 0x80,
  0x03, 0x03, 0xC0, 0xC0, 0x01, 0x81, 0xE0, 0x20, 0x01, 0x80, 0xF0, 0x18,
  0x00, 0xC0, 0x78, 0x0C, 0x00, 0x60, 0x3C, 0x02, 0x00, 0x20, 0x1E, 0x01,
  0x80, 0x30, 0x0F, 0x00, 0xC0, 0x18, 0x07, 0x80, 0x20, 0x08, 0x03, 0xC0,
  0x18, 0x0C, 0x01, 0xE0, 0x0C, 0x06, 0x00, 0xF0, 0x06, 0x03, 0x00, 0x78,
  0x01, 0x83, 0x00, 0x3C, 0x00, 0xC1, 0x80, 0x1E, 0x00, 0x60, 0xC0, 0x0F,
  0x00, 0x10, 0x40, 0x07, 0x80, 0x0C, 0x60, 0x03, 0xC0, 0x06, 0x30, 0x01,
  0xE0, 0x01, 0x10, 0x00, 0xF0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x6C, 0x00,
  0x3C, 0x00, 0x36, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3D, 0x00, 0x00, 0x7B, 0x00, 0x00, 0xF6, 0x00, 0x01, 0xE6, 0x00, 0x03,
  0xCC, 0x00, 0x07, 0x88, 0x00, 0x0F, 0x18, 0x00, 0x1E, 0x10, 0x00, 0x3C,
  0x30, 0x00, 0x78, 0x60, 0x00, 0xF0, 0x60, 0x01, 0xE0, 0xC0, 0x03, 0xC0,
  0xC0, 0x07, 0x81, 0x80, 0x0F, 0x01, 0x00, 0x1E, 0x03, 0x00, 0x3C, 0x02,
  0x00, 0x78, 0x06, 0x00, 0xF0, 0x0C, 0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x18,
  0x07, 0x80, 0x18, 0x0F, 0x00, 0x30, 0x1E, 0x00, 0x20, 0x3C, 0x00, 0x60,
  0x78, 0x00, 0x40, 0xF0, 0x00, 0xC1, 0xE0, 0x01, 0x83, 0xC0, 0x01, 0x87,
  0x80, 0x03, 0x0F, 0x00, 0x02, 0x1E, 0x00, 0x06, 0x3C, 0x00, 0x04, 0x78,
  0x00, 0x0C, 0xF0, 0x00, 0x19, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x80,
  0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x38, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x08, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x40, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0x00, 0x3C, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x01, 0xB0,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80,
  0x03, 0x30, 0x00, 0xE6, 0x00, 0x38, 0xC0, 0x1E, 0x1F, 0xFF, 0x03, 0xFF,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x08, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x09, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x30,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xC0, 0x0F, 0x0C, 0x00, 0x30, 0xC0,
  0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x07, 0x0C, 0x01,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xC0, 0x60, 0x0C, 0x02, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C,
  0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x0E, 0x00, 0xE1, 0xC0, 0x02, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC8, 0x00, 0x38, 0xF0, 0x0F, 0x07, 0xFF, 0xC0, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0,
  0x00, 0x03, 0x60, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x03, 0x0E, 0x00,
  0x0C, 0x1C, 0x00, 0xE0, 0x3C, 0x0F, 0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x08,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x08, 0x00, 0x18,
  0x0C, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x30,
  0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x01, 0x00, 0x80, 0x01, 0x80, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x42, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x24, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xD0, 0x00, 0x03, 0x00, 0x00, 0x36, 0x00, 0x00, 0xE0, 0x00,
  0x0D, 0x80, 0x00, 0x38, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x00, 0x88,
  0x00, 0x06, 0x80, 0x00, 0x63, 0x00, 0x01, 0xA0, 0x00, 0x18, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0x30, 0x00, 0x13, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0xC0,
  0x00, 0xC1, 0x00, 0x03, 0x30, 0x00, 0x30, 0x60, 0x00, 0xC4, 0x00, 0x0C,
  0x18, 0x00, 0x31, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x60, 0x00, 0x81, 0x80,
  0x06, 0x18, 0x00, 0x60, 0x20, 0x01, 0x86, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x80, 0x06, 0x03, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x0C, 0x00,
  0xC0, 0x10, 0x01, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x01,
  0x80, 0x30, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x80, 0x18, 0x03,
  0x01, 0x80, 0x60, 0x02, 0x00, 0x80, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x18,
  0x06, 0x00, 0x30, 0x18, 0x02, 0x01, 0x80, 0x0C, 0x06, 0x00, 0xC0, 0x40,
  0x03, 0x01, 0x80, 0x30, 0x30, 0x00, 0x40, 0x40, 0x0C, 0x0C, 0x00, 0x18,
  0x30, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x40, 0x80, 0x01, 0x83, 0x00,
  0x18, 0x60, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x0C, 0x20, 0x01, 0x86,
  0x00, 0x03, 0x18, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x08, 0x40, 0x00,
  0x31, 0x80, 0x03, 0x30, 0x00, 0x04, 0x60, 0x00, 0xCC, 0x00, 0x01, 0x90,
  0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x0C, 0x80, 0x00, 0x1B, 0x00, 0x01,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x00, 0xB0, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x61,
  0x00, 0x06, 0x18, 0x00, 0x41, 0x80, 0x0C, 0x08, 0x00, 0xC0, 0xC0, 0x18,
  0x0C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0x20, 0x30, 0x03, 0x02,
  0x00, 0x30, 0x60, 0x01, 0x06, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x08,
  0x80, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x50, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00,
  0x18, 0x80, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x03, 0x04, 0x00, 0x30, 0x60,
  0x06, 0x06, 0x00, 0x60, 0x20, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x1A, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0x62, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x82, 0x00, 0x08, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x02, 0x00, 0x20, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x02, 0x02, 0x00, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x02, 0x08, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x02, 0x20, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0xFF, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF,
  0xF8, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xC1,
  0x80, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x0F, 0xF8, 0x1F, 0x0E, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x7F,
  0x03, 0xFF, 0x87, 0x80, 0xC6, 0x00, 0x66, 0x00, 0x36, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1E, 0x80, 0x0B, 0x60, 0x0D,
  0x98, 0x1C, 0xC7, 0xFC, 0x60, 0xF0, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x3F, 0xC0, 0x87,
  0x0F, 0x08, 0xC0, 0x38, 0x98, 0x01, 0x8B, 0x00, 0x0C, 0xA0, 0x00, 0xCA,
  0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6E, 0x00, 0x06, 0xA0, 0x00, 0xCB,
  0x00, 0x0C, 0x98, 0x01, 0x89, 0xC0, 0x30, 0x8E, 0x0F, 0x08, 0x7F, 0xC0,
  0x00, 0x60, 0x00, 0x01, 0xFF, 0x03, 0xC3, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x01, 0x03,
  0xFF, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x3F, 0xC1, 0x07, 0x0F, 0x10, 0xC0, 0x39,
  0x18, 0x01, 0x91, 0x80, 0x0D, 0x30, 0x00, 0x52, 0x00, 0x07, 0x60, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x07, 0x30, 0x00, 0x53, 0x00, 0x0D, 0x18, 0x00,
  0x91, 0xC0, 0x19, 0x0E, 0x07, 0x10, 0x3F, 0xC1, 0x00, 0x60, 0x00, 0x03,
  0xFC, 0x00, 0xE1, 0xC0, 0x30, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60,
  0x01, 0x88, 0x00, 0x33, 0x00, 0x02, 0x60, 0x00, 0x4C, 0x00, 0x0D, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x40, 0xE0, 0x78, 0x0F, 0xFC, 0x00, 0x3C,
  0x00, 0x01, 0xFE, 0x07, 0x08, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03,
  0xFE, 0x10, 0x70, 0xF1, 0x0C, 0x01, 0x91, 0x80, 0x09, 0x30, 0x00, 0xD3,
  0x00, 0x05, 0x20, 0x00, 0x76, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03,
  0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x53,
  0x00, 0x05, 0x30, 0x00, 0xD1, 0x80, 0x19, 0x1C, 0x03, 0x10, 0xE0, 0x61,
  0x03, 0xFC, 0x10, 0x07, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC4, 0x00, 0x18, 0x70,
  0x07, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x07, 0xF0, 0x87, 0x1E, 0x46, 0x03, 0x26, 0x00, 0xD6,
  0x00, 0x2A, 0x00, 0x1D, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x6F, 0xFE, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x06, 0x0E, 0x0F, 0x0E, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0xF8, 0xF0, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x18,
  0x80, 0x10, 0x80, 0x30, 0x80, 0x60, 0x80, 0x60, 0x80, 0xC0, 0x80, 0x80,
  0x81, 0x80, 0x83, 0x00, 0x83, 0x00, 0x86, 0x00, 0x8F, 0x00, 0x8F, 0x00,
  0x99, 0x00, 0x91, 0x80, 0xB1, 0x80, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40,
  0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18,
  0x80, 0x08, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x02,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x87, 0xF0, 0x0F,
  0xE1, 0x1C, 0x30, 0x70, 0xE2, 0x60, 0x30, 0xC0, 0x64, 0x80, 0x33, 0x00,
  0xCA, 0x00, 0x6C, 0x00, 0xD4, 0x00, 0x50, 0x01, 0xB0, 0x00, 0xA0, 0x01,
  0x60, 0x01, 0xC0, 0x02, 0xC0, 0x03, 0x00, 0x07, 0x80, 0x06, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x83, 0xFC, 0x47, 0x87, 0x23, 0x01, 0xD3, 0x00, 0x6B, 0x00, 0x1D,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x03, 0xFE, 0x00, 0x38, 0x78, 0x03, 0x00, 0x60,
  0x30, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00,
  0x04, 0x60, 0x00, 0x32, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x01, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x60,
  0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x06, 0xC0, 0x00, 0x32, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0,
  0x01, 0x03, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x78, 0x38, 0x00, 0xFF, 0x80,
  0x01, 0xE0, 0x00, 0x83, 0xFC, 0x08, 0x70, 0xE0, 0x8C, 0x03, 0x09, 0x80,
  0x18, 0x90, 0x00, 0xCB, 0x00, 0x0C, 0xA0, 0x00, 0x6E, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6E, 0x00,
  0x06, 0xA0, 0x00, 0x4A, 0x00, 0x0C, 0xB0, 0x00, 0xC9, 0x80, 0x18, 0x8C,
  0x03, 0x08, 0xE0, 0xE0, 0x83, 0xFC, 0x08, 0x06, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFC, 0x10, 0x78,
  0xF1, 0x0E, 0x03, 0x91, 0x80, 0x19, 0x18, 0x00, 0xD3, 0x00, 0x05, 0x30,
  0x00, 0x76, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x53, 0x00, 0x05, 0x30,
  0x00, 0x91, 0x80, 0x19, 0x0C, 0x03, 0x10, 0xF0, 0x71, 0x03, 0xFC, 0x10,
  0x07, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x83, 0xF8, 0x76, 0x8C, 0x09, 0x80, 0x90, 0x0B, 0x00, 0xA0, 0x0A,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x1F, 0x0F, 0x38, 0x01,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x0E,
  0xF8, 0x1C, 0x3F, 0xF8, 0x07, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x61, 0x07, 0xF0, 0x1C,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x2E, 0x00, 0x17, 0x00, 0x1A, 0xC0, 0x09, 0x70, 0x0C, 0x9C, 0x1C,
  0x47, 0xFC, 0x20, 0x60, 0x00, 0xC0, 0x00, 0x68, 0x00, 0x0D, 0x80, 0x01,
  0x30, 0x00, 0x66, 0x00, 0x0C, 0x40, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0C,
  0x30, 0x01, 0x82, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x30,
  0x30, 0x06, 0x02, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x10, 0x18, 0x03, 0x02, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x00, 0x83, 0x00,
  0x18, 0x40, 0x03, 0x18, 0x00, 0x63, 0x00, 0x04, 0x60, 0x00, 0x88, 0x00,
  0x19, 0x00, 0x03, 0x60, 0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x40, 0x03, 0xC0,
  0x02, 0x40, 0x03, 0x40, 0x06, 0x60, 0x03, 0x40, 0x06, 0x60, 0x02, 0x60,
  0x06, 0x20, 0x06, 0x60, 0x04, 0x20, 0x06, 0x60, 0x0C, 0x30, 0x06, 0x20,
  0x0C, 0x30, 0x04, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x10, 0x0C, 0x30,
  0x08, 0x18, 0x0C, 0x30, 0x18, 0x18, 0x0C, 0x10, 0x18, 0x18, 0x08, 0x18,
  0x18, 0x08, 0x18, 0x18, 0x10, 0x08, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x18,
  0x30, 0x0C, 0x18, 0x08, 0x30, 0x0C, 0x10, 0x0C, 0x20, 0x04, 0x30, 0x0C,
  0x20, 0x06, 0x30, 0x0C, 0x60, 0x06, 0x30, 0x04, 0x60, 0x06, 0x20, 0x04,
  0x60, 0x02, 0x60, 0x06, 0x40, 0x02, 0x60, 0x06, 0x40, 0x03, 0x60, 0x06,
  0xC0, 0x03, 0x60, 0x02, 0xC0, 0x03, 0x40, 0x02, 0x80, 0x01, 0x40, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC1, 0x80,
  0x30, 0x30, 0x06, 0x02, 0x00, 0x80, 0x60, 0x30, 0x04, 0x06, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30, 0x40, 0x06, 0x0C,
  0x00, 0x81, 0x80, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x30, 0x30, 0x06,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x00, 0x8C, 0x00, 0x1B, 0x00, 0x03,
  0x80, 0x40, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x22, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x04, 0x10, 0x01, 0x83, 0x00,
  0x30, 0x60, 0x06, 0x0C, 0x00, 0x80, 0x80, 0x30, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x10, 0x04, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x02,
  0x00, 0x20, 0xC0, 0x04, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x40, 0x01, 0x18,
  0x00, 0x23, 0x00, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x0B, 0x00, 0x01, 0x60,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xFE, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x1E, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x04, 0xFF, 0x80, 0x1E, 0x07, 0x80, 0xE0, 0x07,
  0x8E, 0x80, 0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 47, 13, 5, -47 },
  { 19, 11, 17, 19, 4, -47 },
  { 43, 26, 47, 28, 1, -47 },
  { 196, 22, 54, 26, 2, -50 },
  { 345, 32, 49, 38, 3, -48 },
  { 541, 23, 49, 25, 2, -48 },
  { 682, 2, 17, 11, 4, -47 },
  { 687, 12, 57, 17, 3, -47 },
  { 773, 11, 57, 17, 3, -47 },
  { 852, 16, 17, 22, 3, -50 },
  { 886, 22, 30, 26, 2, -38 },
  { 969, 5, 16, 12, 3, -7 },
  { 979, 14, 2, 17, 2, -19 },
  { 983, 4, 4, 12, 4, -4 },
  { 985, 18, 47, 22, 2, -47 },
  { 1091, 20, 48, 26, 3, -48 },
  { 1211, 11, 47, 26, 5, -47 },
  { 1276, 20, 48, 26, 3, -48 },
  { 1396, 21, 49, 26, 2, -48 },
  { 1525, 24, 47, 26, 1, -47 },
  { 1666, 20, 48, 26, 3, -47 },
  { 1786, 20, 49, 26, 3, -48 },
  { 1909, 20, 47, 26, 3, -47 },
  { 2027, 22, 49, 26, 2, -48 },
  { 2162, 20, 49, 26, 3, -48 },
  { 2285, 4, 35, 12, 4, -35 },
  { 2303, 5, 44, 12, 3, -35 },
  { 2331, 22, 27, 26, 2, -37 },
  { 2406, 22, 16, 26, 2, -31 },
  { 2450, 22, 27, 26, 2, -37 },
  { 2525, 15, 48, 17, 1, -48 },
  { 2615, 33, 53, 40, 4, -47 },
  { 2834, 25, 47, 25, 0, -47 },
  { 2981, 21, 47, 28, 5, -47 },
  { 3105, 22, 49, 27, 4, -48 },
  { 3240, 23, 47, 31, 5, -47 },
  { 3376, 17, 47, 25, 5, -47 },
  { 3476, 17, 47, 23, 5, -47 },
  { 3576, 27, 49, 34, 4, -48 },
  { 3742, 22, 47, 32, 5, -47 },
  { 3872, 9, 47, 14, 3, -47 },
  { 3925, 10, 59, 12, -3, -47 },
  { 3999, 20, 47, 25, 5, -47 },
  { 4117, 16, 47, 23, 5, -47 },
  { 4211, 33, 47, 43, 5, -47 },
  { 4405, 23, 47, 33, 5, -47 },
  { 4541, 26, 49, 34, 4, -48 },
  { 4701, 19, 47, 26, 5, -47 },
  { 4813, 26, 59, 34, 4, -48 },
  { 5005, 20, 47, 27, 5, -47 },
  { 5123, 20, 49, 26, 3, -48 },
  { 5246, 22, 47, 22, 0, -47 },
  { 5376, 22, 48, 32, 5, -47 },
  { 5508, 24, 47, 24, 0, -47 },
  { 5649, 42, 47, 43, 0, -47 },
  { 5896, 20, 47, 22, 1, -47 },
  { 6014, 21, 47, 21, 0, -47 },
  { 6138, 18, 47, 21, 2, -47 },
  { 6244, 12, 57, 20, 6, -47 },
  { 6330, 18, 47, 22, 2, -47 },
  { 6436, 13, 57, 20, 2, -47 },
  { 6529, 24, 22, 26, 1, -47 },
  { 6595, 26, 2, 26, 0, 6 },
  { 6602, 9, 10, 15, 3, -50 },
  { 6614, 17, 36, 24, 3, -35 },
  { 6691, 20, 51, 28, 5, -50 },
  { 6819, 16, 36, 21, 3, -35 },
  { 6891, 20, 51, 28, 3, -50 },
  { 7019, 19, 36, 25, 3, -35 },
  { 7105, 15, 50, 14, 1, -50 },
  { 7199, 20, 51, 28, 3, -35 },
  { 7327, 17, 50, 27, 5, -50 },
  { 7434, 4, 48, 12, 4, -48 },
  { 7458, 8, 64, 12, 0, -48 },
  { 7522, 16, 50, 21, 5, -50 },
  { 7622, 1, 50, 11, 5, -50 },
  { 7629, 31, 35, 40, 5, -35 },
  { 7765, 17, 35, 27, 5, -35 },
  { 7840, 21, 36, 27, 3, -35 },
  { 7935, 20, 50, 28, 5, -35 },
  { 8060, 20, 50, 28, 3, -35 },
  { 8185, 12, 35, 17, 5, -35 },
  { 8238, 16, 36, 21, 2, -35 },
  { 8310, 12, 44, 14, 1, -43 },
  { 8376, 17, 36, 27, 5, -35 },
  { 8453, 19, 35, 19, 0, -35 },
  { 8537, 32, 35, 34, 1, -35 },
  { 8677, 19, 35, 21, 1, -35 },
  { 8761, 19, 51, 21, 1, -35 },
  { 8883, 14, 35, 17, 2, -35 },
  { 8945, 16, 57, 23, 3, -47 },
  { 9059, 1, 66, 25, 12, -50 },
  { 9068, 16, 57, 23, 3, -47 },
  { 9182, 22, 5, 26, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Thin66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN66PT7B_H_
