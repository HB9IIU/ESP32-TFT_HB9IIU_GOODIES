#ifndef _NOTOSANS_EXTRACONDENSED_THIN49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xAA, 0xAA, 0xAA, 0xA8, 0x00, 0xFC, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x01,
  0x03, 0x00, 0x20, 0x40, 0x04, 0x08, 0x01, 0x81, 0x00, 0x30, 0x20, 0x04,
  0x04, 0x00, 0x80, 0x80, 0x10, 0x10, 0x02, 0x06, 0x00, 0x40, 0xC1, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x60, 0x40, 0x0C, 0x08, 0x01, 0x01, 0x00, 0x20,
  0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10, 0x30, 0x02, 0x06, 0x00, 0x40,
  0x80, 0x18, 0x10, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x08, 0x08, 0x01, 0x01,
  0x00, 0x20, 0x20, 0x04, 0x0C, 0x00, 0x81, 0x80, 0x10, 0x20, 0x06, 0x04,
  0x00, 0xC0, 0x80, 0x10, 0x10, 0x02, 0x02, 0x00, 0x40, 0x40, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x80, 0x1F, 0xF8, 0x31, 0x0C, 0x61, 0x00, 0xC1,
  0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81,
  0x00, 0x81, 0x00, 0xC1, 0x00, 0x61, 0x00, 0x31, 0x00, 0x19, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x01, 0x38, 0x01, 0x0C, 0x01, 0x06, 0x01,
  0x02, 0x01, 0x02, 0x01, 0x03, 0x01, 0x01, 0x01, 0x03, 0x01, 0x03, 0x01,
  0x02, 0x01, 0x02, 0x01, 0x04, 0x81, 0x0C, 0xF9, 0x70, 0x1F, 0xC0, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x1E, 0x00, 0x40, 0x21, 0x00,
  0x40, 0x61, 0x80, 0xC0, 0x40, 0x80, 0x80, 0x40, 0x80, 0x80, 0x40, 0x81,
  0x80, 0xC0, 0xC1, 0x00, 0xC0, 0xC1, 0x00, 0x80, 0xC3, 0x00, 0x80, 0xC2,
  0x00, 0x80, 0xC2, 0x00, 0x80, 0xC6, 0x00, 0x80, 0xC4, 0x00, 0xC0, 0xC4,
  0x10, 0xC0, 0xCC, 0x7C, 0x40, 0x88, 0x84, 0x40, 0x89, 0x86, 0x40, 0x99,
  0x02, 0x61, 0x91, 0x02, 0x21, 0x11, 0x03, 0x1E, 0x31, 0x03, 0x00, 0x23,
  0x03, 0x00, 0x23, 0x01, 0x00, 0x63, 0x01, 0x00, 0x43, 0x01, 0x00, 0x43,
  0x01, 0x00, 0xC3, 0x01, 0x00, 0x83, 0x03, 0x00, 0x81, 0x03, 0x01, 0x81,
  0x02, 0x01, 0x01, 0x02, 0x01, 0x01, 0x02, 0x03, 0x01, 0x86, 0x02, 0x00,
  0x84, 0x02, 0x00, 0x78, 0x0F, 0x80, 0x0C, 0x20, 0x04, 0x10, 0x02, 0x04,
  0x03, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x30, 0x20, 0x08,
  0x10, 0x04, 0x18, 0x02, 0x08, 0x00, 0x84, 0x00, 0x44, 0x00, 0x36, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0D, 0x00, 0x0C, 0xC0, 0x04, 0x20, 0x04, 0x08,
  0x16, 0x04, 0x0A, 0x01, 0x05, 0x00, 0xC2, 0x80, 0x22, 0x40, 0x19, 0x20,
  0x04, 0x90, 0x03, 0xC8, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x31, 0x80, 0x24,
  0x40, 0x33, 0x10, 0x30, 0x87, 0xF0, 0x60, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0x81, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x30, 0x10, 0x18, 0x08, 0x04,
  0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x03,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x30,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x60,
  0xC0, 0x40, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02,
  0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x40, 0xC0, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0xC2, 0x33, 0xAC, 0x07, 0x00, 0x50, 0x09, 0x01, 0x88, 0x10, 0x42,
  0x02, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x1F, 0xFF, 0xF0, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x33, 0x32, 0x26, 0x64, 0x4C, 0x80, 0xFF, 0xE0, 0xFF, 0x80,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0xE0, 0x10, 0x60, 0x60, 0x61, 0x80, 0x42, 0x00, 0x84,
  0x01, 0x98, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x0D, 0x00, 0x1A, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xA0, 0x03, 0x40,
  0x06, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x26, 0x00, 0x44, 0x01, 0x88, 0x02,
  0x18, 0x04, 0x18, 0x10, 0x18, 0x60, 0x1F, 0x80, 0x03, 0x07, 0x0F, 0x1B,
  0x33, 0x43, 0x83, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x1F, 0xE0, 0xC0, 0x61, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x03, 0xFF,
  0xF8, 0x3F, 0xE0, 0xC0, 0x63, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0F, 0x80, 0x07, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x19, 0x80, 0x61, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x03,
  0x20, 0x00, 0x88, 0x00, 0x62, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x02, 0x08,
  0x01, 0x82, 0x00, 0x40, 0x80, 0x30, 0x20, 0x08, 0x08, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x20, 0x20, 0x08, 0x18, 0x02, 0x04, 0x00, 0x83, 0x00,
  0x20, 0x80, 0x08, 0x3F, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x3F, 0xF8, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x13, 0xF0, 0x3E, 0x78, 0x40, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x19, 0x80, 0xE1, 0xFF, 0x00, 0x01, 0xFC, 0x0E, 0x08,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x11, 0xF8,
  0x2C, 0x0C, 0xD0, 0x09, 0xC0, 0x0B, 0x80, 0x16, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x6C, 0x00, 0xC8, 0x01, 0x10, 0x02, 0x10, 0x08, 0x30, 0x30,
  0x3F, 0xC0, 0x1C, 0x00, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0F, 0xE0,
  0x18, 0x18, 0x30, 0x08, 0x60, 0x04, 0x40, 0x04, 0x40, 0x06, 0x40, 0x06,
  0x40, 0x06, 0x40, 0x06, 0x40, 0x06, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x08,
  0x18, 0x10, 0x0C, 0x60, 0x06, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x0C, 0x20,
  0x10, 0x18, 0x20, 0x08, 0x60, 0x04, 0x40, 0x06, 0xC0, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x06,
  0x40, 0x04, 0x60, 0x0C, 0x38, 0x18, 0x0F, 0xF0, 0x0F, 0xE0, 0x30, 0x60,
  0x80, 0x43, 0x00, 0x44, 0x00, 0x88, 0x01, 0xB0, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x40, 0x0E, 0x80, 0x1C, 0x80, 0x79, 0x81, 0xB1, 0xFE, 0x60,
  0x60, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x81,
  0xFE, 0x00, 0xDF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x37, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33,
  0x22, 0x66, 0x44, 0xC8, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x10, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x10, 0x30, 0x03,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xC1, 0xC0, 0x07, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x18,
  0x18, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x20, 0x00, 0x06,
  0x60, 0x00, 0x02, 0x40, 0x1F, 0x02, 0x40, 0x61, 0x02, 0xC0, 0x41, 0x03,
  0xC0, 0x81, 0x03, 0x80, 0x81, 0x01, 0x81, 0x81, 0x01, 0x81, 0x01, 0x01,
  0x81, 0x01, 0x01, 0x81, 0x01, 0x01, 0x81, 0x01, 0x01, 0x81, 0x01, 0x01,
  0x81, 0x03, 0x01, 0x81, 0x03, 0x01, 0x81, 0x03, 0x03, 0x81, 0x03, 0x02,
  0x81, 0x03, 0x02, 0x81, 0x85, 0x06, 0xC0, 0x84, 0x84, 0xC0, 0x78, 0xF8,
  0x40, 0x20, 0x20, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x01, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x03, 0x10, 0x00, 0x84, 0x00, 0x21, 0x80, 0x08, 0x20,
  0x06, 0x08, 0x01, 0x02, 0x00, 0x40, 0xC0, 0x10, 0x10, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x60, 0x20, 0x08, 0x1F, 0xFE, 0x06, 0x00, 0x81, 0x00,
  0x30, 0x40, 0x0C, 0x30, 0x01, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x06,
  0x20, 0x00, 0x98, 0x00, 0x24, 0x00, 0x09, 0x00, 0x03, 0x40, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x04, 0xFF, 0xC1, 0x01, 0xE2, 0x00, 0x64, 0x00, 0x68,
  0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x28, 0x00, 0xD0, 0x01, 0x20, 0x06, 0x40, 0x38, 0xFF, 0xC1,
  0x00, 0xE2, 0x00, 0x64, 0x00, 0x68, 0x00, 0x50, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x40, 0x06, 0x80, 0x19, 0x00, 0xE3, 0xFF, 0x00, 0x01, 0xFE,
  0x06, 0x01, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0x01, 0x01, 0xFF, 0xFF, 0x80, 0x81, 0xE0,
  0x80, 0x30, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x18,
  0x80, 0x30, 0x80, 0xE0, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xFF,
  0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x30, 0x0E, 0x0C, 0x00, 0x20,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x16,
  0x00, 0x01, 0x20, 0x00, 0x13, 0x00, 0x01, 0x10, 0x00, 0x11, 0x80, 0x01,
  0x0C, 0x00, 0x10, 0x70, 0x07, 0x01, 0xFF, 0xC0, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23,
  0xF8, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x0F, 0xF1, 0x00, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x64, 0x00, 0x88,
  0x02, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x60, 0x80, 0x81, 0x02, 0x02, 0x0C,
  0x04, 0x10, 0x08, 0x60, 0x10, 0x80, 0x22, 0x00, 0x4C, 0x00, 0x98, 0x01,
  0x48, 0x02, 0x90, 0x06, 0x10, 0x0C, 0x20, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x80, 0x81, 0x00, 0x82, 0x01, 0x04, 0x01, 0x08, 0x02, 0x10, 0x02,
  0x20, 0x04, 0x40, 0x0C, 0x80, 0x09, 0x00, 0x1A, 0x00, 0x18, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x05, 0xA0, 0x00, 0x05, 0xA0, 0x00, 0x05, 0xB0, 0x00, 0x0D,
  0x90, 0x00, 0x09, 0x90, 0x00, 0x09, 0x98, 0x00, 0x19, 0x88, 0x00, 0x11,
  0x88, 0x00, 0x11, 0x88, 0x00, 0x31, 0x8C, 0x00, 0x21, 0x84, 0x00, 0x21,
  0x84, 0x00, 0x61, 0x86, 0x00, 0x61, 0x82, 0x00, 0x41, 0x82, 0x00, 0x41,
  0x83, 0x00, 0xC1, 0x81, 0x00, 0x81, 0x81, 0x00, 0x81, 0x81, 0x81, 0x81,
  0x80, 0x81, 0x01, 0x80, 0x81, 0x01, 0x80, 0x83, 0x01, 0x80, 0xC2, 0x01,
  0x80, 0x42, 0x01, 0x80, 0x42, 0x01, 0x80, 0x66, 0x01, 0x80, 0x24, 0x01,
  0x80, 0x24, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x80,
  0x06, 0x40, 0x03, 0x30, 0x01, 0x88, 0x00, 0xC6, 0x00, 0x61, 0x00, 0x30,
  0x80, 0x18, 0x20, 0x0C, 0x10, 0x06, 0x0C, 0x03, 0x02, 0x01, 0x81, 0x80,
  0xC0, 0x40, 0x60, 0x20, 0x30, 0x08, 0x18, 0x04, 0x0C, 0x01, 0x06, 0x00,
  0x83, 0x00, 0x61, 0x80, 0x10, 0xC0, 0x0C, 0x60, 0x02, 0x30, 0x01, 0x18,
  0x00, 0x4C, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x03, 0xFC, 0x01, 0x80, 0xC0, 0x60, 0x0C, 0x08, 0x00,
  0xC2, 0x00, 0x08, 0xC0, 0x01, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00,
  0x58, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x26, 0x00, 0x04,
  0xC0, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x0C, 0x18, 0x03, 0x01, 0x80, 0xC0,
  0x1F, 0xF0, 0x00, 0xFF, 0x02, 0x0F, 0x88, 0x03, 0x20, 0x04, 0x80, 0x1A,
  0x00, 0x28, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x28, 0x00, 0xA0, 0x06, 0x80, 0x12, 0x00, 0xC8, 0x1C,
  0x3F, 0xC0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFC, 0x01, 0x80, 0xC0, 0x60, 0x0C,
  0x08, 0x00, 0xC2, 0x00, 0x08, 0xC0, 0x01, 0x90, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x26,
  0x00, 0x04, 0x40, 0x01, 0x88, 0x00, 0x20, 0x80, 0x0C, 0x18, 0x03, 0x01,
  0x80, 0xC0, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0xFF, 0x01, 0x03, 0xC2, 0x00, 0xC4, 0x00, 0xC8, 0x00, 0x90, 0x01, 0x20,
  0x03, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x34, 0x00, 0x68, 0x00,
  0x90, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x31, 0x01, 0xC3, 0xFE, 0x04,
  0x18, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x40, 0x60, 0x80, 0x41, 0x00,
  0x82, 0x01, 0x84, 0x01, 0x08, 0x03, 0x10, 0x02, 0x20, 0x06, 0x40, 0x04,
  0x80, 0x0D, 0x00, 0x0A, 0x00, 0x18, 0x0F, 0xFE, 0x30, 0x08, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x19, 0x80, 0x61, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x02,
  0x40, 0x06, 0x60, 0x04, 0x38, 0x1C, 0x0F, 0xF0, 0x80, 0x00, 0x70, 0x00,
  0x34, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x62, 0x00, 0x10,
  0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC3, 0x00, 0x20, 0x40, 0x08, 0x10,
  0x02, 0x04, 0x00, 0x81, 0x80, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xC0, 0xC0, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x41, 0x80,
  0x18, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x23, 0x00, 0x0C, 0x80, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x80, 0x03, 0x00, 0x05, 0x00,
  0x06, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x36, 0x00, 0x38, 0x00, 0x4C, 0x00,
  0x58, 0x00, 0x88, 0x00, 0xB0, 0x01, 0x10, 0x01, 0x20, 0x06, 0x20, 0x06,
  0x40, 0x0C, 0x60, 0x0C, 0x80, 0x10, 0xC0, 0x11, 0x00, 0x20, 0x80, 0x23,
  0x00, 0x41, 0x00, 0x42, 0x01, 0x82, 0x01, 0x84, 0x03, 0x06, 0x03, 0x08,
  0x04, 0x04, 0x04, 0x10, 0x08, 0x08, 0x08, 0x30, 0x30, 0x10, 0x10, 0x20,
  0x60, 0x30, 0x60, 0x40, 0x80, 0x60, 0xC0, 0x81, 0x00, 0x41, 0x01, 0x02,
  0x00, 0x82, 0x03, 0x0C, 0x01, 0x04, 0x02, 0x18, 0x03, 0x18, 0x04, 0x20,
  0x06, 0x30, 0x08, 0x40, 0x04, 0x40, 0x10, 0x80, 0x08, 0x80, 0x33, 0x00,
  0x11, 0x00, 0x24, 0x00, 0x32, 0x00, 0x48, 0x00, 0x2C, 0x00, 0x90, 0x00,
  0x50, 0x01, 0x60, 0x00, 0xA0, 0x03, 0xC0, 0x01, 0x40, 0x03, 0x00, 0x03,
  0x80, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x30, 0x02, 0x10,
  0x06, 0x10, 0x04, 0x18, 0x04, 0x08, 0x0C, 0x08, 0x08, 0x0C, 0x08, 0x04,
  0x10, 0x04, 0x10, 0x02, 0x30, 0x02, 0x20, 0x03, 0x20, 0x01, 0x60, 0x01,
  0x40, 0x01, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03,
  0x60, 0x02, 0x20, 0x06, 0x20, 0x04, 0x30, 0x04, 0x10, 0x0C, 0x10, 0x08,
  0x18, 0x18, 0x08, 0x10, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60,
  0x06, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x05, 0x00, 0x1A, 0x00,
  0x26, 0x00, 0x44, 0x01, 0x88, 0x02, 0x18, 0x04, 0x10, 0x18, 0x20, 0x20,
  0x60, 0x40, 0x41, 0x80, 0x82, 0x01, 0x84, 0x01, 0x18, 0x02, 0x20, 0x06,
  0x40, 0x05, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x7F,
  0xFC, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0F, 0xFF,
  0xC0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x3F, 0xE0, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0x04, 0x80, 0x03, 0x30, 0x00, 0x84, 0x00, 0x61, 0x80, 0x10, 0x20, 0x0C,
  0x0C, 0x02, 0x01, 0x01, 0x80, 0x60, 0x40, 0x08, 0x30, 0x03, 0x08, 0x00,
  0xC6, 0x00, 0x11, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0xC0, 0xC0, 0x80, 0x81, 0x81, 0x80, 0x1F, 0xC1, 0x83, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x01, 0xF0, 0xF9, 0x8C, 0x0D, 0x80, 0x68, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0x00, 0xE8, 0x05, 0x60,
  0x49, 0xFC, 0x40, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC7, 0xE0, 0xCC, 0x18, 0xD0, 0x08, 0xF0, 0x04, 0xE0, 0x04, 0xE0,
  0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x02, 0xE0, 0x06, 0xE0, 0x04, 0xE0, 0x0C, 0xD0,
  0x08, 0xC8, 0x18, 0xC7, 0xE0, 0x07, 0xF0, 0xC1, 0x18, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x1C, 0x10, 0x7F, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x3F, 0x11, 0x83, 0x22, 0x01, 0x48, 0x03,
  0x90, 0x03, 0x60, 0x06, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x03, 0x60, 0x06, 0x40, 0x14,
  0xC0, 0x28, 0xC1, 0x90, 0xFE, 0x20, 0x07, 0xE0, 0x60, 0xC1, 0x01, 0x08,
  0x02, 0x20, 0x09, 0x80, 0x34, 0x00, 0x50, 0x01, 0x40, 0x07, 0x00, 0x1C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x01,
  0x1C, 0x0C, 0x1F, 0xE0, 0x03, 0xF0, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xF8, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x07, 0xE2, 0x30, 0x64, 0x40, 0x29, 0x00, 0x72, 0x00, 0x68, 0x00, 0xD0,
  0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x0A,
  0x00, 0x34, 0x00, 0x6C, 0x00, 0xC8, 0x02, 0x98, 0x0D, 0x18, 0x32, 0x1F,
  0xC4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x32, 0x00, 0xC7, 0xCF, 0x01, 0xF8, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x31, 0xF8, 0xCC, 0x33, 0x40,
  0x6F, 0x00, 0xB8, 0x02, 0xE0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0C, 0xFD, 0x00, 0x00, 0x09, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00, 0x1C, 0x70, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x86, 0x12, 0xCE, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x6C, 0x02, 0x60, 0x23, 0x03, 0x18, 0x10, 0xC1, 0x86, 0x08,
  0x30, 0x81, 0x8C, 0x0C, 0x40, 0x66, 0x03, 0x38, 0x1A, 0x40, 0xF2, 0x07,
  0x08, 0x30, 0x41, 0x83, 0x0C, 0x08, 0x60, 0x63, 0x01, 0x18, 0x08, 0xC0,
  0x66, 0x01, 0x30, 0x0D, 0x80, 0x2C, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x8F, 0xC1, 0xF9, 0x30, 0xC6, 0x1A,
  0x40, 0xD8, 0x15, 0x00, 0xA0, 0x3E, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x04, 0x87, 0xE2, 0x30,
  0xC9, 0x01, 0xAC, 0x02, 0xA0, 0x0B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x07, 0xE0, 0x18, 0x38, 0x30,
  0x08, 0x20, 0x0C, 0x60, 0x04, 0x40, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x06, 0x60, 0x04, 0x20, 0x04, 0x30, 0x08, 0x18, 0x18, 0x0F, 0xF0, 0x87,
  0xE0, 0x8C, 0x18, 0x98, 0x08, 0x90, 0x04, 0xA0, 0x04, 0xA0, 0x06, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x02, 0xE0, 0x06, 0xE0, 0x04, 0xF0, 0x0C, 0xD0, 0x08, 0xC8,
  0x18, 0xC7, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x07, 0xE2, 0x18, 0x64, 0x40, 0x29, 0x80, 0x72, 0x00, 0x6C, 0x00,
  0xD0, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x05, 0x00,
  0x0A, 0x00, 0x34, 0x00, 0x6C, 0x00, 0xC8, 0x02, 0x98, 0x0D, 0x18, 0x32,
  0x1F, 0xC4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x87,
  0xE6, 0x74, 0x1A, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x00, 0x1F, 0xE3, 0x02, 0x40, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x28, 0x06, 0xC0, 0xC7, 0xF8, 0x10, 0x08, 0x04, 0x02,
  0x03, 0x01, 0x83, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x1E, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00, 0x74, 0x01,
  0x58, 0x09, 0x30, 0x64, 0x7E, 0x10, 0xC0, 0x05, 0x00, 0x34, 0x00, 0xD0,
  0x02, 0x60, 0x08, 0x80, 0x22, 0x01, 0x88, 0x04, 0x30, 0x10, 0xC0, 0x41,
  0x03, 0x04, 0x08, 0x10, 0x20, 0x60, 0x80, 0x86, 0x02, 0x10, 0x08, 0x40,
  0x31, 0x00, 0x4C, 0x01, 0x20, 0x04, 0x80, 0x1A, 0x00, 0x28, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0xA0, 0x06, 0x00, 0x90, 0x07,
  0x00, 0x48, 0x02, 0x80, 0x26, 0x01, 0x40, 0x31, 0x00, 0xB0, 0x10, 0x80,
  0x48, 0x08, 0x40, 0x64, 0x04, 0x30, 0x22, 0x02, 0x08, 0x11, 0x03, 0x04,
  0x08, 0xC1, 0x02, 0x04, 0x20, 0x81, 0x06, 0x10, 0x40, 0xC2, 0x08, 0x60,
  0x21, 0x04, 0x20, 0x10, 0x83, 0x10, 0x08, 0xC0, 0x88, 0x06, 0x60, 0x44,
  0x01, 0x20, 0x26, 0x00, 0x90, 0x1A, 0x00, 0x48, 0x0D, 0x00, 0x2C, 0x02,
  0x80, 0x1C, 0x01, 0x40, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80,
  0x10, 0x00, 0xC0, 0x09, 0x00, 0x66, 0x01, 0x08, 0x0C, 0x30, 0x20, 0x40,
  0x81, 0x84, 0x02, 0x10, 0x08, 0xC0, 0x12, 0x00, 0x58, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0x60, 0x0C, 0x80, 0x23, 0x01, 0x84, 0x04,
  0x18, 0x30, 0x20, 0x80, 0xC6, 0x01, 0x10, 0x04, 0x40, 0x1A, 0x00, 0x30,
  0x40, 0x02, 0xC0, 0x0C, 0x80, 0x11, 0x00, 0x22, 0x00, 0x46, 0x01, 0x84,
  0x02, 0x08, 0x04, 0x10, 0x08, 0x30, 0x30, 0x20, 0x40, 0x40, 0x80, 0x81,
  0x01, 0x86, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x0C, 0xC0, 0x09, 0x00,
  0x12, 0x00, 0x24, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x0F, 0x80, 0x0E, 0x00, 0x00,
  0x7F, 0xC0, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x1F, 0xFC,
  0x00, 0xE0, 0x70, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x07, 0x01, 0xC0, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x7C, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x01, 0xC0, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x10, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x07, 0x80, 0xE0, 0x00,
  0x3F, 0x00, 0xB0, 0xE0, 0x60, 0x1F, 0xC0, 0x01, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Thin49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 35, 10, 4, -35 },
  { 10, 8, 13, 14, 3, -35 },
  { 23, 19, 35, 21, 1, -35 },
  { 107, 16, 40, 19, 2, -37 },
  { 187, 24, 35, 28, 2, -35 },
  { 292, 17, 35, 19, 2, -35 },
  { 367, 2, 13, 8, 3, -35 },
  { 371, 9, 43, 13, 2, -35 },
  { 420, 8, 43, 13, 2, -35 },
  { 463, 12, 12, 17, 2, -37 },
  { 481, 17, 23, 20, 1, -29 },
  { 530, 4, 11, 9, 2, -5 },
  { 536, 11, 1, 13, 1, -14 },
  { 538, 3, 3, 9, 3, -3 },
  { 540, 14, 35, 16, 1, -35 },
  { 602, 15, 35, 19, 2, -35 },
  { 668, 8, 35, 19, 4, -35 },
  { 703, 15, 35, 19, 2, -35 },
  { 769, 15, 35, 19, 2, -35 },
  { 835, 18, 35, 19, 1, -35 },
  { 914, 15, 35, 19, 2, -35 },
  { 980, 15, 36, 19, 2, -35 },
  { 1048, 15, 35, 19, 2, -35 },
  { 1114, 16, 35, 19, 2, -35 },
  { 1184, 15, 35, 19, 2, -35 },
  { 1250, 3, 26, 9, 3, -26 },
  { 1260, 4, 32, 9, 2, -26 },
  { 1276, 17, 20, 20, 1, -27 },
  { 1319, 17, 12, 20, 1, -23 },
  { 1345, 17, 20, 20, 1, -27 },
  { 1388, 11, 35, 13, 1, -35 },
  { 1437, 24, 40, 30, 3, -35 },
  { 1557, 18, 35, 18, 0, -35 },
  { 1636, 15, 35, 21, 4, -35 },
  { 1702, 16, 35, 20, 3, -35 },
  { 1772, 16, 35, 23, 4, -35 },
  { 1842, 12, 35, 19, 4, -35 },
  { 1895, 12, 35, 17, 4, -35 },
  { 1948, 20, 35, 25, 3, -35 },
  { 2036, 16, 35, 24, 4, -35 },
  { 2106, 7, 35, 11, 2, -35 },
  { 2137, 7, 44, 9, -2, -35 },
  { 2176, 15, 35, 19, 4, -35 },
  { 2242, 12, 35, 17, 4, -35 },
  { 2295, 24, 35, 32, 4, -35 },
  { 2400, 17, 35, 25, 4, -35 },
  { 2475, 19, 35, 25, 3, -35 },
  { 2559, 14, 35, 19, 4, -35 },
  { 2621, 19, 43, 25, 3, -35 },
  { 2724, 15, 35, 20, 4, -35 },
  { 2790, 15, 35, 19, 2, -35 },
  { 2856, 16, 35, 16, 0, -35 },
  { 2926, 16, 35, 24, 4, -35 },
  { 2996, 18, 35, 18, 0, -35 },
  { 3075, 31, 35, 32, 0, -35 },
  { 3211, 16, 35, 16, 0, -35 },
  { 3281, 15, 35, 15, 0, -35 },
  { 3347, 14, 35, 16, 1, -35 },
  { 3409, 9, 43, 15, 4, -35 },
  { 3458, 14, 35, 16, 1, -35 },
  { 3520, 9, 43, 15, 2, -35 },
  { 3569, 18, 17, 19, 1, -35 },
  { 3608, 19, 2, 19, 0, 4 },
  { 3613, 7, 7, 11, 2, -37 },
  { 3620, 13, 26, 18, 2, -26 },
  { 3663, 16, 37, 21, 3, -37 },
  { 3737, 12, 26, 15, 2, -26 },
  { 3776, 15, 37, 21, 2, -37 },
  { 3846, 14, 26, 19, 2, -26 },
  { 3892, 12, 37, 10, 0, -37 },
  { 3948, 15, 38, 21, 2, -26 },
  { 4020, 14, 37, 20, 3, -37 },
  { 4085, 3, 35, 9, 3, -35 },
  { 4099, 6, 47, 9, 0, -35 },
  { 4135, 13, 37, 16, 3, -37 },
  { 4196, 2, 37, 8, 3, -37 },
  { 4206, 23, 26, 30, 3, -26 },
  { 4281, 14, 26, 20, 3, -26 },
  { 4327, 16, 26, 20, 2, -26 },
  { 4379, 16, 37, 21, 3, -26 },
  { 4453, 15, 37, 21, 2, -26 },
  { 4523, 9, 26, 13, 3, -26 },
  { 4553, 12, 26, 15, 2, -26 },
  { 4592, 9, 32, 10, 1, -32 },
  { 4628, 14, 26, 20, 3, -26 },
  { 4674, 14, 26, 14, 0, -26 },
  { 4720, 25, 26, 25, 0, -26 },
  { 4802, 14, 26, 15, 1, -26 },
  { 4848, 15, 38, 15, 0, -26 },
  { 4920, 11, 26, 13, 1, -26 },
  { 4956, 11, 43, 17, 3, -35 },
  { 5016, 1, 49, 19, 9, -37 },
  { 5023, 12, 43, 17, 2, -35 },
  { 5088, 17, 4, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Thin49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN49PT7B_H_
