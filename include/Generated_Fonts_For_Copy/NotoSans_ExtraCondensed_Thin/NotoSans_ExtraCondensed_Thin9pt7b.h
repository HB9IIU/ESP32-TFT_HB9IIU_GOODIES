#ifndef _NOTOSANS_EXTRACONDENSED_THIN9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x6F, 0x66, 0xAA, 0x7B, 0x26, 0xEA, 0x46, 0xA9, 0xF5,
  0x95, 0x60, 0x56, 0xAF, 0x78, 0xC0, 0x6A, 0xA4, 0xD5, 0x5C, 0x5C, 0x5D,
  0x20, 0xC0, 0xC0, 0x80, 0x29, 0x29, 0x00, 0x56, 0xDB, 0x58, 0xFC, 0xC4,
  0x92, 0xB8, 0x54, 0xB2, 0x78, 0x2D, 0xD6, 0x40, 0xF3, 0x93, 0xC0, 0xF3,
  0xDB, 0xC0, 0xE4, 0xA4, 0x80, 0x56, 0xAB, 0x78, 0x56, 0xD6, 0x58, 0x88,
  0x8C, 0x39, 0x10, 0xFC, 0xC5, 0x40, 0xD5, 0x88, 0x7D, 0xF7, 0xBB, 0xC1,
  0xC0, 0x4A, 0xFB, 0x40, 0xF7, 0x5B, 0x80, 0x34, 0x88, 0x88, 0x70, 0xF6,
  0xDB, 0x80, 0xEE, 0xB0, 0xEE, 0xA0, 0x34, 0x88, 0x99, 0x70, 0xB7, 0xDB,
  0x40, 0xEA, 0xB0, 0xFF, 0xEA, 0xF0, 0xAA, 0xB0, 0x99, 0x9B, 0xFD, 0xB6,
  0xFB, 0x40, 0x69, 0x99, 0x99, 0x70, 0xFE, 0xA0, 0x69, 0x99, 0x99, 0x52,
  0x10, 0xFE, 0xF0, 0x72, 0x22, 0x78, 0xE9, 0x24, 0x80, 0xB6, 0xDB, 0xC0,
  0xB6, 0xA4, 0x80, 0xA6, 0x9B, 0x6E, 0x49, 0x20, 0xA9, 0x2B, 0x40, 0xB5,
  0x24, 0x80, 0xE9, 0x29, 0xC0, 0xFE, 0x89, 0x22, 0x40, 0xD5, 0x5C, 0x56,
  0x80, 0xF0, 0x90, 0xE5, 0xDE, 0xAF, 0xFC, 0x72, 0x4E, 0x25, 0xDB, 0x78,
  0x77, 0xCE, 0x6E, 0xA8, 0x76, 0xDE, 0x58, 0xAF, 0xFC, 0xBE, 0xBF, 0x80,
  0xAE, 0xAC, 0xFE, 0xFD, 0xDD, 0xD0, 0xFF, 0xC0, 0x76, 0xDE, 0xFF, 0xE8,
  0x76, 0xDE, 0x48, 0xF8, 0xF1, 0x1E, 0xBA, 0xB0, 0xFF, 0xC0, 0xB7, 0x64,
  0xAD, 0x7D, 0xA5, 0x00, 0xB9, 0x6A, 0xB6, 0xA4, 0xB0, 0xD6, 0xC0, 0x69,
  0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 8, 4, 0, -7 },
  { 9, 5, 7, 5, 0, -7 },
  { 14, 3, 7, 3, 0, -7 },
  { 17, 1, 2, 1, 0, -6 },
  { 18, 2, 7, 2, 0, -6 },
  { 20, 2, 7, 2, 0, -6 },
  { 22, 3, 2, 3, 0, -7 },
  { 23, 3, 4, 4, 0, -5 },
  { 25, 1, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -3 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 3, 6, 3, 0, -6 },
  { 31, 3, 7, 4, 0, -7 },
  { 34, 1, 6, 4, 1, -6 },
  { 35, 3, 7, 4, 0, -7 },
  { 38, 3, 7, 4, 0, -7 },
  { 41, 3, 6, 4, 0, -6 },
  { 44, 3, 6, 4, 0, -6 },
  { 47, 3, 6, 4, 0, -6 },
  { 50, 3, 6, 4, 0, -6 },
  { 53, 3, 7, 4, 0, -7 },
  { 56, 3, 7, 4, 0, -7 },
  { 59, 1, 5, 2, 0, -5 },
  { 60, 1, 6, 2, 0, -5 },
  { 61, 3, 4, 4, 0, -5 },
  { 63, 3, 2, 4, 0, -4 },
  { 64, 3, 4, 4, 0, -5 },
  { 66, 2, 7, 2, 0, -7 },
  { 68, 5, 7, 5, 0, -6 },
  { 73, 3, 6, 3, 0, -6 },
  { 76, 3, 6, 4, 1, -6 },
  { 79, 4, 7, 4, 0, -7 },
  { 83, 3, 6, 4, 1, -6 },
  { 86, 2, 6, 3, 1, -6 },
  { 88, 2, 6, 3, 1, -6 },
  { 90, 4, 7, 5, 0, -7 },
  { 94, 3, 6, 4, 1, -6 },
  { 97, 2, 6, 2, 0, -6 },
  { 99, 1, 8, 2, 0, -6 },
  { 100, 2, 6, 3, 1, -6 },
  { 102, 2, 6, 3, 1, -6 },
  { 104, 4, 6, 6, 1, -6 },
  { 107, 3, 6, 5, 1, -6 },
  { 110, 4, 7, 5, 0, -7 },
  { 114, 2, 6, 4, 1, -6 },
  { 116, 4, 9, 5, 0, -7 },
  { 121, 2, 6, 4, 1, -6 },
  { 123, 3, 7, 4, 0, -7 },
  { 126, 3, 6, 3, 0, -6 },
  { 129, 3, 6, 4, 1, -6 },
  { 132, 3, 6, 3, 0, -6 },
  { 135, 6, 6, 6, 0, -6 },
  { 140, 3, 6, 3, 0, -6 },
  { 143, 3, 6, 3, 0, -6 },
  { 146, 3, 6, 3, 0, -6 },
  { 149, 1, 7, 3, 1, -6 },
  { 150, 3, 6, 3, 0, -6 },
  { 153, 2, 7, 3, 0, -6 },
  { 155, 3, 3, 4, 0, -6 },
  { 157, 4, 1, 4, 0, 0 },
  { 158, 2, 2, 2, 0, -7 },
  { 159, 3, 5, 3, 0, -5 },
  { 161, 2, 7, 4, 1, -7 },
  { 163, 3, 5, 3, 0, -5 },
  { 165, 3, 7, 4, 0, -7 },
  { 168, 3, 5, 3, 0, -5 },
  { 170, 2, 7, 2, 0, -7 },
  { 172, 3, 7, 4, 0, -5 },
  { 175, 2, 7, 4, 1, -7 },
  { 177, 1, 7, 2, 0, -7 },
  { 178, 1, 9, 2, 0, -7 },
  { 180, 2, 7, 3, 1, -7 },
  { 182, 1, 7, 2, 0, -7 },
  { 183, 4, 5, 5, 1, -5 },
  { 186, 2, 5, 4, 1, -5 },
  { 188, 3, 5, 4, 0, -5 },
  { 190, 2, 7, 4, 1, -5 },
  { 192, 3, 7, 4, 0, -5 },
  { 195, 1, 5, 2, 1, -5 },
  { 196, 3, 5, 3, 0, -5 },
  { 198, 2, 6, 2, 0, -6 },
  { 200, 2, 5, 4, 1, -5 },
  { 202, 3, 5, 3, 0, -5 },
  { 204, 5, 5, 5, 0, -5 },
  { 208, 3, 5, 3, 0, -5 },
  { 210, 3, 7, 3, 0, -5 },
  { 213, 2, 5, 2, 0, -5 },
  { 215, 3, 7, 3, 0, -6 },
  { 218, 1, 9, 3, 1, -7 },
  { 220, 3, 7, 3, 0, -6 },
  { 223, 3, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Thin9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN9PT7B_H_
