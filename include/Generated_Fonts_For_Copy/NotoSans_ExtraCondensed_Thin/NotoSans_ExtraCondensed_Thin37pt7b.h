#ifndef _NOTOSANS_EXTRACONDENSED_THIN37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin37pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0xE0, 0xC7, 0x1C, 0x71, 0xC5,
  0x14, 0x51, 0x84, 0x04, 0x30, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20,
  0x20, 0x80, 0x82, 0x1F, 0xFF, 0x08, 0x20, 0x20, 0x80, 0x84, 0x02, 0x10,
  0x10, 0x40, 0x41, 0x01, 0x04, 0x04, 0x10, 0xFF, 0xF8, 0x41, 0x01, 0x04,
  0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82,
  0x00, 0x04, 0x00, 0x40, 0x1F, 0xC3, 0x42, 0x44, 0x04, 0x40, 0x84, 0x08,
  0x40, 0x84, 0x08, 0x40, 0x44, 0x04, 0x40, 0x24, 0x01, 0xC0, 0x06, 0x00,
  0x58, 0x04, 0x40, 0x42, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x2C, 0x46, 0x3F, 0x80, 0x40, 0x04, 0x00, 0x40, 0x30, 0x00,
  0x12, 0x02, 0x08, 0x40, 0x82, 0x10, 0x40, 0x82, 0x10, 0x20, 0x84, 0x08,
  0x22, 0x02, 0x08, 0x80, 0x82, 0x20, 0x20, 0x90, 0x08, 0x24, 0x02, 0x09,
  0x3C, 0x82, 0x51, 0x21, 0x24, 0x28, 0x49, 0x09, 0x22, 0x82, 0x31, 0x20,
  0x80, 0x48, 0x20, 0x12, 0x04, 0x08, 0x81, 0x02, 0x20, 0x80, 0x88, 0x20,
  0x42, 0x08, 0x10, 0x42, 0x04, 0x10, 0x82, 0x04, 0x40, 0x80, 0xF0, 0x0E,
  0x00, 0x88, 0x04, 0x40, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x10, 0x80, 0x88, 0x04, 0x40, 0x14, 0x00, 0xC0, 0x0E, 0x00, 0xD0, 0x04,
  0x40, 0x42, 0x0A, 0x08, 0x60, 0x25, 0x01, 0x28, 0x05, 0x40, 0x32, 0x00,
  0x88, 0x0C, 0x40, 0x53, 0x04, 0x8F, 0xC2, 0xFF, 0x55, 0x40, 0x0C, 0x21,
  0x04, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x04, 0x10, 0x40, 0x82, 0x0C, 0x10, 0x20, 0x81, 0xC0, 0x40,
  0xC0, 0x81, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04,
  0x18, 0x60, 0x08, 0x04, 0x02, 0x19, 0x33, 0xE0, 0x40, 0x50, 0x44, 0x41,
  0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x07, 0xFF, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x24, 0x92, 0x92, 0x80, 0xFF, 0xF0, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x00, 0x0E, 0x06, 0x20, 0x82,
  0x20, 0x44, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x05, 0x00, 0x90, 0x12, 0x02, 0x60, 0x84, 0x30, 0x7C, 0x00, 0x0C, 0x52,
  0x51, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x0F, 0x07, 0x08, 0x40, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xF0, 0x0E,
  0x06, 0x18, 0xC0, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x01, 0xF0, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x28, 0x04, 0x7F, 0x80, 0x00, 0x40, 0x06, 0x00, 0x30, 0x02, 0x80, 0x14,
  0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x40, 0x42, 0x02, 0x10, 0x20, 0x81,
  0x04, 0x18, 0x20, 0x81, 0x0C, 0x08, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00,
  0x87, 0xFF, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x7F, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0xF8, 0x61, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x06, 0x81, 0x9F, 0xC0,
  0x03, 0x81, 0x88, 0x40, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x4F, 0x8A, 0x09, 0x80, 0xB0, 0x14, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x02, 0x40, 0x44, 0x10,
  0x6C, 0x02, 0x00, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x07, 0x01, 0x8C, 0x20, 0x24, 0x02, 0x40, 0x24, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x22, 0x02, 0x10, 0x40, 0x88, 0x07, 0x00, 0x70,
  0x18, 0x82, 0x04, 0x60, 0x24, 0x03, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x14, 0x01, 0x40, 0x22, 0x06, 0x1F, 0x80, 0x0F, 0x01, 0x88, 0x20,
  0x44, 0x04, 0x40, 0x24, 0x02, 0x40, 0x2C, 0x02, 0x80, 0x28, 0x01, 0x40,
  0x34, 0x03, 0x40, 0x34, 0x03, 0x20, 0x53, 0x09, 0x0F, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x3E,
  0x00, 0x74, 0x00, 0x00, 0x00, 0x0F, 0x24, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x24, 0x92, 0x92, 0x80, 0x00, 0x08, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x10, 0x00, 0x78,
  0x84, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x40, 0x00, 0xEE, 0x00, 0xC0, 0x60, 0x60, 0x0C, 0x10,
  0x01, 0x08, 0x00, 0x22, 0x00, 0x09, 0x00, 0x01, 0x40, 0xF8, 0x50, 0x42,
  0x1C, 0x30, 0x86, 0x08, 0x41, 0x82, 0x10, 0x61, 0x84, 0x18, 0x41, 0x06,
  0x10, 0x41, 0x84, 0x10, 0x61, 0x04, 0x18, 0x41, 0x06, 0x08, 0x41, 0x82,
  0x28, 0xE0, 0xCA, 0x24, 0x1C, 0x71, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x08, 0x01, 0xFE, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x02, 0x10,
  0x08, 0x40, 0x21, 0x00, 0x84, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x0F, 0xF8, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x40, 0x09, 0x00,
  0x24, 0x00, 0x90, 0x02, 0x80, 0x06, 0x00, 0x10, 0xFF, 0x90, 0x1A, 0x01,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0A, 0x03, 0x41,
  0x8F, 0xF1, 0x01, 0xA0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x9F, 0xE0, 0x03, 0xE0, 0xC1, 0x18,
  0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x81, 0x07,
  0xF0, 0xFF, 0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x68,
  0x0C, 0x81, 0x8F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x07, 0xFE, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x00, 0x00, 0xF0, 0x0C, 0x18, 0x20, 0x08, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x1F, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x48, 0x00, 0x90,
  0x01, 0x10, 0x02, 0x18, 0x04, 0x1F, 0xF0, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFC, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0xFE, 0x80, 0x70, 0x1A, 0x02, 0x40, 0x88,
  0x11, 0x04, 0x21, 0x84, 0x20, 0x88, 0x11, 0x02, 0x40, 0x58, 0x0B, 0x01,
  0x90, 0x32, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08, 0x40, 0x88, 0x11, 0x01,
  0x20, 0x24, 0x02, 0x80, 0x50, 0x04, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xA0, 0x01, 0x68,
  0x00, 0x5A, 0x00, 0x16, 0x40, 0x09, 0x90, 0x02, 0x64, 0x00, 0x98, 0x80,
  0x46, 0x20, 0x11, 0x88, 0x04, 0x61, 0x01, 0x18, 0x40, 0x86, 0x10, 0x21,
  0x84, 0x08, 0x60, 0x84, 0x18, 0x21, 0x06, 0x08, 0x41, 0x81, 0x20, 0x60,
  0x48, 0x18, 0x12, 0x06, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x40, 0x1A, 0x00, 0xC8, 0x06, 0x40, 0x31, 0x01,
  0x88, 0x0C, 0x40, 0x61, 0x03, 0x08, 0x18, 0x20, 0xC1, 0x06, 0x04, 0x30,
  0x21, 0x81, 0x0C, 0x04, 0x60, 0x23, 0x00, 0x98, 0x04, 0xC0, 0x16, 0x00,
  0xB0, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x03, 0x80, 0x18, 0xC0, 0x40, 0x41,
  0x00, 0x46, 0x00, 0x88, 0x00, 0x90, 0x01, 0x20, 0x02, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90,
  0x01, 0x10, 0x04, 0x30, 0x08, 0x30, 0x20, 0x3F, 0x80, 0xFF, 0x20, 0x68,
  0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xA0, 0xCF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x03, 0x80, 0x18, 0xC0, 0x40, 0x41,
  0x00, 0x46, 0x00, 0x88, 0x00, 0x90, 0x01, 0x20, 0x02, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90,
  0x01, 0x10, 0x04, 0x20, 0x08, 0x30, 0x20, 0x3F, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0xFF, 0x10, 0x32, 0x01,
  0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40,
  0x48, 0x11, 0xFC, 0x21, 0x04, 0x20, 0x82, 0x10, 0x42, 0x04, 0x40, 0x88,
  0x09, 0x01, 0x20, 0x14, 0x02, 0x80, 0x70, 0x04, 0x0F, 0x86, 0x09, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x50, 0x13, 0xFC, 0x00, 0xFF, 0xF0,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14,
  0x02, 0x60, 0x61, 0xF8, 0x80, 0x0E, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40,
  0x11, 0x00, 0x42, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80, 0x82, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x41, 0x01, 0x04, 0x02, 0x10, 0x08, 0x40, 0x22, 0x00,
  0x88, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x01, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x40, 0x18, 0x02, 0x40, 0x18, 0x02, 0x40,
  0x18, 0x02, 0x40, 0x28, 0x02, 0x40, 0x24, 0x04, 0x20, 0x24, 0x04, 0x20,
  0x24, 0x04, 0x20, 0x24, 0x04, 0x20, 0x64, 0x04, 0x10, 0x42, 0x08, 0x10,
  0x42, 0x08, 0x10, 0x42, 0x08, 0x10, 0x42, 0x08, 0x10, 0xC2, 0x10, 0x08,
  0x81, 0x10, 0x08, 0x81, 0x10, 0x08, 0x81, 0x10, 0x08, 0x81, 0x10, 0x09,
  0x81, 0x20, 0x05, 0x00, 0xA0, 0x05, 0x00, 0xA0, 0x05, 0x00, 0xA0, 0x05,
  0x00, 0xA0, 0x05, 0x00, 0xC0, 0x02, 0x00, 0x40, 0x60, 0x22, 0x02, 0x20,
  0x21, 0x04, 0x10, 0x41, 0x04, 0x08, 0x80, 0x88, 0x05, 0x00, 0x50, 0x05,
  0x00, 0x20, 0x02, 0x00, 0x50, 0x05, 0x00, 0x50, 0x08, 0x80, 0x88, 0x10,
  0x81, 0x04, 0x10, 0x42, 0x04, 0x20, 0x24, 0x02, 0x40, 0x2C, 0x01, 0x80,
  0x34, 0x02, 0x40, 0x24, 0x04, 0x20, 0x42, 0x04, 0x20, 0x81, 0x08, 0x10,
  0x81, 0x10, 0x09, 0x00, 0x90, 0x0A, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0xFF, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x3F, 0xF0, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x7F, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10,
  0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xFF, 0x02, 0x00, 0x28, 0x01, 0x40, 0x11, 0x00, 0x88,
  0x08, 0x20, 0x41, 0x04, 0x04, 0x20, 0x22, 0x00, 0x90, 0x05, 0x00, 0x30,
  0xFF, 0xFE, 0xC0, 0x83, 0x04, 0x08, 0x10, 0x1F, 0x08, 0x60, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x43, 0xF3, 0x05, 0x81, 0x40, 0x50,
  0x18, 0x06, 0x01, 0x80, 0xD0, 0x34, 0x14, 0xFD, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x8E, 0x16, 0x33, 0x03, 0x60,
  0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x58, 0x0A, 0x82, 0x4F, 0x80, 0x0F,
  0x08, 0x48, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x03, 0xF0, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x0E, 0x26, 0x35,
  0x82, 0xA0, 0x3C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x68, 0x0D, 0x82, 0x9F,
  0x90, 0x1E, 0x0C, 0x44, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x7F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02,
  0x04, 0x7E, 0x0F, 0x84, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x3E,
  0x68, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x1F, 0x26,
  0x35, 0x01, 0xA0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x68, 0x0C, 0x82,
  0x9F, 0x90, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x60,
  0xC3, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x8E, 0x2C, 0x4C, 0x0B, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x74, 0x01, 0x55, 0x55, 0x55, 0x55, 0x54, 0x13, 0x10, 0x00, 0x01,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x2C, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x81,
  0x40, 0xA0, 0x90, 0x88, 0x44, 0x42, 0x21, 0x20, 0xB0, 0x58, 0x32, 0x11,
  0x08, 0x44, 0x22, 0x09, 0x04, 0x82, 0x40, 0xA0, 0x50, 0x10, 0xFF, 0xFF,
  0xFF, 0xF0, 0x9E, 0x1E, 0x51, 0x91, 0xB0, 0x50, 0x50, 0x28, 0x18, 0x08,
  0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x10, 0x9E, 0x2C, 0x4C,
  0x0B, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x1F, 0x06,
  0x31, 0x01, 0x20, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x48, 0x08, 0x82,
  0x0F, 0x80, 0x9E, 0x16, 0x33, 0x03, 0x60, 0x28, 0x05, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02,
  0xC0, 0x58, 0x0A, 0x82, 0x4F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x0E, 0x26, 0x35, 0x82, 0xA0, 0x38,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x40, 0x68, 0x0C, 0x82, 0x8F, 0x90, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x9E, 0xDC,
  0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x1F, 0x10, 0x50, 0x08, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x4F, 0xE0,
  0x20, 0x82, 0x08, 0x7E, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xF0, 0xEF, 0xD0, 0x80, 0x30, 0x09, 0x01, 0x20, 0x24, 0x04,
  0x81, 0x08, 0x21, 0x04, 0x20, 0x84, 0x30, 0x44, 0x08, 0x81, 0x10, 0x22,
  0x04, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x30, 0x02, 0x00, 0x80, 0x40, 0x28,
  0x08, 0x09, 0x01, 0x81, 0x20, 0x50, 0x24, 0x0A, 0x04, 0x81, 0x40, 0x88,
  0x28, 0x21, 0x04, 0x84, 0x21, 0x10, 0x84, 0x22, 0x10, 0x44, 0x44, 0x08,
  0x88, 0x81, 0x20, 0x90, 0x24, 0x12, 0x04, 0x82, 0x40, 0x50, 0x50, 0x0A,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x02, 0x02, 0x00, 0x80, 0x70, 0x24,
  0x09, 0x04, 0x21, 0x08, 0x41, 0x20, 0x48, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x12, 0x04, 0x82, 0x30, 0x84, 0x41, 0x10, 0x28, 0x0A, 0x01, 0x40, 0x28,
  0x05, 0x00, 0x90, 0x12, 0x04, 0x40, 0x88, 0x10, 0x82, 0x10, 0x82, 0x10,
  0x42, 0x04, 0x40, 0x90, 0x12, 0x02, 0x40, 0x28, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x0E, 0x00, 0x7F, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0xFF, 0x07, 0x86,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x80, 0x80, 0x41, 0xC0, 0x30, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x07, 0x06, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0xC1, 0xC0, 0x10, 0x03, 0x70, 0x60, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_Thin37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 26, 7, 3, -26 },
  { 8, 6, 9, 11, 2, -26 },
  { 15, 14, 26, 16, 1, -26 },
  { 61, 12, 30, 15, 1, -28 },
  { 106, 18, 27, 21, 2, -27 },
  { 167, 13, 27, 14, 1, -27 },
  { 211, 2, 9, 6, 2, -26 },
  { 214, 6, 32, 10, 2, -26 },
  { 238, 7, 32, 10, 1, -26 },
  { 266, 9, 9, 13, 2, -28 },
  { 277, 13, 17, 15, 1, -22 },
  { 305, 3, 9, 7, 1, -4 },
  { 309, 8, 1, 10, 1, -11 },
  { 310, 2, 2, 7, 2, -2 },
  { 311, 10, 26, 12, 1, -26 },
  { 344, 11, 27, 15, 2, -27 },
  { 382, 6, 26, 15, 3, -26 },
  { 402, 12, 27, 15, 1, -27 },
  { 443, 12, 27, 15, 1, -27 },
  { 484, 13, 27, 15, 1, -27 },
  { 528, 11, 26, 15, 2, -26 },
  { 564, 11, 28, 15, 2, -27 },
  { 603, 11, 26, 15, 2, -26 },
  { 639, 12, 27, 15, 1, -27 },
  { 680, 12, 27, 15, 1, -27 },
  { 721, 2, 20, 7, 2, -20 },
  { 726, 3, 25, 7, 1, -20 },
  { 736, 13, 16, 15, 1, -21 },
  { 762, 13, 9, 15, 1, -18 },
  { 777, 13, 16, 15, 1, -21 },
  { 803, 8, 27, 10, 1, -27 },
  { 830, 18, 30, 22, 2, -27 },
  { 898, 14, 26, 14, 0, -26 },
  { 944, 11, 26, 16, 3, -26 },
  { 980, 12, 27, 15, 2, -27 },
  { 1021, 12, 26, 17, 3, -26 },
  { 1060, 9, 26, 14, 3, -26 },
  { 1090, 9, 26, 13, 3, -26 },
  { 1120, 15, 27, 19, 2, -27 },
  { 1171, 12, 26, 18, 3, -26 },
  { 1210, 6, 26, 8, 1, -26 },
  { 1230, 6, 32, 7, -2, -26 },
  { 1254, 11, 26, 14, 3, -26 },
  { 1290, 9, 26, 13, 3, -26 },
  { 1320, 18, 26, 24, 3, -26 },
  { 1379, 13, 26, 19, 3, -26 },
  { 1422, 15, 27, 19, 2, -27 },
  { 1473, 10, 26, 15, 3, -26 },
  { 1506, 15, 33, 19, 2, -27 },
  { 1568, 11, 26, 15, 3, -26 },
  { 1604, 11, 27, 14, 2, -27 },
  { 1642, 12, 26, 12, 0, -26 },
  { 1681, 12, 26, 18, 3, -26 },
  { 1720, 14, 26, 14, 0, -26 },
  { 1766, 24, 26, 24, 0, -26 },
  { 1844, 12, 26, 12, 0, -26 },
  { 1883, 12, 26, 12, 0, -26 },
  { 1922, 10, 26, 12, 1, -26 },
  { 1955, 7, 32, 11, 3, -26 },
  { 1983, 10, 26, 12, 1, -26 },
  { 2016, 7, 32, 11, 1, -26 },
  { 2044, 13, 12, 15, 1, -26 },
  { 2064, 15, 1, 15, 0, 3 },
  { 2066, 6, 6, 8, 1, -28 },
  { 2071, 10, 20, 14, 1, -20 },
  { 2096, 11, 28, 16, 3, -28 },
  { 2135, 9, 20, 12, 2, -20 },
  { 2158, 11, 28, 16, 2, -28 },
  { 2197, 10, 20, 14, 2, -20 },
  { 2222, 9, 28, 8, 0, -28 },
  { 2254, 11, 29, 16, 2, -20 },
  { 2294, 10, 28, 15, 3, -28 },
  { 2329, 2, 27, 7, 2, -27 },
  { 2336, 4, 36, 7, 0, -27 },
  { 2354, 9, 28, 12, 3, -28 },
  { 2386, 1, 28, 6, 3, -28 },
  { 2390, 17, 20, 23, 3, -20 },
  { 2433, 10, 20, 15, 3, -20 },
  { 2458, 11, 20, 15, 2, -20 },
  { 2486, 11, 29, 16, 3, -20 },
  { 2526, 11, 29, 16, 2, -20 },
  { 2566, 6, 20, 10, 3, -20 },
  { 2581, 9, 20, 12, 1, -20 },
  { 2604, 6, 24, 8, 1, -24 },
  { 2622, 9, 20, 15, 3, -20 },
  { 2645, 11, 20, 11, 0, -20 },
  { 2673, 19, 20, 19, 0, -20 },
  { 2721, 10, 20, 12, 1, -20 },
  { 2746, 11, 29, 12, 0, -20 },
  { 2786, 8, 20, 10, 1, -20 },
  { 2806, 9, 32, 13, 2, -26 },
  { 2842, 1, 37, 14, 6, -28 },
  { 2847, 9, 32, 13, 2, -26 },
  { 2883, 13, 3, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Thin37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN37PT7B_H_
