#ifndef _NOTOSANS_EXTRACONDENSED_THIN57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin57pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x90, 0x00, 0x00, 0xBF, 0xE0, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x00, 0xC0,
  0x40, 0x02, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0xC0,
  0x02, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x80, 0x06,
  0x02, 0x00, 0x10, 0x08, 0x00, 0x40, 0x20, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF0, 0x10, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x04, 0x00,
  0x30, 0x10, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20,
  0x10, 0x00, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x0F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x04, 0x02, 0x00, 0x10, 0x08, 0x00, 0x40, 0x20, 0x01,
  0x00, 0x80, 0x04, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01,
  0x00, 0x08, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x03, 0xFE,
  0x01, 0xE8, 0xF8, 0x71, 0x03, 0x18, 0x20, 0x03, 0x04, 0x00, 0xC0, 0x80,
  0x18, 0x10, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x08, 0x01, 0x01, 0x00,
  0x30, 0x20, 0x06, 0x04, 0x00, 0x40, 0x80, 0x0C, 0x10, 0x00, 0xC2, 0x00,
  0x0C, 0x40, 0x00, 0xE8, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x05, 0xC0,
  0x00, 0x9C, 0x00, 0x10, 0xE0, 0x02, 0x0E, 0x00, 0x40, 0xC0, 0x08, 0x0C,
  0x01, 0x00, 0x80, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x0C, 0x01, 0x01, 0x20, 0x20, 0xE7,
  0x04, 0x38, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x18, 0x06, 0x20, 0x02, 0x01,
  0x86, 0x00, 0xC0, 0x20, 0x40, 0x18, 0x0C, 0x0C, 0x02, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x04, 0x02, 0x02, 0x00, 0x80, 0x40, 0x40, 0x10,
  0x0C, 0x18, 0x02, 0x01, 0x82, 0x00, 0x40, 0x30, 0x40, 0x08, 0x06, 0x18,
  0x01, 0x00, 0xC2, 0x00, 0x20, 0x18, 0x40, 0x04, 0x03, 0x18, 0x00, 0x80,
  0x42, 0x0E, 0x10, 0x08, 0x46, 0x32, 0x01, 0x18, 0x82, 0x60, 0x22, 0x30,
  0x6C, 0x0C, 0x44, 0x04, 0x81, 0x18, 0x80, 0x98, 0x62, 0x30, 0x19, 0x98,
  0x46, 0x03, 0x1E, 0x18, 0xC0, 0x60, 0x02, 0x18, 0x0C, 0x00, 0x42, 0x00,
  0x80, 0x18, 0x40, 0x10, 0x02, 0x08, 0x02, 0x00, 0x41, 0x00, 0x40, 0x18,
  0x20, 0x08, 0x02, 0x04, 0x01, 0x00, 0x40, 0xC0, 0x60, 0x18, 0x18, 0x0C,
  0x03, 0x03, 0x01, 0x80, 0x40, 0x20, 0x20, 0x18, 0x04, 0x04, 0x03, 0x00,
  0xC1, 0x80, 0x40, 0x08, 0x30, 0x18, 0x01, 0x8C, 0x03, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x80, 0x03, 0xE0, 0x00, 0x63, 0x00, 0x08, 0x10, 0x01, 0x81,
  0x80, 0x18, 0x18, 0x01, 0x00, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x10,
  0x08, 0x01, 0x00, 0x80, 0x18, 0x08, 0x01, 0x81, 0x80, 0x08, 0x18, 0x00,
  0x81, 0x00, 0x0C, 0x30, 0x00, 0x42, 0x00, 0x06, 0x60, 0x00, 0x2C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0D, 0x80, 0x01, 0x88, 0x00, 0x30, 0xC0,
  0x02, 0x04, 0x00, 0x60, 0x60, 0x24, 0x02, 0x06, 0xC0, 0x30, 0x6C, 0x01,
  0x06, 0x80, 0x08, 0x48, 0x00, 0xC4, 0x80, 0x04, 0xC8, 0x00, 0x6C, 0x80,
  0x02, 0x88, 0x00, 0x38, 0xC0, 0x01, 0x0C, 0x00, 0x38, 0x40, 0x06, 0xC6,
  0x00, 0x44, 0x30, 0x0C, 0x63, 0x83, 0x82, 0x0F, 0xE0, 0x30, 0x10, 0x00,
  0xFE, 0xAA, 0xAA, 0xA8, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01,
  0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x82, 0x07, 0x88, 0x61, 0xAE, 0x01, 0xC0,
  0x07, 0x00, 0x12, 0x00, 0x8C, 0x04, 0x10, 0x20, 0x21, 0x80, 0x40, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x23, 0x18, 0x8C, 0x00, 0xFF, 0xF8,
  0xDF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x07, 0x1C, 0x06, 0x02,
  0x02, 0x01, 0x83, 0x00, 0x61, 0x00, 0x31, 0x80, 0x08, 0xC0, 0x06, 0x40,
  0x03, 0x20, 0x01, 0xB0, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x16, 0x00, 0x0A,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x16, 0x00, 0x0B, 0x00, 0x04,
  0x80, 0x06, 0x40, 0x03, 0x30, 0x01, 0x98, 0x00, 0x84, 0x00, 0xC3, 0x00,
  0x60, 0x80, 0x20, 0x60, 0x30, 0x1C, 0x70, 0x07, 0xF0, 0x00, 0x00, 0xC0,
  0x70, 0x3C, 0x1B, 0x0C, 0xC6, 0x37, 0x0F, 0x83, 0x40, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x0F, 0xF0, 0x0F, 0x07, 0x06, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0x0F, 0x0F, 0x06, 0x00, 0xE3, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC8, 0x00, 0x63, 0x80, 0x70, 0x3F, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60, 0x00, 0x33, 0x00, 0x01, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x41, 0x80, 0x06,
  0x0C, 0x00, 0x20, 0x60, 0x03, 0x03, 0x00, 0x10, 0x18, 0x01, 0x80, 0xC0,
  0x08, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x02, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x80, 0x06, 0x0C,
  0x00, 0x30, 0x40, 0x01, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x7F, 0xFE,
  0x3F, 0xFF, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xF0,
  0x3E, 0x0E, 0x08, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x32, 0x00, 0x71, 0x80, 0x70, 0x7F,
  0xE0, 0x01, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xE7, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC3, 0xE0, 0x47, 0xFC, 0x26, 0x03, 0x16, 0x00, 0xCA, 0x00,
  0x27, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x4C, 0x00, 0x66, 0x00, 0x31, 0x80,
  0x10, 0xC0, 0x18, 0x30, 0x18, 0x0F, 0xF8, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0x87, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x09, 0x80, 0x02, 0x60, 0x00, 0xD8, 0x00,
  0x26, 0x00, 0x09, 0x80, 0x02, 0x20, 0x01, 0x8C, 0x00, 0x61, 0x00, 0x30,
  0x60, 0x18, 0x0C, 0x0C, 0x01, 0xC6, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x03,
  0xB0, 0x01, 0x86, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30, 0x03, 0x18, 0x00,
  0x66, 0x00, 0x09, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0D, 0x00, 0x03, 0x60,
  0x01, 0x88, 0x00, 0x63, 0x80, 0x30, 0x70, 0x38, 0x07, 0xFC, 0x00, 0x10,
  0x00, 0x07, 0xF0, 0x07, 0x0C, 0x06, 0x03, 0x06, 0x00, 0xC2, 0x00, 0x23,
  0x00, 0x19, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xA0, 0x00, 0xD0, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x39, 0x80, 0x14,
  0x40, 0x12, 0x38, 0x39, 0x07, 0xF0, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x40, 0xE0, 0x3F, 0xC0, 0x03, 0x00, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x7F, 0x80, 0x39, 0xCE, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC6,
  0x23, 0x18, 0xC4, 0x63, 0x10, 0x8C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0x87, 0x0E, 0x20, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x00, 0x42, 0x00, 0x7F, 0x03, 0x30, 0x0E, 0x10, 0x19, 0x80, 0x60, 0x80,
  0xC8, 0x06, 0x04, 0x02, 0x40, 0x20, 0x20, 0x16, 0x03, 0x01, 0x00, 0xB0,
  0x10, 0x08, 0x05, 0x80, 0x80, 0x40, 0x2C, 0x0C, 0x02, 0x01, 0xE0, 0x60,
  0x10, 0x0F, 0x03, 0x01, 0x80, 0x78, 0x18, 0x0C, 0x02, 0xC0, 0xC0, 0x60,
  0x16, 0x06, 0x03, 0x00, 0xB0, 0x30, 0x18, 0x05, 0x81, 0x80, 0xC0, 0x6C,
  0x0C, 0x06, 0x03, 0x60, 0x20, 0x30, 0x1B, 0x01, 0x82, 0x80, 0x88, 0x0C,
  0x16, 0x0C, 0x40, 0x31, 0x90, 0xC3, 0x00, 0xF8, 0xFC, 0x18, 0x03, 0x00,
  0x80, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x20, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x64, 0x00, 0x03, 0x20, 0x00,
  0x11, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x02, 0x0C,
  0x00, 0x10, 0x60, 0x00, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x40, 0x02,
  0x03, 0x00, 0x10, 0x18, 0x01, 0x80, 0x40, 0x0C, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x30, 0x02, 0x01, 0x80, 0x10, 0x0F, 0xFF, 0xC0, 0x40,
  0x06, 0x06, 0x00, 0x10, 0x30, 0x00, 0x81, 0x80, 0x06, 0x08, 0x00, 0x30,
  0xC0, 0x01, 0x86, 0x00, 0x04, 0x30, 0x00, 0x21, 0x00, 0x01, 0x88, 0x00,
  0x0C, 0xC0, 0x00, 0x26, 0x00, 0x01, 0x20, 0x00, 0x0D, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF, 0xE0, 0x3F, 0xFF, 0x0C, 0x00, 0xE3,
  0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02, 0xC0,
  0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x01, 0x8C, 0x01, 0xC3,
  0xFF, 0xC0, 0xC0, 0x3C, 0x30, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x06, 0xC0,
  0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x63, 0x01, 0xF0, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x3C, 0x1C, 0x0C, 0x00, 0x83, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x03, 0x00, 0x7F, 0xC0, 0x00, 0x80, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xC0,
  0x1C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0x8C,
  0x00, 0x0C, 0xC0, 0x00, 0x4C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0x8C, 0x00, 0x18,
  0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x1F, 0x80, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x07, 0xFF, 0xEC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xB0,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x01, 0xE0, 0xF8, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x10, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x58, 0x00, 0x00, 0x90, 0x00, 0x01, 0x30, 0x00, 0x02, 0x60, 0x00,
  0x04, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x20, 0xC0, 0x00,
  0x40, 0xC0, 0x00, 0x80, 0xE0, 0x0F, 0x00, 0x7F, 0xF8, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x20, 0xFF, 0x3E, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x03, 0x7F, 0x9F, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0x4C, 0x00, 0x33,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0x83, 0x00, 0x60, 0xC0,
  0x30, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0x30, 0x60,
  0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x31, 0x80, 0x0C, 0xE0, 0x03,
  0x38, 0x00, 0xDB, 0x00, 0x34, 0xC0, 0x0F, 0x18, 0x03, 0x86, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x0C, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x30, 0x0C,
  0x0C, 0x01, 0x03, 0x00, 0x60, 0xC0, 0x08, 0x30, 0x03, 0x0C, 0x00, 0x43,
  0x00, 0x18, 0xC0, 0x02, 0x30, 0x00, 0xCC, 0x00, 0x13, 0x00, 0x06, 0xC0,
  0x00, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE8, 0x00, 0x00, 0x2F,
  0x60, 0x00, 0x01, 0x7B, 0x00, 0x00, 0x1B, 0xC8, 0x00, 0x00, 0xDE, 0x40,
  0x00, 0x04, 0xF3, 0x00, 0x00, 0x67, 0x88, 0x00, 0x03, 0x3C, 0x40, 0x00,
  0x11, 0xE3, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x0C, 0x78, 0x40, 0x00, 0x43,
  0xC3, 0x00, 0x02, 0x1E, 0x18, 0x00, 0x30, 0xF0, 0x40, 0x01, 0x07, 0x82,
  0x00, 0x08, 0x3C, 0x18, 0x00, 0xC1, 0xE0, 0x40, 0x06, 0x0F, 0x02, 0x00,
  0x20, 0x78, 0x18, 0x03, 0x03, 0xC0, 0xC0, 0x18, 0x1E, 0x02, 0x00, 0x80,
  0xF0, 0x18, 0x0C, 0x07, 0x80, 0xC0, 0x60, 0x3C, 0x02, 0x02, 0x01, 0xE0,
  0x18, 0x10, 0x0F, 0x00, 0xC1, 0x80, 0x78, 0x02, 0x0C, 0x03, 0xC0, 0x10,
  0x40, 0x1E, 0x00, 0xC6, 0x00, 0xF0, 0x06, 0x30, 0x07, 0x80, 0x11, 0x00,
  0x3C, 0x00, 0xD8, 0x01, 0xE0, 0x06, 0xC0, 0x0F, 0x00, 0x14, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x18, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xD0, 0x00, 0x1D, 0x80, 0x01, 0xD8, 0x00,
  0x1C, 0x80, 0x01, 0xCC, 0x00, 0x1C, 0x40, 0x01, 0xC6, 0x00, 0x1C, 0x20,
  0x01, 0xC3, 0x00, 0x1C, 0x10, 0x01, 0xC1, 0x00, 0x1C, 0x18, 0x01, 0xC0,
  0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x40, 0x1C, 0x06, 0x01, 0xC0, 0x20, 0x1C,
  0x03, 0x01, 0xC0, 0x30, 0x1C, 0x01, 0x01, 0xC0, 0x18, 0x1C, 0x00, 0x81,
  0xC0, 0x0C, 0x1C, 0x00, 0x41, 0xC0, 0x06, 0x1C, 0x00, 0x21, 0xC0, 0x03,
  0x1C, 0x00, 0x31, 0xC0, 0x01, 0x1C, 0x00, 0x19, 0xC0, 0x00, 0x9C, 0x00,
  0x0D, 0xC0, 0x00, 0x5C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0x00, 0xFF, 0x00, 0x07, 0x07, 0x00, 0x18, 0x03, 0x00, 0x60,
  0x03, 0x01, 0x80, 0x03, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x10, 0x00,
  0x04, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x58, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x98, 0x00, 0x01, 0x30, 0x00, 0x06, 0x20, 0x00,
  0x0C, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x60, 0x80, 0x00, 0xC1, 0x80, 0x03,
  0x01, 0x80, 0x04, 0x01, 0x80, 0x18, 0x01, 0xC0, 0xE0, 0x01, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x30, 0x0F, 0x18, 0x01, 0xCC,
  0x00, 0x66, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x05, 0x80,
  0x02, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x98, 0x00, 0xCC, 0x00, 0xC6,
  0x01, 0xC3, 0xFF, 0xC1, 0xFE, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x07,
  0x00, 0x18, 0x03, 0x00, 0x60, 0x03, 0x01, 0x80, 0x03, 0x02, 0x00, 0x02,
  0x0C, 0x00, 0x06, 0x18, 0x00, 0x04, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00, 0x58, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0x98, 0x00, 0x01,
  0x30, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x10, 0xC0, 0x00, 0x60,
  0x80, 0x00, 0xC1, 0x80, 0x03, 0x01, 0x80, 0x04, 0x01, 0x80, 0x18, 0x01,
  0x80, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0xFF, 0x80,
  0x3F, 0xFC, 0x0C, 0x01, 0xC3, 0x00, 0x38, 0xC0, 0x02, 0x30, 0x00, 0xCC,
  0x00, 0x13, 0x00, 0x04, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x03,
  0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x38, 0x3F, 0xFC, 0x0F,
  0xF8, 0x03, 0x03, 0x00, 0xC0, 0x40, 0x30, 0x18, 0x0C, 0x02, 0x03, 0x00,
  0xC0, 0xC0, 0x10, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x0C,
  0x30, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x08, 0xC0, 0x03, 0x30, 0x00, 0x4C,
  0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xC0, 0x03, 0xFE, 0x03, 0xC1, 0xE1,
  0xC0, 0x08, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC8, 0x00, 0x63, 0x80,
  0x70, 0x7F, 0xF8, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x70,
  0x07, 0xFE, 0x00, 0x04, 0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00,
  0x04, 0x80, 0x00, 0x24, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x84,
  0x00, 0x04, 0x20, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x10, 0x20, 0x00,
  0x81, 0x00, 0x04, 0x08, 0x00, 0x60, 0x60, 0x03, 0x01, 0x00, 0x10, 0x08,
  0x00, 0x80, 0x40, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x40, 0x02, 0x02, 0x00, 0x10,
  0x30, 0x00, 0x81, 0x80, 0x06, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00,
  0x04, 0x30, 0x00, 0x31, 0x80, 0x01, 0x88, 0x00, 0x04, 0x40, 0x00, 0x26,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x1A, 0x00, 0x03,
  0x00, 0x00, 0x90, 0x00, 0x1C, 0x00, 0x04, 0xC0, 0x00, 0xE0, 0x00, 0x66,
  0x00, 0x07, 0x00, 0x03, 0x30, 0x00, 0x28, 0x00, 0x10, 0x80, 0x03, 0x40,
  0x00, 0x84, 0x00, 0x1B, 0x00, 0x0C, 0x30, 0x00, 0xD8, 0x00, 0x61, 0x80,
  0x04, 0xC0, 0x03, 0x0C, 0x00, 0x22, 0x00, 0x10, 0x20, 0x03, 0x10, 0x00,
  0x81, 0x00, 0x18, 0xC0, 0x0C, 0x0C, 0x00, 0xC6, 0x00, 0x60, 0x60, 0x04,
  0x30, 0x02, 0x01, 0x00, 0x20, 0x80, 0x10, 0x08, 0x03, 0x04, 0x01, 0x80,
  0x60, 0x18, 0x20, 0x0C, 0x03, 0x00, 0xC1, 0x80, 0x60, 0x18, 0x04, 0x0C,
  0x02, 0x00, 0x40, 0x20, 0x20, 0x10, 0x02, 0x03, 0x01, 0x01, 0x80, 0x18,
  0x18, 0x08, 0x0C, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x06, 0x04, 0x03, 0x02,
  0x00, 0x10, 0x20, 0x08, 0x10, 0x00, 0x83, 0x00, 0x41, 0x80, 0x06, 0x18,
  0x02, 0x0C, 0x00, 0x30, 0xC0, 0x18, 0x40, 0x01, 0x84, 0x00, 0xC2, 0x00,
  0x04, 0x20, 0x02, 0x30, 0x00, 0x33, 0x00, 0x11, 0x80, 0x01, 0x98, 0x00,
  0x8C, 0x00, 0x0C, 0xC0, 0x06, 0x40, 0x00, 0x24, 0x00, 0x32, 0x00, 0x01,
  0x20, 0x00, 0xB0, 0x00, 0x0D, 0x00, 0x05, 0x80, 0x00, 0x78, 0x00, 0x28,
  0x00, 0x03, 0xC0, 0x01, 0x40, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xB0, 0x00, 0xC8, 0x00, 0x46, 0x00, 0x63,
  0x00, 0x30, 0x80, 0x10, 0x60, 0x18, 0x10, 0x0C, 0x08, 0x04, 0x06, 0x06,
  0x01, 0x02, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x10, 0x80, 0x0C, 0xC0, 0x02,
  0x40, 0x01, 0x20, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x05, 0x80, 0x02, 0x40, 0x03, 0x20, 0x01, 0x18, 0x01, 0x84,
  0x00, 0xC3, 0x00, 0x41, 0x80, 0x60, 0x40, 0x20, 0x30, 0x30, 0x18, 0x18,
  0x04, 0x08, 0x03, 0x0C, 0x01, 0x84, 0x00, 0x46, 0x00, 0x33, 0x00, 0x19,
  0x00, 0x05, 0x80, 0x03, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xF0, 0x00, 0x34,
  0x00, 0x09, 0x80, 0x06, 0x60, 0x01, 0x88, 0x00, 0x43, 0x00, 0x30, 0xC0,
  0x0C, 0x10, 0x02, 0x06, 0x01, 0x81, 0x80, 0x60, 0x20, 0x10, 0x0C, 0x0C,
  0x03, 0x03, 0x00, 0x40, 0x80, 0x18, 0x60, 0x06, 0x18, 0x00, 0x84, 0x00,
  0x33, 0x00, 0x0C, 0xC0, 0x01, 0x20, 0x00, 0x58, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0,
  0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F,
  0xFC, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x01, 0xB0, 0x00,
  0x08, 0x80, 0x00, 0xC6, 0x00, 0x04, 0x10, 0x00, 0x60, 0xC0, 0x02, 0x02,
  0x00, 0x30, 0x18, 0x01, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x80, 0x18, 0x0C,
  0x00, 0x60, 0x40, 0x03, 0x06, 0x00, 0x0C, 0x20, 0x00, 0x63, 0x00, 0x01,
  0x10, 0x00, 0x0D, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x03, 0x01, 0xC0, 0x3F,
  0xE0, 0xE0, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x3F, 0x83, 0xC3, 0x1C, 0x06, 0x60, 0x0D, 0x80, 0x1A, 0x00, 0x34, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x2A,
  0x00, 0x56, 0x01, 0x26, 0x06, 0x47, 0xF8, 0x81, 0x80, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x31, 0xFE, 0x0C, 0xC0, 0xC3, 0x60, 0x18, 0xF0, 0x03, 0x38,
  0x00, 0x4E, 0x00, 0x13, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x2C, 0x00,
  0x0B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x02, 0xC0, 0x00, 0xB0,
  0x00, 0x2C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0xB8, 0x00, 0x4A, 0x00,
  0x32, 0xC0, 0x08, 0x98, 0x06, 0x23, 0x07, 0x08, 0x7F, 0x80, 0x02, 0x00,
  0x00, 0x40, 0x1F, 0xF0, 0xE0, 0x86, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x10, 0x7F, 0xC0, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x08, 0x08,
  0x3F, 0x84, 0x70, 0x62, 0x20, 0x09, 0x30, 0x06, 0xB0, 0x01, 0x58, 0x00,
  0x68, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x34, 0x00, 0x1A, 0x00, 0x1D, 0x80, 0x0A, 0x40, 0x0D, 0x30, 0x0C, 0x8C,
  0x0C, 0x43, 0xFC, 0x20, 0x10, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x1C, 0x18,
  0x30, 0x0C, 0x30, 0x04, 0x60, 0x06, 0x60, 0x02, 0x40, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x02, 0x0C, 0x06, 0x07, 0xFC, 0x00, 0x60, 0x00, 0xC0,
  0x3F, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0xFF, 0x80, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x00, 0x80, 0x07, 0xFC, 0x47, 0x07, 0x26, 0x00,
  0x92, 0x00, 0x2B, 0x00, 0x15, 0x00, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x40, 0x01, 0xA0, 0x01, 0x58,
  0x00, 0xA4, 0x00, 0xD3, 0x00, 0xC8, 0xC0, 0xC4, 0x3F, 0xC2, 0x01, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x40, 0x03, 0x18, 0x07, 0x0F,
  0xFF, 0x00, 0x7C, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x1C, 0x18, 0xFE, 0x33, 0x06, 0x6C, 0x06, 0xF0, 0x05,
  0xC0, 0x0E, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x08, 0xDF, 0x20, 0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x0C, 0x1C, 0x30, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x41, 0x9E, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0xC0, 0x23,
  0x01, 0x8C, 0x0C, 0x30, 0x20, 0xC1, 0x83, 0x0C, 0x0C, 0x30, 0x31, 0x80,
  0xC6, 0x03, 0x38, 0x0D, 0xA0, 0x34, 0xC0, 0xF1, 0x02, 0x86, 0x0C, 0x18,
  0x30, 0x20, 0xC0, 0xC3, 0x01, 0x0C, 0x06, 0x30, 0x08, 0xC0, 0x23, 0x00,
  0xCC, 0x01, 0x30, 0x06, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x0C,
  0x11, 0xFC, 0x0F, 0xE2, 0x60, 0xC3, 0x06, 0x48, 0x0C, 0xC0, 0x6A, 0x00,
  0x90, 0x0D, 0x40, 0x1C, 0x00, 0xB0, 0x03, 0x80, 0x16, 0x00, 0x30, 0x03,
  0xC0, 0x04, 0x00, 0x78, 0x00, 0x80, 0x0F, 0x00, 0x10, 0x01, 0xE0, 0x02,
  0x00, 0x3C, 0x00, 0x40, 0x07, 0x80, 0x08, 0x00, 0xF0, 0x01, 0x00, 0x1E,
  0x00, 0x20, 0x03, 0xC0, 0x04, 0x00, 0x78, 0x00, 0x80, 0x0F, 0x00, 0x10,
  0x01, 0xE0, 0x02, 0x00, 0x3C, 0x00, 0x40, 0x07, 0x80, 0x08, 0x00, 0xF0,
  0x01, 0x00, 0x1E, 0x00, 0x20, 0x03, 0xC0, 0x04, 0x00, 0x78, 0x00, 0x80,
  0x0F, 0x00, 0x10, 0x01, 0xE0, 0x02, 0x00, 0x3C, 0x00, 0x40, 0x07, 0x80,
  0x08, 0x00, 0xF0, 0x01, 0x00, 0x18, 0x00, 0xC1, 0x0F, 0xF2, 0x30, 0x74,
  0xC0, 0x6B, 0x00, 0x74, 0x00, 0xE8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x80, 0x00, 0x80, 0x07, 0xFC, 0x07, 0x07, 0x06,
  0x00, 0xC2, 0x00, 0x23, 0x00, 0x19, 0x00, 0x04, 0x80, 0x02, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x40, 0x01, 0x20, 0x00,
  0x98, 0x00, 0xC4, 0x00, 0x43, 0x00, 0x60, 0xE0, 0xE0, 0x1F, 0xE0, 0x01,
  0x00, 0x00, 0xC0, 0x21, 0xFE, 0x08, 0xC0, 0xC2, 0x60, 0x18, 0x90, 0x03,
  0x28, 0x00, 0xCA, 0x00, 0x13, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x2C,
  0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00,
  0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0xA8, 0x00, 0x4E,
  0x00, 0x33, 0x40, 0x08, 0xD8, 0x06, 0x33, 0x07, 0x0C, 0x7F, 0x83, 0x02,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x03, 0xFC, 0x47, 0x07, 0x23, 0x00,
  0x93, 0x00, 0x6B, 0x00, 0x15, 0x80, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x40, 0x01, 0xA0, 0x01, 0x58,
  0x00, 0xA6, 0x00, 0xD3, 0x00, 0xC8, 0xE0, 0xC4, 0x3F, 0xC2, 0x01, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x01, 0x21, 0xF8, 0xC6, 0x60, 0x90, 0x2C, 0x0A, 0x02, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x03, 0x80, 0x7F, 0xE3, 0x80, 0xD8, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x80, 0x1B, 0x81, 0xC7, 0xFE, 0x01,
  0x80, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x83, 0xFF, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0F, 0xC0,
  0x40, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x15, 0x00, 0x2B, 0x00, 0x93, 0x07, 0x23, 0xF8, 0x40, 0xC0, 0x00,
  0xC0, 0x01, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x02, 0x20, 0x02,
  0x20, 0x06, 0x30, 0x06, 0x30, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x18, 0x0C,
  0x18, 0x08, 0x18, 0x08, 0x08, 0x18, 0x08, 0x18, 0x0C, 0x10, 0x0C, 0x10,
  0x04, 0x30, 0x04, 0x30, 0x06, 0x20, 0x06, 0x20, 0x02, 0x20, 0x02, 0x60,
  0x03, 0x60, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x02, 0xC0, 0x0E, 0x00, 0x2C, 0x00,
  0xE0, 0x06, 0x40, 0x0B, 0x00, 0x64, 0x00, 0xB0, 0x04, 0x40, 0x09, 0x00,
  0x46, 0x01, 0x90, 0x04, 0x60, 0x19, 0x00, 0xC2, 0x01, 0x18, 0x0C, 0x20,
  0x11, 0x80, 0x83, 0x03, 0x08, 0x08, 0x30, 0x30, 0x81, 0x81, 0x03, 0x0C,
  0x18, 0x10, 0x20, 0xC1, 0x01, 0x02, 0x0C, 0x10, 0x18, 0x60, 0x41, 0x01,
  0x86, 0x04, 0x30, 0x08, 0x40, 0x63, 0x00, 0x84, 0x06, 0x20, 0x0C, 0x40,
  0x22, 0x00, 0xCC, 0x02, 0x60, 0x04, 0xC0, 0x26, 0x00, 0x48, 0x03, 0x40,
  0x04, 0x80, 0x34, 0x00, 0x78, 0x01, 0x40, 0x03, 0x80, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x40, 0x03, 0x60,
  0x06, 0x20, 0x06, 0x30, 0x0C, 0x10, 0x0C, 0x18, 0x08, 0x08, 0x18, 0x0C,
  0x10, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x04,
  0x20, 0x0C, 0x30, 0x0C, 0x10, 0x18, 0x18, 0x18, 0x18, 0x10, 0x08, 0x30,
  0x0C, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0x40,
  0x01, 0x40, 0x03, 0x60, 0x03, 0x60, 0x02, 0x20, 0x02, 0x20, 0x06, 0x30,
  0x06, 0x30, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x18, 0x0C, 0x18, 0x08, 0x08,
  0x08, 0x08, 0x18, 0x0C, 0x18, 0x0C, 0x10, 0x04, 0x10, 0x04, 0x30, 0x06,
  0x30, 0x06, 0x20, 0x02, 0x20, 0x02, 0x60, 0x03, 0x60, 0x03, 0x40, 0x01,
  0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0xFF, 0xE0, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x08, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x03, 0xF0, 0x1C,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0xF8, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xF8, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7C, 0x01, 0xF0,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0x04, 0x00, 0x07, 0xF0, 0x07, 0x83,
  0x01, 0xC0, 0x3C, 0xE8, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Thin57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 41, 11, 4, -41 },
  { 17, 9, 15, 17, 4, -41 },
  { 34, 22, 41, 24, 1, -41 },
  { 147, 19, 46, 22, 2, -43 },
  { 257, 27, 42, 33, 3, -41 },
  { 399, 20, 42, 22, 2, -41 },
  { 504, 2, 15, 9, 4, -41 },
  { 508, 10, 50, 15, 3, -41 },
  { 571, 10, 50, 15, 2, -41 },
  { 634, 14, 14, 19, 3, -43 },
  { 659, 19, 26, 23, 2, -33 },
  { 721, 5, 13, 10, 2, -6 },
  { 730, 13, 1, 15, 1, -16 },
  { 732, 3, 4, 10, 4, -4 },
  { 734, 17, 41, 19, 1, -41 },
  { 822, 17, 41, 22, 3, -41 },
  { 910, 10, 41, 22, 4, -41 },
  { 962, 18, 41, 22, 2, -41 },
  { 1055, 18, 42, 22, 2, -41 },
  { 1150, 21, 41, 22, 1, -41 },
  { 1258, 17, 42, 22, 3, -41 },
  { 1348, 17, 42, 22, 3, -41 },
  { 1438, 17, 41, 22, 3, -41 },
  { 1526, 18, 42, 22, 2, -41 },
  { 1621, 17, 42, 22, 2, -41 },
  { 1711, 3, 30, 10, 4, -30 },
  { 1723, 5, 37, 10, 2, -30 },
  { 1747, 19, 24, 23, 2, -32 },
  { 1804, 19, 14, 23, 2, -27 },
  { 1838, 19, 24, 23, 2, -32 },
  { 1895, 13, 41, 15, 1, -41 },
  { 1962, 29, 46, 34, 3, -41 },
  { 2129, 21, 41, 21, 0, -41 },
  { 2237, 18, 41, 25, 4, -41 },
  { 2330, 19, 42, 24, 3, -41 },
  { 2430, 20, 41, 27, 4, -41 },
  { 2533, 15, 41, 22, 4, -41 },
  { 2610, 15, 41, 20, 4, -41 },
  { 2687, 23, 42, 30, 3, -41 },
  { 2808, 19, 41, 28, 4, -41 },
  { 2906, 8, 41, 12, 2, -41 },
  { 2947, 9, 51, 11, -3, -41 },
  { 3005, 18, 41, 22, 4, -41 },
  { 3098, 14, 41, 19, 4, -41 },
  { 3170, 29, 41, 37, 4, -41 },
  { 3319, 20, 41, 29, 4, -41 },
  { 3422, 23, 42, 29, 3, -41 },
  { 3543, 17, 41, 23, 4, -41 },
  { 3631, 23, 51, 29, 3, -41 },
  { 3778, 18, 41, 23, 4, -41 },
  { 3871, 18, 42, 22, 2, -41 },
  { 3966, 19, 41, 19, 0, -41 },
  { 4064, 20, 42, 28, 4, -41 },
  { 4169, 21, 41, 21, 0, -41 },
  { 4277, 37, 41, 37, 0, -41 },
  { 4467, 17, 41, 19, 1, -41 },
  { 4555, 18, 41, 18, 0, -41 },
  { 4648, 15, 41, 18, 2, -41 },
  { 4725, 10, 50, 17, 5, -41 },
  { 4788, 17, 41, 19, 1, -41 },
  { 4876, 11, 50, 17, 2, -41 },
  { 4945, 21, 20, 23, 1, -41 },
  { 4998, 22, 2, 22, 0, 5 },
  { 5004, 9, 8, 13, 2, -43 },
  { 5013, 15, 32, 21, 2, -31 },
  { 5073, 18, 44, 24, 4, -43 },
  { 5172, 14, 32, 18, 3, -31 },
  { 5228, 17, 44, 24, 3, -43 },
  { 5322, 16, 32, 22, 3, -31 },
  { 5386, 12, 44, 12, 1, -44 },
  { 5452, 17, 45, 24, 3, -31 },
  { 5548, 15, 43, 23, 4, -43 },
  { 5629, 3, 41, 10, 4, -41 },
  { 5645, 7, 55, 10, 0, -41 },
  { 5694, 14, 43, 18, 4, -43 },
  { 5770, 2, 43, 10, 4, -43 },
  { 5781, 27, 31, 35, 4, -31 },
  { 5886, 15, 31, 23, 4, -31 },
  { 5945, 17, 32, 23, 3, -31 },
  { 6013, 18, 44, 24, 4, -31 },
  { 6112, 17, 44, 24, 3, -31 },
  { 6206, 10, 31, 15, 4, -31 },
  { 6245, 14, 32, 18, 2, -31 },
  { 6301, 10, 38, 12, 1, -37 },
  { 6349, 15, 31, 23, 4, -30 },
  { 6408, 16, 30, 17, 0, -30 },
  { 6468, 28, 30, 29, 1, -30 },
  { 6573, 16, 30, 18, 1, -30 },
  { 6633, 16, 44, 18, 1, -30 },
  { 6721, 11, 30, 15, 2, -30 },
  { 6763, 14, 50, 20, 3, -41 },
  { 6851, 2, 57, 22, 10, -43 },
  { 6866, 14, 50, 20, 3, -41 },
  { 6954, 19, 5, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Thin57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN57PT7B_H_
