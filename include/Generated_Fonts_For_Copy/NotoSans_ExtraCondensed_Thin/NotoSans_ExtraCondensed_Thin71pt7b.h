#ifndef _NOTOSANS_EXTRACONDENSED_THIN71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin71pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00,
  0x4F, 0xFF, 0xE0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x03, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x80, 0x10, 0x00, 0x08, 0x01,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x20, 0x00, 0x30, 0x02, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x20, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F,
  0x10, 0x7C, 0x1C, 0x10, 0x08, 0x38, 0x10, 0x00, 0x30, 0x10, 0x00, 0x60,
  0x10, 0x00, 0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0,
  0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0,
  0x10, 0x00, 0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0x70, 0x10, 0x00, 0x30,
  0x10, 0x00, 0x18, 0x10, 0x00, 0x0E, 0x10, 0x00, 0x07, 0x10, 0x00, 0x03,
  0xD0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x13, 0xC0, 0x00, 0x10, 0xE0, 0x00, 0x10, 0x70, 0x00, 0x10, 0x18, 0x00,
  0x10, 0x0C, 0x00, 0x10, 0x0E, 0x00, 0x10, 0x06, 0x00, 0x10, 0x06, 0x00,
  0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00,
  0x10, 0x03, 0x00, 0x10, 0x02, 0x00, 0x10, 0x06, 0x00, 0x10, 0x06, 0x00,
  0x10, 0x0C, 0x00, 0x10, 0x0C, 0x80, 0x10, 0x38, 0xF0, 0x10, 0x70, 0x7F,
  0x97, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x0F,
  0xC0, 0x00, 0x40, 0x07, 0x18, 0x00, 0x30, 0x03, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0xC0, 0x02, 0x00, 0x20, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x10, 0x01, 0x80, 0x20, 0x0C, 0x00, 0x40, 0x0C, 0x03,
  0x00, 0x10, 0x03, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x03, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0xC0, 0x03, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x30,
  0x03, 0x06, 0x00, 0x0C, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x30, 0xC0, 0x00,
  0xC0, 0x0C, 0x30, 0x7C, 0x10, 0x03, 0x0C, 0x3B, 0x84, 0x00, 0xC6, 0x18,
  0x31, 0x80, 0x21, 0x84, 0x06, 0x60, 0x18, 0x63, 0x01, 0x98, 0x06, 0x30,
  0xC0, 0x62, 0x01, 0x8C, 0x20, 0x0C, 0xC0, 0xC3, 0x18, 0x03, 0x38, 0x31,
  0x86, 0x00, 0xC7, 0x38, 0x61, 0x80, 0x30, 0xFC, 0x18, 0x60, 0x0C, 0x00,
  0x0C, 0x18, 0x03, 0x00, 0x03, 0x06, 0x00, 0x40, 0x00, 0xC1, 0x00, 0x10,
  0x00, 0x20, 0x40, 0x04, 0x00, 0x18, 0x10, 0x01, 0x00, 0x06, 0x04, 0x00,
  0x40, 0x01, 0x01, 0x00, 0x10, 0x00, 0xC0, 0x40, 0x04, 0x00, 0x30, 0x18,
  0x03, 0x00, 0x08, 0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x60, 0x0C, 0x00, 0x40, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x20, 0x02, 0x00, 0x30, 0x18, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x60, 0x01, 0x83, 0x00, 0x10, 0x00, 0x31, 0xC0, 0x0C, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x40, 0x01, 0xFC, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x20, 0x0C, 0x00,
  0x10, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x01, 0x80,
  0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xB0,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0x40, 0x18, 0xC0, 0x30, 0x0C, 0x40, 0x0C, 0x06, 0x60, 0x06, 0x03, 0x30,
  0x01, 0x81, 0x90, 0x00, 0xC0, 0xD8, 0x00, 0x30, 0x4C, 0x00, 0x08, 0x66,
  0x00, 0x06, 0x33, 0x00, 0x01, 0x19, 0x80, 0x00, 0xD8, 0xC0, 0x00, 0x3C,
  0x60, 0x00, 0x1C, 0x10, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03,
  0xC3, 0x00, 0x03, 0x20, 0xC0, 0x03, 0x98, 0x60, 0x03, 0x84, 0x18, 0x03,
  0x83, 0x07, 0x07, 0x80, 0xC1, 0xFF, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x0C,
  0x04, 0x0D, 0xE1, 0x1E, 0x0E, 0x5C, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x06,
  0x80, 0x03, 0x30, 0x01, 0x86, 0x00, 0x40, 0xC0, 0x20, 0x10, 0x18, 0x06,
  0x0C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC6, 0x18,
  0x63, 0x0C, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x5F, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0x3C, 0x00, 0x70,
  0x18, 0x03, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08,
  0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x64, 0x00, 0x01, 0x90, 0x00, 0x02,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x40, 0x00, 0x19,
  0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x10, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x80,
  0xC0, 0x0C, 0x03, 0x80, 0x30, 0x07, 0x01, 0x80, 0x0F, 0x1C, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x30, 0x07, 0x00, 0xF0, 0x1B, 0x03, 0x30, 0x63, 0x0C,
  0x33, 0x83, 0x70, 0x3E, 0x03, 0x40, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0xFC, 0x00, 0x7E, 0x7C,
  0x07, 0x80, 0x38, 0x08, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFC, 0xF8, 0x1C, 0x00, 0xE1,
  0xC0, 0x01, 0x88, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0xC0, 0x01,
  0xC7, 0xC0, 0x7C, 0x0F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x83, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x9F, 0xF0, 0x07, 0xFF, 0xF8, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0xC0, 0x03, 0x83, 0xE0, 0x7C,
  0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0,
  0x1E, 0x01, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0xFE, 0x01, 0x8F, 0xFE, 0x06, 0x70, 0x1C, 0x13, 0x00, 0x18,
  0x48, 0x00, 0x71, 0x60, 0x00, 0xCD, 0x00, 0x01, 0x3C, 0x00, 0x06, 0xE0,
  0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x00, 0xB8, 0x00, 0x03, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x60, 0x00,
  0xC1, 0x80, 0x03, 0x03, 0x00, 0x18, 0x0E, 0x00, 0xC0, 0x1C, 0x07, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0x3E,
  0x00, 0xE0, 0x1C, 0x06, 0x00, 0x18, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC6,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0x60, 0x01, 0xC1, 0x80, 0x06, 0x03,
  0x00, 0x30, 0x06, 0x01, 0x80, 0x0E, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x70, 0x00, 0x38, 0x70, 0x01, 0x80, 0xE0,
  0x0C, 0x00, 0xC0, 0x60, 0x01, 0x83, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x19, 0x80,
  0x00, 0x67, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x3C, 0x0F,
  0x00, 0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x3C, 0xF8, 0x03,
  0x00, 0xE0, 0x30, 0x03, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x31, 0x80, 0x01,
  0x8C, 0x00, 0x04, 0x60, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x6C, 0x00, 0x07, 0x60, 0x00, 0x3B,
  0x00, 0x03, 0xCC, 0x00, 0x16, 0x70, 0x01, 0xB1, 0xC0, 0x19, 0x87, 0x87,
  0x8C, 0x0F, 0xF8, 0x60, 0x04, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0x81, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xDF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1B,
  0xFF, 0xC0, 0x18, 0xE3, 0xCF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0xC3,
  0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0xFC, 0xF8, 0x40, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0x31, 0x80, 0x07, 0xF8, 0x06, 0x60, 0x03, 0xC7, 0x00, 0xCC, 0x00,
  0xE0, 0x60, 0x09, 0x80, 0x18, 0x0C, 0x01, 0xB0, 0x06, 0x01, 0x80, 0x34,
  0x00, 0xC0, 0x30, 0x07, 0x80, 0x30, 0x06, 0x00, 0xF0, 0x06, 0x00, 0xC0,
  0x1E, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x78, 0x06, 0x00,
  0x60, 0x0F, 0x00, 0xC0, 0x0C, 0x01, 0xE0, 0x18, 0x01, 0x80, 0x3C, 0x03,
  0x00, 0x30, 0x07, 0x80, 0x60, 0x0C, 0x00, 0xF0, 0x0C, 0x01, 0x80, 0x1E,
  0x01, 0x80, 0x30, 0x03, 0xC0, 0x30, 0x06, 0x00, 0x78, 0x06, 0x00, 0xC0,
  0x0F, 0x00, 0xC0, 0x18, 0x01, 0xE0, 0x18, 0x03, 0x00, 0x6C, 0x03, 0x00,
  0xE0, 0x0D, 0x80, 0x30, 0x1E, 0x01, 0xB0, 0x06, 0x02, 0xC0, 0x66, 0x00,
  0xE0, 0xC8, 0x0C, 0x60, 0x0C, 0x31, 0x83, 0x0C, 0x00, 0xFE, 0x1F, 0xC1,
  0x80, 0x0F, 0x01, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x04, 0x40, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x30,
  0x00, 0x06, 0x02, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x03, 0x00, 0x10, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x80,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x0C, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x01, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x08, 0x00, 0xF8, 0x20,
  0x00, 0x70, 0x80, 0x00, 0x62, 0x00, 0x01, 0x88, 0x00, 0x03, 0x20, 0x00,
  0x0C, 0x80, 0x00, 0x32, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x06,
  0x80, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x0C, 0x80,
  0x00, 0x32, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x18, 0x80, 0x00,
  0xE2, 0x00, 0x07, 0x08, 0x00, 0x38, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x02,
  0x00, 0x3E, 0x08, 0x00, 0x1C, 0x20, 0x00, 0x38, 0x80, 0x00, 0x72, 0x00,
  0x00, 0xC8, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x1A, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x68, 0x00,
  0x01, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x32, 0x00, 0x00, 0xC8, 0x00, 0x06,
  0x20, 0x00, 0x30, 0x80, 0x03, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x7F, 0x00, 0xE0, 0x06, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x01, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x80, 0x1F, 0x00, 0x80, 0x03, 0x80,
  0x80, 0x01, 0xC0, 0x80, 0x00, 0x60, 0x80, 0x00, 0x70, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x30,
  0x80, 0x00, 0x70, 0x80, 0x00, 0x60, 0x80, 0x00, 0xC0, 0x80, 0x03, 0x80,
  0x80, 0x0F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xA0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x03, 0xE0, 0x1F,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x07, 0x8F, 0xFC, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x19, 0xDF, 0x3F, 0xC0, 0x80, 0x00, 0x34, 0x00, 0x03, 0xA0,
  0x00, 0x19, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x40, 0x00, 0xC2, 0x00, 0x0E,
  0x10, 0x00, 0x60, 0x80, 0x06, 0x04, 0x00, 0x30, 0x20, 0x03, 0x01, 0x00,
  0x38, 0x08, 0x01, 0x80, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x0C, 0x00,
  0x80, 0xE0, 0x04, 0x06, 0x00, 0x20, 0x60, 0x01, 0x03, 0x00, 0x08, 0x30,
  0x00, 0x43, 0x80, 0x02, 0x18, 0x00, 0x11, 0xC0, 0x00, 0x8F, 0x00, 0x04,
  0xD8, 0x00, 0x2C, 0x60, 0x01, 0x63, 0x00, 0x0E, 0x0C, 0x00, 0x60, 0x60,
  0x03, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x06, 0x01, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x40, 0x06, 0x02, 0x00, 0x18,
  0x10, 0x00, 0xC0, 0x80, 0x03, 0x04, 0x00, 0x18, 0x20, 0x00, 0x61, 0x00,
  0x03, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x62, 0x00, 0x01, 0x90, 0x00, 0x0C,
  0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFB, 0x00, 0x00, 0x00, 0x1F, 0x60, 0x00, 0x00, 0x06, 0xEC,
  0x00, 0x00, 0x00, 0xDC, 0x80, 0x00, 0x00, 0x1B, 0x98, 0x00, 0x00, 0x06,
  0x73, 0x00, 0x00, 0x00, 0xCE, 0x60, 0x00, 0x00, 0x19, 0xC6, 0x00, 0x00,
  0x02, 0x38, 0xC0, 0x00, 0x00, 0xC7, 0x18, 0x00, 0x00, 0x18, 0xE1, 0x80,
  0x00, 0x03, 0x1C, 0x30, 0x00, 0x00, 0xC3, 0x86, 0x00, 0x00, 0x18, 0x70,
  0x40, 0x00, 0x03, 0x0E, 0x0C, 0x00, 0x00, 0xC1, 0xC1, 0x80, 0x00, 0x18,
  0x38, 0x30, 0x00, 0x03, 0x07, 0x03, 0x00, 0x00, 0x40, 0xE0, 0x60, 0x00,
  0x18, 0x1C, 0x0C, 0x00, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x70, 0x18,
  0x00, 0x18, 0x0E, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x38,
  0x06, 0x00, 0x18, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x08, 0x00, 0x60,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x60, 0x07, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x03, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x60, 0x03, 0x80, 0x04, 0x0C, 0x00, 0x70, 0x00, 0xC3, 0x00,
  0x0E, 0x00, 0x18, 0x60, 0x01, 0xC0, 0x03, 0x0C, 0x00, 0x38, 0x00, 0x31,
  0x00, 0x07, 0x00, 0x06, 0x60, 0x00, 0xE0, 0x00, 0xCC, 0x00, 0x1C, 0x00,
  0x0D, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x90,
  0x00, 0x03, 0x98, 0x00, 0x03, 0x98, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x86, 0x00, 0x03, 0x86, 0x00, 0x03, 0x83, 0x00, 0x03, 0x83,
  0x00, 0x03, 0x81, 0x00, 0x03, 0x81, 0x80, 0x03, 0x81, 0x80, 0x03, 0x80,
  0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x60, 0x03, 0x80,
  0x30, 0x03, 0x80, 0x30, 0x03, 0x80, 0x10, 0x03, 0x80, 0x18, 0x03, 0x80,
  0x18, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x0C, 0x03, 0x80, 0x06, 0x03, 0x80,
  0x06, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80,
  0x01, 0x83, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xC3, 0x80,
  0x00, 0x63, 0x80, 0x00, 0x63, 0x80, 0x00, 0x23, 0x80, 0x00, 0x31, 0x80,
  0x00, 0x31, 0x80, 0x00, 0x19, 0x80, 0x00, 0x19, 0x80, 0x00, 0x0D, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xC0, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x80, 0x3E, 0x08,
  0x00, 0x70, 0x80, 0x01, 0x88, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x06,
  0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80,
  0x00, 0xC8, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x38, 0x80, 0x0F, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x02, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x20, 0x0F,
  0x81, 0x00, 0x0E, 0x08, 0x00, 0x18, 0x40, 0x00, 0x62, 0x00, 0x03, 0x90,
  0x00, 0x0C, 0x80, 0x00, 0x64, 0x00, 0x01, 0x20, 0x00, 0x0D, 0x00, 0x00,
  0x68, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80,
  0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x19, 0x00, 0x00, 0xC8, 0x00, 0x06,
  0x40, 0x00, 0x62, 0x00, 0x03, 0x10, 0x00, 0x30, 0x80, 0x03, 0x04, 0x00,
  0x70, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x08, 0x06, 0x00, 0x40, 0x30, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x18, 0x04, 0x00, 0xC0, 0x20, 0x03,
  0x01, 0x00, 0x18, 0x08, 0x00, 0x60, 0x40, 0x03, 0x02, 0x00, 0x1C, 0x10,
  0x00, 0x60, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x01,
  0x88, 0x00, 0x0C, 0x40, 0x00, 0x32, 0x00, 0x01, 0x90, 0x00, 0x06, 0x80,
  0x00, 0x34, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x01, 0xFF, 0xC0, 0x1F, 0x8F,
  0xE0, 0xE0, 0x01, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0xC0, 0x01, 0xC3, 0xF0, 0x3E,
  0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x38,
  0x07, 0x81, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08,
  0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x20, 0x00,
  0x10, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x20, 0x04, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x20, 0x30, 0x00,
  0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x10, 0x60,
  0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08,
  0x40, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x98, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x80, 0x00, 0x19,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x78, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x30, 0x00, 0x18, 0x18, 0x00, 0x08, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x63, 0x00, 0x01, 0x81, 0x80, 0x01, 0x86, 0x00, 0x04, 0x03, 0x00, 0x06,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x41,
  0x80, 0x03, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0xC0,
  0x06, 0x00, 0x60, 0x02, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x60, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x00, 0x30, 0x06, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x00, 0xC1,
  0x80, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x33, 0x00, 0x00, 0x09, 0x80, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x01,
  0x30, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x1A,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x78, 0x00, 0x00, 0x14, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x06,
  0x18, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x30, 0x03, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x01, 0x01, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60,
  0x01, 0x81, 0x80, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x30, 0x10, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x08, 0x00, 0x18,
  0x60, 0x00, 0x31, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0,
  0x00, 0x1A, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFC, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0x03, 0x80, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00,
  0x70, 0x0E, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0x80, 0x70, 0x40,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x1F, 0xF0, 0x3F, 0x0C, 0x3C,
  0x03, 0x1C, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x05, 0xC0, 0x01, 0x50, 0x00, 0xD6, 0x00, 0x24, 0xC0,
  0x19, 0x38, 0x1C, 0x43, 0xFE, 0x10, 0x1C, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0xFE, 0x03, 0x0F, 0xFE, 0x0C, 0x60, 0x1C,
  0x33, 0x00, 0x38, 0xD8, 0x00, 0x63, 0x40, 0x00, 0xCF, 0x00, 0x03, 0x38,
  0x00, 0x04, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00,
  0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xE0, 0x00, 0x1B,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0x3C, 0x00, 0x0C, 0xD0, 0x00, 0x33, 0x60,
  0x01, 0x8C, 0xC0, 0x0E, 0x33, 0x80, 0x70, 0xC7, 0x87, 0x83, 0x0F, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x38, 0x08, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x81, 0xC0, 0x7F, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0xFE, 0x0C, 0x0F, 0xFC, 0x30, 0x70, 0x1C,
  0xC3, 0x00, 0x33, 0x1C, 0x00, 0x6C, 0x60, 0x00, 0xF3, 0x00, 0x03, 0xCC,
  0x00, 0x07, 0x30, 0x00, 0x1D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x72, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x34, 0x60,
  0x01, 0x91, 0xC0, 0x06, 0x43, 0x80, 0x31, 0x07, 0x03, 0x84, 0x0F, 0xFC,
  0x10, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0xE0,
  0x18, 0x03, 0x81, 0xC0, 0x0C, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x06, 0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x26,
  0x00, 0x01, 0x30, 0x00, 0x0D, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x04,
  0x0C, 0x00, 0x60, 0x38, 0x1E, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0x01, 0xE6, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x10, 0x70, 0x1C, 0x43, 0x00, 0x3B, 0x18, 0x00,
  0x6C, 0x60, 0x00, 0xF3, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x20, 0x00, 0x1D,
  0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x72, 0x00, 0x01,
  0xCC, 0x00, 0x0F, 0x30, 0x00, 0x2C, 0x60, 0x01, 0xB1, 0xC0, 0x0C, 0xC3,
  0x80, 0x73, 0x07, 0x07, 0x8C, 0x0F, 0xF8, 0x30, 0x07, 0x80, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x10, 0x00, 0x38, 0x70, 0x03,
  0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0xFC, 0x18,
  0x7F, 0xE3, 0x1C, 0x0E, 0x66, 0x00, 0xCD, 0x80, 0x0D, 0xB0, 0x01, 0xBC,
  0x00, 0x17, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x36, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00,
  0x07, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0xFC, 0xF0, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xB0, 0x00,
  0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x83,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC7, 0x80, 0x33, 0x60,
  0x0C, 0xCC, 0x03, 0x63, 0x00, 0xF0, 0x40, 0x3C, 0x18, 0x0E, 0x06, 0x03,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x04, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0x43, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x04, 0xC0, 0x01, 0xB0, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF8, 0x03, 0xF8, 0x43, 0xFE, 0x03, 0xFE, 0x23, 0x81, 0x83, 0x03,
  0x93, 0x00, 0x63, 0x00, 0xED, 0x00, 0x33, 0x00, 0x36, 0x80, 0x0D, 0x00,
  0x0F, 0x80, 0x06, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xC0,
  0x01, 0xE0, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x78, 0x00, 0x18,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x07, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x00,
  0x60, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x78, 0x00, 0x18, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x07, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x78, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x1E,
  0x00, 0x06, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x07, 0x80, 0x01, 0x80, 0x03,
  0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x78, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0xFC, 0x10, 0x7F, 0xE2, 0x1C, 0x0E, 0x46, 0x00, 0xE9, 0x80,
  0x0D, 0xA0, 0x01, 0xBC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x70, 0x1C, 0x03, 0x00, 0x38, 0x18, 0x00, 0x70, 0x60, 0x00,
  0xC3, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x26,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x30, 0x60, 0x00, 0xC1, 0xC0, 0x06, 0x03, 0x80, 0x38, 0x07,
  0x83, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x02, 0x0F,
  0xFC, 0x08, 0x70, 0x1C, 0x23, 0x00, 0x30, 0x98, 0x00, 0x62, 0x60, 0x00,
  0xCB, 0x00, 0x03, 0x2C, 0x00, 0x0C, 0xA0, 0x00, 0x1B, 0x80, 0x00, 0x6E,
  0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x03, 0x3C, 0x00, 0x0C,
  0xD0, 0x00, 0x33, 0x60, 0x01, 0x8C, 0xC0, 0x0E, 0x33, 0x80, 0x70, 0xC7,
  0x87, 0x83, 0x0F, 0xF8, 0x0C, 0x07, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x10, 0x70, 0x1C, 0xC3, 0x80, 0x33,
  0x1C, 0x00, 0x6C, 0x60, 0x00, 0xF3, 0x00, 0x03, 0xCC, 0x00, 0x07, 0x30,
  0x00, 0x1D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00,
  0x0D, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x73,
  0x00, 0x01, 0xCC, 0x00, 0x0F, 0x38, 0x00, 0x2C, 0x60, 0x01, 0xB1, 0xC0,
  0x0C, 0xC3, 0x80, 0x73, 0x07, 0x87, 0x8C, 0x0F, 0xFC, 0x30, 0x07, 0x80,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0xF6, 0x1F, 0xF1, 0xC3, 0x98,
  0x0C, 0x80, 0x6C, 0x03, 0x40, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x07, 0xFC, 0x0F, 0xFF,
  0xCE, 0x00, 0xCE, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0xA0, 0x01, 0xD8, 0x01,
  0xCF, 0x03, 0xC3, 0xFF, 0xC0, 0x1E, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x3F,
  0xFE, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x84, 0x0F, 0xE0,
  0x1C, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0x60, 0x03, 0x6C, 0x00, 0x6C, 0xC0, 0x19,
  0x9E, 0x0E, 0x30, 0xFF, 0x86, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x20, 0x00, 0x63, 0x00, 0x06, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1,
  0x80, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18,
  0x0C, 0x01, 0x00, 0x40, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x02,
  0x00, 0x20, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x04, 0x00, 0x10,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x00,
  0x98, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x1B, 0x00, 0x03, 0x80, 0x03, 0x20, 0x00, 0x50, 0x00, 0x66, 0x00,
  0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0x18, 0x00, 0x6C, 0x00, 0x63,
  0x00, 0x0D, 0x80, 0x0C, 0x20, 0x03, 0x10, 0x01, 0x86, 0x00, 0x63, 0x00,
  0x20, 0xC0, 0x0C, 0x60, 0x0C, 0x18, 0x01, 0x8C, 0x01, 0x81, 0x00, 0x21,
  0x80, 0x30, 0x30, 0x0C, 0x10, 0x06, 0x06, 0x01, 0x83, 0x00, 0x80, 0xC0,
  0x30, 0x60, 0x30, 0x08, 0x06, 0x0C, 0x06, 0x01, 0x01, 0x81, 0x80, 0xC0,
  0x30, 0x30, 0x10, 0x10, 0x06, 0x06, 0x03, 0x02, 0x00, 0xC0, 0xC0, 0x60,
  0xC0, 0x08, 0x10, 0x0C, 0x18, 0x01, 0x86, 0x00, 0x83, 0x00, 0x30, 0xC0,
  0x18, 0x40, 0x06, 0x18, 0x03, 0x18, 0x00, 0x43, 0x00, 0x63, 0x00, 0x0C,
  0x40, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x8C, 0x00, 0x33, 0x00, 0x19, 0x00,
  0x06, 0x60, 0x03, 0x60, 0x00, 0x4C, 0x00, 0x6C, 0x00, 0x0D, 0x00, 0x0D,
  0x80, 0x01, 0xE0, 0x00, 0xA0, 0x00, 0x3C, 0x00, 0x14, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC0,
  0xC0, 0x18, 0x0C, 0x01, 0x80, 0x40, 0x30, 0x06, 0x03, 0x00, 0x60, 0x60,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x00, 0xD8,
  0x00, 0x0D, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xD8, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0E,
  0x60, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x1B, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0x40, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x82, 0x00, 0x0C, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00,
  0x30, 0x10, 0x01, 0x80, 0xC0, 0x08, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0x80, 0x30, 0x06, 0x01, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x04, 0x06,
  0x00, 0x30, 0x20, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x20, 0xC0, 0x01,
  0x84, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x18, 0x00, 0x0C, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x50, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x0F, 0xC0, 0x1E, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0xF8, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xF0, 0x01, 0x70, 0x38, 0x03, 0xC0, 0x0E, 0x0F, 0x80, 0x07,
  0xFC, 0x80, 0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 51, 14, 5, -51 },
  { 27, 11, 19, 21, 5, -51 },
  { 54, 28, 51, 30, 1, -51 },
  { 233, 24, 58, 28, 2, -54 },
  { 407, 34, 52, 41, 3, -51 },
  { 628, 25, 52, 27, 2, -51 },
  { 791, 2, 19, 11, 5, -51 },
  { 796, 12, 62, 19, 4, -51 },
  { 889, 12, 62, 19, 3, -51 },
  { 982, 18, 18, 24, 3, -54 },
  { 1023, 24, 32, 28, 2, -41 },
  { 1119, 6, 16, 13, 3, -7 },
  { 1131, 15, 2, 19, 2, -20 },
  { 1135, 3, 5, 13, 5, -5 },
  { 1137, 20, 51, 23, 2, -51 },
  { 1265, 22, 51, 28, 3, -51 },
  { 1406, 12, 51, 28, 5, -51 },
  { 1483, 22, 51, 28, 3, -51 },
  { 1624, 21, 52, 28, 3, -51 },
  { 1761, 26, 51, 28, 1, -51 },
  { 1927, 22, 52, 28, 3, -51 },
  { 2070, 22, 52, 28, 3, -51 },
  { 2213, 21, 51, 28, 3, -51 },
  { 2347, 22, 52, 28, 3, -51 },
  { 2490, 21, 52, 28, 3, -51 },
  { 2627, 3, 38, 13, 5, -38 },
  { 2642, 6, 47, 13, 3, -38 },
  { 2678, 24, 29, 28, 2, -40 },
  { 2765, 24, 18, 28, 2, -34 },
  { 2819, 24, 29, 28, 2, -40 },
  { 2906, 16, 51, 19, 1, -51 },
  { 3008, 35, 58, 43, 4, -51 },
  { 3262, 27, 51, 27, 0, -51 },
  { 3435, 22, 51, 31, 6, -51 },
  { 3576, 24, 52, 29, 4, -51 },
  { 3732, 24, 51, 34, 6, -51 },
  { 3885, 18, 51, 27, 6, -51 },
  { 4000, 18, 51, 25, 6, -51 },
  { 4115, 29, 52, 37, 4, -51 },
  { 4304, 23, 51, 35, 6, -51 },
  { 4451, 10, 51, 16, 3, -51 },
  { 4515, 11, 63, 13, -3, -51 },
  { 4602, 21, 51, 27, 6, -51 },
  { 4736, 17, 51, 24, 6, -51 },
  { 4845, 35, 51, 46, 6, -51 },
  { 5069, 24, 51, 36, 6, -51 },
  { 5222, 28, 52, 36, 4, -51 },
  { 5404, 20, 51, 28, 6, -51 },
  { 5532, 28, 63, 36, 4, -51 },
  { 5753, 21, 51, 29, 6, -51 },
  { 5887, 22, 52, 28, 3, -51 },
  { 6030, 23, 51, 24, 0, -51 },
  { 6177, 24, 52, 35, 5, -51 },
  { 6333, 26, 51, 26, 0, -51 },
  { 6499, 46, 51, 46, 0, -51 },
  { 6793, 22, 51, 24, 1, -51 },
  { 6934, 22, 51, 22, 0, -51 },
  { 7075, 20, 51, 23, 2, -51 },
  { 7203, 13, 62, 22, 6, -51 },
  { 7304, 20, 51, 23, 2, -51 },
  { 7432, 13, 62, 22, 3, -51 },
  { 7533, 26, 25, 28, 1, -51 },
  { 7615, 28, 2, 28, 0, 6 },
  { 7622, 10, 11, 16, 3, -54 },
  { 7636, 18, 39, 26, 3, -38 },
  { 7724, 22, 55, 30, 5, -54 },
  { 7876, 18, 39, 22, 3, -38 },
  { 7964, 22, 55, 30, 3, -54 },
  { 8116, 21, 39, 27, 3, -38 },
  { 8219, 16, 54, 15, 1, -54 },
  { 8327, 22, 55, 30, 3, -38 },
  { 8479, 19, 54, 29, 5, -54 },
  { 8608, 3, 51, 13, 5, -51 },
  { 8628, 8, 68, 13, 0, -51 },
  { 8696, 18, 54, 23, 5, -54 },
  { 8818, 2, 54, 12, 5, -54 },
  { 8832, 33, 38, 43, 5, -38 },
  { 8989, 19, 38, 29, 5, -38 },
  { 9080, 22, 39, 29, 3, -38 },
  { 9188, 22, 54, 30, 5, -38 },
  { 9337, 22, 54, 30, 3, -38 },
  { 9486, 13, 38, 19, 5, -38 },
  { 9548, 17, 39, 22, 3, -38 },
  { 9631, 13, 48, 15, 1, -47 },
  { 9709, 19, 38, 29, 5, -37 },
  { 9800, 20, 37, 21, 0, -37 },
  { 9893, 35, 37, 36, 1, -37 },
  { 10055, 20, 37, 22, 1, -37 },
  { 10148, 21, 54, 22, 1, -37 },
  { 10290, 15, 37, 18, 2, -37 },
  { 10360, 17, 62, 25, 4, -51 },
  { 10492, 2, 71, 27, 12, -54 },
  { 10510, 17, 62, 25, 4, -51 },
  { 10642, 24, 6, 28, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Thin71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN71PT7B_H_
