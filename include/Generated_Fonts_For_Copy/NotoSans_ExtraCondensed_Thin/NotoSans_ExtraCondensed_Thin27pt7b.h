#ifndef _NOTOSANS_EXTRACONDENSED_THIN27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x60, 0x99, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x22,
  0x04, 0x40, 0x88, 0xFF, 0xC4, 0x20, 0x88, 0x11, 0x02, 0x20, 0x44, 0x08,
  0x8F, 0xFC, 0x22, 0x04, 0x41, 0x08, 0x22, 0x04, 0x40, 0x88, 0x00, 0x08,
  0x04, 0x0F, 0x89, 0x28, 0x84, 0x42, 0x21, 0x10, 0x88, 0x24, 0x0E, 0x01,
  0x80, 0xA0, 0x48, 0x22, 0x11, 0x08, 0x84, 0x42, 0x5D, 0xC1, 0x80, 0x40,
  0x20, 0x30, 0x02, 0x42, 0x12, 0x11, 0x11, 0x08, 0x48, 0x42, 0x42, 0x14,
  0x10, 0xA0, 0x85, 0x34, 0x52, 0x52, 0xA2, 0x95, 0x13, 0x28, 0x82, 0x44,
  0x12, 0x20, 0x91, 0x08, 0x88, 0x44, 0x42, 0x22, 0x20, 0xE0, 0x18, 0x12,
  0x11, 0x08, 0x84, 0x42, 0x21, 0x10, 0x48, 0x28, 0x08, 0x0C, 0x09, 0x08,
  0x8C, 0x26, 0x0B, 0x06, 0x81, 0x40, 0xA0, 0xAF, 0x90, 0xFE, 0x08, 0x88,
  0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x42, 0x08,
  0x20, 0xC2, 0x08, 0x41, 0x08, 0x42, 0x08, 0x42, 0x10, 0x84, 0x22, 0x10,
  0x84, 0x42, 0x23, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x05, 0x11, 0x00, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x55, 0xA0, 0xF8, 0xC0, 0x02, 0x04, 0x08, 0x20, 0x41, 0x02,
  0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x81, 0x02, 0x00, 0x18,
  0x26, 0x42, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x41, 0x41, 0x22, 0x1C, 0x13, 0x59, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x10, 0x10, 0xE6, 0x02, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40,
  0xFF, 0x38, 0x46, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x2C, 0x1C,
  0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x01, 0x00, 0xC0,
  0x30, 0x14, 0x05, 0x02, 0x40, 0x90, 0x44, 0x11, 0x08, 0x42, 0x11, 0x04,
  0x41, 0x3F, 0xF0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x7E, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x98, 0x66, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x02, 0xFC, 0x1F, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x8C,
  0xA2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x41, 0x41, 0x3E, 0xFF,
  0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x1C, 0x11, 0x10, 0x50, 0x28, 0x14,
  0x09, 0x04, 0x82, 0x26, 0x0C, 0x05, 0x0C, 0x44, 0x14, 0x0A, 0x03, 0x01,
  0x80, 0xC0, 0x90, 0x47, 0xC0, 0x18, 0x24, 0x42, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x41, 0x67, 0x11, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04,
  0x78, 0xC0, 0x0C, 0x50, 0x00, 0x01, 0x56, 0x80, 0x00, 0x81, 0x83, 0x06,
  0x0C, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x0C,
  0x08, 0x18, 0x30, 0x20, 0x20, 0x00, 0x33, 0x30, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x21, 0x04, 0x20, 0x82, 0x00, 0x00, 0x02, 0x08, 0x0F, 0xE0, 0x40,
  0x42, 0x01, 0x08, 0x02, 0x40, 0x09, 0x0F, 0x14, 0x44, 0x51, 0x11, 0x88,
  0x46, 0x21, 0x18, 0x84, 0x62, 0x11, 0x88, 0x86, 0x22, 0x14, 0x4C, 0x91,
  0xCC, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0x0C, 0x03,
  0x00, 0xC0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x44, 0x21, 0x08, 0x42, 0x10,
  0xFA, 0x40, 0x90, 0x24, 0x09, 0x02, 0x80, 0x60, 0x18, 0x04, 0xFE, 0x40,
  0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x04, 0xFC, 0x43, 0x20, 0x50, 0x28,
  0x0C, 0x06, 0x03, 0x02, 0x81, 0x41, 0x3F, 0x00, 0x07, 0x06, 0x32, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xFC, 0x41, 0x20,
  0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x02, 0x81, 0x41, 0x3F, 0x00, 0xFF, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF8,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFE, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x00, 0x03, 0x80, 0xC6, 0x10, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x81, 0xE8, 0x01, 0x80,
  0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x12, 0x01, 0x10, 0x10, 0xFE, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0xF4, 0x44, 0x44,
  0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0xF0, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1C, 0x81, 0x82, 0x84, 0x84, 0x88,
  0x88, 0x90, 0xA0, 0xA0, 0xD0, 0x90, 0x88, 0x88, 0x84, 0x84, 0x82, 0x82,
  0x81, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF8, 0x80, 0x0F, 0x00, 0x3C, 0x01,
  0x70, 0x05, 0xA0, 0x16, 0x80, 0x5A, 0x02, 0x64, 0x09, 0x90, 0x26, 0x41,
  0x18, 0x84, 0x62, 0x11, 0x88, 0x86, 0x22, 0x18, 0x48, 0x61, 0x41, 0x85,
  0x06, 0x0C, 0x18, 0x20, 0x40, 0x80, 0x70, 0x1C, 0x06, 0x81, 0xA0, 0x64,
  0x19, 0x06, 0x21, 0x88, 0x62, 0x18, 0x46, 0x11, 0x82, 0x60, 0x98, 0x16,
  0x05, 0x81, 0x60, 0x38, 0x0C, 0x04, 0x03, 0x30, 0x81, 0x20, 0x24, 0x02,
  0x80, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x50, 0x0A, 0x01, 0x40, 0x24, 0x08, 0x81, 0x0F, 0xC0, 0xFC, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x84, 0xF0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x06, 0x03, 0x30, 0x81, 0x20, 0x24, 0x02, 0x80,
  0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50,
  0x0A, 0x01, 0x40, 0x24, 0x08, 0x81, 0x0F, 0xC0, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0xFC, 0x88, 0x88, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81, 0x81, 0x1A, 0x21,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0,
  0x8F, 0x80, 0x80, 0x60, 0x18, 0x09, 0x02, 0x40, 0x90, 0x24, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x20, 0x48, 0x12, 0x04, 0x81, 0x20, 0x50, 0x0C, 0x03,
  0x00, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x50, 0x30, 0x28, 0x28, 0x14, 0x14,
  0x12, 0x0A, 0x09, 0x04, 0x84, 0x42, 0x42, 0x22, 0x21, 0x11, 0x11, 0x08,
  0x88, 0x82, 0x42, 0x41, 0x21, 0x20, 0xA0, 0xA0, 0x50, 0x50, 0x28, 0x28,
  0x0C, 0x14, 0x06, 0x04, 0x02, 0x02, 0x00, 0x41, 0xA0, 0x88, 0x44, 0x41,
  0x20, 0x90, 0x50, 0x18, 0x08, 0x04, 0x03, 0x02, 0x81, 0x21, 0x10, 0x88,
  0x42, 0x41, 0x20, 0xA0, 0x20, 0x81, 0xC0, 0x90, 0x48, 0x44, 0x21, 0x10,
  0x90, 0x48, 0x14, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x00, 0xFE, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x03, 0xF8, 0xFC, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x81,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x81, 0x01,
  0x02, 0x02, 0x04, 0x08, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x04, 0x02, 0x80, 0xA0, 0x44,
  0x11, 0x08, 0x22, 0x09, 0x01, 0xC0, 0x40, 0xFF, 0xE0, 0x84, 0x42, 0x10,
  0x18, 0xC8, 0x08, 0x10, 0x20, 0x40, 0x9F, 0x43, 0x06, 0x0C, 0x18, 0x30,
  0xDE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x98, 0xA6, 0xC2, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xBC, 0x0C,
  0x65, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04, 0x08, 0x0F,
  0x80, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x62, 0x4D, 0x41, 0xA0,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x68, 0x53,
  0xC8, 0x18, 0x26, 0x42, 0x41, 0x81, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x40, 0x3F, 0x0C, 0x42, 0x08, 0x20, 0x82, 0x3E, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x1C, 0x11, 0x50, 0x68,
  0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x34, 0x1A, 0x14,
  0xF2, 0x01, 0x00, 0x80, 0x40, 0x40, 0x24, 0x61, 0xC0, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x26, 0x52, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x20, 0xC3, 0xFF, 0xF0, 0x24, 0x00, 0x09, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x2A, 0x00, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x42, 0x89, 0x12, 0x45, 0x0A, 0x1A, 0x24, 0x48, 0x89, 0x12, 0x14, 0x28,
  0x60, 0xFF, 0xFF, 0xF8, 0x18, 0x47, 0x2D, 0xA1, 0x45, 0x04, 0x18, 0x20,
  0xC1, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18,
  0x20, 0xC1, 0x06, 0x08, 0x20, 0x19, 0x4B, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x80, 0x1C, 0x11, 0x10, 0x48, 0x28,
  0x14, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x24, 0x12, 0x08, 0xF8,
  0x18, 0xA6, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x08, 0x1B, 0x50,
  0x68, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x34, 0x1A,
  0x14, 0xF2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0xBE, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x18, 0xCA, 0x04, 0x08, 0x10, 0x10,
  0x18, 0x08, 0x08, 0x10, 0x10, 0x20, 0xBE, 0x00, 0x44, 0x44, 0xF4, 0x44,
  0x44, 0x44, 0x44, 0x44, 0x47, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x6F, 0x40, 0x81, 0x82, 0x42, 0x42, 0x42, 0x42,
  0x24, 0x24, 0x24, 0x24, 0x18, 0x18, 0x18, 0x10, 0x83, 0x06, 0x0C, 0x24,
  0x30, 0x90, 0xC2, 0x44, 0x89, 0x12, 0x42, 0x49, 0x09, 0x24, 0x24, 0x90,
  0xA1, 0x41, 0x86, 0x06, 0x18, 0x18, 0x60, 0x40, 0x80, 0x41, 0x42, 0x22,
  0x24, 0x14, 0x18, 0x08, 0x18, 0x14, 0x24, 0x22, 0x42, 0x42, 0xC1, 0x41,
  0x41, 0x41, 0x42, 0x22, 0x22, 0x22, 0x24, 0x14, 0x14, 0x14, 0x18, 0x08,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0xF8, 0x42, 0x21, 0x08,
  0x84, 0x42, 0x11, 0x08, 0x7C, 0x0E, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x86, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x20, 0x30, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x38, 0x00, 0x30, 0x44, 0x41, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 19, 5, 2, -19 },
  { 4, 4, 7, 8, 2, -19 },
  { 8, 11, 19, 11, 0, -19 },
  { 35, 9, 23, 11, 1, -21 },
  { 61, 13, 20, 15, 1, -20 },
  { 94, 9, 20, 10, 1, -20 },
  { 117, 1, 7, 4, 2, -19 },
  { 118, 5, 23, 7, 1, -19 },
  { 133, 5, 23, 7, 1, -19 },
  { 148, 7, 7, 9, 1, -21 },
  { 155, 9, 13, 11, 1, -16 },
  { 170, 2, 6, 5, 1, -3 },
  { 172, 5, 1, 7, 1, -8 },
  { 173, 1, 2, 5, 2, -2 },
  { 174, 7, 19, 9, 1, -19 },
  { 191, 8, 20, 11, 1, -20 },
  { 211, 4, 19, 11, 2, -19 },
  { 221, 8, 20, 11, 1, -20 },
  { 241, 8, 20, 11, 1, -20 },
  { 261, 10, 19, 11, 0, -19 },
  { 285, 8, 19, 11, 1, -19 },
  { 304, 8, 19, 11, 1, -19 },
  { 323, 8, 19, 11, 1, -19 },
  { 342, 9, 20, 11, 1, -20 },
  { 365, 8, 20, 11, 1, -20 },
  { 385, 1, 14, 5, 2, -14 },
  { 387, 2, 17, 5, 1, -14 },
  { 392, 9, 11, 11, 1, -15 },
  { 405, 9, 7, 11, 1, -13 },
  { 413, 9, 11, 11, 1, -15 },
  { 426, 6, 20, 7, 0, -20 },
  { 441, 14, 21, 16, 1, -19 },
  { 478, 10, 19, 10, 0, -19 },
  { 502, 9, 19, 12, 2, -19 },
  { 524, 10, 20, 11, 1, -20 },
  { 549, 9, 19, 13, 2, -19 },
  { 571, 7, 19, 10, 2, -19 },
  { 588, 7, 19, 10, 2, -19 },
  { 605, 12, 20, 14, 1, -20 },
  { 635, 9, 19, 13, 2, -19 },
  { 657, 4, 19, 6, 1, -19 },
  { 667, 4, 24, 5, -1, -19 },
  { 679, 8, 19, 10, 2, -19 },
  { 698, 7, 19, 9, 2, -19 },
  { 715, 14, 19, 18, 2, -19 },
  { 749, 10, 19, 14, 2, -19 },
  { 773, 11, 20, 14, 1, -20 },
  { 801, 8, 19, 11, 2, -19 },
  { 820, 11, 25, 14, 1, -20 },
  { 855, 8, 19, 11, 2, -19 },
  { 874, 8, 20, 11, 1, -20 },
  { 894, 9, 19, 9, 0, -19 },
  { 916, 9, 19, 13, 2, -19 },
  { 938, 10, 19, 10, 0, -19 },
  { 962, 17, 19, 17, 0, -19 },
  { 1003, 9, 19, 9, 0, -19 },
  { 1025, 9, 19, 9, 0, -19 },
  { 1047, 7, 19, 9, 1, -19 },
  { 1064, 5, 23, 8, 2, -19 },
  { 1079, 7, 19, 9, 1, -19 },
  { 1096, 5, 23, 8, 1, -19 },
  { 1111, 10, 9, 11, 0, -19 },
  { 1123, 11, 1, 11, 0, 2 },
  { 1125, 4, 5, 6, 1, -21 },
  { 1128, 7, 15, 10, 1, -15 },
  { 1142, 8, 21, 11, 2, -21 },
  { 1163, 7, 15, 8, 1, -15 },
  { 1177, 9, 21, 11, 1, -21 },
  { 1201, 8, 15, 10, 1, -15 },
  { 1216, 6, 21, 6, 0, -21 },
  { 1232, 9, 22, 11, 1, -15 },
  { 1257, 7, 21, 11, 2, -21 },
  { 1276, 1, 20, 5, 2, -20 },
  { 1279, 3, 27, 5, 0, -20 },
  { 1290, 7, 21, 9, 2, -21 },
  { 1309, 1, 21, 5, 2, -21 },
  { 1312, 13, 15, 16, 2, -15 },
  { 1337, 7, 15, 11, 2, -15 },
  { 1351, 9, 15, 11, 1, -15 },
  { 1368, 8, 21, 11, 2, -15 },
  { 1389, 9, 21, 11, 1, -15 },
  { 1413, 5, 14, 7, 2, -14 },
  { 1422, 7, 15, 8, 1, -15 },
  { 1436, 4, 18, 6, 1, -18 },
  { 1445, 7, 14, 11, 2, -14 },
  { 1458, 8, 14, 8, 0, -14 },
  { 1472, 14, 14, 14, 0, -14 },
  { 1497, 8, 14, 8, 0, -14 },
  { 1511, 8, 21, 9, 0, -14 },
  { 1532, 5, 14, 7, 1, -14 },
  { 1541, 7, 23, 9, 1, -19 },
  { 1562, 1, 28, 10, 5, -21 },
  { 1566, 7, 23, 9, 1, -19 },
  { 1587, 9, 3, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Thin27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN27PT7B_H_
