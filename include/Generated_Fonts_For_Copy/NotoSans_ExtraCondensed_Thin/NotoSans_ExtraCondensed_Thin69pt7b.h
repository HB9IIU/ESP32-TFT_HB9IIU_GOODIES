#ifndef _NOTOSANS_EXTRACONDENSED_THIN69PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin69pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xE0, 0x36, 0x03, 0x60,
  0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x40,
  0x34, 0x03, 0x40, 0x34, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x00,
  0x30, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80, 0x30, 0x00, 0x10, 0x06,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x20, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x30, 0x0F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x02,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x40, 0x18, 0x07, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x80, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80, 0x30, 0x00, 0x10,
  0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFE, 0x01,
  0xE6, 0x1F, 0x07, 0x0C, 0x0C, 0x1C, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0x60, 0x01, 0x80, 0xC0, 0x02, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x07, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x30, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x06, 0x78, 0x00,
  0x0C, 0x38, 0x00, 0x18, 0x38, 0x00, 0x30, 0x38, 0x00, 0x60, 0x38, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x20, 0x0C, 0x0E,
  0x70, 0x18, 0x78, 0x7E, 0x37, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x07, 0x80, 0x00, 0x40, 0x0F, 0xE0, 0x00, 0x40, 0x0E, 0x18,
  0x00, 0x60, 0x06, 0x06, 0x00, 0x30, 0x02, 0x03, 0x00, 0x10, 0x03, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x80, 0x30, 0x04, 0x00, 0x40,
  0x18, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x02, 0x01, 0x00, 0x18,
  0x01, 0x01, 0x80, 0x0C, 0x00, 0x80, 0xC0, 0x06, 0x00, 0x40, 0x40, 0x03,
  0x00, 0x20, 0x60, 0x01, 0x80, 0x10, 0x30, 0x00, 0xC0, 0x08, 0x18, 0x00,
  0x60, 0x04, 0x18, 0x00, 0x30, 0x02, 0x0C, 0x00, 0x18, 0x01, 0x06, 0x00,
  0x0C, 0x00, 0x86, 0x0F, 0x86, 0x00, 0xC3, 0x0C, 0x61, 0x00, 0x61, 0x8C,
  0x18, 0xC0, 0x31, 0x86, 0x06, 0x60, 0x18, 0xC6, 0x03, 0x30, 0x08, 0x63,
  0x00, 0x88, 0x0C, 0x61, 0x00, 0x66, 0x06, 0x30, 0x80, 0x31, 0x86, 0x18,
  0xC0, 0x18, 0xFE, 0x18, 0x60, 0x0C, 0x1E, 0x0C, 0x30, 0x06, 0x00, 0x06,
  0x18, 0x01, 0x00, 0x02, 0x0C, 0x00, 0x80, 0x03, 0x06, 0x00, 0x40, 0x01,
  0x83, 0x00, 0x20, 0x00, 0x81, 0x80, 0x10, 0x00, 0xC0, 0xC0, 0x08, 0x00,
  0x60, 0x60, 0x04, 0x00, 0x20, 0x30, 0x02, 0x00, 0x30, 0x18, 0x03, 0x00,
  0x18, 0x0C, 0x01, 0x80, 0x08, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x60,
  0x06, 0x00, 0x80, 0x30, 0x02, 0x00, 0x60, 0x10, 0x03, 0x00, 0x30, 0x18,
  0x01, 0x80, 0x08, 0x0C, 0x00, 0x80, 0x06, 0x0C, 0x00, 0xC0, 0x01, 0x8E,
  0x00, 0x60, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x01,
  0x00, 0x06, 0x00, 0x80, 0x03, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00, 0xC0,
  0x10, 0x00, 0x60, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x06,
  0x02, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x61, 0x80, 0x00,
  0x11, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x86, 0x00,
  0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x10, 0xC0, 0x30, 0x08, 0xC0, 0x08,
  0x04, 0x60, 0x06, 0x06, 0x20, 0x01, 0x03, 0x30, 0x00, 0xC1, 0x98, 0x00,
  0x30, 0xCC, 0x00, 0x18, 0x46, 0x00, 0x06, 0x63, 0x00, 0x03, 0x31, 0x80,
  0x00, 0xD0, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x10, 0x00, 0x0E, 0x0C,
  0x00, 0x0F, 0x06, 0x00, 0x06, 0xC1, 0x80, 0x06, 0x60, 0xC0, 0x06, 0x18,
  0x30, 0x06, 0x0C, 0x0E, 0x0E, 0x03, 0x03, 0xFE, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0xED, 0xB6, 0xDB, 0x6D, 0xB6, 0x92, 0x48, 0x00, 0x60, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x04,
  0x04, 0x07, 0xC2, 0x0E, 0x39, 0x3C, 0x03, 0xF0, 0x00, 0x60, 0x00, 0x58,
  0x00, 0x64, 0x00, 0x61, 0x00, 0x60, 0xC0, 0x20, 0x30, 0x30, 0x0C, 0x30,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x18, 0xC6,
  0x33, 0x98, 0xC6, 0x33, 0x18, 0xC4, 0x63, 0x10, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0x77, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xC0, 0xC0, 0x1C, 0x03, 0x00, 0xC0, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x01, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x01, 0x08, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x02, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x40,
  0x00, 0x1A, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x26, 0x00, 0x03,
  0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x0C, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x06, 0x00, 0x60,
  0x30, 0x06, 0x00, 0xC0, 0x70, 0x03, 0x8F, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x60, 0x1C, 0x06, 0x81, 0x90, 0x62, 0x18, 0x4E, 0x0B, 0x81, 0xE0, 0x28,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x03, 0xF8, 0x00, 0xFF, 0xF0,
  0x0E, 0x01, 0xC0, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xF0,
  0x1E, 0x01, 0xC1, 0xC0, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x70, 0xF8, 0x0F, 0x01, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x18, 0x00, 0x04, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xE1, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0xFF, 0xC0, 0x3F,
  0xCF, 0x81, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE3, 0x00, 0x0E, 0x1F, 0x03, 0xE0, 0x3F, 0xFC,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x00, 0x38, 0x18,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x0F, 0xE0, 0x21,
  0xFF, 0x81, 0x18, 0x07, 0x19, 0x80, 0x18, 0xD8, 0x00, 0x66, 0x80, 0x01,
  0xBC, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0x70, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06,
  0x80, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0x63,
  0x00, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x18, 0x07, 0x03,
  0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x1C, 0x07, 0x00,
  0x70, 0x03, 0x01, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x60, 0x30, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x30, 0x1C, 0x00, 0x38, 0x60, 0x00, 0x3B, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0xC0, 0x0E, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00,
  0x04, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x63, 0x00, 0x01,
  0x86, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x30, 0x07, 0x81, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x03,
  0x81, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x61, 0x80, 0x01,
  0x0C, 0x00, 0x0C, 0x40, 0x00, 0x66, 0x00, 0x01, 0x30, 0x00, 0x0D, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x5B,
  0x00, 0x02, 0x8C, 0x00, 0x34, 0x70, 0x03, 0x21, 0xC0, 0x31, 0x07, 0xFF,
  0x18, 0x0F, 0xE0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x20, 0x38, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x67, 0xF7, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x27, 0xF7, 0x70, 0x11, 0xCE, 0x73, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x18,
  0xCE, 0x63, 0x18, 0xCC, 0x63, 0x11, 0x8C, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0xF0, 0xE0, 0x38, 0x40, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x00, 0x19, 0x80, 0x07, 0xF8, 0x06, 0x60, 0x03, 0x8E,
  0x01, 0x98, 0x01, 0x81, 0x80, 0x26, 0x00, 0xC0, 0x60, 0x0D, 0x00, 0x30,
  0x18, 0x03, 0xC0, 0x18, 0x06, 0x00, 0xF0, 0x06, 0x01, 0x80, 0x3C, 0x03,
  0x00, 0x60, 0x0F, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x30, 0x06, 0x00, 0xF0,
  0x0C, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x60, 0x0F, 0x00, 0x80, 0x18, 0x03,
  0xC0, 0x20, 0x06, 0x00, 0xF0, 0x08, 0x01, 0x80, 0x3C, 0x02, 0x00, 0x60,
  0x0F, 0x00, 0x80, 0x38, 0x03, 0xC0, 0x20, 0x0E, 0x00, 0xF0, 0x0C, 0x03,
  0x80, 0x3C, 0x03, 0x00, 0xE0, 0x0B, 0x00, 0xC0, 0x38, 0x06, 0xC0, 0x30,
  0x1E, 0x01, 0xB0, 0x0C, 0x06, 0x80, 0x6C, 0x01, 0x81, 0x20, 0x33, 0x00,
  0x70, 0xCC, 0x1C, 0x60, 0x0F, 0xE1, 0xFE, 0x18, 0x01, 0xF0, 0x3F, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0x00, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x40, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x40, 0x0C, 0x00, 0x30,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xC0, 0xFF, 0xFE, 0x03, 0x00, 0xFE, 0x0C, 0x00, 0x1C, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x04, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x01,
  0xC3, 0x00, 0x0E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xC0, 0x03, 0x83,
  0x00, 0x03, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x8C, 0x00, 0x3C,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF8,
  0x03, 0x80, 0x38, 0x0E, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x01,
  0x00, 0x78, 0x1E, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xF8, 0x00,
  0xC0, 0x7F, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0,
  0xC0, 0x01, 0xC0, 0xC0, 0x07, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F,
  0xFF, 0xEC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x78, 0x03, 0xE0, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x20,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x30, 0x1E, 0x00, 0x03, 0x00, 0x78, 0x03, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x38, 0xFF, 0x80, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x7F, 0x8F, 0xE0, 0xC0, 0x00,
  0x36, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60,
  0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x01,
  0x83, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00, 0x19, 0xB0,
  0x00, 0xC9, 0x80, 0x06, 0xC6, 0x00, 0x3C, 0x30, 0x01, 0xE0, 0xC0, 0x0E,
  0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60,
  0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x06,
  0x30, 0x00, 0x31, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x13, 0x00,
  0x00, 0xD8, 0x00, 0x02, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFD, 0x00, 0x00,
  0x00, 0x37, 0xB0, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x00, 0xDE, 0x40,
  0x00, 0x00, 0x13, 0xCC, 0x00, 0x00, 0x06, 0x79, 0x80, 0x00, 0x00, 0xCF,
  0x30, 0x00, 0x00, 0x11, 0xE3, 0x00, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x00,
  0xC7, 0x8C, 0x00, 0x00, 0x18, 0xF0, 0xC0, 0x00, 0x06, 0x1E, 0x18, 0x00,
  0x00, 0xC3, 0xC3, 0x00, 0x00, 0x18, 0x78, 0x20, 0x00, 0x06, 0x0F, 0x06,
  0x00, 0x00, 0xC1, 0xE0, 0xC0, 0x00, 0x18, 0x3C, 0x18, 0x00, 0x02, 0x07,
  0x81, 0x80, 0x00, 0xC0, 0xF0, 0x30, 0x00, 0x18, 0x1E, 0x06, 0x00, 0x03,
  0x03, 0xC0, 0x60, 0x00, 0xC0, 0x78, 0x0C, 0x00, 0x18, 0x0F, 0x01, 0x80,
  0x03, 0x01, 0xE0, 0x10, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0x18, 0x07, 0x80,
  0x60, 0x03, 0x00, 0xF0, 0x04, 0x00, 0x40, 0x1E, 0x00, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0x00, 0x78, 0x03, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x18,
  0x01, 0xE0, 0x06, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x60, 0x07, 0x80, 0x0C,
  0x18, 0x00, 0xF0, 0x01, 0x83, 0x00, 0x1E, 0x00, 0x30, 0x60, 0x03, 0xC0,
  0x02, 0x18, 0x00, 0x78, 0x00, 0x63, 0x00, 0x0F, 0x00, 0x0C, 0x60, 0x01,
  0xE0, 0x01, 0x88, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x03, 0x60,
  0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xCC, 0x00, 0x01,
  0xCC, 0x00, 0x01, 0xC4, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xC6, 0x00, 0x01,
  0xC3, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0x80, 0x01, 0xC1, 0x80, 0x01,
  0xC0, 0x80, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0x40, 0x01, 0xC0, 0x60, 0x01,
  0xC0, 0x60, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0x01,
  0xC0, 0x18, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x0C, 0x01,
  0xC0, 0x06, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01,
  0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81, 0xC0, 0x00, 0x81, 0xC0, 0x00, 0xC1,
  0xC0, 0x00, 0xC1, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x31,
  0xC0, 0x00, 0x31, 0xC0, 0x00, 0x11, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x09,
  0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x64, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x38, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x06,
  0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF8, 0x0C, 0x0F, 0xE0, 0xC0, 0x07,
  0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x06, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xF8, 0x03,
  0x07, 0xF8, 0x0C, 0x00, 0x70, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x08, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0xE0, 0xC0, 0x0E, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02,
  0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1C,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xC0, 0x1C, 0x38, 0x00, 0x23, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x10, 0x00, 0x70, 0xF8, 0x0F, 0x03, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x40,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x07, 0x81, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x10, 0x00, 0x18, 0x0C, 0x00, 0x08, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x06, 0x00, 0x80, 0x03, 0x00, 0x60, 0x01, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x04, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0x80, 0xC0,
  0x00, 0x60, 0x40, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x02, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x36, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x07, 0x00, 0x00, 0x36, 0x00, 0x00, 0x70, 0x00,
  0x02, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x62, 0x00, 0x00, 0xF0, 0x00, 0x06,
  0x30, 0x00, 0x0D, 0x00, 0x00, 0x63, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x30,
  0x00, 0x09, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x18, 0x00,
  0x19, 0x80, 0x00, 0xC1, 0x80, 0x01, 0x88, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0,
  0x01, 0x80, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x40, 0x01,
  0x80, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x60, 0x03, 0x00,
  0x40, 0x06, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x60, 0x03, 0x00, 0x60,
  0x06, 0x02, 0x00, 0x30, 0x06, 0x00, 0x60, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x30, 0x0C, 0x01, 0x80,
  0xC0, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0x80, 0x18, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x81, 0x80, 0x01,
  0x81, 0x80, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0xC1, 0x80, 0x00, 0xC3,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x00, 0x00, 0xC3, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00, 0x06, 0x20,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x02, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x19,
  0x80, 0x00, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00,
  0x30, 0x30, 0x01, 0x81, 0x80, 0x18, 0x04, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x80, 0x60, 0x06, 0x03, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x06, 0x08,
  0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x00,
  0x98, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x02, 0x00,
  0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x02, 0x00, 0x60, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x02, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00,
  0xD8, 0x00, 0x03, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x20, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x03, 0x04, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x80, 0x80, 0x0C,
  0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x60, 0x02, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x41,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x08, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0x60, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0xF8, 0x07, 0xFF, 0x03, 0x80, 0x60, 0x80,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x1F, 0xC0, 0x7F, 0xF0, 0x78, 0x0C, 0x70,
  0x03, 0x38, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x02, 0xD8, 0x01, 0xB7, 0x00, 0xCC, 0xE0,
  0x63, 0x1F, 0xF0, 0xC0, 0xF0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x1F, 0x80,
  0xC3, 0xFF, 0x06, 0x70, 0x1C, 0x33, 0x00, 0x31, 0xB0, 0x01, 0xCD, 0x00,
  0x06, 0x78, 0x00, 0x13, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x36,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0xC0,
  0x00, 0x6E, 0x00, 0x03, 0x70, 0x00, 0x13, 0xC0, 0x01, 0x9A, 0x00, 0x0C,
  0xD8, 0x00, 0xC4, 0x60, 0x0C, 0x21, 0xC1, 0xC1, 0x07, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC1, 0xE0, 0x21, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x30, 0x1F, 0xF8, 0x01, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x1F, 0x81, 0x03, 0xFF, 0x08, 0x30, 0x1C, 0x43, 0x00,
  0x32, 0x30, 0x00, 0x91, 0x80, 0x06, 0x98, 0x00, 0x14, 0xC0, 0x00, 0xEC,
  0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x40, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x98, 0x00, 0x14,
  0xC0, 0x00, 0xA7, 0x00, 0x0D, 0x18, 0x00, 0xC8, 0x60, 0x0C, 0x41, 0xC1,
  0xC2, 0x07, 0xFC, 0x10, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0,
  0x06, 0x03, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00,
  0x63, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x02, 0x60, 0x00, 0x36, 0x00,
  0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x02, 0x0E, 0x00, 0x60, 0x78,
  0x1E, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xFC, 0x0E, 0x08,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x01, 0xFF, 0xE0, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xF8, 0x43, 0x80, 0x62, 0x18, 0x01, 0x91, 0x80, 0x06, 0x98,
  0x00, 0x14, 0xC0, 0x00, 0xA6, 0x00, 0x07, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x34, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x14, 0xC0, 0x00, 0xA6, 0x00, 0x0D, 0x30, 0x00,
  0x48, 0xC0, 0x06, 0x43, 0x00, 0x66, 0x0E, 0x0E, 0x30, 0x3F, 0xE1, 0x80,
  0x78, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x18, 0x00, 0x70,
  0xF0, 0x0F, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x07, 0xE0, 0xC3, 0xFE, 0x33, 0x81,
  0xCC, 0xC0, 0x3B, 0x60, 0x06, 0xD0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x67, 0xF7, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x06, 0x07, 0x0F, 0x07, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x9C, 0xF8,
  0x60, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x07, 0x60, 0x03, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x86, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x60, 0x18, 0x30,
  0x0C, 0x30, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x9B, 0x00, 0xCD, 0x80, 0x6C,
  0x40, 0x34, 0x30, 0x1E, 0x18, 0x0E, 0x06, 0x06, 0x03, 0x03, 0x00, 0x81,
  0x80, 0x60, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x01, 0x0C, 0x00,
  0xC6, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x02, 0x60, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xE0, 0x87, 0xFC, 0x0F,
  0xF8, 0x8C, 0x0E, 0x18, 0x1C, 0x98, 0x06, 0x30, 0x0E, 0x90, 0x03, 0x20,
  0x06, 0xB0, 0x03, 0x60, 0x03, 0xA0, 0x01, 0x40, 0x03, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x01, 0xFC, 0x20,
  0xFF, 0x88, 0xE0, 0x32, 0x30, 0x06, 0x98, 0x01, 0xAC, 0x00, 0x3A, 0x00,
  0x0E, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x40, 0x00, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0,
  0x01, 0x83, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00,
  0x66, 0x00, 0x01, 0x90, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x02, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x66, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0xC0, 0xE0,
  0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x04, 0x1F, 0xF8, 0x21,
  0x80, 0xE1, 0x18, 0x03, 0x89, 0x80, 0x0C, 0x48, 0x00, 0x32, 0xC0, 0x01,
  0x94, 0x00, 0x06, 0xA0, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x05, 0x80, 0x00, 0x6E, 0x00, 0x03, 0x70, 0x00,
  0x1B, 0x80, 0x00, 0x9E, 0x00, 0x0C, 0xD8, 0x00, 0xE6, 0xC0, 0x06, 0x33,
  0x00, 0x61, 0x8E, 0x0E, 0x0C, 0x3F, 0xE0, 0x60, 0x78, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x41, 0xC0, 0xE2, 0x18, 0x01,
  0x91, 0x80, 0x04, 0x8C, 0x00, 0x34, 0xC0, 0x00, 0xA6, 0x00, 0x07, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x34, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xD8, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x14, 0xC0, 0x00, 0xA6,
  0x00, 0x0D, 0x18, 0x00, 0x48, 0xE0, 0x06, 0x43, 0x80, 0x66, 0x0E, 0x0E,
  0x30, 0x3F, 0xE1, 0x80, 0x3C, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x01, 0xF8,
  0x3F, 0x86, 0x18, 0xC0, 0x98, 0x09, 0x00, 0xD0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0x00,
  0xE7, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x01, 0xDF, 0x03, 0xC3, 0xFF,
  0x80, 0x3F, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x07, 0xFF, 0xC3, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x10, 0x3F, 0x00, 0x70, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x5C, 0x00, 0x15, 0x80, 0x0D, 0x60, 0x06, 0x5C, 0x03, 0x13, 0xC3,
  0x84, 0x7F, 0xC1, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x36, 0x00, 0x02, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x04, 0x30, 0x00, 0xC3,
  0x00, 0x0C, 0x30, 0x00, 0xC1, 0x00, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x18,
  0x18, 0x01, 0x80, 0x80, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x30, 0x06, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x20,
  0x60, 0x03, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01,
  0x08, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0x90, 0x00,
  0x0D, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x1E, 0x00,
  0x19, 0x00, 0x07, 0x80, 0x06, 0x60, 0x01, 0xE0, 0x01, 0x98, 0x00, 0x58,
  0x00, 0x46, 0x00, 0x32, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x0C, 0x20, 0x03,
  0x30, 0x03, 0x0C, 0x00, 0xCC, 0x00, 0x83, 0x00, 0x23, 0x00, 0x20, 0xC0,
  0x18, 0x40, 0x18, 0x10, 0x06, 0x18, 0x06, 0x06, 0x01, 0x86, 0x01, 0x81,
  0x80, 0x41, 0x80, 0x40, 0x60, 0x30, 0x20, 0x30, 0x18, 0x0C, 0x0C, 0x0C,
  0x02, 0x03, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0x30, 0x20, 0x30,
  0x20, 0x0C, 0x18, 0x04, 0x18, 0x01, 0x06, 0x01, 0x86, 0x00, 0x61, 0x80,
  0x61, 0x80, 0x18, 0x60, 0x18, 0x40, 0x06, 0x30, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x8C, 0x00, 0x23, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x03,
  0x20, 0x03, 0x20, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0x16, 0x00, 0x16, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x63,
  0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x01, 0x80, 0x80, 0x18,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x60, 0x60, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0xB0, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0x90, 0x00, 0x19, 0x80, 0x03, 0x08, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x18,
  0x18, 0x01, 0x83, 0x00, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00,
  0x6C, 0x00, 0x07, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x22, 0x00,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x41, 0x00, 0x0C, 0x18,
  0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x80, 0x80, 0x18, 0x0C, 0x01, 0x80,
  0xC0, 0x18, 0x0C, 0x01, 0x00, 0x40, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30,
  0x06, 0x02, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x04,
  0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x88, 0x00, 0x19,
  0x80, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0xD0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x8C, 0x00, 0x0F, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x3F, 0x80, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x02,
  0x7B, 0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x78, 0xE8, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Thin69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 49, 13, 5, -49 },
  { 20, 12, 18, 20, 4, -49 },
  { 47, 27, 49, 29, 1, -49 },
  { 213, 23, 56, 27, 2, -52 },
  { 374, 33, 51, 39, 3, -50 },
  { 585, 25, 51, 27, 2, -50 },
  { 745, 3, 18, 11, 4, -49 },
  { 752, 11, 60, 18, 4, -49 },
  { 835, 12, 60, 18, 3, -49 },
  { 925, 17, 17, 23, 3, -52 },
  { 962, 23, 32, 28, 2, -40 },
  { 1054, 5, 16, 12, 3, -7 },
  { 1064, 14, 2, 18, 2, -20 },
  { 1068, 4, 4, 12, 4, -4 },
  { 1070, 19, 49, 23, 2, -49 },
  { 1187, 21, 50, 27, 3, -50 },
  { 1319, 11, 49, 27, 5, -49 },
  { 1387, 21, 50, 27, 3, -50 },
  { 1519, 21, 51, 27, 3, -50 },
  { 1653, 26, 50, 27, 1, -50 },
  { 1816, 21, 50, 27, 3, -49 },
  { 1948, 21, 51, 27, 3, -50 },
  { 2082, 21, 49, 27, 3, -49 },
  { 2211, 23, 51, 27, 2, -50 },
  { 2358, 21, 51, 27, 3, -50 },
  { 2492, 4, 37, 12, 4, -37 },
  { 2511, 5, 46, 12, 3, -37 },
  { 2540, 23, 29, 28, 2, -39 },
  { 2624, 23, 17, 28, 2, -33 },
  { 2673, 23, 29, 28, 2, -39 },
  { 2757, 16, 50, 18, 1, -50 },
  { 2857, 34, 56, 42, 4, -50 },
  { 3095, 26, 49, 26, 0, -49 },
  { 3255, 22, 49, 30, 5, -49 },
  { 3390, 23, 51, 29, 4, -50 },
  { 3537, 24, 49, 33, 5, -49 },
  { 3684, 18, 49, 26, 5, -49 },
  { 3795, 18, 49, 24, 5, -49 },
  { 3906, 28, 51, 36, 4, -50 },
  { 4085, 23, 49, 34, 5, -49 },
  { 4226, 9, 49, 15, 3, -49 },
  { 4282, 11, 61, 13, -3, -49 },
  { 4366, 21, 49, 26, 5, -49 },
  { 4495, 17, 49, 24, 5, -49 },
  { 4600, 35, 49, 45, 5, -49 },
  { 4815, 24, 49, 35, 5, -49 },
  { 4962, 28, 51, 35, 4, -50 },
  { 5141, 20, 49, 27, 5, -49 },
  { 5264, 28, 62, 35, 4, -50 },
  { 5481, 22, 49, 28, 5, -49 },
  { 5616, 21, 51, 27, 3, -50 },
  { 5750, 23, 49, 23, 0, -49 },
  { 5891, 24, 50, 34, 5, -49 },
  { 6041, 25, 49, 25, 0, -49 },
  { 6195, 44, 49, 45, 0, -49 },
  { 6465, 21, 49, 23, 1, -49 },
  { 6594, 22, 49, 22, 0, -49 },
  { 6729, 19, 49, 22, 2, -49 },
  { 6846, 13, 60, 21, 6, -49 },
  { 6944, 19, 49, 23, 2, -49 },
  { 7061, 13, 60, 21, 2, -49 },
  { 7159, 25, 23, 27, 1, -49 },
  { 7231, 27, 2, 27, 0, 6 },
  { 7238, 10, 11, 16, 3, -53 },
  { 7252, 18, 38, 25, 3, -37 },
  { 7338, 21, 53, 29, 5, -52 },
  { 7478, 17, 38, 22, 3, -37 },
  { 7559, 21, 53, 29, 3, -52 },
  { 7699, 20, 38, 26, 3, -37 },
  { 7794, 15, 53, 15, 1, -53 },
  { 7894, 21, 54, 29, 3, -37 },
  { 8036, 18, 52, 28, 5, -52 },
  { 8153, 4, 50, 12, 4, -50 },
  { 8178, 8, 67, 12, 0, -50 },
  { 8245, 17, 52, 22, 5, -52 },
  { 8356, 2, 52, 12, 5, -52 },
  { 8369, 32, 37, 42, 5, -37 },
  { 8517, 18, 37, 28, 5, -37 },
  { 8601, 22, 38, 28, 3, -37 },
  { 8706, 21, 53, 29, 5, -37 },
  { 8846, 21, 53, 29, 3, -37 },
  { 8986, 12, 37, 18, 5, -37 },
  { 9042, 17, 38, 22, 2, -37 },
  { 9123, 13, 46, 14, 1, -45 },
  { 9198, 18, 37, 28, 5, -36 },
  { 9282, 20, 36, 20, 0, -36 },
  { 9372, 34, 36, 35, 1, -36 },
  { 9525, 20, 36, 22, 1, -36 },
  { 9615, 20, 53, 22, 1, -36 },
  { 9748, 14, 36, 18, 2, -36 },
  { 9811, 16, 60, 24, 4, -49 },
  { 9931, 2, 70, 26, 12, -53 },
  { 9949, 17, 60, 24, 3, -49 },
  { 10077, 23, 5, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Thin69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN69PT7B_H_
