#ifndef _NOTOSANS_EXTRACONDENSED_THIN55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin55pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x80, 0x00, 0x2F, 0xF8, 0x81, 0xC0, 0xE0, 0x70, 0x28, 0x14, 0x0A, 0x05,
  0x02, 0x81, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x08, 0x00, 0x80, 0xC0, 0x04,
  0x04, 0x00, 0x20, 0x20, 0x03, 0x01, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x40,
  0x04, 0x02, 0x00, 0x20, 0x30, 0x01, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x40,
  0x40, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x81, 0x80, 0x80, 0x0C, 0x04, 0x00,
  0x40, 0x20, 0x02, 0x01, 0x00, 0x10, 0x18, 0x00, 0x80, 0xC0, 0x04, 0x06,
  0x00, 0x60, 0x20, 0x03, 0x01, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x40, 0x04,
  0x02, 0x07, 0xFF, 0xFF, 0x81, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x40, 0x60,
  0x06, 0x02, 0x00, 0x30, 0x10, 0x01, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x40,
  0x20, 0x02, 0x03, 0x00, 0x10, 0x18, 0x00, 0x80, 0xC0, 0x04, 0x04, 0x00,
  0x60, 0x20, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x0F, 0xC0,
  0x0F, 0xFE, 0x0E, 0x20, 0xC6, 0x08, 0x01, 0x82, 0x00, 0xC0, 0x80, 0x30,
  0x20, 0x08, 0x08, 0x02, 0x02, 0x00, 0x80, 0x80, 0x20, 0x20, 0x08, 0x08,
  0x03, 0x02, 0x00, 0x40, 0x80, 0x18, 0x20, 0x03, 0x08, 0x00, 0x62, 0x00,
  0x0E, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x02, 0xE0, 0x00, 0x8C, 0x00,
  0x21, 0x80, 0x08, 0x30, 0x02, 0x06, 0x00, 0x80, 0x80, 0x20, 0x30, 0x08,
  0x0C, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x20, 0x30, 0x08, 0x0C, 0x02, 0x02,
  0x00, 0x81, 0xA0, 0x20, 0xCE, 0x08, 0x61, 0xFF, 0xF0, 0x07, 0xE0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0xC0, 0x0C, 0x06, 0x10, 0x02, 0x01, 0x06, 0x00, 0x80, 0xC0, 0x80,
  0x60, 0x20, 0x30, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x03, 0x00, 0x80,
  0x40, 0x80, 0x20, 0x10, 0x20, 0x08, 0x04, 0x18, 0x02, 0x01, 0x04, 0x00,
  0x80, 0x41, 0x00, 0x20, 0x10, 0xC0, 0x08, 0x04, 0x20, 0x02, 0x01, 0x08,
  0x00, 0x80, 0x46, 0x1E, 0x20, 0x31, 0x08, 0xC8, 0x0C, 0x44, 0x13, 0x02,
  0x33, 0x06, 0xC0, 0x88, 0xC0, 0x90, 0x62, 0x20, 0x26, 0x11, 0x88, 0x0C,
  0xFC, 0x42, 0x03, 0x1C, 0x11, 0x80, 0xC0, 0x0C, 0x60, 0x10, 0x02, 0x18,
  0x04, 0x00, 0x86, 0x01, 0x00, 0x61, 0x80, 0x40, 0x10, 0x60, 0x10, 0x04,
  0x18, 0x04, 0x03, 0x06, 0x03, 0x00, 0x80, 0x80, 0xC0, 0x20, 0x20, 0x30,
  0x18, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0xC0, 0x80, 0xC0, 0x10,
  0x60, 0x30, 0x06, 0x30, 0x08, 0x00, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x03,
  0x80, 0x00, 0xFC, 0x00, 0x20, 0xC0, 0x0C, 0x08, 0x01, 0x01, 0x00, 0x20,
  0x30, 0x04, 0x06, 0x00, 0x80, 0xC0, 0x10, 0x18, 0x02, 0x03, 0x00, 0x40,
  0x60, 0x08, 0x08, 0x01, 0x81, 0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0x23,
  0x00, 0x04, 0x40, 0x00, 0xD0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xD0,
  0x00, 0x31, 0x00, 0x0C, 0x20, 0x03, 0x02, 0x02, 0x40, 0x60, 0x48, 0x04,
  0x0B, 0x00, 0xC1, 0x40, 0x08, 0x68, 0x01, 0x8D, 0x00, 0x11, 0x20, 0x01,
  0x24, 0x00, 0x2C, 0x80, 0x03, 0x10, 0x00, 0x63, 0x00, 0x0C, 0x20, 0x03,
  0xC4, 0x00, 0xC8, 0x40, 0x31, 0x8C, 0x0C, 0x10, 0xFF, 0x01, 0x01, 0x00,
  0x00, 0xFF, 0xFC, 0x01, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x10, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C,
  0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x0C,
  0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0x84, 0x31, 0x97, 0x01, 0xE0, 0x03,
  0x80, 0x1A, 0x00, 0x44, 0x02, 0x08, 0x10, 0x30, 0xC0, 0x60, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0xC4, 0x63, 0x18, 0x84,
  0x63, 0x10, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C,
  0x20, 0x04, 0x60, 0x06, 0x40, 0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x60, 0x04,
  0x20, 0x04, 0x30, 0x0C, 0x18, 0x18, 0x0C, 0x30, 0x07, 0xE0, 0x01, 0x81,
  0xC1, 0xA1, 0x91, 0x89, 0x87, 0x82, 0x81, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x07, 0xC0, 0x0F, 0xFC, 0x1C, 0x07,
  0x08, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0xFC, 0x1C,
  0x07, 0x18, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x64, 0x00, 0x73, 0x80, 0x70, 0x7F, 0xE0, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0A, 0x00, 0x00, 0xA0, 0x00, 0x1A, 0x00,
  0x01, 0x20, 0x00, 0x32, 0x00, 0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x20,
  0x00, 0xC2, 0x00, 0x08, 0x20, 0x01, 0x82, 0x00, 0x10, 0x20, 0x03, 0x02,
  0x00, 0x20, 0x20, 0x06, 0x02, 0x00, 0x40, 0x20, 0x0C, 0x02, 0x00, 0x80,
  0x20, 0x18, 0x02, 0x01, 0x00, 0x20, 0x30, 0x02, 0x02, 0x00, 0x20, 0x60,
  0x02, 0x06, 0x00, 0x20, 0xC0, 0x02, 0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xF0,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x7F, 0xFC, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xE0, 0xE0,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x80, 0x18, 0xC0, 0x70, 0x7F, 0xE0, 0x04, 0x00, 0x00, 0x70, 0x03,
  0xFE, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x87, 0xE0, 0x8F, 0x78, 0x98, 0x0C, 0xB0,
  0x04, 0xA0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20, 0x06, 0x30,
  0x0C, 0x18, 0x18, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0x80,
  0xE0, 0xC0, 0x08, 0x20, 0x03, 0x18, 0x00, 0x46, 0x00, 0x19, 0x00, 0x06,
  0x40, 0x01, 0x90, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x20, 0x01, 0x0C,
  0x00, 0xC1, 0x00, 0x20, 0x60, 0x18, 0x0C, 0x0C, 0x01, 0x8C, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x07, 0x30, 0x03, 0x06, 0x01, 0x80, 0xC0, 0xC0, 0x18,
  0x20, 0x03, 0x18, 0x00, 0x44, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xB0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x24, 0x00,
  0x19, 0x80, 0x06, 0x60, 0x03, 0x0C, 0x01, 0x81, 0xC0, 0xE0, 0x3F, 0xE0,
  0x00, 0x80, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x06, 0x06, 0x06, 0x00, 0x82,
  0x00, 0x63, 0x00, 0x11, 0x00, 0x08, 0x80, 0x06, 0x40, 0x01, 0x60, 0x00,
  0xB0, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x39,
  0x80, 0x2C, 0x60, 0x36, 0x1E, 0xF3, 0x07, 0xE1, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x81,
  0x01, 0x80, 0x7F, 0x80, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x31, 0xCE, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x18, 0x8C, 0x63, 0x10, 0x8C, 0x62,
  0x11, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x00, 0x1E, 0x0F, 0xF8, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x01, 0x30, 0x07, 0xF0, 0x26, 0x01, 0x86, 0x06,
  0x80, 0x60, 0xC0, 0xD0, 0x18, 0x18, 0x0E, 0x03, 0x03, 0x01, 0xC0, 0x40,
  0x60, 0x38, 0x18, 0x08, 0x07, 0x03, 0x01, 0x00, 0xE0, 0x40, 0x20, 0x1C,
  0x08, 0x04, 0x03, 0x01, 0x00, 0x80, 0x60, 0x20, 0x10, 0x0C, 0x04, 0x02,
  0x01, 0x80, 0x80, 0xC0, 0x38, 0x10, 0x18, 0x07, 0x02, 0x03, 0x01, 0xE0,
  0x60, 0x60, 0x3C, 0x0C, 0x0C, 0x05, 0x80, 0x82, 0x41, 0x90, 0x18, 0xC8,
  0x62, 0x01, 0xF1, 0xFC, 0x40, 0x1C, 0x0E, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x02, 0x80, 0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0x4C,
  0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x8C, 0x00, 0x08, 0x60, 0x00,
  0x41, 0x00, 0x02, 0x08, 0x00, 0x30, 0x40, 0x01, 0x83, 0x00, 0x08, 0x08,
  0x00, 0x40, 0x40, 0x06, 0x02, 0x00, 0x30, 0x18, 0x01, 0x00, 0xC0, 0x08,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x18, 0x00, 0x80, 0xC0, 0x06, 0x04, 0x00, 0x30, 0x20, 0x00, 0x83, 0x00,
  0x04, 0x18, 0x00, 0x20, 0xC0, 0x01, 0x84, 0x00, 0x04, 0x20, 0x00, 0x23,
  0x00, 0x01, 0x18, 0x00, 0x0C, 0x80, 0x00, 0x64, 0x00, 0x01, 0x60, 0x00,
  0x0B, 0x00, 0x00, 0x60, 0xFF, 0xF0, 0x30, 0x0F, 0x0C, 0x00, 0x63, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x01, 0x30, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x1E, 0x0F, 0xFF, 0x03, 0x00,
  0x70, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x13, 0x00, 0x06, 0xC0, 0x00,
  0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x2C,
  0x00, 0x0B, 0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x0E, 0x30, 0x1F, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0xFC, 0x0E, 0x01, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x10, 0x07, 0xFE, 0x00, 0x18, 0x00, 0xFF, 0xE0,
  0x18, 0x0F, 0x03, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03,
  0x30, 0x00, 0x66, 0x00, 0x04, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01,
  0x60, 0x00, 0x2C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x01, 0xB0, 0x00, 0x36,
  0x00, 0x04, 0xC0, 0x01, 0x98, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x0C,
  0x01, 0xC1, 0x83, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x06, 0x00, 0x70, 0x38, 0x00,
  0x20, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x90, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x20, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60,
  0xE0, 0x00, 0xC0, 0x70, 0x07, 0x80, 0x7F, 0xF8, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x04, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x03, 0x02, 0x06, 0xFC, 0x70, 0xC0, 0x03, 0x60, 0x01, 0x30,
  0x01, 0x98, 0x01, 0x8C, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x41, 0x80, 0x60,
  0xC0, 0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x10, 0x0C, 0x18, 0x06, 0x18,
  0x03, 0x08, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x37, 0x80, 0x1A,
  0x40, 0x0F, 0x30, 0x07, 0x08, 0x03, 0x06, 0x01, 0x81, 0x00, 0xC0, 0xC0,
  0x60, 0x20, 0x30, 0x18, 0x18, 0x04, 0x0C, 0x03, 0x06, 0x00, 0x83, 0x00,
  0x61, 0x80, 0x10, 0xC0, 0x0C, 0x60, 0x02, 0x30, 0x01, 0x98, 0x00, 0x4C,
  0x00, 0x36, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0F, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xBD, 0x00, 0x00, 0x0B,
  0xD0, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x1B, 0xC8, 0x00, 0x01, 0x3C, 0x80,
  0x00, 0x33, 0xCC, 0x00, 0x03, 0x3C, 0x40, 0x00, 0x23, 0xC4, 0x00, 0x02,
  0x3C, 0x60, 0x00, 0x63, 0xC6, 0x00, 0x04, 0x3C, 0x20, 0x00, 0x43, 0xC2,
  0x00, 0x0C, 0x3C, 0x30, 0x00, 0x83, 0xC1, 0x00, 0x08, 0x3C, 0x10, 0x01,
  0x83, 0xC1, 0x80, 0x18, 0x3C, 0x08, 0x01, 0x03, 0xC0, 0x80, 0x30, 0x3C,
  0x0C, 0x03, 0x03, 0xC0, 0xC0, 0x20, 0x3C, 0x04, 0x02, 0x03, 0xC0, 0x60,
  0x60, 0x3C, 0x06, 0x04, 0x03, 0xC0, 0x20, 0x40, 0x3C, 0x02, 0x0C, 0x03,
  0xC0, 0x30, 0xC0, 0x3C, 0x01, 0x08, 0x03, 0xC0, 0x11, 0x80, 0x3C, 0x01,
  0x98, 0x03, 0xC0, 0x19, 0x00, 0x3C, 0x00, 0xB0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1D, 0x00, 0x03, 0xB0, 0x00, 0x72, 0x00,
  0x0E, 0x40, 0x01, 0xCC, 0x00, 0x38, 0x80, 0x07, 0x18, 0x00, 0xE1, 0x00,
  0x1C, 0x30, 0x03, 0x82, 0x00, 0x70, 0x60, 0x0E, 0x0C, 0x01, 0xC0, 0x80,
  0x38, 0x18, 0x07, 0x01, 0x00, 0xE0, 0x30, 0x1C, 0x02, 0x03, 0x80, 0x60,
  0x70, 0x04, 0x0E, 0x00, 0x81, 0xC0, 0x18, 0x38, 0x01, 0x07, 0x00, 0x30,
  0xE0, 0x02, 0x1C, 0x00, 0x63, 0x80, 0x04, 0x70, 0x00, 0xCE, 0x00, 0x09,
  0xC0, 0x01, 0x38, 0x00, 0x37, 0x00, 0x02, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0x40, 0x00, 0x83, 0x00, 0x03,
  0x08, 0x00, 0x04, 0x60, 0x00, 0x19, 0x80, 0x00, 0x64, 0x00, 0x00, 0x90,
  0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x40, 0x00,
  0x0D, 0x00, 0x00, 0x26, 0x00, 0x00, 0x98, 0x00, 0x06, 0x20, 0x00, 0x18,
  0xC0, 0x00, 0x43, 0x00, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x30,
  0x03, 0x00, 0x70, 0x38, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xE0,
  0xC0, 0x78, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C,
  0xC0, 0x18, 0xC0, 0x70, 0xFF, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0x40, 0x00, 0x83, 0x00, 0x03, 0x08,
  0x00, 0x04, 0x60, 0x00, 0x19, 0x80, 0x00, 0x64, 0x00, 0x00, 0x90, 0x00,
  0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x0D,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x98, 0x00, 0x06, 0x20, 0x00, 0x18, 0xC0,
  0x00, 0x43, 0x00, 0x03, 0x06, 0x00, 0x08, 0x08, 0x00, 0x60, 0x30, 0x03,
  0x00, 0x70, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x14, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0xFF, 0xE0, 0x60, 0x3C, 0x30,
  0x07, 0x18, 0x00, 0x8C, 0x00, 0x66, 0x00, 0x13, 0x00, 0x0D, 0x80, 0x06,
  0xC0, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x09, 0x80, 0x04, 0xC0, 0x06, 0x60, 0x06, 0x30, 0x06, 0x18,
  0x0E, 0x0F, 0xFC, 0x06, 0x04, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x30, 0x08, 0x18, 0x06, 0x0C, 0x01, 0x06, 0x00, 0xC3, 0x00,
  0x21, 0x80, 0x18, 0xC0, 0x04, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x0B, 0x00, 0x06, 0x01, 0xF0, 0x03, 0xFF, 0xC7, 0x00,
  0x46, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x33, 0x80, 0x70, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x19, 0x80,
  0x03, 0x10, 0x00, 0xC3, 0x00, 0x30, 0x38, 0x0C, 0x01, 0xFF, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0x43,
  0x00, 0x0C, 0x30, 0x00, 0xC1, 0x00, 0x08, 0x10, 0x00, 0x81, 0x80, 0x18,
  0x18, 0x01, 0x80, 0x80, 0x10, 0x08, 0x01, 0x00, 0xC0, 0x10, 0x0C, 0x03,
  0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0x40, 0x20, 0x06, 0x06, 0x00, 0x20,
  0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01,
  0x08, 0x00, 0x10, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0x90, 0x00,
  0x09, 0x00, 0x00, 0x90, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x0D,
  0x00, 0x03, 0x80, 0x01, 0xB0, 0x00, 0x70, 0x00, 0x26, 0x00, 0x0A, 0x00,
  0x04, 0x40, 0x01, 0x60, 0x00, 0x88, 0x00, 0x2C, 0x00, 0x31, 0x00, 0x0D,
  0x80, 0x06, 0x30, 0x01, 0x90, 0x00, 0x86, 0x00, 0x32, 0x00, 0x10, 0x40,
  0x04, 0x60, 0x06, 0x08, 0x00, 0x8C, 0x00, 0xC1, 0x80, 0x31, 0x80, 0x18,
  0x30, 0x06, 0x10, 0x02, 0x06, 0x00, 0xC2, 0x00, 0x40, 0x40, 0x10, 0x60,
  0x18, 0x08, 0x02, 0x0C, 0x03, 0x01, 0x80, 0xC1, 0x80, 0x40, 0x30, 0x18,
  0x10, 0x08, 0x06, 0x03, 0x02, 0x03, 0x00, 0x40, 0x40, 0x60, 0x60, 0x08,
  0x08, 0x0C, 0x0C, 0x01, 0x83, 0x01, 0x81, 0x00, 0x30, 0x60, 0x10, 0x20,
  0x02, 0x0C, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x0C,
  0x20, 0x01, 0x8C, 0x01, 0x84, 0x00, 0x31, 0x80, 0x10, 0x80, 0x02, 0x30,
  0x02, 0x30, 0x00, 0x44, 0x00, 0x46, 0x00, 0x0C, 0x80, 0x0C, 0x80, 0x01,
  0x90, 0x01, 0x90, 0x00, 0x36, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x02, 0xC0,
  0x00, 0x50, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x01, 0x90, 0x01, 0x88, 0x00,
  0xC6, 0x00, 0x41, 0x00, 0x60, 0x80, 0x20, 0x60, 0x10, 0x10, 0x18, 0x0C,
  0x08, 0x06, 0x0C, 0x01, 0x06, 0x00, 0xC2, 0x00, 0x23, 0x00, 0x11, 0x00,
  0x0C, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x38,
  0x00, 0x14, 0x00, 0x0B, 0x00, 0x0D, 0x80, 0x04, 0x40, 0x06, 0x30, 0x02,
  0x18, 0x01, 0x04, 0x01, 0x83, 0x00, 0x81, 0x80, 0xC0, 0x40, 0x40, 0x30,
  0x20, 0x08, 0x30, 0x04, 0x10, 0x03, 0x18, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x36, 0x00, 0x0A, 0x00, 0x06, 0xC0, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x4C,
  0x00, 0x22, 0x00, 0x31, 0x00, 0x10, 0xC0, 0x08, 0x20, 0x0C, 0x10, 0x04,
  0x0C, 0x02, 0x02, 0x03, 0x01, 0x01, 0x00, 0xC0, 0x80, 0x20, 0xC0, 0x10,
  0x40, 0x0C, 0x20, 0x02, 0x30, 0x01, 0x10, 0x00, 0xC8, 0x00, 0x2C, 0x00,
  0x14, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03,
  0xFF, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x1F, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00, 0x09, 0x80, 0x01, 0x88,
  0x00, 0x10, 0xC0, 0x03, 0x04, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x10, 0x18, 0x01, 0x81, 0x00, 0x08, 0x30,
  0x00, 0xC2, 0x00, 0x04, 0x60, 0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x30,
  0xFF, 0xFF, 0xFC, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x01, 0x80, 0x7F, 0xC3, 0x03, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x70, 0x3F, 0xC3, 0x81, 0x30, 0x04, 0x80, 0x16, 0x00, 0x50, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x34, 0x01, 0xD8,
  0x05, 0x30, 0x24, 0x7F, 0x10, 0x30, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x08, 0x04, 0x3F,
  0x82, 0x30, 0x71, 0x20, 0x08, 0xB0, 0x06, 0x50, 0x01, 0x38, 0x00, 0xD8,
  0x00, 0x2C, 0x00, 0x16, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x6C,
  0x00, 0x35, 0x00, 0x12, 0x80, 0x19, 0x20, 0x18, 0x8C, 0x18, 0x43, 0xF8,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x3F, 0xC3, 0x02, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0xC0, 0x83, 0xFC, 0x06, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x01, 0x01, 0x0F, 0xF1, 0x18, 0x19,
  0x30, 0x0D, 0x20, 0x05, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x07, 0x60, 0x05,
  0x30, 0x0D, 0x18, 0x19, 0x0F, 0xF1, 0x01, 0x00, 0x01, 0x80, 0x1F, 0xC0,
  0x60, 0xC1, 0x80, 0xC2, 0x00, 0xCC, 0x00, 0x90, 0x01, 0x60, 0x03, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x11, 0xC0, 0xC0, 0xFF, 0x00, 0x20, 0x00, 0x03, 0xF0, 0x73, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x0F, 0xF8, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0x80,
  0x0F, 0xF1, 0x18, 0x19, 0x30, 0x0D, 0x20, 0x05, 0x60, 0x03, 0x40, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03,
  0x40, 0x05, 0x60, 0x05, 0x30, 0x09, 0x18, 0x19, 0x0F, 0xE1, 0x01, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x80, 0x0C, 0xF0, 0x38, 0x3F, 0xE0,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x08,
  0x10, 0xFE, 0x23, 0x06, 0x48, 0x04, 0xB0, 0x0D, 0x40, 0x0B, 0x00, 0x16,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x30, 0xC3, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x08, 0x21, 0xA6, 0xF0, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x0E, 0x00, 0xD0, 0x04, 0x80,
  0x64, 0x06, 0x20, 0x21, 0x03, 0x08, 0x10, 0x41, 0x82, 0x18, 0x10, 0x80,
  0x8C, 0x04, 0x70, 0x24, 0x81, 0x66, 0x0A, 0x30, 0x60, 0x83, 0x06, 0x10,
  0x10, 0x80, 0xC4, 0x02, 0x20, 0x11, 0x00, 0xC8, 0x02, 0x40, 0x1A, 0x00,
  0x50, 0x02, 0x80, 0x1C, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0x00, 0x10, 0x23, 0xF8, 0x3F, 0x89, 0x83, 0x18, 0x32, 0xC0, 0x4C,
  0x06, 0xA0, 0x1A, 0x01, 0xA8, 0x03, 0x80, 0x2C, 0x00, 0xC0, 0x0B, 0x00,
  0x30, 0x03, 0xC0, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x0E,
  0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00,
  0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x38,
  0x00, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00,
  0x38, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03,
  0x00, 0x30, 0x00, 0x81, 0x0F, 0xE2, 0x70, 0x64, 0x80, 0x6A, 0x00, 0xD4,
  0x00, 0xB0, 0x01, 0x60, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0xF8, 0x06, 0x06, 0x06, 0x01, 0x86, 0x00, 0x63, 0x00, 0x11,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x28, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0B, 0x00, 0x05,
  0x80, 0x06, 0x40, 0x03, 0x30, 0x01, 0x08, 0x01, 0x86, 0x01, 0x81, 0x81,
  0x80, 0x7F, 0x80, 0x02, 0x00, 0x00, 0x80, 0x43, 0xF8, 0x23, 0x07, 0x13,
  0x01, 0x8B, 0x00, 0x65, 0x00, 0x13, 0x80, 0x0D, 0x80, 0x02, 0xC0, 0x01,
  0x60, 0x00, 0xB0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x16, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x06, 0xE0, 0x03, 0x50, 0x01,
  0x2C, 0x01, 0x93, 0x01, 0x88, 0xC1, 0x84, 0x3F, 0x82, 0x02, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x0F, 0xF1, 0x1C, 0x19, 0x30, 0x0D, 0x20, 0x05, 0x60,
  0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x40, 0x03, 0x60, 0x05, 0x20, 0x05, 0x30, 0x09, 0x18, 0x19, 0x0F,
  0xF1, 0x01, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x87, 0xE3, 0x19, 0x82, 0xC0, 0xA0, 0x28, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x01, 0x80, 0xFF, 0x8E, 0x06, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x07,
  0x00, 0x6E, 0x07, 0x3F, 0xE0, 0x18, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x03, 0xFF, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x06, 0x00, 0x80, 0x3F, 0x01, 0x00, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x2D, 0x80, 0xDB, 0x83, 0x33, 0xFC,
  0x60, 0x40, 0x00, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x60,
  0x06, 0x20, 0x06, 0x20, 0x04, 0x30, 0x04, 0x30, 0x0C, 0x10, 0x0C, 0x10,
  0x08, 0x10, 0x08, 0x18, 0x18, 0x18, 0x18, 0x08, 0x10, 0x08, 0x10, 0x0C,
  0x30, 0x0C, 0x30, 0x04, 0x20, 0x04, 0x20, 0x06, 0x60, 0x06, 0x60, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0A, 0x00, 0x38, 0x01, 0x60,
  0x07, 0x00, 0x64, 0x01, 0xA0, 0x0C, 0x80, 0x34, 0x01, 0x10, 0x06, 0x80,
  0x23, 0x00, 0x98, 0x04, 0x60, 0x13, 0x01, 0x84, 0x06, 0x20, 0x30, 0x80,
  0xC4, 0x04, 0x18, 0x10, 0xC0, 0x83, 0x02, 0x18, 0x30, 0x20, 0x41, 0x06,
  0x04, 0x18, 0x20, 0x80, 0x83, 0x04, 0x10, 0x18, 0x40, 0xC2, 0x03, 0x08,
  0x18, 0xC0, 0x23, 0x01, 0x18, 0x04, 0x60, 0x22, 0x00, 0xC8, 0x04, 0x40,
  0x19, 0x00, 0xC8, 0x01, 0x20, 0x1B, 0x00, 0x2C, 0x01, 0x40, 0x05, 0x80,
  0x28, 0x00, 0xE0, 0x05, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00,
  0x30, 0x01, 0x00, 0xC0, 0x06, 0xC0, 0x08, 0x80, 0x31, 0x80, 0x61, 0x01,
  0x83, 0x03, 0x06, 0x04, 0x04, 0x18, 0x0C, 0x20, 0x08, 0xC0, 0x19, 0x00,
  0x16, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x02, 0xC0, 0x0C,
  0x80, 0x11, 0x80, 0x61, 0x00, 0x82, 0x03, 0x06, 0x06, 0x04, 0x18, 0x0C,
  0x30, 0x08, 0x40, 0x19, 0x80, 0x12, 0x00, 0x3C, 0x00, 0x20, 0xC0, 0x03,
  0x40, 0x02, 0x40, 0x02, 0x60, 0x02, 0x60, 0x06, 0x20, 0x04, 0x20, 0x04,
  0x30, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x18, 0x18, 0x18, 0x18,
  0x08, 0x10, 0x08, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x04, 0x20, 0x04, 0x20,
  0x06, 0x60, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x98, 0x00, 0xF0, 0x00, 0xFF, 0xE0,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0x0F, 0xFE, 0x00, 0x78, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x1E, 0x00, 0x78, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0xE0, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x06, 0x03, 0xE0, 0x18, 0x00, 0x1E, 0x00, 0x1F,
  0xE0, 0x1C, 0x0C, 0x0E, 0x01, 0xFE, 0x80, 0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Thin55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 39, 11, 4, -39 },
  { 16, 9, 14, 16, 4, -39 },
  { 32, 21, 39, 23, 1, -39 },
  { 135, 18, 45, 22, 2, -42 },
  { 237, 26, 41, 31, 3, -40 },
  { 371, 19, 41, 21, 2, -40 },
  { 469, 1, 14, 9, 4, -39 },
  { 471, 9, 48, 14, 3, -39 },
  { 525, 10, 48, 14, 2, -39 },
  { 585, 14, 14, 19, 2, -42 },
  { 610, 18, 25, 22, 2, -32 },
  { 667, 5, 13, 10, 2, -6 },
  { 676, 12, 2, 14, 1, -16 },
  { 679, 2, 4, 10, 4, -4 },
  { 680, 16, 39, 18, 1, -39 },
  { 758, 16, 40, 22, 3, -40 },
  { 838, 9, 39, 22, 4, -39 },
  { 882, 17, 40, 22, 2, -40 },
  { 967, 17, 41, 22, 2, -40 },
  { 1055, 20, 39, 22, 1, -39 },
  { 1153, 16, 40, 22, 3, -39 },
  { 1233, 16, 41, 22, 3, -40 },
  { 1315, 17, 39, 22, 2, -39 },
  { 1398, 18, 41, 22, 2, -40 },
  { 1491, 17, 41, 22, 2, -40 },
  { 1579, 2, 29, 10, 4, -29 },
  { 1587, 5, 36, 10, 2, -29 },
  { 1610, 18, 23, 22, 2, -31 },
  { 1662, 18, 13, 22, 2, -26 },
  { 1692, 18, 23, 22, 2, -31 },
  { 1744, 12, 40, 14, 1, -40 },
  { 1804, 27, 44, 33, 3, -39 },
  { 1953, 21, 39, 21, 0, -39 },
  { 2056, 18, 39, 24, 4, -39 },
  { 2144, 19, 41, 23, 3, -40 },
  { 2242, 19, 39, 26, 4, -39 },
  { 2335, 14, 39, 21, 4, -39 },
  { 2404, 14, 39, 19, 4, -39 },
  { 2473, 23, 41, 29, 3, -40 },
  { 2591, 18, 39, 27, 4, -39 },
  { 2679, 8, 39, 12, 2, -39 },
  { 2718, 8, 49, 10, -2, -39 },
  { 2767, 17, 39, 21, 4, -39 },
  { 2850, 14, 39, 19, 4, -39 },
  { 2919, 28, 39, 36, 4, -39 },
  { 3056, 19, 39, 28, 4, -39 },
  { 3149, 22, 41, 28, 3, -40 },
  { 3262, 16, 39, 22, 4, -39 },
  { 3340, 22, 49, 28, 3, -40 },
  { 3475, 17, 39, 22, 4, -39 },
  { 3558, 17, 41, 21, 2, -40 },
  { 3646, 18, 39, 18, 0, -39 },
  { 3734, 19, 40, 27, 4, -39 },
  { 3829, 20, 39, 20, 0, -39 },
  { 3927, 35, 39, 36, 0, -39 },
  { 4098, 17, 39, 18, 1, -39 },
  { 4181, 17, 39, 17, 0, -39 },
  { 4264, 15, 39, 18, 2, -39 },
  { 4338, 10, 48, 17, 5, -39 },
  { 4398, 16, 39, 18, 1, -39 },
  { 4476, 10, 48, 17, 2, -39 },
  { 4536, 20, 19, 22, 1, -39 },
  { 4584, 22, 1, 22, 0, 5 },
  { 4587, 8, 9, 12, 2, -42 },
  { 4596, 14, 31, 20, 2, -30 },
  { 4651, 17, 43, 23, 4, -42 },
  { 4743, 13, 31, 17, 3, -30 },
  { 4794, 16, 43, 23, 3, -42 },
  { 4880, 15, 31, 21, 3, -30 },
  { 4939, 12, 42, 12, 1, -42 },
  { 5002, 16, 43, 23, 3, -30 },
  { 5088, 15, 42, 22, 4, -42 },
  { 5167, 2, 40, 10, 4, -40 },
  { 5177, 6, 53, 10, 0, -40 },
  { 5217, 13, 42, 18, 4, -42 },
  { 5286, 1, 42, 9, 4, -42 },
  { 5292, 26, 30, 33, 4, -30 },
  { 5390, 15, 30, 22, 4, -30 },
  { 5447, 17, 31, 22, 3, -30 },
  { 5513, 17, 43, 23, 4, -30 },
  { 5605, 16, 43, 23, 3, -30 },
  { 5691, 10, 29, 14, 4, -29 },
  { 5728, 13, 31, 17, 2, -30 },
  { 5779, 10, 37, 12, 1, -36 },
  { 5826, 15, 30, 22, 4, -29 },
  { 5883, 16, 29, 16, 0, -29 },
  { 5941, 27, 29, 28, 1, -29 },
  { 6039, 15, 29, 17, 1, -29 },
  { 6094, 16, 42, 17, 1, -29 },
  { 6178, 11, 29, 14, 2, -29 },
  { 6218, 13, 48, 19, 3, -39 },
  { 6296, 1, 55, 21, 10, -42 },
  { 6303, 13, 48, 19, 3, -39 },
  { 6381, 18, 5, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Thin55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN55PT7B_H_
