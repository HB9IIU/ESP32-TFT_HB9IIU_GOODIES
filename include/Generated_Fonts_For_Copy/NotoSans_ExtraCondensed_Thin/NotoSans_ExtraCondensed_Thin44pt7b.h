#ifndef _NOTOSANS_EXTRACONDENSED_THIN44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin44pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x00, 0xFC, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00,
  0x81, 0x00, 0x41, 0x00, 0x20, 0x80, 0x30, 0x40, 0x10, 0x20, 0x08, 0x10,
  0x04, 0x08, 0x3F, 0xFF, 0xC1, 0x02, 0x00, 0x81, 0x00, 0x41, 0x80, 0x60,
  0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x10, 0x04, 0x08, 0x02, 0x04, 0x01,
  0x02, 0x0F, 0xFF, 0xF0, 0x41, 0x80, 0x60, 0x80, 0x20, 0x40, 0x10, 0x20,
  0x08, 0x10, 0x04, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x41,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x3F, 0xC0, 0xC8, 0xE2, 0x10, 0x4C, 0x20,
  0x10, 0x40, 0x20, 0x80, 0xC1, 0x01, 0x82, 0x03, 0x04, 0x02, 0x08, 0x04,
  0x10, 0x04, 0x20, 0x0C, 0x40, 0x06, 0x80, 0x07, 0x00, 0x03, 0x80, 0x05,
  0x80, 0x08, 0xC0, 0x10, 0xC0, 0x20, 0x80, 0x41, 0x80, 0x81, 0x01, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x30, 0x10, 0x50, 0x21, 0x3C, 0x4C, 0x0F,
  0xE0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x01,
  0x30, 0x08, 0x10, 0x80, 0x40, 0x82, 0x04, 0x0C, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x10, 0x20, 0x80, 0x81, 0x04, 0x04, 0x0C, 0x40, 0x20,
  0x62, 0x01, 0x02, 0x10, 0x08, 0x11, 0x00, 0x40, 0x88, 0xF2, 0x04, 0x48,
  0x58, 0x24, 0x42, 0x41, 0x24, 0x1A, 0x11, 0x20, 0x49, 0x91, 0x02, 0x38,
  0x88, 0x10, 0x04, 0x40, 0x80, 0x42, 0x04, 0x02, 0x10, 0x20, 0x10, 0x81,
  0x01, 0x04, 0x08, 0x08, 0x20, 0x40, 0x41, 0x02, 0x06, 0x08, 0x10, 0x20,
  0x41, 0x81, 0x01, 0x08, 0x18, 0x08, 0x40, 0x80, 0x3C, 0x07, 0x00, 0x0C,
  0x80, 0x18, 0x40, 0x10, 0x40, 0x10, 0x20, 0x10, 0x20, 0x10, 0x20, 0x10,
  0x20, 0x10, 0x20, 0x10, 0x40, 0x18, 0x40, 0x08, 0x40, 0x08, 0x80, 0x05,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x11, 0x00, 0x21, 0x00, 0x60,
  0x82, 0x40, 0xC2, 0x40, 0x42, 0x40, 0x22, 0xC0, 0x24, 0xC0, 0x14, 0xC0,
  0x14, 0x40, 0x08, 0x40, 0x0C, 0x40, 0x14, 0x60, 0x36, 0x30, 0x62, 0x1F,
  0x81, 0xFF, 0xE0, 0x03, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20,
  0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x10,
  0x08, 0x0C, 0x04, 0x06, 0x03, 0xC0, 0x80, 0x81, 0x81, 0x03, 0x02, 0x04,
  0x0C, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x41, 0x82, 0x0C, 0x10, 0x20, 0x83,
  0x04, 0x10, 0x00, 0x04, 0x00, 0x80, 0x10, 0x42, 0x17, 0x5C, 0x1C, 0x02,
  0x80, 0x50, 0x11, 0x04, 0x11, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x03, 0xFF, 0xF8, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x25,
  0xB4, 0x94, 0x90, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x00, 0x07, 0x80,
  0xE6, 0x04, 0x18, 0x40, 0x42, 0x01, 0x30, 0x09, 0x00, 0x48, 0x03, 0x40,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x28,
  0x01, 0x40, 0x0A, 0x00, 0xD0, 0x04, 0xC0, 0x22, 0x03, 0x18, 0x10, 0x61,
  0x01, 0xF0, 0x03, 0x0F, 0x1B, 0x33, 0x63, 0xC3, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x0F, 0x03, 0xCE,
  0x30, 0x18, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x1F,
  0xFF, 0x1F, 0x03, 0x8E, 0x30, 0x19, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x03, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x1A, 0x01, 0x8F, 0xF0, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x50, 0x00, 0x50, 0x00, 0x90, 0x00, 0x90, 0x01, 0x10, 0x01, 0x10, 0x02,
  0x10, 0x02, 0x10, 0x06, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x18,
  0x10, 0x10, 0x10, 0x30, 0x10, 0x20, 0x10, 0x60, 0x10, 0x40, 0x10, 0xC0,
  0x10, 0x80, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x7F, 0xF2, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0xF0, 0x7C, 0xE0, 0x00, 0x80, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x40, 0x31, 0xFE, 0x00,
  0x01, 0xE0, 0x39, 0x83, 0x00, 0x30, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x47, 0xE2, 0x61,
  0x94, 0x02, 0xA0, 0x16, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x16, 0x01, 0x10,
  0x08, 0x40, 0x83, 0xF8, 0x03, 0x00, 0xFF, 0xF8, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x07, 0x80, 0x73,
  0x82, 0x03, 0x10, 0x04, 0x40, 0x1B, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0xC0,
  0x09, 0x00, 0x24, 0x01, 0x08, 0x04, 0x30, 0x20, 0x63, 0x00, 0xD8, 0x01,
  0xC0, 0x0D, 0x80, 0x41, 0x02, 0x02, 0x10, 0x04, 0xC0, 0x1A, 0x00, 0x28,
  0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x02, 0xC0, 0x09,
  0x00, 0x43, 0x02, 0x07, 0xF0, 0x0F, 0x00, 0xC6, 0x08, 0x18, 0x80, 0x44,
  0x01, 0x60, 0x0A, 0x00, 0x50, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x78, 0x03, 0x40, 0x2B, 0x01, 0x4C, 0x32,
  0x1F, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xE0, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x6C, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0xDA,
  0x4A, 0x48, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x00, 0x3C, 0x31, 0xC0, 0x18, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0xFC, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0x20, 0x60, 0x00, 0x41, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x20, 0x00, 0x08,
  0x80, 0x20, 0x26, 0x07, 0xE0, 0xD0, 0x10, 0x81, 0x40, 0x82, 0x05, 0x06,
  0x08, 0x14, 0x10, 0x20, 0x70, 0x40, 0x81, 0xC1, 0x02, 0x07, 0x04, 0x08,
  0x1C, 0x10, 0x20, 0x70, 0x40, 0x81, 0xC1, 0x02, 0x07, 0x04, 0x18, 0x1C,
  0x10, 0x60, 0x50, 0x41, 0x83, 0x41, 0x8E, 0x09, 0x02, 0x24, 0x64, 0x07,
  0x0E, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x7F, 0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x24,
  0x00, 0x13, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x02, 0x18, 0x01,
  0x04, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x40, 0x80, 0x20, 0x20, 0x10, 0x10,
  0x18, 0x08, 0x08, 0x04, 0x07, 0xFF, 0x02, 0x00, 0x83, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x18, 0x40, 0x04, 0x20, 0x02, 0x20, 0x01, 0x10, 0x00, 0xC8,
  0x00, 0x24, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x06, 0xFF, 0xE3, 0x00, 0xCC,
  0x01, 0xB0, 0x02, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0, 0x0B,
  0x00, 0x2C, 0x00, 0xB0, 0x06, 0xC0, 0x33, 0x01, 0x8F, 0xF8, 0x30, 0x18,
  0xC0, 0x13, 0x00, 0x2C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x02, 0xC0, 0x13, 0x01,
  0xCF, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0x1C, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x80, 0xFF, 0xFF, 0xC1, 0x80, 0xC3, 0x00, 0x46, 0x00, 0x4C, 0x00,
  0xD8, 0x00, 0xB0, 0x01, 0x60, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x02,
  0xC0, 0x05, 0x80, 0x1B, 0x00, 0x26, 0x00, 0xCC, 0x03, 0x18, 0x1C, 0x3F,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F,
  0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0xE0, 0x60, 0x04, 0x30, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x07, 0xFC, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50,
  0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x48, 0x00, 0x13, 0x00,
  0x04, 0x40, 0x01, 0x18, 0x00, 0x43, 0x00, 0x10, 0x70, 0x0C, 0x07, 0xFE,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x80, 0xFC,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8F, 0xC0, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0x5B, 0x9C, 0x00, 0xC0, 0x1B,
  0x00, 0x4C, 0x03, 0x30, 0x08, 0xC0, 0x43, 0x03, 0x0C, 0x08, 0x30, 0x60,
  0xC1, 0x03, 0x08, 0x0C, 0x60, 0x31, 0x00, 0xCC, 0x03, 0x20, 0x0D, 0xC0,
  0x3D, 0x00, 0xE6, 0x03, 0x08, 0x0C, 0x30, 0x30, 0x40, 0xC1, 0x83, 0x02,
  0x0C, 0x0C, 0x30, 0x10, 0xC0, 0x63, 0x00, 0x8C, 0x03, 0x30, 0x04, 0xC0,
  0x13, 0x00, 0x2C, 0x00, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xF8,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x17, 0x40, 0x00, 0x5D, 0x00, 0x03, 0x76, 0x00, 0x09, 0xC8, 0x00,
  0x27, 0x20, 0x00, 0x9C, 0x80, 0x04, 0x71, 0x00, 0x11, 0xC4, 0x00, 0x47,
  0x10, 0x03, 0x1C, 0x60, 0x08, 0x70, 0x80, 0x21, 0xC2, 0x01, 0x87, 0x0C,
  0x04, 0x1C, 0x10, 0x10, 0x70, 0x40, 0xC1, 0xC1, 0x02, 0x07, 0x02, 0x08,
  0x1C, 0x08, 0x20, 0x70, 0x21, 0x01, 0xC0, 0xC4, 0x07, 0x01, 0x10, 0x1C,
  0x04, 0xC0, 0x70, 0x1A, 0x01, 0xC0, 0x28, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x40, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xD0, 0x01,
  0xD0, 0x01, 0xC8, 0x01, 0xC8, 0x01, 0xC4, 0x01, 0xC4, 0x01, 0xC6, 0x01,
  0xC2, 0x01, 0xC2, 0x01, 0xC1, 0x01, 0xC1, 0x01, 0xC0, 0x81, 0xC0, 0x81,
  0xC0, 0x41, 0xC0, 0x41, 0xC0, 0x61, 0xC0, 0x21, 0xC0, 0x21, 0xC0, 0x11,
  0xC0, 0x11, 0xC0, 0x09, 0xC0, 0x09, 0xC0, 0x0D, 0xC0, 0x05, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0x01, 0xF0, 0x01, 0xC7, 0x00, 0xC0, 0x60, 0x60,
  0x08, 0x30, 0x01, 0x08, 0x00, 0x42, 0x00, 0x09, 0x80, 0x02, 0x40, 0x00,
  0x90, 0x00, 0x34, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00,
  0x98, 0x00, 0x22, 0x00, 0x18, 0xC0, 0x04, 0x10, 0x03, 0x06, 0x00, 0x80,
  0xC0, 0xC0, 0x0F, 0xE0, 0xFF, 0x86, 0x03, 0x30, 0x0D, 0x80, 0x2C, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0x60, 0x0B, 0x00, 0xD8, 0x0C, 0xFF, 0x87, 0xE0, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xC7, 0x00,
  0xC0, 0x60, 0x60, 0x08, 0x30, 0x01, 0x08, 0x00, 0x42, 0x00, 0x09, 0x80,
  0x02, 0x40, 0x00, 0x90, 0x00, 0x34, 0x00, 0x05, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x0D, 0x00,
  0x03, 0x40, 0x00, 0x88, 0x00, 0x22, 0x00, 0x18, 0xC0, 0x04, 0x10, 0x03,
  0x06, 0x00, 0x80, 0xC0, 0xC0, 0x0F, 0xE0, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0xFF,
  0x83, 0x01, 0x8C, 0x03, 0x30, 0x04, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xB0,
  0x02, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xB0, 0x06, 0xC0, 0x13, 0x00, 0xCC,
  0x06, 0x30, 0xF0, 0xFE, 0x03, 0x0C, 0x0C, 0x10, 0x30, 0x60, 0xC0, 0x83,
  0x03, 0x0C, 0x04, 0x30, 0x10, 0xC0, 0x23, 0x00, 0x8C, 0x01, 0x30, 0x04,
  0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xC0, 0x07, 0xE0, 0xE1, 0xC8, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x1A, 0x01, 0x9F, 0xF8, 0xFF, 0xFC,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x02, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x22, 0x00, 0xC6,
  0x03, 0x03, 0xFC, 0x00, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x10, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10,
  0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x14, 0x00, 0x60,
  0x01, 0x40, 0x06, 0x00, 0x34, 0x00, 0x70, 0x02, 0x40, 0x05, 0x00, 0x26,
  0x00, 0xD0, 0x02, 0x20, 0x09, 0x00, 0x62, 0x00, 0x90, 0x06, 0x20, 0x09,
  0x80, 0x43, 0x00, 0x88, 0x04, 0x10, 0x18, 0x80, 0x41, 0x01, 0x08, 0x0C,
  0x10, 0x10, 0x80, 0x81, 0x01, 0x08, 0x08, 0x18, 0x10, 0xC0, 0x80, 0x83,
  0x04, 0x08, 0x08, 0x20, 0x41, 0x80, 0x82, 0x04, 0x10, 0x08, 0x20, 0x41,
  0x00, 0xC2, 0x06, 0x10, 0x04, 0x60, 0x23, 0x00, 0x44, 0x02, 0x20, 0x04,
  0x40, 0x22, 0x00, 0x64, 0x02, 0x20, 0x02, 0x40, 0x32, 0x00, 0x2C, 0x01,
  0x60, 0x02, 0x80, 0x14, 0x00, 0x28, 0x01, 0x40, 0x03, 0x80, 0x14, 0x00,
  0x18, 0x01, 0x40, 0x01, 0x80, 0x08, 0x00, 0x60, 0x04, 0x80, 0x21, 0x00,
  0x84, 0x06, 0x18, 0x10, 0x20, 0x40, 0x82, 0x03, 0x08, 0x04, 0x20, 0x11,
  0x00, 0x24, 0x00, 0xB0, 0x02, 0x80, 0x06, 0x00, 0x10, 0x00, 0x60, 0x02,
  0x80, 0x0A, 0x00, 0x64, 0x01, 0x10, 0x04, 0x40, 0x20, 0x80, 0x82, 0x06,
  0x08, 0x10, 0x10, 0x40, 0x42, 0x01, 0x88, 0x02, 0x60, 0x09, 0x00, 0x3C,
  0x00, 0x40, 0x80, 0x0D, 0x00, 0x24, 0x00, 0x90, 0x06, 0x20, 0x10, 0x80,
  0x42, 0x03, 0x04, 0x08, 0x10, 0x20, 0x41, 0x80, 0x84, 0x02, 0x10, 0x08,
  0xC0, 0x12, 0x00, 0x48, 0x01, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0xF0, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0xF0, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x06, 0x40, 0x04,
  0x20, 0x0C, 0x20, 0x08, 0x30, 0x18, 0x10, 0x10, 0x18, 0x30, 0x08, 0x20,
  0x0C, 0x60, 0x04, 0x40, 0x06, 0xC0, 0x02, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x0C, 0x07, 0xF1, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83, 0xF3, 0x82,
  0xC0, 0x50, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x81,
  0x50, 0x29, 0xF9, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x0C, 0x08, 0xFE, 0x24, 0x08,
  0xA0, 0x12, 0x80, 0x6C, 0x00, 0xB0, 0x02, 0xC0, 0x0A, 0x00, 0x28, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x2C, 0x00, 0xB0, 0x02, 0xC0, 0x0A, 0x80, 0x4A, 0x03, 0x24, 0x18, 0x8F,
  0xC0, 0x01, 0x81, 0xFC, 0x60, 0x18, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x06, 0x00, 0x7F, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x0C, 0x31, 0xFC, 0xCC, 0x0B, 0x20, 0x1D, 0x80, 0x74, 0x00,
  0xD0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xD0, 0x03, 0x40,
  0x15, 0x00, 0x52, 0x03, 0x4C, 0x19, 0x1F, 0xC4, 0x02, 0x00, 0xEE, 0x0C,
  0x18, 0x40, 0x46, 0x01, 0x20, 0x09, 0x00, 0x58, 0x02, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x60, 0x41, 0xFC, 0x01,
  0x81, 0x90, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x83, 0xFC, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x03, 0x00, 0xFE, 0x4C, 0x0A, 0x40,
  0x34, 0x01, 0xA0, 0x05, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x50,
  0x02, 0x80, 0x34, 0x01, 0x90, 0x14, 0xC1, 0xA3, 0xF9, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x40, 0x23,
  0xDE, 0x01, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x30, 0x8F, 0xC9, 0x06, 0xA0, 0x2A, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x10, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x18, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x17, 0xB0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x01, 0x40, 0x48, 0x19, 0x02, 0x20,
  0xC4, 0x10, 0x84, 0x11, 0x82, 0x20, 0x4C, 0x09, 0x41, 0x48, 0x30, 0x86,
  0x10, 0x83, 0x10, 0x22, 0x04, 0x40, 0x48, 0x09, 0x01, 0xA0, 0x14, 0x02,
  0x80, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x01, 0x04, 0xEC, 0x37,
  0x2C, 0x12, 0x0D, 0x40, 0xA0, 0x2C, 0x07, 0x01, 0x60, 0x18, 0x0F, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x03, 0x08,
  0xDC, 0x90, 0x6A, 0x02, 0xC0, 0x3C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x03, 0x00,
  0x7F, 0x83, 0x02, 0x08, 0x04, 0x40, 0x19, 0x00, 0x24, 0x00, 0xB0, 0x02,
  0x80, 0x0A, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0B, 0x00, 0x24, 0x00, 0x90, 0x02, 0x60, 0x18, 0x80,
  0x41, 0x02, 0x03, 0xF0, 0x03, 0x02, 0x3F, 0x09, 0x02, 0x28, 0x04, 0xA0,
  0x1B, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0x80, 0x0A, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x02, 0x80, 0x0B, 0x00, 0x2C,
  0x00, 0xB0, 0x06, 0xA0, 0x12, 0x80, 0xC9, 0x06, 0x23, 0xF0, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x00, 0x03, 0x00, 0x7E, 0x44, 0x0A, 0x40, 0x36, 0x01,
  0xA0, 0x05, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x50, 0x02, 0x80,
  0x36, 0x01, 0x90, 0x14, 0xC1, 0xA1, 0xF9, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x8F, 0x90, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x06, 0x0E, 0xF4, 0x06, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x38, 0x1B, 0xFC, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x1E, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x05, 0x40, 0x56, 0x09, 0x3F, 0x10, 0xC0, 0x1A,
  0x00, 0x90, 0x04, 0x80, 0x24, 0x03, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20,
  0x60, 0x82, 0x04, 0x10, 0x20, 0x81, 0x0C, 0x0C, 0x40, 0x22, 0x01, 0x10,
  0x08, 0x80, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x03, 0x00, 0x08, 0x00,
  0xC0, 0x10, 0x05, 0x00, 0xC0, 0x14, 0x02, 0x80, 0xD0, 0x0A, 0x02, 0x60,
  0x28, 0x08, 0x80, 0xA0, 0x22, 0x04, 0x80, 0x88, 0x11, 0x04, 0x20, 0x44,
  0x10, 0x41, 0x10, 0x41, 0x0C, 0x41, 0x04, 0x21, 0x8C, 0x10, 0x82, 0x20,
  0x62, 0x08, 0x80, 0x88, 0x22, 0x02, 0x60, 0x88, 0x09, 0x03, 0x40, 0x34,
  0x05, 0x00, 0x50, 0x14, 0x01, 0x40, 0x50, 0x06, 0x01, 0x40, 0x18, 0x02,
  0x00, 0x20, 0x08, 0x00, 0xC0, 0x34, 0x02, 0x60, 0x62, 0x04, 0x30, 0xC1,
  0x08, 0x10, 0x80, 0x90, 0x09, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x90, 0x09, 0x01, 0x18, 0x10, 0x83, 0x0C, 0x20, 0x46, 0x04, 0x40, 0x2C,
  0x02, 0x80, 0x10, 0x40, 0x0B, 0x00, 0x48, 0x02, 0x40, 0x32, 0x01, 0x18,
  0x08, 0x40, 0x42, 0x06, 0x10, 0x20, 0xC1, 0x02, 0x08, 0x10, 0xC0, 0x84,
  0x06, 0x20, 0x11, 0x00, 0x98, 0x04, 0x80, 0x34, 0x00, 0xA0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x7F,
  0x80, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08, 0x04, 0x04, 0x02, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x06, 0x03,
  0xFE, 0x01, 0xE0, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x03, 0xC0, 0x18, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x38, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x60, 0x07, 0x80, 0xE0, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x06, 0x03, 0x81, 0xC0, 0x00, 0x3E, 0x03, 0x83, 0x06, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 31, 9, 3, -31 },
  { 9, 7, 11, 13, 3, -31 },
  { 19, 17, 31, 19, 1, -31 },
  { 85, 15, 36, 17, 1, -33 },
  { 153, 21, 32, 25, 2, -32 },
  { 237, 16, 32, 17, 1, -32 },
  { 301, 1, 11, 7, 3, -31 },
  { 303, 8, 38, 12, 2, -31 },
  { 341, 7, 38, 12, 2, -31 },
  { 375, 11, 11, 15, 2, -33 },
  { 391, 15, 21, 18, 1, -26 },
  { 431, 3, 10, 8, 2, -4 },
  { 435, 9, 2, 12, 1, -13 },
  { 438, 2, 3, 8, 3, -3 },
  { 439, 13, 31, 14, 1, -31 },
  { 490, 13, 32, 17, 2, -32 },
  { 542, 8, 31, 17, 3, -31 },
  { 573, 13, 32, 17, 2, -32 },
  { 625, 13, 32, 17, 2, -32 },
  { 677, 16, 32, 17, 1, -32 },
  { 741, 13, 31, 17, 2, -31 },
  { 792, 13, 33, 17, 2, -32 },
  { 846, 13, 31, 17, 2, -31 },
  { 897, 14, 32, 17, 2, -32 },
  { 953, 13, 32, 17, 2, -32 },
  { 1005, 2, 23, 8, 3, -23 },
  { 1011, 3, 29, 8, 2, -23 },
  { 1022, 15, 18, 18, 1, -25 },
  { 1056, 15, 11, 18, 1, -21 },
  { 1077, 15, 18, 18, 1, -25 },
  { 1111, 10, 32, 12, 1, -32 },
  { 1151, 22, 36, 27, 2, -32 },
  { 1250, 17, 31, 17, 0, -31 },
  { 1316, 14, 31, 19, 3, -31 },
  { 1371, 15, 32, 18, 2, -32 },
  { 1431, 15, 31, 21, 3, -31 },
  { 1490, 12, 31, 17, 3, -31 },
  { 1537, 12, 31, 15, 3, -31 },
  { 1584, 18, 32, 23, 2, -32 },
  { 1656, 15, 31, 21, 3, -31 },
  { 1715, 6, 31, 10, 2, -31 },
  { 1739, 7, 39, 8, -2, -31 },
  { 1774, 14, 31, 17, 3, -31 },
  { 1829, 11, 31, 15, 3, -31 },
  { 1872, 22, 31, 29, 3, -31 },
  { 1958, 16, 31, 22, 3, -31 },
  { 2020, 18, 32, 22, 2, -32 },
  { 2092, 13, 31, 17, 3, -31 },
  { 2143, 18, 39, 22, 2, -32 },
  { 2231, 14, 31, 18, 3, -31 },
  { 2286, 13, 32, 17, 2, -32 },
  { 2338, 14, 31, 15, 0, -31 },
  { 2393, 15, 31, 21, 3, -31 },
  { 2452, 16, 31, 16, 0, -31 },
  { 2514, 28, 31, 28, 0, -31 },
  { 2623, 14, 31, 15, 0, -31 },
  { 2678, 14, 31, 14, 0, -31 },
  { 2733, 12, 31, 14, 1, -31 },
  { 2780, 8, 38, 13, 4, -31 },
  { 2818, 13, 31, 14, 1, -31 },
  { 2869, 8, 38, 13, 2, -31 },
  { 2907, 16, 15, 17, 1, -31 },
  { 2937, 17, 1, 17, 0, 4 },
  { 2940, 6, 7, 10, 2, -34 },
  { 2946, 11, 24, 16, 2, -24 },
  { 2979, 14, 33, 19, 3, -33 },
  { 3037, 11, 24, 14, 2, -24 },
  { 3070, 14, 33, 19, 2, -33 },
  { 3128, 13, 24, 17, 2, -24 },
  { 3167, 10, 34, 9, 0, -34 },
  { 3210, 13, 35, 19, 2, -24 },
  { 3267, 12, 33, 18, 3, -33 },
  { 3317, 2, 32, 8, 3, -32 },
  { 3325, 5, 43, 8, 0, -32 },
  { 3352, 11, 33, 14, 3, -33 },
  { 3398, 1, 33, 7, 3, -33 },
  { 3403, 21, 24, 27, 3, -24 },
  { 3466, 12, 24, 18, 3, -24 },
  { 3502, 14, 24, 18, 2, -24 },
  { 3544, 14, 34, 19, 3, -24 },
  { 3604, 13, 34, 19, 2, -24 },
  { 3660, 8, 24, 12, 3, -24 },
  { 3684, 10, 24, 14, 2, -24 },
  { 3714, 8, 29, 9, 1, -29 },
  { 3743, 12, 23, 18, 3, -23 },
  { 3778, 13, 23, 13, 0, -23 },
  { 3816, 22, 23, 23, 0, -23 },
  { 3880, 12, 23, 14, 1, -23 },
  { 3915, 13, 34, 14, 0, -23 },
  { 3971, 9, 23, 11, 1, -23 },
  { 3997, 11, 38, 15, 2, -31 },
  { 4050, 1, 44, 17, 8, -33 },
  { 4056, 11, 38, 15, 2, -31 },
  { 4109, 15, 3, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Thin44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN44PT7B_H_
