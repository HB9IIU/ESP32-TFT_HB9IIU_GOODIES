#ifndef _NOTOSANS_EXTRACONDENSED_THIN7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x5E, 0xEC, 0xD1, 0x3E, 0xEC, 0xF3, 0x70, 0xDA, 0x7E,
  0xC0, 0x6A, 0x90, 0xFC, 0xC0, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x56, 0x80,
  0xFF, 0xC0, 0xF8, 0xD5, 0xC0, 0xD5, 0xC0, 0x4B, 0x74, 0xE5, 0xC0, 0xEF,
  0xC0, 0xD5, 0x80, 0xF5, 0x5E, 0xFD, 0xC0, 0x90, 0x98, 0x71, 0x80, 0xE0,
  0xC7, 0x00, 0xDA, 0x80, 0x7B, 0xFF, 0x86, 0x5B, 0x5A, 0xBB, 0xC0, 0xF2,
  0x46, 0xBF, 0x80, 0xF8, 0xF8, 0x72, 0x56, 0xFF, 0xC0, 0xF8, 0xFC, 0xEA,
  0xC0, 0xF8, 0xB6, 0xFE, 0xFF, 0xC0, 0xF6, 0xDE, 0xBA, 0x80, 0xF6, 0xDE,
  0x40, 0xBA, 0xC0, 0xE5, 0xC0, 0xD5, 0x40, 0xB6, 0xDE, 0xB7, 0x64, 0xAD,
  0x7C, 0xE5, 0x00, 0xD7, 0xC0, 0xF9, 0x40, 0xD6, 0xC0, 0xFC, 0xA5, 0x40,
  0xD5, 0x70, 0x54, 0xE0, 0x80, 0xDF, 0x9E, 0xDE, 0x6B, 0x7F, 0xC0, 0xFB,
  0xEA, 0x80, 0xFF, 0x70, 0xBF, 0xC0, 0xF8, 0xFE, 0xBB, 0xC0, 0xF8, 0xFB,
  0xBB, 0xFF, 0xD6, 0xF0, 0xF6, 0xF9, 0x00, 0xFF, 0x50, 0xEA, 0xE7, 0xF8,
  0xFF, 0xFA, 0xDD, 0xAA, 0xEB, 0xF5, 0xA0, 0xDB, 0x57, 0x50, 0xFE, 0xD5,
  0x70, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 1, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 3, 5, 3, 0, -5 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 3, 5, 3, 0, -5 },
  { 12, 1, 2, 1, 0, -5 },
  { 13, 2, 6, 2, 0, -5 },
  { 15, 1, 6, 2, 0, -5 },
  { 16, 2, 1, 2, 0, -5 },
  { 17, 3, 3, 3, 0, -4 },
  { 19, 1, 2, 1, 0, -1 },
  { 20, 2, 1, 2, 0, -2 },
  { 21, 1, 1, 1, 0, -1 },
  { 22, 2, 5, 2, 0, -5 },
  { 24, 2, 5, 3, 0, -5 },
  { 26, 1, 5, 3, 1, -5 },
  { 27, 2, 5, 3, 0, -5 },
  { 29, 2, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 2, 5, 3, 0, -5 },
  { 35, 2, 5, 3, 0, -5 },
  { 37, 2, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 2, 5, 3, 0, -5 },
  { 43, 1, 4, 1, 0, -4 },
  { 44, 1, 5, 1, 0, -4 },
  { 45, 3, 3, 3, 0, -4 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 2, 5, 2, 0, -5 },
  { 52, 4, 6, 4, 0, -5 },
  { 55, 3, 5, 3, 0, -5 },
  { 57, 2, 5, 3, 1, -5 },
  { 59, 3, 5, 3, 0, -5 },
  { 61, 2, 5, 3, 1, -5 },
  { 63, 1, 5, 3, 1, -5 },
  { 64, 1, 5, 2, 1, -5 },
  { 65, 3, 5, 4, 0, -5 },
  { 67, 2, 5, 3, 1, -5 },
  { 69, 1, 5, 2, 0, -5 },
  { 70, 1, 6, 1, 0, -5 },
  { 71, 2, 5, 3, 1, -5 },
  { 73, 1, 5, 2, 1, -5 },
  { 74, 3, 5, 5, 1, -5 },
  { 76, 2, 5, 4, 1, -5 },
  { 78, 3, 5, 4, 0, -5 },
  { 80, 2, 5, 3, 1, -5 },
  { 82, 3, 6, 4, 0, -5 },
  { 85, 2, 5, 3, 1, -5 },
  { 87, 2, 5, 3, 0, -5 },
  { 89, 2, 5, 2, 0, -5 },
  { 91, 3, 5, 3, 0, -5 },
  { 93, 3, 5, 3, 0, -5 },
  { 95, 5, 5, 5, 0, -5 },
  { 99, 2, 5, 2, 0, -5 },
  { 101, 2, 5, 2, 0, -5 },
  { 103, 2, 5, 2, 0, -5 },
  { 105, 1, 6, 2, 1, -5 },
  { 106, 2, 5, 2, 0, -5 },
  { 108, 2, 6, 2, 0, -5 },
  { 110, 3, 2, 3, 0, -5 },
  { 111, 3, 1, 3, 0, 0 },
  { 112, 1, 1, 2, 0, -5 },
  { 113, 2, 4, 3, 0, -4 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 2, 4, 2, 0, -4 },
  { 117, 2, 5, 3, 0, -5 },
  { 119, 2, 4, 3, 0, -4 },
  { 120, 2, 5, 1, 0, -5 },
  { 122, 2, 6, 3, 0, -4 },
  { 124, 2, 5, 3, 0, -5 },
  { 126, 1, 5, 1, 0, -5 },
  { 127, 1, 7, 1, 0, -5 },
  { 128, 2, 5, 2, 0, -5 },
  { 130, 1, 5, 1, 0, -5 },
  { 131, 4, 4, 4, 0, -4 },
  { 133, 2, 4, 3, 0, -4 },
  { 134, 3, 4, 3, 0, -4 },
  { 136, 3, 6, 3, 0, -4 },
  { 139, 2, 6, 3, 0, -4 },
  { 141, 2, 4, 2, 0, -4 },
  { 142, 2, 4, 2, 0, -4 },
  { 143, 1, 5, 1, 0, -5 },
  { 144, 2, 4, 3, 0, -4 },
  { 145, 2, 4, 2, 0, -4 },
  { 146, 4, 4, 4, 0, -4 },
  { 148, 2, 4, 2, 0, -4 },
  { 149, 2, 6, 2, 0, -4 },
  { 151, 2, 4, 2, 0, -4 },
  { 152, 2, 6, 2, 0, -5 },
  { 154, 1, 7, 3, 1, -5 },
  { 155, 2, 6, 2, 0, -5 },
  { 157, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Thin7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN7PT7B_H_
