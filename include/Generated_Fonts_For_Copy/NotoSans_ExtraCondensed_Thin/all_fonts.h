#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_ExtraCondensed_Thin
// Headers: 67

#include "NotoSans_ExtraCondensed_Thin6pt7b.h"
#include "NotoSans_ExtraCondensed_Thin7pt7b.h"
#include "NotoSans_ExtraCondensed_Thin8pt7b.h"
#include "NotoSans_ExtraCondensed_Thin9pt7b.h"
#include "NotoSans_ExtraCondensed_Thin10pt7b.h"
#include "NotoSans_ExtraCondensed_Thin11pt7b.h"
#include "NotoSans_ExtraCondensed_Thin12pt7b.h"
#include "NotoSans_ExtraCondensed_Thin13pt7b.h"
#include "NotoSans_ExtraCondensed_Thin14pt7b.h"
#include "NotoSans_ExtraCondensed_Thin15pt7b.h"
#include "NotoSans_ExtraCondensed_Thin16pt7b.h"
#include "NotoSans_ExtraCondensed_Thin17pt7b.h"
#include "NotoSans_ExtraCondensed_Thin18pt7b.h"
#include "NotoSans_ExtraCondensed_Thin19pt7b.h"
#include "NotoSans_ExtraCondensed_Thin20pt7b.h"
#include "NotoSans_ExtraCondensed_Thin21pt7b.h"
#include "NotoSans_ExtraCondensed_Thin22pt7b.h"
#include "NotoSans_ExtraCondensed_Thin23pt7b.h"
#include "NotoSans_ExtraCondensed_Thin24pt7b.h"
#include "NotoSans_ExtraCondensed_Thin25pt7b.h"
#include "NotoSans_ExtraCondensed_Thin26pt7b.h"
#include "NotoSans_ExtraCondensed_Thin27pt7b.h"
#include "NotoSans_ExtraCondensed_Thin28pt7b.h"
#include "NotoSans_ExtraCondensed_Thin29pt7b.h"
#include "NotoSans_ExtraCondensed_Thin30pt7b.h"
#include "NotoSans_ExtraCondensed_Thin31pt7b.h"
#include "NotoSans_ExtraCondensed_Thin32pt7b.h"
#include "NotoSans_ExtraCondensed_Thin33pt7b.h"
#include "NotoSans_ExtraCondensed_Thin34pt7b.h"
#include "NotoSans_ExtraCondensed_Thin35pt7b.h"
#include "NotoSans_ExtraCondensed_Thin36pt7b.h"
#include "NotoSans_ExtraCondensed_Thin37pt7b.h"
#include "NotoSans_ExtraCondensed_Thin38pt7b.h"
#include "NotoSans_ExtraCondensed_Thin39pt7b.h"
#include "NotoSans_ExtraCondensed_Thin40pt7b.h"
#include "NotoSans_ExtraCondensed_Thin41pt7b.h"
#include "NotoSans_ExtraCondensed_Thin42pt7b.h"
#include "NotoSans_ExtraCondensed_Thin43pt7b.h"
#include "NotoSans_ExtraCondensed_Thin44pt7b.h"
#include "NotoSans_ExtraCondensed_Thin45pt7b.h"
#include "NotoSans_ExtraCondensed_Thin46pt7b.h"
#include "NotoSans_ExtraCondensed_Thin47pt7b.h"
#include "NotoSans_ExtraCondensed_Thin48pt7b.h"
#include "NotoSans_ExtraCondensed_Thin49pt7b.h"
#include "NotoSans_ExtraCondensed_Thin50pt7b.h"
#include "NotoSans_ExtraCondensed_Thin51pt7b.h"
#include "NotoSans_ExtraCondensed_Thin52pt7b.h"
#include "NotoSans_ExtraCondensed_Thin53pt7b.h"
#include "NotoSans_ExtraCondensed_Thin54pt7b.h"
#include "NotoSans_ExtraCondensed_Thin55pt7b.h"
#include "NotoSans_ExtraCondensed_Thin56pt7b.h"
#include "NotoSans_ExtraCondensed_Thin57pt7b.h"
#include "NotoSans_ExtraCondensed_Thin58pt7b.h"
#include "NotoSans_ExtraCondensed_Thin59pt7b.h"
#include "NotoSans_ExtraCondensed_Thin60pt7b.h"
#include "NotoSans_ExtraCondensed_Thin61pt7b.h"
#include "NotoSans_ExtraCondensed_Thin62pt7b.h"
#include "NotoSans_ExtraCondensed_Thin63pt7b.h"
#include "NotoSans_ExtraCondensed_Thin64pt7b.h"
#include "NotoSans_ExtraCondensed_Thin65pt7b.h"
#include "NotoSans_ExtraCondensed_Thin66pt7b.h"
#include "NotoSans_ExtraCondensed_Thin67pt7b.h"
#include "NotoSans_ExtraCondensed_Thin68pt7b.h"
#include "NotoSans_ExtraCondensed_Thin69pt7b.h"
#include "NotoSans_ExtraCondensed_Thin70pt7b.h"
#include "NotoSans_ExtraCondensed_Thin71pt7b.h"
#include "NotoSans_ExtraCondensed_Thin72pt7b.h"
