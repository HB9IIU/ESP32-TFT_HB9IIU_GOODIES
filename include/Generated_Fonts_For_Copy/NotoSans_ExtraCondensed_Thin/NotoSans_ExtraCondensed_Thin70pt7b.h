#ifndef _NOTOSANS_EXTRACONDENSED_THIN70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin70pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x04,
  0xEF, 0xFE, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0,
  0x10, 0x00, 0x18, 0x02, 0x00, 0x02, 0x00, 0x40, 0x00, 0x40, 0x18, 0x00,
  0x08, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00,
  0xC0, 0x10, 0x00, 0x10, 0x06, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0x80, 0x20, 0x00, 0x20, 0x04, 0x00, 0x04, 0x00, 0x80,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x08, 0x00,
  0x08, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x0C, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x18, 0x02, 0x00, 0x02, 0x00, 0x40, 0x00, 0x40, 0x18,
  0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x80, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x7E, 0x03, 0x8C, 0x0E,
  0x0C, 0x18, 0x04, 0x30, 0x30, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x01, 0x00, 0xC0, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x18,
  0x00, 0x0E, 0x30, 0x00, 0x07, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x06, 0xF0, 0x00, 0x0C, 0x70, 0x00, 0x18, 0x38,
  0x00, 0x30, 0x38, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x07, 0x40, 0x18, 0x1C, 0xF0, 0x30,
  0x70, 0xFE, 0x6F, 0x80, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x01, 0x86, 0x00, 0x0C,
  0x00, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x30, 0x01, 0x80, 0x18, 0x04, 0x00,
  0x60, 0x06, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x10, 0x02, 0x00, 0x80, 0x0C, 0x00, 0x80, 0x60, 0x03, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0x0C, 0x04, 0x00, 0x30, 0x03, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0xC0, 0x03, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x0C, 0x18, 0x00,
  0x30, 0x03, 0x06, 0x00, 0x0C, 0x00, 0xC1, 0x00, 0x03, 0x00, 0x30, 0xC0,
  0x00, 0xC0, 0x0C, 0x30, 0x38, 0x30, 0x02, 0x08, 0x3F, 0x04, 0x00, 0x86,
  0x18, 0x61, 0x00, 0x61, 0x8C, 0x0C, 0x60, 0x18, 0x43, 0x03, 0x18, 0x06,
  0x30, 0x80, 0x66, 0x01, 0x0C, 0x60, 0x18, 0xC0, 0xC2, 0x18, 0x06, 0x30,
  0x31, 0x86, 0x00, 0x86, 0x18, 0x61, 0x00, 0x30, 0xFC, 0x10, 0x40, 0x0C,
  0x0C, 0x0C, 0x10, 0x03, 0x00, 0x03, 0x0C, 0x00, 0xC0, 0x00, 0x83, 0x00,
  0x30, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x18, 0x30, 0x03, 0x00, 0x04, 0x0C,
  0x00, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x30,
  0x30, 0x03, 0x00, 0x18, 0x04, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x30, 0x01,
  0x80, 0x40, 0x08, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x30, 0x06, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x60, 0x06, 0x00, 0x20, 0x18, 0x01, 0x80, 0x0C, 0x0C,
  0x00, 0x60, 0x01, 0x03, 0x00, 0x30, 0x00, 0x61, 0x80, 0x0C, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x20, 0x18, 0x00,
  0x30, 0x04, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x08,
  0x00, 0x10, 0x04, 0x00, 0x08, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0x88, 0x00, 0x01, 0x86, 0x00, 0x01, 0x81, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0xC0, 0x30, 0x0C, 0x60, 0x18, 0x06, 0x60, 0x06, 0x02,
  0x30, 0x01, 0x01, 0x10, 0x00, 0xC0, 0x98, 0x00, 0x20, 0xCC, 0x00, 0x18,
  0x66, 0x00, 0x04, 0x33, 0x00, 0x03, 0x11, 0x80, 0x00, 0xD8, 0xC0, 0x00,
  0x6C, 0x60, 0x00, 0x1C, 0x10, 0x00, 0x06, 0x08, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x83, 0x00, 0x03, 0x60, 0xC0, 0x03, 0x18, 0x60, 0x03, 0x8C, 0x18,
  0x03, 0x83, 0x07, 0x07, 0x81, 0x81, 0xFF, 0x00, 0x60, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x70, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x0C,
  0x1C, 0xF3, 0x3C, 0x07, 0xB8, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x04, 0x80,
  0x02, 0x10, 0x01, 0x86, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30, 0x03, 0x04,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x18, 0xC6, 0x31, 0x98, 0xC6, 0x33, 0x18, 0xC6, 0x63, 0x10,
  0xFF, 0xFF, 0xFF, 0xFC, 0x5F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xF0, 0x00, 0xE1, 0xC0, 0x0C, 0x03, 0x00, 0xC0, 0x0C,
  0x06, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80,
  0x01, 0x8C, 0x00, 0x0C, 0x40, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x09,
  0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1A, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0xB0, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30,
  0x30, 0x03, 0x01, 0xC0, 0x38, 0x07, 0x01, 0x80, 0x1E, 0x78, 0x00, 0x7F,
  0x80, 0x00, 0x30, 0x07, 0x01, 0xF0, 0x3B, 0x07, 0x30, 0xE3, 0x1C, 0x33,
  0x83, 0xE0, 0x34, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0x83, 0xC0,
  0xE0, 0x03, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x0F,
  0x03, 0xC0, 0xE0, 0x07, 0x0C, 0x00, 0x0C, 0x40, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18,
  0xC0, 0x01, 0xC7, 0xC0, 0x78, 0x0F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x10,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x61, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0x80, 0x78, 0x08, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x30, 0x00, 0xE0, 0xF8, 0x1F, 0x00, 0xFF, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xE3, 0x80, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x04, 0x00, 0x61, 0xFF,
  0x01, 0x0F, 0x0E, 0x04, 0xE0, 0x0C, 0x13, 0x00, 0x18, 0xD8, 0x00, 0x33,
  0x40, 0x00, 0xCF, 0x00, 0x03, 0x38, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80,
  0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xC0, 0x00, 0x09, 0x00, 0x00,
  0x24, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x60, 0x00, 0x09, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x18, 0x80, 0x00, 0x63, 0x00,
  0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x01, 0x81, 0xC0, 0x06,
  0x03, 0x80, 0x30, 0x07, 0x03, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x78, 0x07, 0x00, 0x30, 0x18,
  0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC1, 0x80, 0x06, 0x07, 0x00, 0x30, 0x0E, 0x01, 0x80, 0x1C, 0x0C,
  0x00, 0x38, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00,
  0x38, 0xE0, 0x01, 0xC0, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x03, 0x03, 0x00,
  0x06, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x80, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x0E, 0x00, 0x18,
  0x1C, 0x00, 0xE0, 0x3C, 0x0F, 0x00, 0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x1F, 0xF0, 0x03, 0xC1, 0xC0, 0x38, 0x07, 0x01, 0x80, 0x1C,
  0x18, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x26, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x0B,
  0x00, 0x00, 0x58, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xE8,
  0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x03, 0xCC, 0x00, 0x16, 0x60, 0x01,
  0xB1, 0x80, 0x19, 0x87, 0x03, 0x8C, 0x1F, 0xF8, 0x60, 0x1F, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0x81, 0xE0, 0x0F, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x5F, 0xFE, 0x39, 0xCE, 0x71, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x63, 0x18, 0xC6, 0x73, 0x18, 0xCC, 0x63, 0x11, 0x8C, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xF0,
  0xF0, 0x78, 0x40, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x1F, 0x00, 0x63, 0x00, 0x0F, 0xF8, 0x06,
  0x60, 0x03, 0x03, 0x00, 0xCC, 0x00, 0xC0, 0x60, 0x19, 0x80, 0x30, 0x0C,
  0x03, 0x20, 0x06, 0x01, 0x00, 0x6C, 0x01, 0x80, 0x20, 0x05, 0x80, 0x30,
  0x0C, 0x00, 0xF0, 0x04, 0x01, 0x80, 0x1E, 0x01, 0x80, 0x30, 0x03, 0xC0,
  0x30, 0x06, 0x00, 0x78, 0x06, 0x00, 0xC0, 0x0F, 0x00, 0xC0, 0x18, 0x01,
  0xE0, 0x18, 0x03, 0x00, 0x3C, 0x03, 0x00, 0x60, 0x07, 0x80, 0x60, 0x0C,
  0x00, 0xF0, 0x0C, 0x01, 0x80, 0x1E, 0x01, 0x80, 0x30, 0x02, 0xC0, 0x30,
  0x06, 0x00, 0xD8, 0x06, 0x00, 0xC0, 0x1B, 0x00, 0xC0, 0x38, 0x03, 0x60,
  0x18, 0x05, 0x00, 0x6C, 0x03, 0x00, 0xA0, 0x19, 0x80, 0x30, 0x36, 0x03,
  0x30, 0x06, 0x06, 0xC0, 0xE2, 0x00, 0x61, 0x8C, 0x38, 0x60, 0x0F, 0xE1,
  0xFE, 0x0C, 0x00, 0x78, 0x1F, 0x81, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x08, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x01, 0x80, 0x20, 0x00, 0x60, 0x0C, 0x00, 0x10, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x80, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0x81, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x30, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0C, 0x00, 0x3C, 0x30, 0x00,
  0x38, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0xE3,
  0x00, 0x07, 0x0C, 0x00, 0x78, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0x00,
  0x07, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0xCC, 0x00, 0x0E, 0x30,
  0x00, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0xF8, 0x03, 0xE0, 0x78, 0x0E, 0x00, 0x10, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x02, 0x00, 0xF0, 0x1C, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x07, 0x80, 0xC0,
  0x01, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0,
  0x07, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0xFE, 0xFF, 0xFF, 0xB0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x11, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x10, 0x38, 0x00, 0x01, 0x00, 0xE0, 0x00, 0x30, 0x07, 0xC0,
  0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xFF, 0xCF, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x1E, 0x3F, 0xF0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xCF, 0xF9, 0xFC, 0x00, 0xC0, 0x00, 0x3B, 0x00, 0x00,
  0xCC, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0xE0, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x30, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x60, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x31, 0xE0,
  0x00, 0xCD, 0x80, 0x03, 0x67, 0x00, 0x0D, 0x8C, 0x00, 0x3C, 0x30, 0x00,
  0xE0, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFD,
  0x00, 0x00, 0x00, 0x1F, 0xB0, 0x00, 0x00, 0x03, 0xF6, 0x00, 0x00, 0x00,
  0xDE, 0x40, 0x00, 0x00, 0x1B, 0xCC, 0x00, 0x00, 0x03, 0x79, 0x80, 0x00,
  0x00, 0x4F, 0x30, 0x00, 0x00, 0x19, 0xE3, 0x00, 0x00, 0x03, 0x3C, 0x60,
  0x00, 0x00, 0x67, 0x8C, 0x00, 0x00, 0x18, 0xF0, 0xC0, 0x00, 0x03, 0x1E,
  0x18, 0x00, 0x00, 0x63, 0xC3, 0x00, 0x00, 0x18, 0x78, 0x20, 0x00, 0x03,
  0x0F, 0x06, 0x00, 0x00, 0x61, 0xE0, 0xC0, 0x00, 0x18, 0x3C, 0x18, 0x00,
  0x03, 0x07, 0x81, 0x80, 0x00, 0x60, 0xF0, 0x30, 0x00, 0x08, 0x1E, 0x06,
  0x00, 0x03, 0x03, 0xC0, 0x60, 0x00, 0x60, 0x78, 0x0C, 0x00, 0x0C, 0x0F,
  0x01, 0x80, 0x03, 0x01, 0xE0, 0x10, 0x00, 0x60, 0x3C, 0x03, 0x00, 0x0C,
  0x07, 0x80, 0x60, 0x03, 0x00, 0xF0, 0x04, 0x00, 0x60, 0x1E, 0x00, 0xC0,
  0x0C, 0x03, 0xC0, 0x18, 0x01, 0x00, 0x78, 0x03, 0x00, 0x60, 0x0F, 0x00,
  0x30, 0x0C, 0x01, 0xE0, 0x06, 0x01, 0x80, 0x3C, 0x00, 0xC0, 0x60, 0x07,
  0x80, 0x0C, 0x0C, 0x00, 0xF0, 0x01, 0x81, 0x80, 0x1E, 0x00, 0x30, 0x60,
  0x03, 0xC0, 0x02, 0x0C, 0x00, 0x78, 0x00, 0x61, 0x80, 0x0F, 0x00, 0x0C,
  0x60, 0x01, 0xE0, 0x01, 0x8C, 0x00, 0x3C, 0x00, 0x19, 0x80, 0x07, 0x80,
  0x03, 0x30, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0C, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3D, 0x80, 0x00,
  0x1E, 0xC0, 0x00, 0x0F, 0x20, 0x00, 0x07, 0x98, 0x00, 0x03, 0xC4, 0x00,
  0x01, 0xE3, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x78, 0x60, 0x00, 0x3C, 0x30,
  0x00, 0x1E, 0x0C, 0x00, 0x0F, 0x06, 0x00, 0x07, 0x81, 0x00, 0x03, 0xC0,
  0xC0, 0x01, 0xE0, 0x60, 0x00, 0xF0, 0x18, 0x00, 0x78, 0x0C, 0x00, 0x3C,
  0x03, 0x00, 0x1E, 0x01, 0x80, 0x0F, 0x00, 0x60, 0x07, 0x80, 0x30, 0x03,
  0xC0, 0x08, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x00, 0xC0,
  0x3C, 0x00, 0x60, 0x1E, 0x00, 0x18, 0x0F, 0x00, 0x0C, 0x07, 0x80, 0x03,
  0x03, 0xC0, 0x01, 0x81, 0xE0, 0x00, 0x40, 0xF0, 0x00, 0x30, 0x78, 0x00,
  0x18, 0x3C, 0x00, 0x06, 0x1E, 0x00, 0x03, 0x0F, 0x00, 0x00, 0xC7, 0x80,
  0x00, 0x63, 0xC0, 0x00, 0x11, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x06, 0x78,
  0x00, 0x01, 0xBC, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xC0, 0x00,
  0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C,
  0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x70, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x0E, 0x00,
  0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x0C, 0x00, 0xF0, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00,
  0x4C, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00,
  0x0C, 0x30, 0x00, 0x60, 0xC0, 0x07, 0x03, 0x00, 0xF8, 0x0F, 0xFF, 0x80,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x01,
  0x80, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60,
  0xC0, 0x01, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x01, 0xE0, 0x3E,
  0x1C, 0x00, 0x21, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x80, 0x01,
  0xC7, 0xC0, 0x7C, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x07, 0x81, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x60, 0x40, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x04,
  0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10, 0x60, 0x00, 0x06, 0x18,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x50, 0x00, 0x03, 0x10, 0x00, 0x02, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x36, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0x30, 0x00,
  0x0D, 0x80, 0x00, 0x61, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x04, 0x00, 0x02,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x31, 0x80, 0x01, 0x81, 0x80, 0x01, 0x8C,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x60, 0x00, 0x63, 0x00,
  0x03, 0x01, 0x80, 0x02, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x80, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x18, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x02, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x60, 0x02, 0x00, 0x60, 0x30, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x80, 0x30, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x0C,
  0x02, 0x00, 0x06, 0x03, 0x00, 0x20, 0x30, 0x00, 0x30, 0x30, 0x01, 0x81,
  0x80, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x08, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x61, 0x80, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x01,
  0x8C, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x02, 0x30, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x00, 0x4C, 0x00, 0x06, 0x40, 0x00, 0x03, 0x60, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0xB0, 0x00, 0x00, 0xD0, 0x00, 0x05,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x20,
  0x04, 0x03, 0x00, 0x30, 0x18, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x30,
  0x60, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x00, 0x98, 0x00,
  0x06, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00,
  0x66, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x0C, 0x02, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30,
  0x02, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x02, 0x06, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x36, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80,
  0x06, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x33,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x06, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x19, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x00, 0xE0, 0x03, 0xFF, 0x03, 0xE0, 0xE0, 0xC0, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x3F, 0xEC, 0x3C, 0x03, 0x1C, 0x00,
  0xCC, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xB6, 0x00, 0x6D, 0xC0, 0x13, 0x38, 0x1C,
  0xC7, 0xFC, 0x30, 0x3C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0xC1, 0xFE, 0x03, 0x1E, 0x1E, 0x0C, 0xE0, 0x1C, 0x36, 0x00, 0x38,
  0xD8, 0x00, 0x63, 0xC0, 0x00, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xE0,
  0x00, 0x1B, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xE0, 0x00, 0x13, 0x80, 0x00, 0xCE,
  0x00, 0x03, 0x3C, 0x00, 0x18, 0xD8, 0x00, 0x63, 0x60, 0x03, 0x0C, 0xC0,
  0x1C, 0x31, 0xC1, 0xE0, 0x83, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x3F, 0xF0, 0x3C, 0x18, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x81, 0x80, 0x7F, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x03, 0x01, 0xFE,
  0x0C, 0x1E, 0x1E, 0x30, 0xE0, 0x1C, 0xC3, 0x00, 0x33, 0x18, 0x00, 0x6C,
  0xE0, 0x00, 0xF3, 0x00, 0x03, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80,
  0x00, 0x76, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00, 0x03, 0xCC,
  0x00, 0x0B, 0x18, 0x00, 0x6C, 0x60, 0x03, 0x30, 0xC0, 0x1C, 0xC1, 0xC0,
  0xE3, 0x03, 0xFE, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xE0,
  0x07, 0x87, 0x00, 0xE0, 0x18, 0x1C, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00,
  0x63, 0x00, 0x06, 0x30, 0x00, 0x26, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x34, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x10, 0xE0,
  0x06, 0x07, 0x81, 0xE0, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0x01, 0xC2, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x38, 0x00,
  0x07, 0xFC, 0x30, 0x78, 0x78, 0xC3, 0x80, 0x33, 0x1C, 0x00, 0x6C, 0x60,
  0x01, 0xB3, 0x00, 0x03, 0xCC, 0x00, 0x07, 0x20, 0x00, 0x1D, 0x80, 0x00,
  0x76, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x01, 0xD8,
  0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x03, 0xCC, 0x00,
  0x0B, 0x30, 0x00, 0x2C, 0x60, 0x01, 0xB1, 0x80, 0x0C, 0xC3, 0x00, 0x63,
  0x07, 0x07, 0x0C, 0x0F, 0xF8, 0x30, 0x07, 0x80, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x38, 0x78, 0x03, 0x80, 0x7F,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x01, 0x00, 0xC3, 0xFE, 0x18, 0xF1, 0xE3,
  0x38, 0x0E, 0x6E, 0x00, 0xCD, 0x80, 0x0D, 0xE0, 0x01, 0xBC, 0x00, 0x37,
  0x00, 0x02, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x5F,
  0xFE, 0x00, 0x00, 0x00, 0x36, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x06, 0x07, 0x0F, 0x07, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C,
  0x0C, 0xF8, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x30,
  0x18, 0x30, 0x0C, 0x18, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x8E, 0x00, 0xCD,
  0x80, 0x66, 0xC0, 0x36, 0x30, 0x1E, 0x18, 0x0F, 0x06, 0x07, 0x03, 0x03,
  0x01, 0x81, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03,
  0x0C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x02, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0xC0, 0x41, 0xFE, 0x03, 0xFC, 0x21, 0x83, 0x83, 0x87, 0x11, 0x80,
  0xC3, 0x01, 0xC9, 0x80, 0x33, 0x00, 0x64, 0x80, 0x19, 0x00, 0x1A, 0x80,
  0x05, 0x80, 0x0D, 0xC0, 0x03, 0x80, 0x06, 0xE0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x18, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x07,
  0x80, 0x01, 0x00, 0x03, 0xC0, 0x00, 0x80, 0x01, 0xE0, 0x00, 0x40, 0x00,
  0xF0, 0x00, 0x20, 0x00, 0x78, 0x00, 0x10, 0x00, 0x3C, 0x00, 0x08, 0x00,
  0x1E, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x07, 0x80, 0x01, 0x00,
  0x03, 0xC0, 0x00, 0x80, 0x01, 0xE0, 0x00, 0x40, 0x00, 0xF0, 0x00, 0x20,
  0x00, 0x78, 0x00, 0x10, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x1E, 0x00, 0x04,
  0x00, 0x0F, 0x00, 0x02, 0x00, 0x07, 0x80, 0x01, 0x00, 0x03, 0xC0, 0x00,
  0x80, 0x01, 0xE0, 0x00, 0x40, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x78, 0x00,
  0x10, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x70, 0x10, 0x7F, 0xC2, 0x1C, 0x1C, 0x47, 0x01, 0xC9, 0x80, 0x19, 0x30,
  0x01, 0xAC, 0x00, 0x35, 0x00, 0x06, 0xA0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x00,
  0x78, 0x78, 0x03, 0x80, 0x30, 0x1C, 0x00, 0x60, 0x60, 0x01, 0xC3, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x98, 0x00, 0x02, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x62, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00,
  0x30, 0x60, 0x00, 0xC1, 0xC0, 0x06, 0x03, 0x80, 0x30, 0x07, 0x03, 0x80,
  0x0F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x04, 0x1F, 0xF0, 0x21,
  0xE1, 0xE1, 0x1C, 0x03, 0x88, 0xC0, 0x0C, 0x4C, 0x00, 0x32, 0x40, 0x00,
  0xD6, 0x00, 0x06, 0xA0, 0x00, 0x35, 0x00, 0x00, 0xB8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x0B, 0x80, 0x00, 0xDE, 0x00, 0x06, 0xD0, 0x00, 0x66, 0xC0, 0x03, 0x37,
  0x00, 0x31, 0x9C, 0x03, 0x8C, 0x70, 0x78, 0x61, 0xFF, 0x03, 0x01, 0xE0,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x30, 0x78, 0x78,
  0xC3, 0x80, 0x73, 0x0C, 0x00, 0xEC, 0x60, 0x01, 0xB1, 0x80, 0x02, 0xCC,
  0x00, 0x0F, 0x30, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1D,
  0x80, 0x00, 0x76, 0x00, 0x01, 0xCC, 0x00, 0x0B, 0x30, 0x00, 0x2C, 0x60,
  0x01, 0xB1, 0xC0, 0x0C, 0xC3, 0x80, 0x63, 0x07, 0x87, 0x8C, 0x0F, 0xF8,
  0x30, 0x07, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x83, 0xFC, 0x3D,
  0xA3, 0x81, 0x98, 0x0D, 0x80, 0x68, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x0F, 0xFE, 0x1E, 0x0F, 0x30, 0x01, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x06, 0x80, 0x0E, 0xF0, 0x3C,
  0x7F, 0xF0, 0x07, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x03, 0xFF, 0xFF, 0xFE, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x81, 0xF8, 0x03, 0x80, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0B, 0x60, 0x03, 0x6C, 0x00, 0xCC, 0xC0, 0x39, 0x9E, 0x0E, 0x31, 0xFF,
  0x06, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x06, 0x60, 0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C,
  0x30, 0x00, 0xC1, 0x00, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x01,
  0x80, 0x80, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x03, 0x00, 0x60, 0x20, 0x06, 0x06, 0x00, 0x60, 0x60, 0x02,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00,
  0x18, 0xC0, 0x01, 0x88, 0x00, 0x19, 0x80, 0x00, 0x98, 0x00, 0x0D, 0x80,
  0x00, 0xD0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x02, 0x40, 0x01, 0xE0, 0x01, 0x98, 0x00,
  0x68, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x04, 0xC0, 0x06, 0x20,
  0x03, 0x30, 0x01, 0x0C, 0x00, 0xCC, 0x00, 0xC3, 0x00, 0x31, 0x00, 0x30,
  0xC0, 0x0C, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x02, 0x04, 0x01, 0x86, 0x01,
  0x81, 0x80, 0x61, 0x80, 0x60, 0x60, 0x18, 0x20, 0x18, 0x18, 0x04, 0x0C,
  0x06, 0x02, 0x03, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0x30, 0x30,
  0x10, 0x30, 0x0C, 0x0C, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x82, 0x00, 0x41,
  0x80, 0x61, 0x80, 0x18, 0x60, 0x18, 0x60, 0x06, 0x18, 0x02, 0x18, 0x01,
  0x84, 0x00, 0xC6, 0x00, 0x23, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x0C, 0xC0,
  0x03, 0x30, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x4C, 0x00, 0x32, 0x00, 0x1A,
  0x00, 0x05, 0x80, 0x06, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x18, 0x01, 0xC1, 0x80, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x06,
  0x03, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00,
  0x19, 0x80, 0x01, 0x98, 0x00, 0x0D, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x19, 0x80, 0x01, 0x98,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x81, 0x80, 0x18, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00,
  0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x0C,
  0x01, 0x80, 0xC0, 0x18, 0x04, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x30, 0x02, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x01, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0x98,
  0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0x50, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x08, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x1F,
  0xC0, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0x70, 0x78, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0x07, 0xFC, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Thin70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 50, 14, 5, -50 },
  { 26, 11, 18, 21, 5, -50 },
  { 51, 27, 50, 30, 1, -50 },
  { 220, 23, 57, 28, 2, -53 },
  { 384, 34, 52, 40, 3, -51 },
  { 605, 25, 52, 27, 2, -51 },
  { 768, 2, 18, 11, 5, -50 },
  { 773, 12, 61, 18, 4, -50 },
  { 865, 12, 61, 18, 3, -50 },
  { 957, 18, 18, 24, 3, -53 },
  { 998, 24, 32, 28, 2, -41 },
  { 1094, 5, 16, 12, 3, -7 },
  { 1104, 15, 2, 18, 2, -20 },
  { 1108, 3, 5, 13, 5, -5 },
  { 1110, 20, 50, 23, 2, -50 },
  { 1235, 21, 51, 28, 3, -51 },
  { 1369, 12, 50, 28, 5, -50 },
  { 1444, 21, 51, 28, 3, -51 },
  { 1578, 21, 52, 28, 3, -51 },
  { 1715, 26, 50, 28, 1, -50 },
  { 1878, 22, 51, 28, 3, -50 },
  { 2019, 22, 51, 28, 3, -50 },
  { 2160, 21, 50, 28, 3, -50 },
  { 2292, 22, 52, 28, 3, -51 },
  { 2435, 21, 52, 28, 3, -51 },
  { 2572, 3, 37, 13, 5, -37 },
  { 2586, 5, 46, 12, 3, -37 },
  { 2615, 24, 29, 28, 2, -39 },
  { 2702, 24, 17, 28, 2, -33 },
  { 2753, 24, 29, 28, 2, -39 },
  { 2840, 16, 51, 18, 1, -51 },
  { 2942, 35, 56, 42, 4, -50 },
  { 3187, 26, 50, 26, 0, -50 },
  { 3350, 22, 50, 30, 5, -50 },
  { 3488, 23, 52, 29, 4, -51 },
  { 3638, 24, 50, 33, 5, -50 },
  { 3788, 18, 50, 27, 5, -50 },
  { 3901, 18, 50, 25, 5, -50 },
  { 4014, 28, 52, 36, 4, -51 },
  { 4196, 24, 50, 34, 5, -50 },
  { 4346, 10, 50, 15, 3, -50 },
  { 4409, 11, 62, 13, -3, -50 },
  { 4495, 22, 50, 27, 5, -50 },
  { 4633, 18, 50, 24, 5, -50 },
  { 4746, 35, 50, 46, 5, -50 },
  { 4965, 25, 50, 35, 5, -50 },
  { 5122, 28, 52, 36, 4, -51 },
  { 5304, 20, 50, 28, 5, -50 },
  { 5429, 28, 63, 36, 4, -51 },
  { 5650, 22, 50, 28, 5, -50 },
  { 5788, 21, 52, 27, 3, -51 },
  { 5925, 23, 50, 24, 0, -50 },
  { 6069, 24, 51, 34, 5, -50 },
  { 6222, 26, 50, 26, 0, -50 },
  { 6385, 45, 50, 45, 0, -50 },
  { 6667, 21, 50, 23, 1, -50 },
  { 6799, 22, 50, 22, 0, -50 },
  { 6937, 19, 50, 23, 2, -50 },
  { 7056, 13, 61, 21, 6, -50 },
  { 7156, 20, 50, 23, 2, -50 },
  { 7281, 13, 61, 21, 3, -50 },
  { 7381, 25, 24, 28, 1, -50 },
  { 7456, 28, 2, 27, 0, 6 },
  { 7463, 10, 11, 16, 3, -53 },
  { 7477, 18, 39, 26, 3, -38 },
  { 7565, 22, 54, 30, 5, -53 },
  { 7714, 18, 39, 22, 3, -38 },
  { 7802, 22, 54, 30, 3, -53 },
  { 7951, 20, 39, 27, 3, -38 },
  { 8049, 16, 54, 15, 1, -54 },
  { 8157, 22, 55, 30, 3, -38 },
  { 8309, 19, 53, 29, 5, -53 },
  { 8435, 3, 51, 12, 5, -51 },
  { 8455, 8, 68, 12, 0, -51 },
  { 8523, 17, 53, 23, 5, -53 },
  { 8636, 2, 53, 12, 5, -53 },
  { 8650, 33, 38, 43, 5, -38 },
  { 8807, 19, 38, 29, 5, -38 },
  { 8898, 22, 39, 28, 3, -38 },
  { 9006, 21, 54, 30, 5, -38 },
  { 9148, 22, 54, 30, 3, -38 },
  { 9297, 13, 37, 18, 5, -37 },
  { 9358, 16, 39, 22, 3, -38 },
  { 9436, 13, 47, 15, 1, -46 },
  { 9513, 19, 38, 29, 5, -37 },
  { 9604, 20, 37, 21, 0, -37 },
  { 9697, 34, 37, 36, 1, -37 },
  { 9855, 20, 37, 22, 1, -37 },
  { 9948, 20, 54, 22, 1, -37 },
  { 10083, 14, 37, 18, 2, -37 },
  { 10148, 17, 61, 24, 4, -50 },
  { 10278, 2, 70, 26, 12, -53 },
  { 10296, 18, 61, 24, 3, -50 },
  { 10434, 24, 6, 28, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Thin70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN70PT7B_H_
