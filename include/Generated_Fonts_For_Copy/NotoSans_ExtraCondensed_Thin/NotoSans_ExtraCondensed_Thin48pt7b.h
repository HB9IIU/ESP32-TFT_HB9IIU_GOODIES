#ifndef _NOTOSANS_EXTRACONDENSED_THIN48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin48pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x00,
  0x03, 0xEC, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0x81,
  0x81, 0x81, 0x01, 0x02, 0x00, 0x40, 0x80, 0x30, 0x20, 0x08, 0x08, 0x02,
  0x02, 0x00, 0x81, 0x80, 0x20, 0x60, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81,
  0x07, 0xFF, 0xFC, 0x18, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x40, 0x40,
  0x10, 0x30, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x30, 0x20, 0x0C,
  0x08, 0x02, 0x02, 0x0F, 0xFF, 0xF8, 0x20, 0x20, 0x08, 0x18, 0x02, 0x06,
  0x00, 0x81, 0x00, 0x20, 0x40, 0x18, 0x10, 0x06, 0x04, 0x01, 0x01, 0x00,
  0x40, 0x40, 0x10, 0x30, 0x04, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03,
  0xF0, 0x0F, 0xBC, 0x31, 0x86, 0x21, 0x80, 0x61, 0x80, 0x41, 0x80, 0x41,
  0x80, 0xC1, 0x80, 0xC1, 0x80, 0x41, 0x80, 0x41, 0x80, 0x41, 0x80, 0x21,
  0x80, 0x31, 0x80, 0x1D, 0x80, 0x07, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x01,
  0xB8, 0x01, 0x8C, 0x01, 0x86, 0x01, 0x83, 0x01, 0x81, 0x01, 0x81, 0x01,
  0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x01, 0x83, 0x01, 0x82, 0x41,
  0x8C, 0x79, 0xB8, 0x0F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x64, 0x01, 0x80, 0x84, 0x02, 0x02, 0x0C, 0x04,
  0x04, 0x08, 0x18, 0x08, 0x10, 0x20, 0x30, 0x20, 0x40, 0x40, 0x41, 0x80,
  0x80, 0x82, 0x01, 0x01, 0x04, 0x02, 0x02, 0x08, 0x04, 0x04, 0x20, 0x08,
  0x08, 0x40, 0x10, 0x10, 0x80, 0x20, 0x22, 0x1E, 0x60, 0x44, 0x44, 0x40,
  0x89, 0x04, 0x81, 0x22, 0x09, 0x04, 0x44, 0x09, 0x08, 0x98, 0x13, 0x62,
  0x20, 0x23, 0x84, 0x40, 0x40, 0x08, 0x80, 0x80, 0x31, 0x01, 0x00, 0x42,
  0x02, 0x00, 0x84, 0x04, 0x03, 0x08, 0x08, 0x04, 0x10, 0x10, 0x08, 0x20,
  0x20, 0x30, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x83, 0x03, 0x01, 0x04,
  0x04, 0x01, 0x18, 0x08, 0x03, 0xE0, 0x07, 0x00, 0x06, 0xC0, 0x04, 0x10,
  0x02, 0x08, 0x03, 0x06, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x18, 0x30, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x44, 0x00,
  0x26, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x05, 0x00, 0x04, 0x80, 0x04, 0x20,
  0x04, 0x10, 0x32, 0x04, 0x1A, 0x03, 0x09, 0x00, 0x84, 0x80, 0x62, 0x40,
  0x11, 0x20, 0x05, 0x90, 0x02, 0x88, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x71,
  0x80, 0x2C, 0x40, 0x32, 0x10, 0x31, 0x87, 0xE0, 0x60, 0xFF, 0xFF, 0xFE,
  0x01, 0x81, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03, 0x00, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0xC0, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02,
  0x02, 0x02, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x08,
  0x18, 0x10, 0x30, 0x60, 0x40, 0x80, 0x02, 0x00, 0x20, 0x02, 0x08, 0x21,
  0x62, 0x71, 0xF8, 0x06, 0x00, 0x50, 0x09, 0x81, 0x08, 0x20, 0x46, 0x02,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x1F,
  0xFF, 0xF0, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x33,
  0x22, 0x26, 0x44, 0x4C, 0x80, 0xFF, 0xFF, 0xF0, 0xDF, 0x00, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x1D, 0xC0, 0x60, 0xC0, 0x80, 0x83, 0x01, 0x84, 0x01, 0x18, 0x03, 0x30,
  0x06, 0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x2C, 0x00, 0x58, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x12, 0x00, 0x26, 0x00, 0xC4, 0x01, 0x08, 0x02, 0x18, 0x0C, 0x18, 0x10,
  0x18, 0x60, 0x1F, 0x00, 0x02, 0x1C, 0x69, 0x96, 0x38, 0x60, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x07, 0x80,
  0x7B, 0xC1, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x03, 0xFF, 0xF8, 0x0F, 0x80, 0x7B, 0xC3, 0x80, 0xC4, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0,
  0x3F, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x19, 0x80, 0x61, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x02, 0x40, 0x03,
  0x20, 0x01, 0x10, 0x01, 0x88, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00,
  0x60, 0x80, 0x20, 0x40, 0x30, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x04, 0x01, 0x02, 0x00, 0x82, 0x00, 0x41, 0x00, 0x21, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x3F,
  0xF8, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x1F, 0xF8, 0x20, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0xC0,
  0x60, 0xFF, 0x80, 0x00, 0x60, 0x07, 0xF0, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x11, 0xF0, 0x66, 0x18, 0xD0, 0x19, 0xC0,
  0x13, 0x80, 0x16, 0x00, 0x2C, 0x00, 0x58, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x06, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x34, 0x00, 0x48, 0x00, 0x98,
  0x01, 0x10, 0x06, 0x30, 0x08, 0x30, 0x20, 0x3F, 0x80, 0x1C, 0x00, 0xFF,
  0xFC, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x00, 0x03,
  0x80, 0x3F, 0xE0, 0xC0, 0x61, 0x00, 0x46, 0x00, 0xC8, 0x00, 0x90, 0x01,
  0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x13, 0x00, 0x62, 0x00, 0x86,
  0x03, 0x06, 0x0C, 0x02, 0x60, 0x03, 0x80, 0x0F, 0x00, 0x31, 0x80, 0x81,
  0x82, 0x01, 0x8C, 0x01, 0x90, 0x01, 0x60, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xF0, 0x01, 0x20, 0x02, 0x60,
  0x08, 0x60, 0x30, 0x3F, 0x80, 0x07, 0x80, 0x7F, 0x83, 0x03, 0x08, 0x04,
  0x40, 0x09, 0x00, 0x2C, 0x00, 0xB0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0x40, 0x0D, 0x00,
  0x36, 0x01, 0x48, 0x0D, 0x1C, 0xE4, 0x1E, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x07, 0xF8, 0x00, 0x5B, 0xA0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0xF8, 0x27, 0x72, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x32, 0x22, 0x64, 0x44, 0x88, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x10, 0x00,
  0x00, 0x3C, 0x1E, 0xE2, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0x00, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x10, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x04, 0x60, 0x00, 0x04, 0x40, 0x0C, 0x06, 0x40, 0x3F, 0x02, 0xC0,
  0x41, 0x02, 0xC0, 0x81, 0x02, 0x81, 0x81, 0x02, 0x81, 0x03, 0x02, 0x81,
  0x03, 0x02, 0x81, 0x03, 0x03, 0x81, 0x03, 0x03, 0x83, 0x03, 0x03, 0x83,
  0x03, 0x03, 0x83, 0x02, 0x02, 0x83, 0x02, 0x02, 0x81, 0x02, 0x02, 0x81,
  0x02, 0x02, 0x81, 0x05, 0x06, 0x81, 0x85, 0x04, 0x80, 0x8D, 0x0C, 0xC0,
  0xF8, 0xF8, 0x40, 0x20, 0x20, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x01, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x13, 0x00,
  0x0C, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x80, 0x18, 0x20, 0x04,
  0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x30, 0x30, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x7F, 0xF8, 0x1F, 0xFE, 0x04, 0x00, 0x81, 0x00, 0x20,
  0xC0, 0x0C, 0x30, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x06, 0x60,
  0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x10, 0xFF, 0xC1, 0x00, 0x62, 0x00, 0x64, 0x00, 0x48, 0x00, 0xD0, 0x00,
  0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x68,
  0x00, 0x90, 0x03, 0x20, 0x0C, 0x7F, 0xE0, 0xFF, 0xE1, 0x00, 0x62, 0x00,
  0x24, 0x00, 0x68, 0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x28, 0x00, 0x50, 0x01, 0xA0, 0x02, 0x40,
  0x0C, 0x80, 0x71, 0xFF, 0x80, 0x00, 0x78, 0x03, 0xDF, 0x0E, 0x01, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x01, 0x01, 0xFE, 0xFF, 0x80, 0x80, 0x60, 0x80, 0x30, 0x80, 0x18, 0x80,
  0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x30, 0x80, 0xE0, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0xFF,
  0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x7C, 0x00, 0x3D, 0xF0, 0x18, 0x01,
  0x86, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x7F, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x16,
  0x00, 0x02, 0x40, 0x00, 0x4C, 0x00, 0x08, 0xC0, 0x01, 0x0C, 0x00, 0x20,
  0xE0, 0x0C, 0x07, 0xFF, 0x00, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x05, 0xF8, 0x80, 0x0E, 0x00, 0x68,
  0x01, 0x20, 0x08, 0x80, 0x62, 0x01, 0x08, 0x0C, 0x20, 0x20, 0x81, 0x02,
  0x0C, 0x08, 0x20, 0x21, 0x80, 0x84, 0x02, 0x30, 0x09, 0x80, 0x26, 0x00,
  0xBC, 0x02, 0x90, 0x0C, 0x60, 0x30, 0x80, 0x83, 0x02, 0x04, 0x08, 0x18,
  0x20, 0x20, 0x80, 0xC2, 0x01, 0x08, 0x06, 0x20, 0x08, 0x80, 0x32, 0x00,
  0x48, 0x01, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x10, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFC, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xA0, 0x00, 0x0F, 0xA0, 0x00,
  0x0B, 0xB0, 0x00, 0x0B, 0x90, 0x00, 0x1B, 0x90, 0x00, 0x13, 0x98, 0x00,
  0x13, 0x88, 0x00, 0x33, 0x88, 0x00, 0x23, 0x88, 0x00, 0x23, 0x8C, 0x00,
  0x63, 0x84, 0x00, 0x43, 0x84, 0x00, 0x43, 0x86, 0x00, 0x43, 0x82, 0x00,
  0xC3, 0x82, 0x00, 0x83, 0x83, 0x00, 0x83, 0x81, 0x01, 0x83, 0x81, 0x01,
  0x03, 0x81, 0x81, 0x03, 0x80, 0x83, 0x03, 0x80, 0x82, 0x03, 0x80, 0x82,
  0x03, 0x80, 0xC2, 0x03, 0x80, 0x46, 0x03, 0x80, 0x44, 0x03, 0x80, 0x64,
  0x03, 0x80, 0x2C, 0x03, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x74, 0x00, 0x3A, 0x00, 0x1C,
  0x80, 0x0E, 0x40, 0x07, 0x30, 0x03, 0x88, 0x01, 0xC6, 0x00, 0xE1, 0x00,
  0x70, 0x80, 0x38, 0x20, 0x1C, 0x10, 0x0E, 0x0C, 0x07, 0x02, 0x03, 0x81,
  0x81, 0xC0, 0x40, 0xE0, 0x30, 0x70, 0x08, 0x38, 0x04, 0x1C, 0x01, 0x0E,
  0x00, 0x87, 0x00, 0x63, 0x80, 0x11, 0xC0, 0x0C, 0xE0, 0x02, 0x70, 0x01,
  0x38, 0x00, 0x5C, 0x00, 0x2E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF7, 0x80, 0x30, 0x18, 0x08, 0x01, 0x83,
  0x00, 0x10, 0x40, 0x01, 0x18, 0x00, 0x22, 0x00, 0x06, 0x40, 0x00, 0x58,
  0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0B, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x0C, 0xC0,
  0x01, 0x08, 0x00, 0x61, 0x80, 0x08, 0x18, 0x03, 0x01, 0x80, 0xC0, 0x1F,
  0xE0, 0x00, 0xFF, 0x84, 0x07, 0x20, 0x0D, 0x00, 0x28, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x02, 0x80, 0x34, 0x07, 0x3F, 0xE1, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0xF7, 0x80, 0x30, 0x18, 0x08, 0x01, 0x83, 0x00, 0x10, 0x40, 0x01,
  0x18, 0x00, 0x22, 0x00, 0x06, 0x40, 0x00, 0x58, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0B,
  0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x0C, 0xC0, 0x01, 0x08, 0x00, 0x61,
  0x80, 0x08, 0x18, 0x03, 0x01, 0x80, 0xC0, 0x1F, 0xE0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0xFF, 0x82, 0x03, 0x88, 0x03, 0x20, 0x04,
  0x80, 0x1A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x01, 0x20, 0x0C, 0x80, 0x63, 0xFE,
  0x0F, 0xE0, 0x20, 0xC0, 0x81, 0x02, 0x06, 0x08, 0x08, 0x20, 0x30, 0x80,
  0x42, 0x01, 0x88, 0x02, 0x20, 0x08, 0x80, 0x12, 0x00, 0x48, 0x01, 0xA0,
  0x02, 0x80, 0x0E, 0x00, 0x10, 0x03, 0xC0, 0x1E, 0xF8, 0xC0, 0x11, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x19, 0x80, 0x61, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xA0, 0x00, 0x50, 0x00, 0x68, 0x00, 0x34, 0x00, 0x13, 0x00, 0x08, 0x80,
  0x0C, 0x60, 0x0C, 0x18, 0x0C, 0x07, 0xFC, 0x00, 0x80, 0x00, 0xF0, 0x00,
  0x24, 0x00, 0x09, 0x00, 0x06, 0x40, 0x01, 0x18, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x0C, 0x20, 0x03, 0x08, 0x00, 0x83, 0x00, 0x20, 0x40, 0x08, 0x10,
  0x06, 0x04, 0x01, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x02, 0x02,
  0x00, 0xC0, 0x80, 0x10, 0x20, 0x04, 0x18, 0x01, 0x04, 0x00, 0x41, 0x00,
  0x08, 0x40, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x22, 0x00, 0x0C, 0x80, 0x01,
  0x20, 0x00, 0x58, 0x00, 0x14, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x80, 0x06, 0x00, 0x09, 0x00, 0x0E, 0x00,
  0x12, 0x00, 0x14, 0x00, 0x26, 0x00, 0x28, 0x00, 0xCC, 0x00, 0x50, 0x01,
  0x88, 0x01, 0xA0, 0x02, 0x10, 0x03, 0x60, 0x04, 0x20, 0x04, 0x40, 0x08,
  0x60, 0x08, 0x80, 0x30, 0x40, 0x11, 0x00, 0x40, 0x80, 0x62, 0x00, 0x81,
  0x00, 0xC6, 0x01, 0x03, 0x01, 0x0C, 0x06, 0x06, 0x02, 0x08, 0x0C, 0x04,
  0x04, 0x10, 0x10, 0x08, 0x08, 0x20, 0x20, 0x10, 0x30, 0x60, 0x40, 0x30,
  0x40, 0xC1, 0x80, 0x60, 0x80, 0x82, 0x00, 0x41, 0x01, 0x04, 0x00, 0x82,
  0x02, 0x08, 0x01, 0x0C, 0x06, 0x10, 0x03, 0x10, 0x0C, 0x60, 0x02, 0x20,
  0x08, 0x80, 0x04, 0x40, 0x11, 0x00, 0x08, 0x80, 0x22, 0x00, 0x13, 0x00,
  0x6C, 0x00, 0x34, 0x00, 0xD8, 0x00, 0x28, 0x00, 0xA0, 0x00, 0x50, 0x01,
  0x40, 0x00, 0xA0, 0x02, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x02, 0x60, 0x0C, 0x40, 0x10, 0x80, 0x21, 0x80, 0xC1, 0x01,
  0x02, 0x06, 0x06, 0x08, 0x04, 0x10, 0x0C, 0x60, 0x08, 0x80, 0x11, 0x00,
  0x36, 0x00, 0x28, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x05,
  0x00, 0x1A, 0x00, 0x26, 0x00, 0xC4, 0x01, 0x08, 0x02, 0x18, 0x0C, 0x10,
  0x10, 0x20, 0x60, 0x60, 0x80, 0x41, 0x00, 0x86, 0x00, 0x88, 0x01, 0x30,
  0x03, 0x40, 0x03, 0x80, 0x04, 0xC0, 0x02, 0x80, 0x0D, 0x00, 0x13, 0x00,
  0x22, 0x00, 0xC4, 0x01, 0x0C, 0x02, 0x08, 0x0C, 0x10, 0x10, 0x30, 0x20,
  0x20, 0xC0, 0x41, 0x00, 0x82, 0x00, 0x8C, 0x01, 0x10, 0x02, 0x20, 0x02,
  0xC0, 0x05, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x7F, 0xF8, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0xFF, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x58, 0x00, 0x64, 0x00, 0x23, 0x00, 0x30, 0x80, 0x10, 0x60,
  0x18, 0x10, 0x08, 0x0C, 0x0C, 0x02, 0x04, 0x01, 0x06, 0x00, 0xC2, 0x00,
  0x23, 0x00, 0x19, 0x00, 0x05, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x81, 0x81, 0x81, 0x81, 0x01, 0x01, 0x01, 0x0F, 0x07, 0xDC, 0x20, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x07, 0xF1, 0x81, 0x20, 0x14, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x34, 0x05, 0x60, 0xD3, 0xF9, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x0F, 0x06, 0x7B, 0x8D, 0x81, 0x9E, 0x01,
  0x38, 0x01, 0x70, 0x02, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0x70, 0x02, 0xE0, 0x0D,
  0xA0, 0x33, 0x60, 0xC4, 0x7F, 0x00, 0x01, 0xE0, 0xF7, 0x18, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x10, 0xFF, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x0F, 0x08, 0x77, 0x11, 0x81, 0x26, 0x01, 0x48,
  0x02, 0xB0, 0x03, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x14, 0x00, 0x68, 0x00, 0xD0, 0x01, 0xB0, 0x03, 0x20, 0x0A, 0x60,
  0x34, 0x60, 0xC8, 0x7F, 0x10, 0x03, 0x80, 0x3B, 0x81, 0x03, 0x0C, 0x04,
  0x20, 0x09, 0x80, 0x24, 0x00, 0x90, 0x01, 0x40, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x01, 0x18,
  0x08, 0x1F, 0xC0, 0x01, 0xC0, 0xEC, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x0F, 0xF8, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x03, 0xC0, 0x1D, 0xE4, 0x40, 0x49,
  0x80, 0x52, 0x00, 0xEC, 0x00, 0xD0, 0x01, 0xA0, 0x03, 0x40, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x34, 0x00, 0x6C, 0x01, 0x48,
  0x02, 0x98, 0x0D, 0x18, 0x32, 0x1F, 0xC4, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x22,
  0x01, 0x83, 0xFE, 0x00, 0x40, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xF1,
  0x9D, 0xCD, 0x83, 0x68, 0x0B, 0x80, 0x7C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x10, 0x5F, 0x20, 0x00, 0x01, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00, 0x08, 0x71, 0x82, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x21, 0x86, 0x13, 0xCC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x02, 0xC0, 0x6C, 0x04, 0xC0, 0x8C, 0x18, 0xC1, 0x0C, 0x20, 0xC6, 0x0C,
  0x40, 0xCC, 0x0C, 0xC0, 0xD6, 0x0F, 0x20, 0xE3, 0x0C, 0x10, 0xC1, 0x0C,
  0x18, 0xC0, 0x8C, 0x0C, 0xC0, 0x4C, 0x04, 0xC0, 0x2C, 0x02, 0xC0, 0x3C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80,
  0xE1, 0x19, 0x87, 0x72, 0x40, 0x98, 0x35, 0x01, 0x20, 0x2A, 0x01, 0x80,
  0x78, 0x03, 0x00, 0xF0, 0x06, 0x00, 0xE0, 0x08, 0x01, 0xC0, 0x10, 0x03,
  0x80, 0x20, 0x07, 0x00, 0x40, 0x0E, 0x00, 0x80, 0x1C, 0x01, 0x00, 0x38,
  0x02, 0x00, 0x70, 0x04, 0x00, 0xE0, 0x08, 0x01, 0xC0, 0x10, 0x03, 0x80,
  0x20, 0x07, 0x00, 0x40, 0x0E, 0x00, 0x80, 0x1C, 0x01, 0x00, 0x38, 0x02,
  0x00, 0x70, 0x04, 0x00, 0xE0, 0x08, 0x01, 0xC0, 0x10, 0x03, 0x80, 0x20,
  0x04, 0x03, 0x84, 0x77, 0x26, 0x0D, 0x60, 0x3A, 0x00, 0xD0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x40, 0x03, 0x80, 0x1D, 0xE0,
  0x40, 0x61, 0x00, 0x42, 0x00, 0xC8, 0x00, 0x90, 0x01, 0x20, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x4C,
  0x00, 0x88, 0x03, 0x18, 0x04, 0x18, 0x10, 0x1F, 0xC0, 0x03, 0xC1, 0x1D,
  0xE2, 0x60, 0x64, 0x80, 0x4A, 0x00, 0xD4, 0x00, 0xB0, 0x01, 0x60, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x5C, 0x00, 0xB8, 0x03, 0x68, 0x0C, 0xD8, 0x31, 0x9F, 0xC3, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xC4, 0x60,
  0x49, 0x80, 0x52, 0x00, 0xAC, 0x00, 0xD0, 0x01, 0xA0, 0x03, 0x40, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x34, 0x00, 0x6C, 0x01,
  0x48, 0x02, 0x98, 0x09, 0x18, 0x32, 0x1F, 0xC4, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x03, 0x47, 0xE6, 0x12, 0x0E, 0x07, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x07,
  0x87, 0xBD, 0x80, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x03, 0xC0, 0xCF, 0xF0, 0x10,
  0x10, 0x30, 0x30, 0x30, 0x30, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x10, 0x10, 0x1F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x34, 0x01, 0xA0, 0x15, 0x80, 0xA6, 0x09, 0x1F, 0x88, 0xC0,
  0x0D, 0x00, 0x24, 0x00, 0x90, 0x02, 0x60, 0x18, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x30, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x18, 0x60, 0x21, 0x80,
  0x84, 0x02, 0x10, 0x08, 0x40, 0x33, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x1E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x08, 0x01, 0x40, 0x1C,
  0x03, 0x40, 0x14, 0x02, 0x60, 0x14, 0x02, 0x20, 0x14, 0x02, 0x20, 0x34,
  0x02, 0x20, 0x36, 0x06, 0x20, 0x22, 0x04, 0x30, 0x22, 0x04, 0x10, 0x22,
  0x04, 0x10, 0x62, 0x04, 0x10, 0x43, 0x0C, 0x18, 0x41, 0x08, 0x08, 0x41,
  0x08, 0x08, 0x41, 0x08, 0x08, 0xC1, 0x98, 0x08, 0x81, 0x90, 0x0C, 0x80,
  0x90, 0x04, 0x80, 0x90, 0x05, 0x80, 0x90, 0x05, 0x80, 0xF0, 0x07, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0xC0, 0x1A,
  0x00, 0x88, 0x0C, 0x40, 0x43, 0x06, 0x08, 0x20, 0x61, 0x01, 0x18, 0x0C,
  0x80, 0x2C, 0x01, 0x40, 0x06, 0x00, 0x30, 0x02, 0x80, 0x16, 0x01, 0x90,
  0x08, 0x80, 0xC2, 0x04, 0x10, 0x60, 0xC2, 0x02, 0x30, 0x19, 0x00, 0x58,
  0x03, 0x80, 0x08, 0x60, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x63, 0x00,
  0x82, 0x01, 0x04, 0x02, 0x08, 0x0C, 0x18, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x41, 0x80, 0xC2, 0x00, 0x84, 0x01, 0x08, 0x02, 0x30, 0x06, 0x40, 0x04,
  0x80, 0x09, 0x00, 0x16, 0x00, 0x28, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x07, 0xC0, 0x06, 0x00,
  0x00, 0x7F, 0xC0, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x18,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x04, 0x01, 0x80, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x70, 0x1C, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0xF8, 0x08, 0x00, 0x1E, 0x00, 0xB1, 0xC0, 0x70, 0x38, 0xD0, 0x07,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 34, 9, 3, -34 },
  { 14, 8, 12, 14, 3, -34 },
  { 26, 18, 34, 20, 1, -34 },
  { 103, 16, 39, 19, 1, -36 },
  { 181, 23, 35, 27, 2, -35 },
  { 282, 17, 35, 18, 2, -35 },
  { 357, 2, 12, 8, 3, -34 },
  { 360, 9, 42, 13, 2, -34 },
  { 408, 8, 42, 13, 2, -34 },
  { 450, 12, 12, 16, 2, -36 },
  { 468, 17, 22, 19, 1, -28 },
  { 515, 4, 11, 8, 2, -5 },
  { 521, 10, 2, 13, 1, -14 },
  { 524, 3, 3, 9, 3, -3 },
  { 526, 14, 34, 16, 1, -34 },
  { 586, 15, 35, 19, 2, -35 },
  { 652, 7, 34, 19, 4, -34 },
  { 682, 15, 35, 19, 2, -35 },
  { 748, 15, 35, 19, 2, -35 },
  { 814, 17, 34, 19, 1, -34 },
  { 887, 15, 34, 19, 2, -34 },
  { 951, 15, 36, 19, 2, -35 },
  { 1019, 14, 34, 19, 2, -34 },
  { 1079, 15, 35, 19, 2, -35 },
  { 1145, 14, 35, 19, 2, -35 },
  { 1207, 3, 26, 9, 3, -26 },
  { 1217, 4, 32, 9, 2, -26 },
  { 1233, 17, 20, 19, 1, -27 },
  { 1276, 17, 12, 19, 1, -23 },
  { 1302, 17, 20, 19, 1, -27 },
  { 1345, 11, 35, 13, 1, -35 },
  { 1394, 24, 38, 29, 3, -34 },
  { 1508, 18, 34, 18, 0, -34 },
  { 1585, 15, 34, 21, 4, -34 },
  { 1649, 16, 35, 20, 3, -35 },
  { 1719, 16, 34, 23, 4, -34 },
  { 1787, 12, 34, 18, 4, -34 },
  { 1838, 12, 34, 17, 4, -34 },
  { 1889, 19, 35, 25, 3, -35 },
  { 1973, 16, 34, 23, 4, -34 },
  { 2041, 7, 34, 11, 2, -34 },
  { 2071, 7, 42, 9, -2, -34 },
  { 2108, 14, 34, 18, 4, -34 },
  { 2168, 11, 34, 16, 4, -34 },
  { 2215, 24, 34, 31, 4, -34 },
  { 2317, 17, 34, 24, 4, -34 },
  { 2390, 19, 35, 25, 3, -35 },
  { 2474, 13, 34, 19, 4, -34 },
  { 2530, 19, 43, 25, 3, -35 },
  { 2633, 14, 34, 19, 4, -34 },
  { 2693, 15, 35, 19, 2, -35 },
  { 2759, 16, 34, 16, 0, -34 },
  { 2827, 17, 34, 23, 3, -34 },
  { 2900, 18, 34, 18, 0, -34 },
  { 2977, 31, 34, 31, 0, -34 },
  { 3109, 15, 34, 16, 0, -34 },
  { 3173, 15, 34, 15, 0, -34 },
  { 3237, 14, 34, 16, 1, -34 },
  { 3297, 9, 42, 15, 4, -34 },
  { 3345, 14, 34, 16, 1, -34 },
  { 3405, 9, 42, 15, 2, -34 },
  { 3453, 17, 16, 19, 1, -34 },
  { 3487, 19, 2, 19, 0, 4 },
  { 3492, 7, 8, 11, 2, -37 },
  { 3499, 12, 26, 18, 2, -26 },
  { 3538, 15, 36, 20, 3, -36 },
  { 3606, 12, 26, 15, 2, -26 },
  { 3645, 15, 36, 20, 2, -36 },
  { 3713, 14, 26, 18, 2, -26 },
  { 3759, 11, 37, 10, 0, -37 },
  { 3810, 15, 38, 20, 2, -26 },
  { 3882, 13, 36, 20, 3, -36 },
  { 3941, 3, 35, 9, 3, -35 },
  { 3955, 6, 47, 9, 0, -35 },
  { 3991, 12, 36, 16, 3, -36 },
  { 4045, 2, 36, 8, 3, -36 },
  { 4054, 23, 26, 29, 3, -26 },
  { 4129, 13, 26, 20, 3, -26 },
  { 4172, 15, 26, 19, 2, -26 },
  { 4221, 15, 37, 20, 3, -26 },
  { 4291, 15, 37, 20, 2, -26 },
  { 4361, 9, 26, 13, 3, -26 },
  { 4391, 11, 26, 15, 2, -26 },
  { 4427, 8, 31, 10, 1, -31 },
  { 4458, 13, 25, 20, 3, -25 },
  { 4499, 14, 25, 14, 0, -25 },
  { 4543, 24, 25, 25, 0, -25 },
  { 4618, 13, 25, 15, 1, -25 },
  { 4659, 15, 37, 15, 0, -25 },
  { 4729, 10, 25, 12, 1, -25 },
  { 4761, 12, 42, 17, 2, -34 },
  { 4824, 2, 49, 18, 8, -37 },
  { 4837, 12, 42, 17, 2, -34 },
  { 4900, 17, 4, 19, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Thin48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN48PT7B_H_
