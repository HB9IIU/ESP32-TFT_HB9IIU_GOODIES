#ifndef _NOTOSANS_EXTRACONDENSED_THIN52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0x06, 0x83, 0x41, 0xA0, 0xD0, 0x68,
  0x34, 0x18, 0x01, 0x81, 0x80, 0x10, 0x10, 0x01, 0x01, 0x00, 0x10, 0x10,
  0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x30, 0x10, 0x03, 0x03,
  0x00, 0x30, 0x30, 0x02, 0x02, 0x07, 0xFF, 0xFF, 0x02, 0x02, 0x00, 0x20,
  0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x06, 0x02, 0x00, 0x60, 0x60, 0x06,
  0x06, 0x00, 0x40, 0x60, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00,
  0x40, 0x40, 0xFF, 0xFF, 0xE0, 0xC0, 0x40, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x08, 0x0C, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x08,
  0x00, 0x80, 0x80, 0x18, 0x08, 0x01, 0x81, 0x80, 0x10, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x7C, 0x01, 0xFF, 0xC1, 0x88, 0x31,
  0x84, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20,
  0x08, 0x10, 0x04, 0x08, 0x02, 0x04, 0x01, 0x82, 0x00, 0x41, 0x00, 0x30,
  0x80, 0x0E, 0x40, 0x01, 0xA0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x05, 0xC0,
  0x02, 0x30, 0x01, 0x0E, 0x00, 0x81, 0x00, 0x40, 0xC0, 0x20, 0x20, 0x10,
  0x18, 0x08, 0x0C, 0x04, 0x02, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0x80,
  0x40, 0xC0, 0x20, 0xCC, 0x10, 0xC7, 0xEF, 0xC0, 0x3F, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x10, 0x0D, 0x80,
  0x10, 0x08, 0x60, 0x08, 0x04, 0x10, 0x0C, 0x04, 0x0C, 0x04, 0x02, 0x02,
  0x02, 0x01, 0x01, 0x03, 0x00, 0x80, 0x81, 0x00, 0xC0, 0x40, 0x80, 0x60,
  0x20, 0xC0, 0x30, 0x10, 0x40, 0x18, 0x08, 0x20, 0x0C, 0x04, 0x30, 0x06,
  0x02, 0x10, 0x03, 0x01, 0x08, 0x00, 0x80, 0x8C, 0x38, 0x40, 0x44, 0x26,
  0x20, 0x22, 0x21, 0x90, 0x11, 0x30, 0x4C, 0x19, 0x90, 0x32, 0x08, 0x88,
  0x09, 0x8C, 0x44, 0x04, 0x7C, 0x62, 0x02, 0x18, 0x23, 0x01, 0x00, 0x11,
  0x80, 0x80, 0x18, 0xC0, 0x40, 0x08, 0x60, 0x20, 0x04, 0x30, 0x10, 0x06,
  0x18, 0x08, 0x02, 0x0C, 0x04, 0x01, 0x02, 0x02, 0x01, 0x81, 0x01, 0x00,
  0x80, 0x80, 0x80, 0x40, 0x40, 0xC0, 0x60, 0x30, 0x60, 0x20, 0x08, 0x20,
  0x10, 0x06, 0x30, 0x18, 0x01, 0xF0, 0x03, 0x00, 0x03, 0xF0, 0x00, 0x86,
  0x00, 0x40, 0x80, 0x10, 0x30, 0x04, 0x0C, 0x01, 0x01, 0x00, 0x40, 0x40,
  0x10, 0x10, 0x04, 0x04, 0x01, 0x03, 0x00, 0x40, 0x80, 0x18, 0x20, 0x02,
  0x08, 0x00, 0x84, 0x00, 0x33, 0x00, 0x05, 0x80, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x2C, 0x00, 0x11, 0x00, 0x08, 0x20, 0x06, 0x08, 0x09, 0x01, 0x02,
  0xC0, 0x60, 0xA0, 0x08, 0x28, 0x03, 0x1A, 0x00, 0x44, 0x80, 0x19, 0x20,
  0x02, 0xC8, 0x00, 0x62, 0x00, 0x18, 0x80, 0x06, 0x30, 0x03, 0xC4, 0x00,
  0x91, 0x80, 0x46, 0x30, 0x60, 0x87, 0xF0, 0x30, 0x20, 0x00, 0xFF, 0xD5,
  0x55, 0x40, 0x01, 0x81, 0x01, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x30,
  0x10, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x40, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x40, 0x18, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x02, 0x01,
  0x80, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x00, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x71, 0x0C, 0xE9, 0x80, 0xF0, 0x03, 0x00, 0x24,
  0x02, 0x10, 0x20, 0x83, 0x02, 0x10, 0x08, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x1F, 0xFF, 0xF0, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x13, 0x33,
  0x22, 0x66, 0x44, 0xC8, 0xFF, 0xFF, 0xFC, 0xFD, 0x80, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xF0, 0x0C,
  0x18, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x20, 0x02, 0x60,
  0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40,
  0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0x40,
  0x03, 0x40, 0x03, 0x60, 0x02, 0x60, 0x02, 0x60, 0x02, 0x20, 0x06, 0x30,
  0x06, 0x30, 0x04, 0x18, 0x0C, 0x18, 0x08, 0x0C, 0x38, 0x07, 0xE0, 0x01,
  0x07, 0x0D, 0x19, 0x31, 0x61, 0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x03, 0x80, 0x1F, 0xF0, 0x70, 0x18, 0x40, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0x07, 0x80, 0x1F, 0xF0, 0x60, 0x18, 0xC0, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0xE0, 0x38, 0x7F, 0xF0, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x48,
  0x00, 0x19, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x10, 0x80, 0x02, 0x10,
  0x00, 0x82, 0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20,
  0x04, 0x04, 0x01, 0x80, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x40,
  0x60, 0x08, 0x08, 0x01, 0x03, 0x00, 0x20, 0x40, 0x04, 0x18, 0x00, 0x82,
  0x00, 0x10, 0x7F, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x3F, 0xFC, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x5F, 0xE0, 0x78, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x80, 0x18,
  0xE0, 0x30, 0x7F, 0xE0, 0x03, 0xFC, 0x0C, 0x08, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0xE0, 0x47, 0xF8, 0x90, 0x19,
  0x40, 0x13, 0x80, 0x16, 0x00, 0x2C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x01, 0xA0, 0x02, 0x40, 0x04, 0xC0, 0x18, 0x80, 0x20, 0x80, 0xC0,
  0xFE, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x00, 0x80, 0x07, 0xF8, 0x06, 0x07,
  0x06, 0x00, 0x82, 0x00, 0x63, 0x00, 0x11, 0x00, 0x0C, 0x80, 0x06, 0x40,
  0x03, 0x20, 0x01, 0x90, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x21, 0x80, 0x30,
  0x40, 0x30, 0x10, 0x30, 0x06, 0x30, 0x01, 0xF0, 0x00, 0x70, 0x00, 0xCC,
  0x00, 0xC3, 0x00, 0xC0, 0x40, 0xC0, 0x10, 0xC0, 0x0C, 0x40, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x05,
  0x00, 0x02, 0xC0, 0x01, 0x20, 0x01, 0x98, 0x00, 0x86, 0x00, 0xC1, 0x81,
  0xC0, 0x7F, 0x80, 0x06, 0x00, 0x01, 0x80, 0x0F, 0xE0, 0x18, 0x18, 0x30,
  0x08, 0x20, 0x0C, 0x60, 0x04, 0x40, 0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x07, 0x60, 0x07, 0x20, 0x0B, 0x30,
  0x1B, 0x1F, 0xF3, 0x03, 0xC2, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0xE0, 0x3F, 0x80, 0x0C, 0x00, 0x5F,
  0xB0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xB0, 0x23, 0x33,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x33, 0x32,
  0x26, 0x64, 0x4C, 0x80, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x0F, 0xF2, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x46, 0x00, 0x60, 0x19, 0x00, 0x7F, 0x02, 0x40, 0x30,
  0xC0, 0x90, 0x18, 0x20, 0x2C, 0x0C, 0x08, 0x0B, 0x03, 0x02, 0x03, 0xC0,
  0x80, 0x80, 0xE0, 0x20, 0x20, 0x38, 0x18, 0x08, 0x0E, 0x06, 0x02, 0x03,
  0x81, 0x80, 0x80, 0xE0, 0x60, 0x20, 0x38, 0x18, 0x08, 0x0E, 0x06, 0x06,
  0x03, 0x81, 0x81, 0x80, 0xA0, 0x60, 0x60, 0x28, 0x08, 0x18, 0x1B, 0x02,
  0x0E, 0x06, 0xC0, 0xC2, 0x43, 0x30, 0x19, 0x99, 0x84, 0x03, 0xC3, 0xC1,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x01, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xA0, 0x00, 0x0B, 0x00, 0x00, 0x90,
  0x00, 0x19, 0x00, 0x01, 0x90, 0x00, 0x11, 0x80, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x03, 0x08, 0x00, 0x20, 0xC0, 0x02, 0x0C, 0x00, 0x20, 0x40, 0x06,
  0x04, 0x00, 0x40, 0x60, 0x04, 0x06, 0x00, 0x40, 0x20, 0x0C, 0x02, 0x00,
  0xC0, 0x20, 0x08, 0x03, 0x00, 0xFF, 0xF0, 0x18, 0x01, 0x01, 0x80, 0x10,
  0x10, 0x01, 0x81, 0x00, 0x08, 0x30, 0x00, 0x83, 0x00, 0x08, 0x20, 0x00,
  0xC2, 0x00, 0x0C, 0x20, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00, 0x64, 0x00,
  0x06, 0x40, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x30, 0xFF, 0xE0, 0x80,
  0x78, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x70, 0xFF, 0xC0, 0x80, 0x38, 0x80,
  0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x02, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x78, 0xFF, 0xE0, 0x00,
  0x18, 0x00, 0xFF, 0xC1, 0xC0, 0x21, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x08, 0x07, 0xFC, 0x00, 0x60, 0xFF, 0xC0,
  0x20, 0x1C, 0x08, 0x01, 0x82, 0x00, 0x30, 0x80, 0x06, 0x20, 0x00, 0x88,
  0x00, 0x32, 0x00, 0x04, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x0A, 0x00,
  0x02, 0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00,
  0x06, 0x80, 0x01, 0xA0, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x80, 0x06,
  0x20, 0x03, 0x08, 0x01, 0x82, 0x03, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xFF, 0x00, 0xE0, 0x0E, 0x0C, 0x00, 0x20, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80,
  0x00, 0x14, 0x00, 0x00, 0xB0, 0x00, 0x04, 0x80, 0x00, 0x26, 0x00, 0x01,
  0x10, 0x00, 0x08, 0xC0, 0x00, 0x43, 0x00, 0x02, 0x0C, 0x00, 0x10, 0x38,
  0x03, 0x80, 0x7F, 0xF0, 0x00, 0x20, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x8C, 0xF8, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x10, 0x80, 0x30, 0x80, 0x20, 0x80,
  0x60, 0x80, 0xC0, 0x80, 0x80, 0x81, 0x80, 0x81, 0x00, 0x83, 0x00, 0x86,
  0x00, 0x84, 0x00, 0x8C, 0x00, 0x8C, 0x00, 0x9C, 0x00, 0xB6, 0x00, 0xA2,
  0x00, 0xE3, 0x00, 0xC1, 0x00, 0x81, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x80,
  0x40, 0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80,
  0x08, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0x80,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x16, 0x80, 0x00,
  0x05, 0xA0, 0x00, 0x03, 0x6C, 0x00, 0x00, 0x99, 0x00, 0x00, 0x26, 0x40,
  0x00, 0x19, 0x98, 0x00, 0x06, 0x62, 0x00, 0x01, 0x18, 0x80, 0x00, 0x46,
  0x30, 0x00, 0x31, 0x8C, 0x00, 0x08, 0x61, 0x00, 0x02, 0x18, 0x40, 0x01,
  0x86, 0x18, 0x00, 0x41, 0x82, 0x00, 0x10, 0x60, 0x80, 0x0C, 0x18, 0x30,
  0x03, 0x06, 0x04, 0x00, 0x81, 0x81, 0x00, 0x20, 0x60, 0x60, 0x18, 0x18,
  0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x20,
  0x18, 0x04, 0x08, 0x06, 0x01, 0x06, 0x01, 0x80, 0x61, 0x80, 0x60, 0x08,
  0x40, 0x18, 0x02, 0x30, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x12, 0x00, 0x60,
  0x04, 0x80, 0x18, 0x01, 0xE0, 0x06, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x06, 0x80, 0x01, 0xB0, 0x00,
  0x64, 0x00, 0x19, 0x80, 0x06, 0x20, 0x01, 0x88, 0x00, 0x61, 0x00, 0x18,
  0x40, 0x06, 0x18, 0x01, 0x82, 0x00, 0x60, 0xC0, 0x18, 0x10, 0x06, 0x06,
  0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x01, 0x80, 0x60,
  0x60, 0x08, 0x18, 0x03, 0x06, 0x00, 0x41, 0x80, 0x18, 0x60, 0x02, 0x18,
  0x00, 0x86, 0x00, 0x31, 0x80, 0x04, 0x60, 0x01, 0x98, 0x00, 0x26, 0x00,
  0x0D, 0x80, 0x01, 0x60, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x01, 0x80, 0xC0, 0x10, 0x03, 0x01,
  0x80, 0x0C, 0x18, 0x00, 0x20, 0x80, 0x01, 0x8C, 0x00, 0x04, 0x60, 0x00,
  0x22, 0x00, 0x01, 0x90, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00, 0x05,
  0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x19, 0x80, 0x00, 0x84, 0x00,
  0x04, 0x30, 0x00, 0x61, 0x80, 0x02, 0x06, 0x00, 0x30, 0x18, 0x03, 0x00,
  0x60, 0x30, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x81, 0x01, 0xE2,
  0x00, 0xE4, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x40, 0x02, 0x80, 0x0D, 0x00, 0x32, 0x00, 0xC4, 0x07, 0x0F, 0xF8, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x01,
  0x80, 0xC0, 0x10, 0x03, 0x01, 0x80, 0x0C, 0x18, 0x00, 0x20, 0x80, 0x01,
  0x8C, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00, 0x01, 0x90, 0x00, 0x05, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00,
  0x19, 0x80, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x61, 0x80, 0x02, 0x06,
  0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x30, 0x01, 0xFE, 0x00, 0x01, 0xA0,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xFF, 0x80,
  0x80, 0xF0, 0x80, 0x18, 0x80, 0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x06,
  0x80, 0x06, 0x80, 0x06, 0x80, 0x02, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x10, 0x80, 0x60,
  0xFF, 0xC0, 0x81, 0x00, 0x81, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x80, 0x40,
  0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80, 0x18,
  0x80, 0x08, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03,
  0x00, 0xC0, 0x07, 0xFF, 0x1C, 0x02, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0xC0, 0x38, 0x7F, 0xF0, 0x03, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x2C, 0x00, 0x0B, 0x00,
  0x06, 0x40, 0x01, 0x18, 0x00, 0xC3, 0x00, 0x20, 0x60, 0x30, 0x0F, 0xF8,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0x20, 0x00,
  0x24, 0x00, 0x04, 0xC0, 0x01, 0x88, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00,
  0x86, 0x00, 0x30, 0xC0, 0x06, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x06,
  0x06, 0x00, 0xC0, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x18,
  0x02, 0x02, 0x00, 0x40, 0x40, 0x08, 0x08, 0x01, 0x83, 0x00, 0x30, 0x40,
  0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x60, 0x01, 0x8C, 0x00, 0x11, 0x00,
  0x02, 0x20, 0x00, 0x44, 0x00, 0x0D, 0x80, 0x00, 0xA0, 0x00, 0x14, 0x00,
  0x02, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xA0,
  0x00, 0x60, 0x00, 0x50, 0x00, 0x30, 0x00, 0x68, 0x00, 0x38, 0x00, 0x36,
  0x00, 0x1C, 0x00, 0x13, 0x00, 0x0B, 0x00, 0x08, 0x80, 0x05, 0x80, 0x0C,
  0x40, 0x02, 0x40, 0x06, 0x30, 0x03, 0x20, 0x03, 0x18, 0x01, 0x90, 0x01,
  0x04, 0x00, 0x8C, 0x00, 0x82, 0x00, 0x46, 0x00, 0xC1, 0x00, 0x23, 0x00,
  0x60, 0xC0, 0x30, 0x80, 0x20, 0x60, 0x18, 0x40, 0x10, 0x10, 0x08, 0x30,
  0x08, 0x08, 0x04, 0x18, 0x0C, 0x04, 0x02, 0x0C, 0x06, 0x03, 0x03, 0x02,
  0x02, 0x01, 0x81, 0x81, 0x01, 0x00, 0x40, 0x80, 0x81, 0x80, 0x20, 0x40,
  0x60, 0xC0, 0x18, 0x20, 0x30, 0x40, 0x0C, 0x30, 0x08, 0x20, 0x06, 0x18,
  0x04, 0x10, 0x01, 0x08, 0x02, 0x18, 0x00, 0x84, 0x01, 0x8C, 0x00, 0x62,
  0x00, 0xC4, 0x00, 0x33, 0x00, 0x22, 0x00, 0x09, 0x80, 0x13, 0x00, 0x04,
  0x80, 0x09, 0x80, 0x02, 0x40, 0x06, 0x80, 0x01, 0xA0, 0x03, 0x40, 0x00,
  0xF0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x40, 0x03, 0x60, 0x02, 0x20, 0x06, 0x30, 0x04,
  0x30, 0x0C, 0x10, 0x0C, 0x18, 0x08, 0x08, 0x18, 0x08, 0x10, 0x0C, 0x10,
  0x04, 0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40,
  0x06, 0x60, 0x04, 0x20, 0x0C, 0x20, 0x0C, 0x30, 0x08, 0x10, 0x18, 0x10,
  0x10, 0x18, 0x10, 0x08, 0x30, 0x08, 0x20, 0x0C, 0x60, 0x04, 0x40, 0x04,
  0x40, 0x06, 0xC0, 0x02, 0x80, 0x03, 0xC0, 0x01, 0x40, 0x03, 0x40, 0x03,
  0x60, 0x02, 0x20, 0x06, 0x20, 0x06, 0x30, 0x04, 0x10, 0x0C, 0x10, 0x0C,
  0x18, 0x08, 0x08, 0x08, 0x08, 0x18, 0x0C, 0x10, 0x04, 0x10, 0x04, 0x30,
  0x06, 0x20, 0x02, 0x20, 0x02, 0x60, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x7F, 0xFC, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x60, 0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x02, 0xC0, 0x00, 0xD8, 0x00, 0x11, 0x00, 0x06, 0x30,
  0x00, 0x82, 0x00, 0x30, 0x60, 0x04, 0x04, 0x01, 0x80, 0xC0, 0x20, 0x08,
  0x0C, 0x01, 0x81, 0x00, 0x10, 0x60, 0x03, 0x08, 0x00, 0x23, 0x00, 0x06,
  0x40, 0x00, 0xD8, 0x00, 0x0C, 0xFF, 0xFF, 0xF0, 0xC0, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x03, 0x0F, 0xC1, 0xE7, 0x08, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x07, 0x83, 0xF4, 0x70, 0x26, 0x01, 0x60, 0x0A, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x78, 0x03, 0xC0, 0x1A, 0x01, 0x48, 0x1A,
  0x3F, 0x90, 0x60, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x87, 0xC0, 0x8E, 0x70, 0x90, 0x18, 0xA0, 0x0C,
  0xA0, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x02,
  0xC0, 0x06, 0xC0, 0x04, 0xA0, 0x0C, 0xB0, 0x08, 0x98, 0x38, 0x8F, 0xE0,
  0x01, 0x00, 0x01, 0xF0, 0x3C, 0xC3, 0x00, 0x30, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x02, 0x0F, 0xF0,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x03, 0xE1, 0x0E, 0x71, 0x18, 0x09, 0x10, 0x05, 0x30, 0x07,
  0x20, 0x03, 0x60, 0x03, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x60, 0x03,
  0x20, 0x03, 0x30, 0x05, 0x10, 0x0D, 0x18, 0x19, 0x07, 0xF1, 0x01, 0x80,
  0x03, 0xE0, 0x1C, 0xE0, 0x60, 0x60, 0x80, 0x63, 0x00, 0x44, 0x00, 0x98,
  0x01, 0xB0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x04, 0x30, 0x38, 0x3F, 0xC0, 0x04, 0x00, 0x03, 0xC0, 0xFC, 0x30, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x81, 0xFF, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x03, 0xE0, 0x0F, 0x79, 0x18, 0x0D, 0x10, 0x05, 0x20, 0x03,
  0x20, 0x03, 0x60, 0x03, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x60, 0x03,
  0x20, 0x07, 0x30, 0x05, 0x10, 0x0D, 0x18, 0x19, 0x07, 0xF1, 0x01, 0x81,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x60, 0x18, 0x3F, 0xF0, 0x03, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x87, 0xC2, 0x3B,
  0x89, 0x03, 0x28, 0x06, 0xA0, 0x0B, 0x00, 0x2C, 0x00, 0xB0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x5F, 0xA0,
  0x00, 0x00, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x80, 0x08, 0x71, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x86, 0x1B, 0xC4, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x02, 0x80, 0x68, 0x04, 0x80, 0x88, 0x18, 0x81, 0x08, 0x30, 0x82, 0x08,
  0x40, 0x8C, 0x08, 0xC0, 0x94, 0x0B, 0x60, 0xA2, 0x0E, 0x20, 0xC3, 0x08,
  0x10, 0x81, 0x88, 0x08, 0x80, 0x88, 0x0C, 0x80, 0x48, 0x06, 0x80, 0x28,
  0x02, 0x80, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0xF0,
  0x9C, 0xC1, 0x9C, 0xB0, 0x22, 0x06, 0xA0, 0x34, 0x02, 0xC0, 0x14, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x07, 0xC2, 0x33,
  0xC9, 0x01, 0x28, 0x06, 0xE0, 0x0B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x03, 0xE0,
  0x07, 0x3C, 0x06, 0x03, 0x06, 0x00, 0xC2, 0x00, 0x21, 0x00, 0x11, 0x80,
  0x0C, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x58, 0x00, 0x2C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00,
  0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x13, 0x00, 0x09, 0x80, 0x0C, 0x40,
  0x04, 0x30, 0x06, 0x08, 0x02, 0x03, 0x07, 0x00, 0xFE, 0x00, 0x08, 0x00,
  0x07, 0xC0, 0x8E, 0x70, 0x98, 0x18, 0xB0, 0x0C, 0xA0, 0x04, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xE0, 0x04,
  0xA0, 0x0C, 0xB0, 0x18, 0x98, 0x30, 0x8F, 0xE0, 0x81, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x79,
  0x18, 0x0D, 0x10, 0x05, 0x30, 0x07, 0x20, 0x03, 0x60, 0x03, 0x60, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x03, 0x60, 0x03, 0x20, 0x03, 0x30, 0x05, 0x18, 0x0D,
  0x0C, 0x19, 0x07, 0xF1, 0x00, 0x81, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x07, 0x47, 0xE4, 0x16, 0x0A, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00,
  0x0F, 0xC3, 0xCF, 0x60, 0x14, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x38, 0x03, 0xC0, 0x67, 0xFC, 0x04, 0x00, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x41, 0xFF, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x07, 0xC0, 0x80,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x40, 0x2D, 0x83, 0x33, 0xF8, 0xC1,
  0x00, 0xC0, 0x06, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x26, 0x00, 0xC4, 0x01,
  0x88, 0x02, 0x10, 0x04, 0x30, 0x18, 0x20, 0x30, 0x40, 0x40, 0x80, 0x81,
  0x83, 0x01, 0x06, 0x02, 0x08, 0x04, 0x10, 0x0C, 0x20, 0x08, 0xC0, 0x11,
  0x00, 0x22, 0x00, 0x64, 0x00, 0xD8, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x05,
  0x00, 0x58, 0x02, 0x80, 0x24, 0x01, 0x40, 0x12, 0x01, 0xB0, 0x19, 0x00,
  0xD8, 0x0C, 0xC0, 0x44, 0x04, 0x20, 0x22, 0x02, 0x10, 0x11, 0x01, 0x08,
  0x18, 0xC1, 0x84, 0x0C, 0x60, 0xC3, 0x04, 0x10, 0x40, 0x82, 0x08, 0x20,
  0x43, 0x04, 0x10, 0x21, 0x83, 0x18, 0x18, 0x80, 0x88, 0x04, 0x40, 0x44,
  0x02, 0x20, 0x22, 0x01, 0x30, 0x13, 0x00, 0xD8, 0x0D, 0x80, 0x68, 0x02,
  0x80, 0x14, 0x01, 0x40, 0x0A, 0x00, 0xA0, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0D, 0x80, 0x22, 0x01, 0x8C, 0x04,
  0x10, 0x10, 0x60, 0xC0, 0x82, 0x02, 0x18, 0x0C, 0x40, 0x13, 0x00, 0x68,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xA0, 0x04, 0xC0, 0x31,
  0x00, 0x86, 0x06, 0x08, 0x10, 0x30, 0xC0, 0xC2, 0x01, 0x18, 0x06, 0x60,
  0x09, 0x00, 0x3C, 0x00, 0x40, 0xC0, 0x06, 0x80, 0x09, 0x00, 0x13, 0x00,
  0x26, 0x00, 0xC4, 0x01, 0x08, 0x02, 0x18, 0x04, 0x30, 0x18, 0x20, 0x20,
  0x40, 0x40, 0x80, 0x81, 0x83, 0x01, 0x04, 0x02, 0x08, 0x06, 0x10, 0x0C,
  0x60, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x6C, 0x00, 0x50, 0x00, 0xA0,
  0x01, 0x40, 0x03, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x3C, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0x00, 0xF0, 0x1C, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x1C, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xF0, 0x00,
  0x08, 0x00, 0x3F, 0x80, 0x70, 0x70, 0x70, 0x0F, 0xE8, 0x01, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 37, 10, 4, -37 },
  { 11, 9, 13, 15, 3, -37 },
  { 26, 20, 37, 22, 1, -37 },
  { 119, 17, 43, 20, 2, -40 },
  { 211, 25, 38, 30, 2, -38 },
  { 330, 18, 39, 20, 2, -38 },
  { 418, 2, 13, 8, 3, -37 },
  { 422, 9, 45, 14, 3, -37 },
  { 473, 9, 45, 14, 2, -37 },
  { 524, 13, 14, 18, 2, -40 },
  { 547, 17, 24, 21, 2, -30 },
  { 598, 4, 12, 9, 2, -5 },
  { 604, 11, 2, 14, 1, -15 },
  { 607, 3, 3, 9, 3, -3 },
  { 609, 15, 37, 17, 1, -37 },
  { 679, 16, 38, 20, 2, -38 },
  { 755, 8, 37, 20, 4, -37 },
  { 792, 16, 38, 20, 2, -38 },
  { 868, 16, 39, 20, 2, -38 },
  { 946, 19, 37, 20, 1, -37 },
  { 1034, 16, 37, 20, 2, -37 },
  { 1108, 15, 38, 20, 3, -37 },
  { 1180, 16, 37, 20, 2, -37 },
  { 1254, 17, 39, 20, 2, -38 },
  { 1337, 16, 39, 20, 2, -38 },
  { 1415, 3, 28, 9, 3, -28 },
  { 1426, 4, 35, 9, 2, -28 },
  { 1444, 17, 21, 21, 2, -29 },
  { 1489, 17, 13, 21, 2, -25 },
  { 1517, 17, 21, 21, 2, -29 },
  { 1562, 11, 38, 14, 1, -38 },
  { 1615, 26, 42, 31, 3, -37 },
  { 1752, 20, 37, 20, 0, -37 },
  { 1845, 16, 37, 22, 4, -37 },
  { 1919, 17, 39, 22, 3, -38 },
  { 2002, 18, 37, 25, 4, -37 },
  { 2086, 13, 37, 20, 4, -37 },
  { 2147, 13, 37, 18, 4, -37 },
  { 2208, 21, 39, 27, 3, -38 },
  { 2311, 17, 37, 25, 4, -37 },
  { 2390, 7, 37, 11, 2, -37 },
  { 2423, 8, 46, 10, -2, -37 },
  { 2469, 16, 37, 20, 4, -37 },
  { 2543, 13, 37, 18, 4, -37 },
  { 2604, 26, 37, 34, 4, -37 },
  { 2725, 18, 37, 26, 4, -37 },
  { 2809, 21, 39, 27, 3, -38 },
  { 2912, 15, 37, 21, 4, -37 },
  { 2982, 21, 47, 27, 3, -38 },
  { 3106, 16, 37, 21, 4, -37 },
  { 3180, 16, 39, 20, 2, -38 },
  { 3258, 17, 37, 17, 0, -37 },
  { 3337, 18, 38, 25, 4, -37 },
  { 3423, 19, 37, 19, 0, -37 },
  { 3511, 33, 37, 34, 0, -37 },
  { 3664, 16, 37, 17, 1, -37 },
  { 3738, 16, 37, 16, 0, -37 },
  { 3812, 15, 37, 17, 1, -37 },
  { 3882, 10, 45, 16, 4, -37 },
  { 3939, 15, 37, 17, 1, -37 },
  { 4009, 10, 45, 16, 2, -37 },
  { 4066, 19, 18, 21, 1, -37 },
  { 4109, 20, 1, 20, 0, 5 },
  { 4112, 8, 8, 12, 2, -40 },
  { 4120, 13, 29, 19, 2, -28 },
  { 4168, 16, 41, 22, 4, -40 },
  { 4250, 13, 29, 16, 2, -28 },
  { 4298, 16, 41, 22, 2, -40 },
  { 4380, 15, 29, 20, 2, -28 },
  { 4435, 11, 40, 11, 1, -40 },
  { 4490, 16, 41, 22, 2, -28 },
  { 4572, 14, 40, 21, 4, -40 },
  { 4642, 3, 38, 9, 3, -38 },
  { 4657, 6, 51, 9, 0, -38 },
  { 4696, 12, 40, 17, 4, -40 },
  { 4756, 1, 40, 9, 4, -40 },
  { 4761, 24, 28, 32, 4, -28 },
  { 4845, 14, 28, 21, 4, -28 },
  { 4894, 17, 29, 21, 2, -28 },
  { 4956, 16, 40, 22, 4, -28 },
  { 5036, 16, 40, 22, 2, -28 },
  { 5116, 9, 28, 14, 4, -28 },
  { 5148, 12, 29, 16, 2, -28 },
  { 5192, 9, 35, 11, 1, -34 },
  { 5232, 14, 28, 21, 4, -27 },
  { 5281, 15, 27, 15, 0, -27 },
  { 5332, 25, 27, 27, 1, -27 },
  { 5417, 14, 27, 16, 1, -27 },
  { 5465, 15, 40, 16, 1, -27 },
  { 5540, 10, 27, 13, 2, -27 },
  { 5574, 12, 45, 18, 3, -37 },
  { 5642, 2, 53, 20, 9, -40 },
  { 5656, 12, 45, 18, 3, -37 },
  { 5724, 17, 5, 21, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Thin52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN52PT7B_H_
