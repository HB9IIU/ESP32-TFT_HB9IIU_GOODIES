#ifndef _NOTOSANS_EXTRACONDENSED_THIN28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x30, 0x99, 0x99, 0x99, 0x90, 0x08, 0x41, 0x10, 0x22,
  0x04, 0x40, 0x88, 0x11, 0x1F, 0xF8, 0x84, 0x10, 0x82, 0x10, 0x42, 0x08,
  0x81, 0x11, 0xFF, 0xC4, 0x40, 0x88, 0x21, 0x04, 0x20, 0x84, 0x11, 0x00,
  0x08, 0x0F, 0x1A, 0x51, 0x08, 0x84, 0x42, 0x21, 0x10, 0x48, 0x34, 0x06,
  0x01, 0x80, 0xB0, 0x44, 0x22, 0x11, 0x08, 0x84, 0x42, 0x5D, 0xC1, 0x80,
  0x40, 0x20, 0x78, 0x21, 0x21, 0x08, 0x44, 0x21, 0x10, 0x84, 0x82, 0x12,
  0x08, 0x48, 0x21, 0x40, 0x85, 0x7A, 0x25, 0x24, 0xA8, 0x5E, 0xA1, 0x02,
  0x84, 0x12, 0x10, 0x48, 0x41, 0x21, 0x08, 0x84, 0x22, 0x10, 0x84, 0x84,
  0x0E, 0x3C, 0x09, 0x04, 0x21, 0x08, 0x42, 0x11, 0x02, 0x40, 0x90, 0x18,
  0x04, 0x06, 0x81, 0x22, 0x84, 0xA1, 0x28, 0x2A, 0x0A, 0x81, 0x20, 0x44,
  0x29, 0xF1, 0xFE, 0x08, 0x84, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x42,
  0x08, 0x42, 0x10, 0x42, 0x10, 0x41, 0x82, 0x08, 0x41, 0x08, 0x41, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x84, 0x22, 0x11, 0x18, 0x10, 0x23, 0x59,
  0xC1, 0x84, 0x90, 0x80, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x43, 0xFE,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x55, 0x68, 0xFC, 0xC0, 0x01,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x1E, 0x11, 0x10, 0x48, 0x24,
  0x14, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02,
  0x82, 0x41, 0x20, 0x88, 0x83, 0xC0, 0x09, 0xD3, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x7E, 0x41, 0x00, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x1F, 0xF0, 0x7E, 0x40, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x1E, 0x01, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x5F, 0xC0, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x50,
  0x0A, 0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0x84, 0x10, 0x84, 0x10, 0x82,
  0x3F, 0xF8, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x7F, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xFC, 0x01, 0x80, 0x40, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x9F, 0x80, 0x0F, 0x08, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0xBE, 0x60, 0xB0, 0x50, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x40, 0xA0, 0x90, 0x47, 0xC0, 0xFF, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x00, 0x3E, 0x20, 0x90, 0x50, 0x18, 0x0A,
  0x05, 0x04, 0x44, 0x14, 0x04, 0x0D, 0x88, 0x24, 0x14, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x50, 0x47, 0xC0, 0x3C, 0x21, 0x10, 0x50, 0x28, 0x14, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xD0, 0xA7, 0xD0, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x8F, 0x80, 0xC0, 0x06, 0x50, 0x00, 0x00, 0x55, 0x68, 0x00,
  0x80, 0xC1, 0x83, 0x06, 0x04, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x10, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x10, 0x00, 0xF8,
  0x08, 0x08, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08,
  0x00, 0x00, 0x00, 0x81, 0x00, 0x0F, 0x80, 0x83, 0x08, 0x04, 0x80, 0x24,
  0x00, 0xC0, 0x06, 0x1E, 0x31, 0x11, 0x88, 0x8C, 0x44, 0x64, 0x23, 0x21,
  0x19, 0x08, 0xC8, 0x46, 0x22, 0x31, 0x31, 0x86, 0x74, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x40, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x28, 0x05,
  0x00, 0xA0, 0x24, 0x04, 0x80, 0x88, 0x11, 0x04, 0x20, 0x84, 0x1F, 0xC2,
  0x08, 0x81, 0x10, 0x22, 0x02, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x10, 0xFE,
  0x40, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x05, 0x02, 0x82, 0x7E, 0x20, 0xD0,
  0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x5F, 0x80, 0x1F, 0x90,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x03, 0xF0, 0xFC, 0x20, 0x88,
  0x12, 0x02, 0x80, 0xA0, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x23, 0xF0, 0xFF, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x03, 0xFC, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0x1F, 0xC4,
  0x05, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x0F, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x28, 0x04, 0x80,
  0x8F, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x2F, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xE0,
  0x81, 0x40, 0xA0, 0x90, 0x88, 0x44, 0x42, 0x21, 0x20, 0xA0, 0x50, 0x34,
  0x11, 0x08, 0x84, 0x22, 0x11, 0x04, 0x82, 0x40, 0xA0, 0x50, 0x30, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x07, 0xF0, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xA0, 0x16, 0x80, 0x5A, 0x01, 0x64, 0x05, 0x90, 0x26, 0x40, 0x98, 0x82,
  0x62, 0x11, 0x88, 0x46, 0x21, 0x18, 0x48, 0x61, 0x21, 0x84, 0x86, 0x0A,
  0x18, 0x30, 0x60, 0xC1, 0x80, 0x70, 0x1C, 0x06, 0x81, 0xA0, 0x64, 0x19,
  0x06, 0x41, 0x88, 0x62, 0x18, 0x46, 0x11, 0x82, 0x60, 0x98, 0x16, 0x05,
  0x81, 0x60, 0x38, 0x0E, 0x01, 0x1F, 0x0C, 0x11, 0x01, 0x40, 0x28, 0x05,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x02, 0x80, 0x48, 0x09, 0x82, 0x1F, 0x80, 0xFC, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x8C, 0xF0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x0C, 0x11, 0x01, 0x40, 0x28, 0x05,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x02, 0x80, 0x48, 0x08, 0x82, 0x0F, 0x80, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x05,
  0x02, 0x81, 0x41, 0x3F, 0x11, 0x08, 0x84, 0x22, 0x11, 0x04, 0x82, 0x40,
  0xA0, 0x50, 0x10, 0x3F, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x5F, 0xC0, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x24,
  0x08, 0xFC, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x90, 0x24, 0x08, 0x82,
  0x21, 0x08, 0x42, 0x10, 0x44, 0x12, 0x04, 0x81, 0x20, 0x48, 0x0A, 0x03,
  0x00, 0xC0, 0x10, 0x80, 0x40, 0x60, 0x30, 0x14, 0x0C, 0x05, 0x03, 0x02,
  0x40, 0xC0, 0x90, 0x48, 0x24, 0x12, 0x08, 0x84, 0x84, 0x21, 0x21, 0x08,
  0x48, 0x42, 0x21, 0x10, 0x88, 0x44, 0x12, 0x12, 0x04, 0x84, 0x81, 0x21,
  0x20, 0x50, 0x28, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30,
  0x40, 0xA0, 0x48, 0x44, 0x22, 0x20, 0x90, 0x48, 0x18, 0x0C, 0x04, 0x03,
  0x01, 0x81, 0x40, 0x90, 0x88, 0x42, 0x21, 0x20, 0x90, 0x30, 0x10, 0x80,
  0xC0, 0x90, 0x48, 0x24, 0x21, 0x10, 0x88, 0x48, 0x14, 0x0A, 0x06, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFE, 0x04,
  0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x07, 0xF0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3F, 0x04, 0x00, 0xC0,
  0x28, 0x04, 0x81, 0x10, 0x21, 0x08, 0x22, 0x02, 0x40, 0x50, 0x04, 0xFF,
  0xE0, 0xC4, 0x21, 0x7C, 0x04, 0x08, 0x10, 0x20, 0x41, 0x9D, 0x43, 0x06,
  0x0C, 0x18, 0x30, 0xDF, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0xF1, 0x84, 0xC1, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xA0, 0x58, 0x4B, 0xE0, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x02, 0x04, 0x04, 0x0F, 0x80, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x7A, 0x43, 0x41, 0xA0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xA0, 0x50, 0x68, 0x33, 0xE8, 0x1C, 0x22, 0x41, 0x41, 0x81,
  0x81, 0x81, 0xFE, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x1F, 0x1E, 0x40,
  0x81, 0x02, 0x04, 0x3E, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x00, 0x1E, 0x90, 0xD0, 0x68, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x14, 0x1A, 0x0C, 0xFA, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x24, 0x21, 0xE0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x2F,
  0x61, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x20, 0xC7, 0xFF, 0xF0, 0x24, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x27, 0x00, 0x81, 0x02, 0x04, 0x08, 0x10, 0x21, 0xC2, 0x89, 0x12,
  0x45, 0x0A, 0x1A, 0x24, 0x44, 0x89, 0x0A, 0x14, 0x28, 0x20, 0xFF, 0xFF,
  0xF8, 0xBC, 0xF6, 0x28, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08,
  0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06,
  0x08, 0x20, 0xBD, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0x80, 0x1E, 0x10, 0x90, 0x48, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x28, 0x14, 0x12, 0x08, 0xF8, 0xBC, 0x61, 0x30,
  0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x28, 0x16,
  0x12, 0xF1, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x1E, 0x90,
  0xD0, 0x68, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x14,
  0x1A, 0x0C, 0xFA, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xBE,
  0x31, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x00, 0x3E, 0x82, 0x04,
  0x08, 0x08, 0x18, 0x08, 0x08, 0x08, 0x08, 0x10, 0x20, 0xBF, 0x00, 0x44,
  0x4F, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x47, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xDE, 0x80, 0x81, 0x81,
  0x41, 0x42, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x24, 0x18, 0x18, 0x18,
  0x08, 0x81, 0x06, 0x04, 0x14, 0x30, 0x50, 0xA2, 0x42, 0x89, 0x0A, 0x22,
  0x48, 0x89, 0x22, 0x24, 0x50, 0x91, 0x42, 0x85, 0x06, 0x14, 0x18, 0x50,
  0x60, 0x81, 0x82, 0x00, 0x41, 0x41, 0x22, 0x22, 0x14, 0x14, 0x18, 0x08,
  0x14, 0x14, 0x24, 0x22, 0x22, 0x41, 0xC1, 0x40, 0xA0, 0x90, 0x48, 0x22,
  0x11, 0x10, 0x88, 0x44, 0x12, 0x0A, 0x05, 0x02, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x06, 0x00, 0xFC, 0x20, 0x82, 0x10,
  0x41, 0x08, 0x21, 0x04, 0x10, 0x82, 0x0F, 0xC0, 0x06, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x0E, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x20, 0x40,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x61, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x78, 0x78, 0xC3, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 20, 5, 2, -20 },
  { 4, 4, 7, 8, 2, -20 },
  { 8, 11, 20, 12, 0, -20 },
  { 36, 9, 23, 11, 1, -21 },
  { 62, 14, 20, 16, 1, -20 },
  { 97, 10, 20, 11, 1, -20 },
  { 122, 1, 7, 5, 2, -20 },
  { 123, 5, 24, 7, 1, -20 },
  { 138, 5, 24, 7, 1, -20 },
  { 153, 7, 7, 9, 1, -21 },
  { 160, 9, 13, 11, 1, -16 },
  { 175, 2, 7, 5, 1, -3 },
  { 177, 6, 1, 7, 1, -8 },
  { 178, 1, 2, 5, 2, -2 },
  { 179, 8, 20, 9, 1, -20 },
  { 199, 9, 20, 11, 1, -20 },
  { 222, 5, 20, 11, 2, -20 },
  { 235, 9, 20, 11, 1, -20 },
  { 258, 9, 20, 11, 1, -20 },
  { 281, 11, 20, 11, 0, -20 },
  { 309, 9, 20, 11, 1, -20 },
  { 332, 9, 20, 11, 1, -20 },
  { 355, 9, 20, 11, 1, -20 },
  { 378, 9, 20, 11, 1, -20 },
  { 401, 9, 20, 11, 1, -20 },
  { 424, 1, 15, 5, 2, -15 },
  { 426, 2, 19, 5, 1, -15 },
  { 431, 9, 12, 11, 1, -16 },
  { 445, 9, 7, 11, 1, -13 },
  { 453, 9, 12, 11, 1, -16 },
  { 467, 7, 20, 7, 0, -20 },
  { 485, 13, 23, 17, 2, -20 },
  { 523, 11, 20, 11, 0, -20 },
  { 551, 9, 20, 12, 2, -20 },
  { 574, 9, 20, 12, 2, -20 },
  { 597, 10, 20, 13, 2, -20 },
  { 622, 7, 20, 11, 2, -20 },
  { 640, 7, 20, 10, 2, -20 },
  { 658, 11, 20, 15, 2, -20 },
  { 686, 9, 20, 14, 2, -20 },
  { 709, 4, 20, 6, 1, -20 },
  { 719, 4, 25, 5, -1, -20 },
  { 732, 9, 20, 11, 2, -20 },
  { 755, 7, 20, 10, 2, -20 },
  { 773, 14, 20, 18, 2, -20 },
  { 808, 10, 20, 14, 2, -20 },
  { 833, 11, 20, 14, 2, -20 },
  { 861, 8, 20, 11, 2, -20 },
  { 881, 11, 25, 14, 2, -20 },
  { 916, 9, 20, 11, 2, -20 },
  { 939, 9, 20, 11, 1, -20 },
  { 962, 9, 20, 9, 0, -20 },
  { 985, 10, 20, 14, 2, -20 },
  { 1010, 10, 20, 10, 0, -20 },
  { 1035, 18, 20, 18, 0, -20 },
  { 1080, 9, 20, 9, 0, -20 },
  { 1103, 9, 20, 9, 0, -20 },
  { 1126, 7, 20, 9, 1, -20 },
  { 1144, 6, 24, 9, 2, -20 },
  { 1162, 8, 20, 9, 1, -20 },
  { 1182, 5, 24, 9, 1, -20 },
  { 1197, 11, 10, 11, 0, -20 },
  { 1211, 11, 1, 11, 0, 2 },
  { 1213, 4, 4, 6, 1, -21 },
  { 1215, 7, 15, 10, 1, -15 },
  { 1229, 9, 21, 12, 2, -21 },
  { 1253, 7, 15, 9, 1, -15 },
  { 1267, 9, 21, 12, 1, -21 },
  { 1291, 8, 15, 11, 1, -15 },
  { 1306, 7, 21, 6, 0, -21 },
  { 1325, 9, 22, 12, 1, -15 },
  { 1350, 7, 21, 11, 2, -21 },
  { 1369, 1, 20, 5, 2, -20 },
  { 1372, 3, 27, 5, 0, -20 },
  { 1383, 7, 21, 9, 2, -21 },
  { 1402, 1, 21, 5, 2, -21 },
  { 1405, 13, 15, 17, 2, -15 },
  { 1430, 7, 15, 11, 2, -15 },
  { 1444, 9, 15, 11, 1, -15 },
  { 1461, 9, 22, 12, 2, -15 },
  { 1486, 9, 22, 12, 1, -15 },
  { 1511, 5, 15, 7, 2, -15 },
  { 1521, 7, 15, 9, 1, -15 },
  { 1535, 4, 18, 6, 1, -18 },
  { 1544, 7, 15, 11, 2, -15 },
  { 1558, 8, 15, 8, 0, -15 },
  { 1573, 14, 15, 14, 0, -15 },
  { 1600, 8, 15, 9, 0, -15 },
  { 1615, 9, 22, 9, 0, -15 },
  { 1640, 6, 15, 7, 1, -15 },
  { 1652, 7, 24, 10, 1, -20 },
  { 1673, 1, 28, 11, 5, -21 },
  { 1677, 7, 24, 10, 1, -20 },
  { 1698, 9, 2, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Thin28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN28PT7B_H_
