#ifndef _NOTOSANS_EXTRACONDENSED_THIN32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin32pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x50, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x81, 0x08, 0x10, 0x8F, 0xFF,
  0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x21, 0x0F, 0xFE,
  0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x22, 0x00, 0x04,
  0x01, 0x80, 0xD7, 0x22, 0x08, 0x41, 0x08, 0x21, 0x04, 0x20, 0x84, 0x08,
  0x81, 0x90, 0x0A, 0x00, 0xC0, 0x0E, 0x01, 0x20, 0x22, 0x04, 0x40, 0x84,
  0x10, 0x82, 0x20, 0x45, 0x09, 0x1F, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x38,
  0x10, 0x44, 0x10, 0x44, 0x10, 0x44, 0x20, 0x82, 0x20, 0x82, 0x20, 0x82,
  0x40, 0x82, 0x40, 0x82, 0x40, 0x82, 0x9C, 0x44, 0x92, 0x44, 0xA2, 0x45,
  0x21, 0x39, 0x21, 0x01, 0x21, 0x02, 0x21, 0x02, 0x21, 0x02, 0x21, 0x04,
  0x21, 0x04, 0x21, 0x04, 0x22, 0x08, 0x22, 0x08, 0x1C, 0x1C, 0x04, 0x40,
  0x88, 0x10, 0x82, 0x10, 0x42, 0x08, 0x81, 0x10, 0x12, 0x02, 0x80, 0x20,
  0x0C, 0x02, 0x40, 0x88, 0x60, 0x8C, 0x11, 0x81, 0x50, 0x2A, 0x03, 0x40,
  0x48, 0x0C, 0x82, 0x4F, 0x88, 0xFF, 0x08, 0x84, 0x42, 0x21, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x21, 0x08, 0x21, 0x04, 0x10,
  0x81, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x21, 0x04, 0x30, 0x84, 0x30, 0x08, 0x08, 0xC9,
  0x3E, 0x08, 0x14, 0x22, 0x41, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x07, 0xFF, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x25, 0x24, 0xA0, 0xFE, 0xF0, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00, 0x1E, 0x08, 0x42,
  0x09, 0x02, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x14, 0x05, 0x01, 0x40, 0x50, 0x14, 0x05, 0x02, 0x20, 0x8C,
  0x41, 0xE0, 0x04, 0x73, 0x51, 0xC4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x3E, 0x10, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0F,
  0xFC, 0x3E, 0x30, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x78, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0xA0, 0x67, 0xF0, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x10, 0x81, 0x08,
  0x20, 0x82, 0x08, 0x40, 0x84, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x5C, 0x31, 0x80, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x14, 0x1B, 0xF0, 0x0F, 0x18, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x4F, 0x38, 0x50, 0x28, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x08, 0xF8, 0xFF, 0xC0, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x1F, 0x08, 0x24, 0x05, 0x01, 0x40, 0x50, 0x14, 0x05, 0x02,
  0x20, 0x84, 0x40, 0xE0, 0x28, 0x31, 0x18, 0x24, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x40, 0x58, 0x23, 0xF0, 0x1E, 0x08, 0x44, 0x09, 0x02,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x03, 0x41, 0x4F,
  0x90, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x87, 0xC0,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x09, 0x49,
  0x28, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x20, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x00,
  0xF9, 0x08, 0x10, 0x10, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x07, 0xE0, 0x08,
  0x10, 0x10, 0x08, 0x20, 0x04, 0x40, 0x04, 0x40, 0x02, 0x40, 0x82, 0x83,
  0x62, 0x84, 0x22, 0x84, 0x21, 0x84, 0x21, 0x88, 0x21, 0x88, 0x41, 0x88,
  0x41, 0x88, 0x41, 0x88, 0x42, 0x88, 0x42, 0x84, 0xA2, 0x87, 0xBC, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x18, 0x20, 0x07,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x50, 0x09, 0x00, 0x90, 0x09, 0x00,
  0x90, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x20, 0x43, 0xFC, 0x20, 0x42,
  0x04, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x18, 0x01, 0x80, 0x10,
  0xFE, 0x10, 0x32, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80,
  0x50, 0x13, 0xFC, 0x41, 0x88, 0x09, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x30,
  0x06, 0x01, 0x40, 0x28, 0x05, 0x01, 0x3F, 0xC0, 0x0F, 0xE2, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x03, 0xF0, 0xFE, 0x10, 0x22, 0x02, 0x40, 0x28, 0x05, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x09, 0x02, 0x3F, 0x80,
  0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F,
  0xD0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0xFE, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x0F, 0xF4, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x00, 0x07, 0xE0, 0xC0, 0xC8, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x0F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x50, 0x02, 0x80,
  0x12, 0x00, 0x88, 0x04, 0x3F, 0xC0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x13, 0xE0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x85, 0x6C, 0x00,
  0x80, 0x60, 0x28, 0x12, 0x04, 0x82, 0x20, 0x88, 0x42, 0x20, 0x88, 0x24,
  0x09, 0x02, 0xA0, 0xC8, 0x32, 0x08, 0x42, 0x10, 0x82, 0x20, 0x88, 0x12,
  0x04, 0x80, 0xA0, 0x28, 0x04, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xA0, 0x03, 0xA0, 0x03,
  0xA0, 0x03, 0xA0, 0x05, 0x90, 0x05, 0x90, 0x05, 0x90, 0x09, 0x88, 0x09,
  0x88, 0x09, 0x88, 0x09, 0x84, 0x11, 0x84, 0x11, 0x84, 0x11, 0x84, 0x21,
  0x82, 0x21, 0x82, 0x21, 0x82, 0x41, 0x81, 0x41, 0x81, 0x41, 0x81, 0x41,
  0x80, 0x81, 0xC0, 0x1C, 0x01, 0xA0, 0x1A, 0x01, 0xA0, 0x19, 0x01, 0x90,
  0x18, 0x81, 0x88, 0x18, 0x41, 0x84, 0x18, 0x21, 0x82, 0x18, 0x21, 0x81,
  0x18, 0x11, 0x80, 0x98, 0x09, 0x80, 0x58, 0x05, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x0F, 0x81, 0x02, 0x08, 0x08, 0x80, 0x44, 0x01, 0x40, 0x0A, 0x00,
  0x50, 0x02, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x02, 0x80, 0x14, 0x00, 0x90, 0x04, 0x80, 0x46, 0x02, 0x10,
  0x20, 0x7E, 0x00, 0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80, 0xA0, 0x18, 0x06,
  0x01, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0xFE, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x0F, 0x81, 0x82, 0x08,
  0x08, 0x80, 0x44, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x02, 0x80, 0x14,
  0x00, 0x90, 0x04, 0x80, 0x42, 0x02, 0x10, 0x20, 0x7E, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0xFC, 0x20, 0xC8, 0x0A, 0x02, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x0A, 0x0C, 0xFC, 0x21, 0x08,
  0x42, 0x08, 0x82, 0x20, 0x48, 0x12, 0x02, 0x80, 0xA0, 0x18, 0x04, 0x1F,
  0xC8, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x2F, 0xF0, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xA0, 0x14, 0x02, 0x40, 0x87, 0xE0, 0x80, 0x18, 0x02, 0x80,
  0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x42, 0x04, 0x20, 0x42, 0x04, 0x20,
  0x81, 0x08, 0x10, 0x81, 0x08, 0x11, 0x01, 0x10, 0x09, 0x00, 0x90, 0x0A,
  0x00, 0xA0, 0x06, 0x00, 0x60, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x90, 0x18, 0x04, 0x80, 0xC0, 0x24, 0x05, 0x01, 0x20, 0x28, 0x11, 0x01,
  0x40, 0x84, 0x12, 0x04, 0x20, 0x90, 0x21, 0x04, 0x41, 0x08, 0x22, 0x10,
  0x21, 0x10, 0x81, 0x10, 0x84, 0x08, 0x84, 0x20, 0x44, 0x12, 0x02, 0x20,
  0x90, 0x09, 0x04, 0x80, 0x50, 0x24, 0x02, 0x81, 0x20, 0x14, 0x06, 0x00,
  0xA0, 0x30, 0x03, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x40, 0x48, 0x12, 0x08,
  0x82, 0x10, 0x84, 0x41, 0x10, 0x24, 0x0A, 0x02, 0x80, 0x40, 0x10, 0x0A,
  0x02, 0x80, 0xA0, 0x44, 0x11, 0x08, 0x42, 0x08, 0x82, 0x40, 0x90, 0x18,
  0x04, 0x80, 0x60, 0x14, 0x09, 0x02, 0x40, 0x88, 0x42, 0x10, 0x84, 0x12,
  0x04, 0x81, 0x20, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0xFF, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x03, 0xFE, 0xFE, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0xFC, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x7F, 0x04, 0x01, 0x40, 0x28, 0x08, 0x81, 0x10, 0x42,
  0x08, 0x22, 0x04, 0x40, 0x50, 0x0A, 0x00, 0x80, 0xFF, 0xF8, 0xC1, 0x08,
  0x20, 0x80, 0x3E, 0x20, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x0F, 0x38,
  0xA0, 0x50, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x85, 0x3C, 0x80, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x7C, 0xA0, 0xB0, 0x2C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x70, 0x2A, 0x0A, 0x7C, 0x0F, 0x30, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x1F, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x7D, 0x20, 0xC8, 0x34, 0x05, 0x01,
  0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x01, 0x40, 0x50,
  0x32, 0x0C, 0x7D, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x40, 0x50, 0x14, 0x07,
  0xFF, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x81, 0x1F,
  0x80, 0x1F, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0xFC, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x1F, 0x48, 0x34, 0x0D, 0x01, 0x40, 0x50, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x05, 0x01, 0x40, 0x50, 0x14, 0x0C, 0x83, 0x1F, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x09, 0x06, 0x3E, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x3C, 0xA1, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xF0, 0x0A, 0xAA, 0xAA, 0xAA, 0xA8, 0x33, 0x00, 0x00, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90,
  0xB0, 0xA8, 0xC8, 0x84, 0x84, 0x84, 0x82, 0x82, 0x81, 0x81, 0xFF, 0xFF,
  0xFF, 0x9E, 0x3D, 0x44, 0x87, 0x06, 0x0E, 0x0C, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x02, 0x9E, 0x50, 0xB0,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x40, 0x50,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x50, 0x14, 0x04,
  0x82, 0x1F, 0x00, 0x9F, 0x28, 0x2C, 0x0B, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x0A, 0x86, 0x9F,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x1F, 0x48, 0x32,
  0x0D, 0x01, 0x40, 0x50, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01,
  0x40, 0x50, 0x14, 0x0C, 0x83, 0x1F, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x9E, 0x8C, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x80, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x80, 0x40, 0x20,
  0x18, 0x04, 0x02, 0x01, 0x01, 0x01, 0x01, 0x82, 0xFC, 0x42, 0x10, 0x8F,
  0xA1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x83, 0x80, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x0E, 0x06, 0x85, 0x3C, 0x80, 0x80, 0xC0, 0x50, 0x28, 0x24,
  0x12, 0x08, 0x84, 0x42, 0x22, 0x11, 0x04, 0x82, 0x41, 0x40, 0xA0, 0x50,
  0x18, 0x08, 0x00, 0x80, 0x81, 0x40, 0x81, 0x41, 0x81, 0x41, 0x42, 0x41,
  0x42, 0x41, 0x42, 0x22, 0x42, 0x22, 0x42, 0x22, 0x24, 0x22, 0x24, 0x12,
  0x24, 0x14, 0x24, 0x14, 0x28, 0x14, 0x18, 0x14, 0x18, 0x08, 0x18, 0x08,
  0x10, 0x81, 0x40, 0x90, 0x88, 0x42, 0x41, 0x20, 0x50, 0x30, 0x18, 0x0C,
  0x09, 0x04, 0x82, 0x22, 0x11, 0x09, 0x02, 0x81, 0x80, 0x40, 0x50, 0x14,
  0x09, 0x02, 0x20, 0x88, 0x22, 0x10, 0x84, 0x11, 0x04, 0x41, 0x20, 0x48,
  0x0A, 0x02, 0x80, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0xC0, 0xE0, 0x00, 0xFC, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x04, 0x08, 0x20, 0x40, 0xFE, 0x06, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x0C, 0x30, 0x10, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80,
  0x81, 0x81, 0x84, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0xC6, 0x00, 0x30, 0x19, 0x86, 0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Thin32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 23, 6, 2, -23 },
  { 7, 5, 8, 9, 2, -23 },
  { 12, 12, 23, 14, 1, -23 },
  { 47, 11, 26, 13, 1, -24 },
  { 83, 16, 23, 18, 1, -23 },
  { 129, 11, 23, 12, 1, -23 },
  { 161, 1, 8, 5, 2, -23 },
  { 162, 5, 28, 8, 2, -23 },
  { 180, 6, 28, 8, 1, -23 },
  { 201, 8, 8, 11, 1, -24 },
  { 209, 11, 15, 13, 1, -19 },
  { 230, 3, 7, 6, 1, -3 },
  { 233, 7, 1, 8, 1, -9 },
  { 234, 2, 2, 6, 2, -2 },
  { 235, 9, 23, 11, 1, -23 },
  { 261, 10, 23, 13, 1, -23 },
  { 290, 6, 23, 13, 2, -23 },
  { 308, 10, 23, 13, 1, -23 },
  { 337, 10, 23, 13, 1, -23 },
  { 366, 12, 23, 13, 0, -23 },
  { 401, 9, 23, 13, 2, -23 },
  { 427, 9, 23, 13, 2, -23 },
  { 453, 10, 23, 13, 1, -23 },
  { 482, 10, 23, 13, 1, -23 },
  { 511, 10, 23, 13, 1, -23 },
  { 540, 2, 17, 6, 2, -17 },
  { 545, 3, 21, 6, 1, -17 },
  { 553, 11, 13, 13, 1, -18 },
  { 571, 11, 8, 13, 1, -15 },
  { 582, 11, 13, 13, 1, -18 },
  { 600, 7, 23, 8, 1, -23 },
  { 621, 16, 26, 19, 2, -23 },
  { 673, 12, 23, 12, 0, -23 },
  { 708, 11, 23, 14, 2, -23 },
  { 740, 11, 23, 13, 2, -23 },
  { 772, 11, 23, 15, 2, -23 },
  { 804, 9, 23, 12, 2, -23 },
  { 830, 9, 23, 11, 2, -23 },
  { 856, 13, 23, 17, 2, -23 },
  { 894, 11, 23, 16, 2, -23 },
  { 926, 5, 23, 7, 1, -23 },
  { 941, 5, 29, 6, -1, -23 },
  { 960, 10, 23, 12, 2, -23 },
  { 989, 8, 23, 11, 2, -23 },
  { 1012, 16, 23, 21, 2, -23 },
  { 1058, 12, 23, 16, 2, -23 },
  { 1093, 13, 23, 16, 2, -23 },
  { 1131, 10, 23, 13, 2, -23 },
  { 1160, 13, 28, 16, 2, -23 },
  { 1206, 10, 23, 13, 2, -23 },
  { 1235, 10, 23, 12, 1, -23 },
  { 1264, 11, 23, 11, 0, -23 },
  { 1296, 11, 23, 16, 2, -23 },
  { 1328, 12, 23, 12, 0, -23 },
  { 1363, 21, 23, 21, 0, -23 },
  { 1424, 10, 23, 11, 0, -23 },
  { 1453, 10, 23, 10, 0, -23 },
  { 1482, 9, 23, 10, 1, -23 },
  { 1508, 6, 28, 10, 3, -23 },
  { 1529, 9, 23, 10, 1, -23 },
  { 1555, 6, 28, 10, 1, -23 },
  { 1576, 11, 11, 13, 1, -23 },
  { 1592, 13, 1, 13, 0, 3 },
  { 1594, 5, 5, 7, 1, -24 },
  { 1598, 9, 17, 12, 1, -17 },
  { 1618, 10, 24, 14, 2, -24 },
  { 1648, 8, 17, 10, 1, -17 },
  { 1665, 10, 24, 14, 1, -24 },
  { 1695, 10, 17, 12, 1, -17 },
  { 1717, 8, 24, 7, 0, -24 },
  { 1741, 10, 25, 14, 1, -17 },
  { 1773, 9, 24, 13, 2, -24 },
  { 1800, 2, 23, 6, 2, -23 },
  { 1806, 4, 31, 6, 0, -23 },
  { 1822, 8, 24, 10, 2, -24 },
  { 1846, 1, 24, 5, 2, -24 },
  { 1849, 15, 17, 19, 2, -17 },
  { 1881, 9, 17, 13, 2, -17 },
  { 1901, 10, 17, 13, 1, -17 },
  { 1923, 10, 24, 14, 2, -17 },
  { 1953, 10, 24, 14, 1, -17 },
  { 1983, 6, 17, 8, 2, -17 },
  { 1996, 8, 17, 10, 1, -17 },
  { 2013, 5, 21, 7, 1, -21 },
  { 2027, 9, 17, 13, 2, -17 },
  { 2047, 9, 17, 9, 0, -17 },
  { 2067, 16, 17, 16, 0, -17 },
  { 2101, 9, 17, 10, 1, -17 },
  { 2121, 10, 25, 10, 0, -17 },
  { 2153, 7, 17, 8, 1, -17 },
  { 2168, 7, 28, 11, 2, -23 },
  { 2193, 1, 32, 12, 6, -24 },
  { 2197, 7, 28, 11, 2, -23 },
  { 2222, 11, 3, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Thin32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN32PT7B_H_
