#ifndef _NOTOSANS_EXTRACONDENSED_THIN20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE4, 0x99, 0x99, 0x90, 0x12, 0x12, 0x12, 0x12, 0x6F, 0x24,
  0x24, 0x24, 0x24, 0xFF, 0x24, 0x24, 0x24, 0x44, 0x21, 0xFA, 0x28, 0xA2,
  0x8A, 0x18, 0x38, 0x92, 0x49, 0x26, 0xB7, 0x08, 0xE2, 0x24, 0x89, 0x22,
  0x50, 0x94, 0x25, 0x49, 0xAA, 0xA9, 0x4C, 0x45, 0x11, 0x44, 0x49, 0x22,
  0x88, 0xE0, 0x70, 0x92, 0x22, 0x85, 0x0A, 0x18, 0x50, 0x93, 0x2A, 0x34,
  0x28, 0xCE, 0x40, 0xF8, 0x29, 0x29, 0x24, 0x92, 0x48, 0x91, 0x20, 0x89,
  0x12, 0x49, 0x24, 0x92, 0x52, 0x80, 0x25, 0x5C, 0xA9, 0x00, 0x20, 0x82,
  0x08, 0xFC, 0x82, 0x08, 0x20, 0x80, 0xF8, 0xF0, 0x80, 0x04, 0x10, 0x82,
  0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x00, 0x7A, 0x28, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x49, 0xE0, 0x76, 0x92, 0x49, 0x24, 0x92,
  0x40, 0xF8, 0x10, 0x41, 0x04, 0x20, 0x82, 0x10, 0x82, 0x10, 0x83, 0xF0,
  0xF8, 0x10, 0x41, 0x04, 0x27, 0x02, 0x04, 0x10, 0x41, 0x07, 0xE0, 0x04,
  0x0C, 0x0C, 0x14, 0x14, 0x24, 0x24, 0x44, 0x44, 0x84, 0x7F, 0x04, 0x04,
  0x04, 0xFA, 0x08, 0x20, 0x83, 0xC0, 0x81, 0x04, 0x10, 0x41, 0x0B, 0xC0,
  0x39, 0x08, 0x20, 0x82, 0xEC, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0xFC,
  0x10, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x41, 0x00, 0x7A, 0x18,
  0x61, 0x85, 0x23, 0x12, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x7A, 0x28, 0x61,
  0x86, 0x18, 0x73, 0x34, 0x10, 0x42, 0x0B, 0xC0, 0xC0, 0x20, 0xC0, 0x7C,
  0x04, 0x66, 0x20, 0x40, 0x81, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x81,
  0x08, 0x46, 0x20, 0xF0, 0x42, 0x10, 0x88, 0x44, 0x22, 0x10, 0x00, 0x20,
  0x1F, 0x08, 0x24, 0x09, 0x11, 0x8A, 0x64, 0x99, 0x26, 0x49, 0x92, 0x64,
  0x99, 0x26, 0x36, 0x80, 0x10, 0x02, 0x00, 0x78, 0x10, 0x18, 0x28, 0x28,
  0x24, 0x24, 0x24, 0x44, 0x7C, 0x42, 0x42, 0x82, 0x82, 0x81, 0xFA, 0x18,
  0x61, 0x86, 0x2F, 0x22, 0x86, 0x18, 0x61, 0x8B, 0xC0, 0x3E, 0x81, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x07, 0xC0, 0xF2, 0x28,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x8B, 0xC0, 0xFC, 0x21, 0x08,
  0x43, 0xD0, 0x84, 0x21, 0x08, 0x7C, 0xFC, 0x21, 0x08, 0x42, 0x1E, 0x84,
  0x21, 0x08, 0x40, 0x3F, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x87, 0x81,
  0x81, 0x81, 0x41, 0x41, 0x3F, 0x86, 0x18, 0x61, 0x86, 0x1F, 0xE1, 0x86,
  0x18, 0x61, 0x86, 0x10, 0xE9, 0x24, 0x92, 0x49, 0x25, 0xC0, 0x24, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x38, 0x8A, 0x29, 0x28, 0xA3, 0x0C, 0x28, 0xA2,
  0x49, 0x22, 0x8A, 0x10, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80,
  0xE0, 0x38, 0x0E, 0x05, 0xC1, 0x70, 0x5A, 0x26, 0x89, 0xA2, 0x65, 0x19,
  0x46, 0x51, 0x94, 0x62, 0x10, 0x83, 0x06, 0x0E, 0x1A, 0x34, 0x68, 0xC9,
  0x93, 0x16, 0x2C, 0x38, 0x70, 0x40, 0x3E, 0x42, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0xF4, 0x63, 0x18, 0xC6,
  0x3E, 0x84, 0x21, 0x08, 0x40, 0x3E, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0x04, 0x04, 0x02, 0xF2, 0x28,
  0xA2, 0x8A, 0x29, 0x38, 0xA2, 0x49, 0x22, 0x8A, 0x10, 0x7E, 0x08, 0x20,
  0x81, 0x02, 0x06, 0x04, 0x10, 0x41, 0x07, 0xE0, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x14, 0x27, 0x80, 0x83, 0x06,
  0x0A, 0x14, 0x48, 0x91, 0x12, 0x28, 0x50, 0xA1, 0x41, 0x02, 0x00, 0x82,
  0x0C, 0x10, 0x61, 0x84, 0x8A, 0x24, 0x51, 0x22, 0x89, 0x14, 0x45, 0x24,
  0x28, 0xA1, 0x45, 0x0A, 0x28, 0x51, 0x81, 0x0C, 0x08, 0x20, 0x45, 0x14,
  0x4A, 0x28, 0x41, 0x04, 0x28, 0xA4, 0x91, 0x46, 0x10, 0x86, 0x14, 0x52,
  0x48, 0xA3, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0xF8, 0x44, 0x21, 0x10,
  0x84, 0x42, 0x21, 0x08, 0x7C, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0,
  0xC1, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0xE4,
  0x92, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x18, 0x18, 0x24, 0x24, 0x42, 0x42,
  0x81, 0xFF, 0x88, 0x80, 0xF0, 0x42, 0x10, 0xBE, 0x31, 0x8C, 0x7E, 0x81,
  0x02, 0x04, 0x0B, 0x98, 0xA1, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x38, 0xAE,
  0x00, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x84, 0x1E, 0x04, 0x10, 0x41, 0x35,
  0x38, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x31, 0x28, 0x61, 0x87,
  0xF8, 0x20, 0x82, 0x07, 0x80, 0x3A, 0x10, 0x8F, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x00, 0x35, 0x38, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC1,
  0x04, 0x10, 0x7E, 0x82, 0x08, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x40, 0x9F, 0xFC, 0x41, 0x55, 0x55, 0x55, 0x58, 0x84, 0x21,
  0x08, 0xC6, 0x54, 0xA7, 0x25, 0x28, 0xC6, 0x20, 0xFF, 0xFE, 0xB3, 0xB3,
  0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x44,
  0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0x31, 0x28, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x17, 0x80, 0xB9, 0x8A, 0x14, 0x18, 0x30, 0x60,
  0xC1, 0x85, 0x8A, 0xE4, 0x08, 0x10, 0x20, 0x40, 0x35, 0x38, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x17, 0xC1, 0x04, 0x10, 0x41, 0xBC, 0x88, 0x88, 0x88,
  0x88, 0x80, 0x7C, 0x21, 0x08, 0x30, 0x41, 0x08, 0x7C, 0x44, 0xF4, 0x44,
  0x44, 0x44, 0x44, 0x70, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17,
  0xC0, 0x86, 0x18, 0x92, 0x49, 0x24, 0x8C, 0x30, 0xC2, 0x00, 0x84, 0x61,
  0x18, 0xC5, 0x31, 0x4A, 0x92, 0xA5, 0x28, 0xCA, 0x32, 0x88, 0x42, 0x10,
  0x85, 0x14, 0x8A, 0x30, 0x43, 0x0A, 0x49, 0x28, 0x40, 0x86, 0x14, 0x51,
  0x49, 0x22, 0x8A, 0x30, 0x41, 0x04, 0x20, 0x82, 0x30, 0xF1, 0x22, 0x24,
  0x48, 0x88, 0xF0, 0x39, 0x08, 0x42, 0x10, 0x84, 0xC1, 0x08, 0x42, 0x10,
  0x84, 0x18, 0xFF, 0xFF, 0xF0, 0xC1, 0x08, 0x42, 0x10, 0x84, 0x19, 0x08,
  0x42, 0x10, 0x84, 0xC0, 0xE6, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_Thin20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 14, 4, 1, -14 },
  { 3, 4, 5, 6, 1, -14 },
  { 6, 8, 14, 8, 0, -14 },
  { 20, 6, 16, 8, 1, -15 },
  { 32, 10, 14, 11, 1, -14 },
  { 50, 7, 14, 8, 1, -14 },
  { 63, 1, 5, 3, 1, -14 },
  { 64, 3, 17, 5, 1, -14 },
  { 71, 3, 17, 5, 1, -14 },
  { 78, 5, 5, 7, 1, -15 },
  { 82, 6, 10, 8, 1, -12 },
  { 90, 1, 5, 4, 1, -2 },
  { 91, 4, 1, 5, 1, -6 },
  { 92, 1, 1, 4, 1, -1 },
  { 93, 6, 14, 7, 0, -14 },
  { 104, 6, 14, 8, 1, -14 },
  { 115, 3, 14, 8, 2, -14 },
  { 121, 6, 14, 8, 1, -14 },
  { 132, 6, 14, 8, 1, -14 },
  { 143, 8, 14, 8, 0, -14 },
  { 157, 6, 14, 8, 1, -14 },
  { 168, 6, 14, 8, 1, -14 },
  { 179, 6, 14, 8, 1, -14 },
  { 190, 6, 14, 8, 1, -14 },
  { 201, 6, 14, 8, 1, -14 },
  { 212, 1, 11, 4, 1, -11 },
  { 214, 1, 14, 4, 1, -11 },
  { 216, 6, 8, 8, 1, -11 },
  { 222, 6, 4, 8, 1, -9 },
  { 225, 6, 8, 8, 1, -11 },
  { 231, 5, 14, 5, 0, -14 },
  { 240, 10, 16, 12, 1, -14 },
  { 260, 8, 14, 8, 0, -14 },
  { 274, 6, 14, 9, 2, -14 },
  { 285, 7, 14, 8, 1, -14 },
  { 298, 6, 14, 9, 2, -14 },
  { 309, 5, 14, 8, 2, -14 },
  { 318, 5, 14, 7, 2, -14 },
  { 327, 8, 14, 10, 1, -14 },
  { 341, 6, 14, 10, 2, -14 },
  { 352, 3, 14, 4, 1, -14 },
  { 358, 3, 18, 4, -1, -14 },
  { 365, 6, 14, 8, 2, -14 },
  { 376, 4, 14, 7, 2, -14 },
  { 383, 10, 14, 13, 2, -14 },
  { 401, 7, 14, 10, 2, -14 },
  { 414, 8, 14, 10, 1, -14 },
  { 428, 5, 14, 8, 2, -14 },
  { 437, 8, 17, 10, 1, -14 },
  { 454, 6, 14, 8, 2, -14 },
  { 465, 6, 14, 8, 1, -14 },
  { 476, 7, 14, 7, 0, -14 },
  { 489, 7, 14, 10, 1, -14 },
  { 502, 7, 14, 7, 0, -14 },
  { 515, 13, 14, 13, 0, -14 },
  { 538, 6, 14, 7, 0, -14 },
  { 549, 6, 14, 6, 0, -14 },
  { 560, 5, 14, 6, 1, -14 },
  { 569, 3, 17, 6, 2, -14 },
  { 576, 6, 14, 7, 0, -14 },
  { 587, 3, 17, 6, 1, -14 },
  { 594, 8, 7, 8, 0, -14 },
  { 601, 8, 1, 8, 0, 2 },
  { 602, 3, 3, 5, 1, -15 },
  { 604, 5, 11, 7, 1, -11 },
  { 611, 7, 15, 8, 1, -15 },
  { 625, 5, 11, 6, 1, -11 },
  { 632, 6, 15, 8, 1, -15 },
  { 644, 6, 11, 8, 1, -11 },
  { 653, 5, 15, 4, 0, -15 },
  { 663, 6, 16, 8, 1, -11 },
  { 675, 6, 15, 8, 1, -15 },
  { 687, 1, 14, 4, 1, -14 },
  { 689, 2, 19, 4, 0, -14 },
  { 694, 5, 15, 6, 1, -15 },
  { 704, 1, 15, 3, 1, -15 },
  { 706, 10, 11, 12, 1, -11 },
  { 720, 6, 11, 8, 1, -11 },
  { 729, 6, 11, 8, 1, -11 },
  { 738, 7, 16, 8, 1, -11 },
  { 752, 6, 16, 8, 1, -11 },
  { 764, 4, 11, 5, 1, -11 },
  { 770, 5, 11, 6, 1, -11 },
  { 777, 4, 13, 4, 0, -13 },
  { 784, 6, 11, 8, 1, -11 },
  { 793, 6, 11, 6, 0, -11 },
  { 802, 10, 11, 10, 0, -11 },
  { 816, 6, 11, 6, 0, -11 },
  { 825, 6, 16, 6, 0, -11 },
  { 837, 4, 11, 5, 1, -11 },
  { 843, 5, 17, 7, 1, -14 },
  { 854, 1, 20, 8, 3, -15 },
  { 857, 5, 17, 7, 1, -14 },
  { 868, 6, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Thin20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN20PT7B_H_
