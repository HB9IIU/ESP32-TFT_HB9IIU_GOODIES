#ifndef _NOTOSANS_EXTRACONDENSED_THIN50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xAA, 0x00, 0x3F, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x01,
  0x01, 0x00, 0x20, 0x20, 0x04, 0x0C, 0x00, 0x81, 0x80, 0x10, 0x20, 0x06,
  0x04, 0x00, 0xC0, 0x80, 0x10, 0x10, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08,
  0x08, 0x3F, 0xFF, 0xF0, 0x20, 0x60, 0x04, 0x0C, 0x01, 0x81, 0x00, 0x30,
  0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10, 0x10, 0x02, 0x02, 0x00, 0x40,
  0x40, 0x08, 0x18, 0x01, 0x03, 0x07, 0xFF, 0xFE, 0x0C, 0x08, 0x01, 0x01,
  0x00, 0x20, 0x20, 0x04, 0x04, 0x00, 0x80, 0x80, 0x10, 0x10, 0x02, 0x06,
  0x00, 0x40, 0xC0, 0x18, 0x10, 0x03, 0x02, 0x00, 0x40, 0x40, 0x08, 0x08,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x0F, 0xF8, 0x39, 0x1E, 0x61,
  0x04, 0x41, 0x00, 0xC1, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81,
  0x00, 0x81, 0x00, 0x81, 0x00, 0xC1, 0x00, 0x41, 0x00, 0x61, 0x00, 0x39,
  0x00, 0x0D, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x01, 0x70, 0x01, 0x18, 0x01,
  0x0C, 0x01, 0x06, 0x01, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0x01, 0x02, 0x01, 0x06, 0x81, 0x0C, 0xF9,
  0x78, 0x0F, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x1E,
  0x00, 0x60, 0x31, 0x00, 0x40, 0x61, 0x80, 0x40, 0x40, 0x80, 0xC0, 0x40,
  0x80, 0x80, 0x40, 0xC0, 0x80, 0x40, 0xC1, 0x80, 0xC0, 0x41, 0x00, 0xC0,
  0x41, 0x00, 0xC0, 0x43, 0x00, 0xC0, 0x42, 0x00, 0xC0, 0x42, 0x00, 0xC0,
  0x46, 0x00, 0xC0, 0x44, 0x00, 0xC0, 0x44, 0x38, 0x40, 0xC4, 0x44, 0x40,
  0xC8, 0x82, 0x40, 0x88, 0x82, 0x40, 0x89, 0x83, 0x21, 0x99, 0x01, 0x33,
  0x11, 0x01, 0x1E, 0x11, 0x01, 0x00, 0x31, 0x01, 0x00, 0x21, 0x01, 0x00,
  0x21, 0x01, 0x00, 0x61, 0x01, 0x00, 0x41, 0x01, 0x00, 0x41, 0x01, 0x00,
  0xC1, 0x01, 0x00, 0x81, 0x01, 0x00, 0x81, 0x01, 0x01, 0x81, 0x01, 0x01,
  0x01, 0x83, 0x01, 0x00, 0x82, 0x03, 0x00, 0xC6, 0x02, 0x00, 0x7C, 0x07,
  0x80, 0x04, 0x60, 0x04, 0x18, 0x02, 0x04, 0x03, 0x02, 0x01, 0x81, 0x00,
  0xC0, 0x80, 0x60, 0x40, 0x30, 0x20, 0x08, 0x10, 0x04, 0x08, 0x02, 0x0C,
  0x01, 0x84, 0x00, 0x42, 0x00, 0x32, 0x00, 0x0A, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x06, 0xC0, 0x06, 0x20, 0x06, 0x18, 0x02, 0x04, 0x0B, 0x03, 0x05,
  0x00, 0x82, 0x80, 0x21, 0x40, 0x10, 0xA0, 0x04, 0xD0, 0x03, 0x48, 0x00,
  0xA4, 0x00, 0x62, 0x00, 0x11, 0x00, 0x14, 0x40, 0x1A, 0x30, 0x18, 0x8C,
  0x18, 0x43, 0xF8, 0x10, 0x20, 0x00, 0xFF, 0xFF, 0xFD, 0x40, 0x01, 0x02,
  0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x04, 0x02, 0x03, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0xC0,
  0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x18, 0x00, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x0C, 0x21, 0x99, 0x30, 0x3E, 0x00, 0x60, 0x05, 0x00, 0x44,
  0x04, 0x10, 0x40, 0x42, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x1F, 0xFF, 0xF0, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x33, 0x32, 0x26, 0x64, 0x4C,
  0x80, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x00, 0x07, 0xE0, 0x18, 0x60, 0x60, 0x60, 0x80, 0x43, 0x00, 0xC4, 0x00,
  0x88, 0x01, 0x30, 0x02, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x1A, 0x00, 0x36, 0x00, 0x64, 0x00, 0x88, 0x01, 0x18,
  0x06, 0x10, 0x08, 0x30, 0x30, 0x30, 0xC0, 0x3F, 0x00, 0x01, 0x07, 0x0D,
  0x19, 0x31, 0x61, 0xC1, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x1F, 0xC0, 0xE0,
  0xE1, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0xE0, 0xE3, 0x00, 0x64, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x1F, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x33, 0x00, 0xC3, 0xFF,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x2C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0x30, 0x00, 0xCC, 0x00,
  0x23, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x0C, 0x00, 0x83, 0x00, 0x60,
  0xC0, 0x10, 0x30, 0x0C, 0x0C, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x30,
  0x30, 0x0C, 0x08, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x30, 0xC0, 0x0C, 0x20,
  0x03, 0x0F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x3F, 0xFC, 0x3F, 0xFC, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x7F, 0xE0, 0x60, 0x38, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x30, 0x7F, 0xC0,
  0x00, 0xF8, 0x03, 0x8C, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x43, 0xC0, 0x4F, 0x70, 0x58, 0x08, 0xD0, 0x04,
  0xE0, 0x04, 0xE0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0x40, 0x02, 0x40, 0x03, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x60, 0x02, 0x20, 0x06, 0x30, 0x04, 0x10, 0x0C, 0x18, 0x18, 0x0F, 0xF0,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x07, 0xE0,
  0x1C, 0x38, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x40, 0x06, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x0C,
  0x10, 0x08, 0x08, 0x30, 0x06, 0x60, 0x03, 0xC0, 0x03, 0x80, 0x06, 0x60,
  0x18, 0x30, 0x30, 0x18, 0x20, 0x0C, 0x40, 0x06, 0xC0, 0x02, 0xC0, 0x02,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x02,
  0xC0, 0x02, 0x60, 0x06, 0x20, 0x0C, 0x38, 0x18, 0x0F, 0xF0, 0x01, 0x00,
  0x0F, 0xC0, 0x30, 0x60, 0xC0, 0x41, 0x00, 0x44, 0x00, 0xC8, 0x00, 0xB0,
  0x01, 0x60, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x40, 0x06, 0x80, 0x0D, 0x80, 0x29,
  0x00, 0xD1, 0x83, 0x21, 0xFC, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0xFC, 0x00, 0xC0, 0x00, 0x5F, 0xA0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x23, 0x73, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x32, 0x26, 0x64,
  0x4C, 0x80, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x08, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x18,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x10, 0x60, 0x00,
  0x0C, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x03, 0x80, 0xC8, 0x07,
  0xF0, 0x24, 0x06, 0x18, 0x16, 0x06, 0x0C, 0x0B, 0x02, 0x06, 0x05, 0x01,
  0x03, 0x02, 0x81, 0x81, 0x81, 0xC0, 0x80, 0x80, 0xE0, 0x40, 0x40, 0x70,
  0x20, 0x20, 0x38, 0x10, 0x10, 0x1C, 0x08, 0x08, 0x0E, 0x04, 0x04, 0x05,
  0x02, 0x02, 0x02, 0x81, 0x03, 0x01, 0x40, 0x81, 0x80, 0xA0, 0x60, 0xC0,
  0xD0, 0x10, 0xD0, 0x4C, 0x0C, 0x4C, 0x66, 0x03, 0xC3, 0xE1, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x02, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1A, 0x00, 0x02, 0x60, 0x00,
  0x44, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x63, 0x00, 0x08, 0x20, 0x01,
  0x04, 0x00, 0x20, 0x80, 0x0C, 0x18, 0x01, 0x03, 0x00, 0x20, 0x20, 0x04,
  0x04, 0x01, 0x80, 0x80, 0x30, 0x18, 0x04, 0x01, 0x00, 0x80, 0x20, 0x3F,
  0xFC, 0x06, 0x00, 0xC0, 0x80, 0x08, 0x10, 0x01, 0x06, 0x00, 0x20, 0xC0,
  0x06, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x18, 0x00, 0x32, 0x00,
  0x06, 0x40, 0x00, 0x48, 0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x30, 0xFF,
  0x80, 0xFF, 0xF0, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0x80, 0xE0, 0xFF, 0xE0, 0x80,
  0x38, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x06, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x70, 0xFF, 0xC0, 0x01,
  0xFE, 0x01, 0x81, 0xC3, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x60, 0x3F, 0xE0, 0x01, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x20, 0x0C,
  0x10, 0x03, 0x08, 0x00, 0xC4, 0x00, 0x32, 0x00, 0x09, 0x00, 0x04, 0x80,
  0x03, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x40,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x68, 0x00, 0x24, 0x00, 0x12, 0x00, 0x19,
  0x00, 0x18, 0x80, 0x08, 0x40, 0x1C, 0x20, 0x38, 0x1F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x07, 0xFF, 0xA0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x3F, 0xFD, 0xFF, 0xE8, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x38, 0x0E, 0x06, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x60, 0x00, 0x12, 0x00, 0x01,
  0x30, 0x00, 0x11, 0x00, 0x01, 0x08, 0x00, 0x10, 0xC0, 0x01, 0x03, 0x00,
  0x70, 0x1F, 0xFC, 0x00, 0x08, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x47, 0xF0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0xFC, 0x78, 0x80,
  0x05, 0x00, 0x1A, 0x00, 0x24, 0x00, 0xC8, 0x03, 0x10, 0x04, 0x20, 0x18,
  0x40, 0x20, 0x80, 0xC1, 0x03, 0x02, 0x04, 0x04, 0x18, 0x08, 0x20, 0x10,
  0xC0, 0x23, 0x00, 0x44, 0x00, 0x98, 0x01, 0x38, 0x02, 0x90, 0x07, 0x30,
  0x0C, 0x20, 0x10, 0x60, 0x20, 0x40, 0x40, 0xC0, 0x80, 0x81, 0x01, 0x82,
  0x01, 0x04, 0x03, 0x08, 0x02, 0x10, 0x06, 0x20, 0x04, 0x40, 0x0C, 0x80,
  0x09, 0x00, 0x1A, 0x00, 0x14, 0x00, 0x30, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7A, 0x00, 0x00, 0x7D, 0x00, 0x00, 0x3E, 0xC0, 0x00, 0x17, 0x20,
  0x00, 0x0B, 0x90, 0x00, 0x0D, 0xCC, 0x00, 0x04, 0xE2, 0x00, 0x02, 0x71,
  0x00, 0x03, 0x38, 0xC0, 0x01, 0x1C, 0x60, 0x00, 0x8E, 0x10, 0x00, 0xC7,
  0x08, 0x00, 0x43, 0x86, 0x00, 0x21, 0xC1, 0x00, 0x30, 0xE0, 0x80, 0x18,
  0x70, 0x60, 0x08, 0x38, 0x10, 0x04, 0x1C, 0x08, 0x06, 0x0E, 0x06, 0x02,
  0x07, 0x01, 0x01, 0x03, 0x80, 0x81, 0x81, 0xC0, 0x40, 0x80, 0xE0, 0x30,
  0x40, 0x70, 0x08, 0x60, 0x38, 0x04, 0x30, 0x1C, 0x03, 0x10, 0x0E, 0x00,
  0x88, 0x07, 0x00, 0x4C, 0x03, 0x80, 0x34, 0x01, 0xC0, 0x0A, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x34, 0x00, 0x1A, 0x00, 0x0D, 0x80, 0x06, 0x40, 0x03, 0x30, 0x01, 0x88,
  0x00, 0xC6, 0x00, 0x61, 0x00, 0x30, 0x80, 0x18, 0x20, 0x0C, 0x10, 0x06,
  0x0C, 0x03, 0x02, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x08,
  0x18, 0x04, 0x0C, 0x03, 0x06, 0x00, 0x83, 0x00, 0x61, 0x80, 0x10, 0xC0,
  0x0C, 0x60, 0x02, 0x30, 0x01, 0x18, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x1B,
  0x00, 0x05, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x10, 0x03,
  0xF8, 0x00, 0x60, 0xE0, 0x08, 0x03, 0x01, 0x00, 0x18, 0x30, 0x00, 0x82,
  0x00, 0x0C, 0x60, 0x00, 0x44, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x02,
  0xC0, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x66,
  0x00, 0x04, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x10, 0x01, 0x81, 0x80, 0x30,
  0x0E, 0x06, 0x00, 0x3F, 0xC0, 0x00, 0x40, 0x00, 0xFE, 0x03, 0xFF, 0x08,
  0x07, 0x20, 0x06, 0x80, 0x0A, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x02,
  0x80, 0x1A, 0x00, 0x48, 0x07, 0x3F, 0xF0, 0xFE, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03,
  0xF8, 0x00, 0x60, 0xE0, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x30, 0x00, 0x82,
  0x00, 0x0C, 0x60, 0x00, 0x44, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x02,
  0xC0, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x66,
  0x00, 0x04, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x10, 0x01, 0x81, 0x80, 0x30,
  0x0E, 0x06, 0x00, 0x3F, 0xC0, 0x00, 0x58, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0xFE, 0x01, 0xFF, 0x82, 0x01, 0xC4, 0x00, 0xC8,
  0x00, 0x90, 0x01, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x28, 0x00, 0x50, 0x01, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x11,
  0x00, 0x62, 0x07, 0x07, 0xF8, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x40,
  0x40, 0x80, 0xC1, 0x00, 0x82, 0x01, 0x84, 0x01, 0x08, 0x03, 0x10, 0x02,
  0x20, 0x06, 0x40, 0x04, 0x80, 0x0D, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x30,
  0x07, 0xF8, 0x38, 0x1C, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x13, 0x00, 0xE3, 0xFF, 0x00, 0x20, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x14,
  0x00, 0x0B, 0x00, 0x04, 0x80, 0x06, 0x60, 0x02, 0x10, 0x03, 0x0E, 0x03,
  0x01, 0xFE, 0x00, 0x18, 0x00, 0x80, 0x00, 0x70, 0x00, 0x14, 0x00, 0x0D,
  0x00, 0x03, 0x40, 0x00, 0x90, 0x00, 0x26, 0x00, 0x08, 0x80, 0x06, 0x20,
  0x01, 0x08, 0x00, 0x43, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x04, 0x00,
  0x81, 0x80, 0x20, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x30, 0x10, 0x04, 0x0C, 0x01, 0x02, 0x00, 0x40, 0x80, 0x18, 0x20, 0x02,
  0x18, 0x00, 0x84, 0x00, 0x21, 0x00, 0x0C, 0x40, 0x01, 0x30, 0x00, 0x48,
  0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x40, 0x01, 0x80, 0x03, 0x40, 0x01,
  0x80, 0x03, 0x40, 0x01, 0x80, 0x02, 0x60, 0x01, 0xC0, 0x02, 0x60, 0x03,
  0xC0, 0x02, 0x20, 0x03, 0x40, 0x06, 0x20, 0x02, 0x40, 0x06, 0x20, 0x02,
  0x40, 0x04, 0x30, 0x02, 0x60, 0x04, 0x30, 0x06, 0x60, 0x0C, 0x10, 0x06,
  0x20, 0x0C, 0x10, 0x04, 0x20, 0x08, 0x10, 0x04, 0x20, 0x08, 0x18, 0x04,
  0x30, 0x08, 0x18, 0x0C, 0x30, 0x18, 0x08, 0x0C, 0x10, 0x18, 0x08, 0x08,
  0x10, 0x10, 0x0C, 0x08, 0x10, 0x10, 0x0C, 0x08, 0x18, 0x10, 0x04, 0x18,
  0x18, 0x30, 0x04, 0x18, 0x08, 0x20, 0x04, 0x10, 0x08, 0x20, 0x06, 0x10,
  0x08, 0x20, 0x06, 0x10, 0x0C, 0x60, 0x02, 0x30, 0x0C, 0x60, 0x02, 0x30,
  0x04, 0x40, 0x02, 0x20, 0x04, 0x40, 0x03, 0x20, 0x04, 0x40, 0x03, 0x20,
  0x04, 0xC0, 0x01, 0x60, 0x06, 0x80, 0x01, 0x60, 0x02, 0x80, 0x01, 0x40,
  0x02, 0x80, 0x01, 0xC0, 0x02, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x20, 0x01, 0x30, 0x03, 0x10, 0x02, 0x10, 0x06, 0x18, 0x04,
  0x08, 0x04, 0x08, 0x0C, 0x0C, 0x08, 0x04, 0x08, 0x04, 0x18, 0x06, 0x10,
  0x02, 0x30, 0x03, 0x20, 0x01, 0x20, 0x01, 0x60, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x60, 0x03, 0x20, 0x02, 0x20,
  0x06, 0x30, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x18, 0x08, 0x08, 0x18, 0x08,
  0x10, 0x0C, 0x10, 0x04, 0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x60, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x04,
  0x20, 0x04, 0x20, 0x0C, 0x30, 0x08, 0x10, 0x08, 0x10, 0x18, 0x18, 0x10,
  0x08, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x60, 0x06, 0x40,
  0x02, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF,
  0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x01, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x3F, 0xF0, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x04, 0x80, 0x01, 0x30, 0x00, 0x84, 0x00, 0x61, 0x80, 0x10, 0x20, 0x0C,
  0x0C, 0x02, 0x01, 0x01, 0x80, 0x60, 0x40, 0x08, 0x30, 0x03, 0x08, 0x00,
  0xC6, 0x00, 0x19, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xF0, 0xC0,
  0xC0, 0x80, 0x81, 0x81, 0x81, 0x81, 0x07, 0x81, 0xEF, 0x08, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x1F, 0x87, 0x04, 0xC0, 0x2C, 0x01, 0x40, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x05, 0x40, 0x2B, 0x02,
  0x4F, 0xE2, 0x08, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x3E, 0x09, 0xEE, 0x16, 0x02, 0x28, 0x02, 0x60, 0x06, 0xC0, 0x05,
  0x80, 0x0A, 0x00, 0x14, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x40, 0x02, 0xC0, 0x05, 0x80, 0x1B, 0x80, 0x25, 0x00, 0xC9,
  0x83, 0x11, 0xFC, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x3D, 0xC3, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x60,
  0x41, 0xFE, 0x01, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x03, 0xC3, 0x0E, 0x73, 0x18, 0x1B, 0x30, 0x0F, 0x20, 0x07,
  0x60, 0x07, 0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x05,
  0x20, 0x05, 0x30, 0x09, 0x18, 0x11, 0x0F, 0xE1, 0x01, 0x00, 0x03, 0xC0,
  0x1D, 0xE0, 0x60, 0x41, 0x80, 0x42, 0x00, 0x8C, 0x00, 0x98, 0x01, 0x20,
  0x02, 0x40, 0x04, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x04, 0x18, 0x18, 0x1F,
  0xE0, 0x04, 0x00, 0x03, 0xF0, 0x61, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0xFF, 0x80, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x03, 0xC0, 0x0F, 0x71, 0x18, 0x19, 0x30, 0x0F, 0x20, 0x07, 0x60, 0x07,
  0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x07, 0x60, 0x07, 0x20, 0x0F,
  0x30, 0x0B, 0x18, 0x13, 0x0F, 0xE3, 0x01, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x40, 0x18, 0x70, 0x70, 0x1F, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x0F, 0x09, 0xEE, 0x58, 0x1A, 0x80, 0x58, 0x02, 0xC0, 0x1E, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0xFF, 0x80, 0x00, 0x01,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20, 0x1C, 0x71,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x18, 0x6B, 0x38, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x68, 0x04, 0x80, 0x88, 0x18, 0x81, 0x08,
  0x30, 0x82, 0x08, 0x40, 0x8C, 0x08, 0x80, 0x9C, 0x09, 0x40, 0xA4, 0x0E,
  0x60, 0xC2, 0x08, 0x30, 0x81, 0x08, 0x10, 0x81, 0x88, 0x08, 0x80, 0xC8,
  0x04, 0x80, 0x48, 0x02, 0x80, 0x28, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x00, 0xE1, 0x3B, 0x86, 0x72, 0x81, 0x90, 0x35, 0x01, 0x60, 0x2C,
  0x02, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x07, 0x84, 0xE7, 0x2C, 0x0D, 0x40,
  0x2C, 0x01, 0xE0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x03, 0xC0, 0x0E, 0x70, 0x18, 0x18, 0x30, 0x0C, 0x20, 0x04,
  0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x03, 0x40, 0x02, 0x40, 0x02, 0x60, 0x02, 0x20, 0x06,
  0x20, 0x04, 0x10, 0x0C, 0x18, 0x18, 0x0F, 0xF0, 0x00, 0x80, 0x07, 0xC1,
  0x3D, 0xC2, 0xC0, 0x45, 0x00, 0xCE, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0x40,
  0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x28,
  0x00, 0x58, 0x00, 0xB0, 0x03, 0x50, 0x04, 0xB0, 0x19, 0x30, 0x62, 0x3F,
  0x84, 0x08, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xC0, 0x0F, 0x71, 0x18, 0x19, 0x30, 0x0F, 0x20, 0x07, 0x20, 0x07,
  0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x07, 0x60, 0x07, 0x30, 0x0F,
  0x30, 0x0B, 0x18, 0x13, 0x0F, 0xE3, 0x01, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xCF, 0xA4, 0x14, 0x0A, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x00, 0x07, 0xC3, 0xDF, 0x60, 0x14, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x6C, 0x0C, 0x7F, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xC1, 0xFF, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x0F, 0x81, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40, 0x0D, 0x00,
  0x54, 0x01, 0x58, 0x09, 0x30, 0x64, 0x7F, 0x10, 0x20, 0x00, 0xC0, 0x05,
  0x00, 0x14, 0x00, 0xD0, 0x02, 0x60, 0x08, 0x80, 0x22, 0x01, 0x88, 0x06,
  0x30, 0x10, 0x40, 0x41, 0x03, 0x04, 0x0C, 0x18, 0x20, 0x20, 0x80, 0x82,
  0x02, 0x18, 0x0C, 0x40, 0x31, 0x00, 0x44, 0x01, 0x30, 0x04, 0x80, 0x1A,
  0x00, 0x28, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xA0,
  0x06, 0x00, 0xD0, 0x03, 0x00, 0x4C, 0x03, 0xC0, 0x22, 0x01, 0x60, 0x11,
  0x00, 0x90, 0x08, 0x80, 0x48, 0x0C, 0x60, 0x24, 0x04, 0x30, 0x33, 0x02,
  0x08, 0x10, 0x81, 0x04, 0x08, 0x41, 0x82, 0x04, 0x20, 0xC1, 0x86, 0x10,
  0x40, 0x43, 0x0C, 0x20, 0x21, 0x02, 0x10, 0x10, 0x81, 0x18, 0x0C, 0x40,
  0x88, 0x06, 0x60, 0x64, 0x01, 0x20, 0x32, 0x00, 0x90, 0x0B, 0x00, 0x48,
  0x05, 0x80, 0x34, 0x02, 0x80, 0x0E, 0x01, 0x40, 0x06, 0x00, 0xE0, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x10, 0x00, 0xC0, 0x0D, 0x80, 0x62, 0x01, 0x0C,
  0x0C, 0x10, 0x20, 0x40, 0x81, 0x86, 0x02, 0x10, 0x0C, 0xC0, 0x12, 0x00,
  0x78, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x01, 0x20, 0x0C, 0xC0,
  0x21, 0x01, 0x84, 0x04, 0x08, 0x30, 0x20, 0x80, 0xC6, 0x01, 0x10, 0x06,
  0x40, 0x0B, 0x00, 0x30, 0x60, 0x02, 0x40, 0x04, 0x80, 0x19, 0x00, 0x23,
  0x00, 0x42, 0x00, 0x84, 0x03, 0x08, 0x04, 0x18, 0x08, 0x10, 0x10, 0x20,
  0x60, 0x40, 0x80, 0xC1, 0x00, 0x82, 0x01, 0x0C, 0x02, 0x10, 0x06, 0x20,
  0x04, 0x40, 0x09, 0x80, 0x12, 0x00, 0x34, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x09,
  0x80, 0x1E, 0x00, 0x00, 0x7F, 0xE0, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x1F, 0xFC, 0x00, 0x70, 0x1F, 0x03, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x0F,
  0x00, 0xF0, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x07, 0xE0, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x7C, 0x01, 0xE0, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x70, 0x38, 0x70,
  0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 36, 10, 4, -36 },
  { 10, 8, 13, 15, 3, -36 },
  { 23, 19, 36, 21, 1, -36 },
  { 109, 16, 41, 20, 2, -38 },
  { 191, 24, 36, 29, 2, -36 },
  { 299, 17, 37, 19, 2, -36 },
  { 378, 2, 13, 8, 3, -36 },
  { 382, 8, 44, 13, 3, -36 },
  { 426, 9, 44, 13, 2, -36 },
  { 476, 13, 13, 17, 2, -38 },
  { 498, 17, 23, 20, 1, -29 },
  { 547, 4, 11, 9, 2, -5 },
  { 553, 11, 1, 13, 1, -14 },
  { 555, 3, 3, 9, 3, -3 },
  { 557, 15, 36, 16, 1, -36 },
  { 625, 15, 36, 20, 2, -36 },
  { 693, 8, 36, 20, 4, -36 },
  { 729, 15, 36, 20, 2, -36 },
  { 797, 15, 37, 20, 2, -36 },
  { 867, 18, 36, 20, 1, -36 },
  { 948, 16, 36, 20, 2, -36 },
  { 1020, 16, 37, 20, 2, -36 },
  { 1094, 15, 36, 20, 2, -36 },
  { 1162, 16, 37, 20, 2, -36 },
  { 1236, 15, 37, 20, 2, -36 },
  { 1306, 3, 27, 9, 3, -27 },
  { 1317, 4, 33, 9, 2, -27 },
  { 1334, 17, 21, 20, 1, -28 },
  { 1379, 17, 12, 20, 1, -24 },
  { 1405, 17, 21, 20, 1, -28 },
  { 1450, 11, 36, 13, 1, -36 },
  { 1500, 25, 41, 30, 3, -36 },
  { 1629, 19, 36, 19, 0, -36 },
  { 1715, 16, 36, 22, 4, -36 },
  { 1787, 17, 37, 21, 3, -36 },
  { 1866, 17, 36, 24, 4, -36 },
  { 1943, 13, 36, 19, 4, -36 },
  { 2002, 13, 36, 18, 4, -36 },
  { 2061, 20, 37, 26, 3, -36 },
  { 2154, 16, 36, 24, 4, -36 },
  { 2226, 7, 36, 11, 2, -36 },
  { 2258, 8, 45, 9, -2, -36 },
  { 2303, 15, 36, 19, 4, -36 },
  { 2371, 12, 36, 17, 4, -36 },
  { 2425, 25, 36, 33, 4, -36 },
  { 2538, 17, 36, 25, 4, -36 },
  { 2615, 20, 37, 26, 3, -36 },
  { 2708, 14, 36, 20, 4, -36 },
  { 2771, 20, 45, 26, 3, -36 },
  { 2884, 15, 36, 20, 4, -36 },
  { 2952, 15, 37, 19, 2, -36 },
  { 3022, 16, 36, 17, 0, -36 },
  { 3094, 17, 37, 24, 4, -36 },
  { 3173, 18, 36, 18, 0, -36 },
  { 3254, 32, 36, 32, 0, -36 },
  { 3398, 16, 36, 17, 0, -36 },
  { 3470, 16, 36, 16, 0, -36 },
  { 3542, 14, 36, 16, 1, -36 },
  { 3605, 10, 44, 15, 4, -36 },
  { 3660, 14, 36, 16, 1, -36 },
  { 3723, 9, 44, 15, 2, -36 },
  { 3773, 18, 17, 20, 1, -36 },
  { 3812, 20, 1, 20, 0, 5 },
  { 3815, 7, 8, 11, 2, -38 },
  { 3822, 13, 28, 18, 2, -27 },
  { 3868, 15, 39, 21, 4, -38 },
  { 3942, 13, 28, 16, 2, -27 },
  { 3988, 16, 39, 21, 2, -38 },
  { 4066, 15, 28, 19, 2, -27 },
  { 4119, 12, 38, 11, 0, -38 },
  { 4176, 16, 39, 21, 2, -27 },
  { 4254, 13, 38, 20, 4, -38 },
  { 4316, 3, 36, 9, 3, -36 },
  { 4330, 6, 48, 9, 0, -36 },
  { 4366, 12, 38, 16, 4, -38 },
  { 4423, 1, 38, 8, 4, -38 },
  { 4428, 23, 27, 30, 4, -27 },
  { 4506, 13, 27, 20, 4, -27 },
  { 4550, 16, 28, 20, 2, -27 },
  { 4606, 15, 39, 21, 4, -27 },
  { 4680, 16, 39, 21, 2, -27 },
  { 4758, 9, 27, 13, 4, -27 },
  { 4789, 12, 28, 16, 2, -27 },
  { 4831, 9, 34, 10, 1, -33 },
  { 4870, 14, 27, 20, 3, -26 },
  { 4918, 14, 26, 15, 0, -26 },
  { 4964, 25, 26, 26, 0, -26 },
  { 5046, 14, 26, 16, 1, -26 },
  { 5092, 15, 38, 16, 0, -26 },
  { 5164, 11, 26, 13, 1, -26 },
  { 5200, 12, 44, 17, 3, -36 },
  { 5266, 1, 50, 19, 9, -38 },
  { 5273, 13, 44, 17, 2, -36 },
  { 5345, 17, 4, 20, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Thin50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN50PT7B_H_
