#ifndef _NOTOSANS_EXTRACONDENSED_THIN38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin38pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x3C, 0xC7, 0x8D, 0x0A, 0x14,
  0x28, 0x50, 0xA1, 0x42, 0x84, 0x04, 0x10, 0x10, 0x40, 0x41, 0x01, 0x04,
  0x04, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x7F, 0xFC, 0x20, 0x80, 0x82,
  0x02, 0x08, 0x08, 0x20, 0x21, 0x01, 0x04, 0x04, 0x10, 0x10, 0x43, 0xFF,
  0xE1, 0x04, 0x04, 0x10, 0x10, 0x40, 0x41, 0x01, 0x08, 0x08, 0x20, 0x20,
  0x80, 0x82, 0x02, 0x08, 0x00, 0x02, 0x00, 0x10, 0x03, 0xE0, 0x64, 0xE6,
  0x20, 0x21, 0x03, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x80, 0x84,
  0x06, 0x20, 0x19, 0x00, 0x38, 0x00, 0x60, 0x02, 0xC0, 0x13, 0x00, 0x8C,
  0x04, 0x20, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x10, 0x10, 0xB0,
  0x98, 0x7F, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x10, 0x00, 0x1A, 0x01,
  0x04, 0x40, 0x82, 0x10, 0x20, 0x82, 0x08, 0x20, 0x84, 0x08, 0x21, 0x02,
  0x08, 0x40, 0x82, 0x20, 0x20, 0x88, 0x08, 0x22, 0x02, 0x09, 0x18, 0x82,
  0x49, 0xA0, 0x92, 0x28, 0x49, 0x09, 0x12, 0x41, 0x68, 0x90, 0x44, 0x44,
  0x10, 0x11, 0x04, 0x04, 0x41, 0x02, 0x10, 0x40, 0x84, 0x10, 0x21, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x80, 0x88, 0x20, 0x3C, 0x04,
  0x00, 0x6C, 0x01, 0x08, 0x0C, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x08,
  0x20, 0x10, 0x80, 0x42, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x30, 0x01,
  0x40, 0x08, 0x80, 0x62, 0x09, 0x04, 0x24, 0x10, 0xA0, 0x22, 0x80, 0x92,
  0x01, 0x48, 0x03, 0x20, 0x08, 0x40, 0x31, 0x01, 0x42, 0x08, 0x87, 0xC3,
  0xD5, 0x55, 0x50, 0x04, 0x20, 0x84, 0x30, 0x82, 0x10, 0x41, 0x0C, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x02, 0x08,
  0x10, 0x40, 0x82, 0x04, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x20,
  0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x61,
  0x04, 0x20, 0x84, 0x10, 0x80, 0x08, 0x04, 0x02, 0x11, 0x17, 0xF0, 0x40,
  0x50, 0x44, 0x42, 0x20, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x32, 0x22, 0x24,
  0x44, 0x80, 0xFF, 0xD0, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x04, 0x03, 0x60, 0x82, 0x30, 0x24,
  0x04, 0x80, 0xB0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x50, 0x1A, 0x02, 0x40, 0x44, 0x18, 0xC2, 0x0F, 0x80, 0x04, 0x73, 0x59,
  0xC4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x0C, 0x0F, 0xE2, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x7F, 0xF0, 0x04, 0x03, 0xB8,
  0xC0, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x81, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x80, 0x47, 0xF8, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x40,
  0x09, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x21, 0x00, 0x84, 0x04, 0x10,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x10, 0x40, 0x43, 0x01, 0x08, 0x04,
  0x3F, 0xFF, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x7F, 0xC8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0x88, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x50, 0x33, 0xFC, 0x00, 0x0F, 0xC3, 0x00, 0xC0, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x10, 0x4C, 0xCA, 0x05, 0x80,
  0xB0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50,
  0x0A, 0x01, 0x40, 0x44, 0x18, 0x6E, 0x02, 0x00, 0xFF, 0xE0, 0x04, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x00, 0x1F, 0xC1,
  0x83, 0x08, 0x08, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x20,
  0x21, 0x01, 0x04, 0x10, 0x1B, 0x00, 0x60, 0x06, 0xC0, 0x43, 0x04, 0x0C,
  0x60, 0x22, 0x00, 0x90, 0x05, 0x00, 0x38, 0x00, 0xC0, 0x0D, 0x00, 0x48,
  0x02, 0x60, 0x31, 0x83, 0x07, 0xF0, 0x04, 0x07, 0x61, 0x02, 0x20, 0x28,
  0x05, 0x00, 0xA0, 0x14, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x1A, 0x05, 0x33, 0x21, 0x84, 0x00, 0x80, 0x10, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x3F, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1D, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x32, 0x22,
  0x24, 0x44, 0x80, 0x00, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x20, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x00, 0x10, 0xEC, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x0C, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x03, 0xF8, 0x00, 0xC0, 0xC0, 0x20, 0x0C, 0x08, 0x00, 0xC3, 0x00, 0x08,
  0x40, 0x01, 0x88, 0x00, 0x12, 0x01, 0x02, 0x40, 0xD8, 0x48, 0x21, 0x07,
  0x0C, 0x20, 0xC1, 0x04, 0x18, 0x20, 0x83, 0x04, 0x10, 0x60, 0x82, 0x0C,
  0x20, 0x41, 0x84, 0x08, 0x30, 0x43, 0x06, 0x08, 0x60, 0xC1, 0x0C, 0x28,
  0x22, 0x84, 0x82, 0xC9, 0x10, 0x30, 0xC2, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x0F, 0xF0, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x10, 0x08, 0x40, 0x21, 0x00, 0x84, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x07, 0xFC, 0x30, 0x10, 0x80, 0x42, 0x01, 0x08,
  0x02, 0x20, 0x09, 0x00, 0x24, 0x00, 0x90, 0x03, 0x40, 0x06, 0x00, 0x18,
  0x00, 0x40, 0xFF, 0x08, 0x0C, 0x80, 0x68, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x0C, 0xFF, 0x08, 0x18, 0x80,
  0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x02, 0x80, 0x68, 0x0C, 0xFF, 0x00, 0x00, 0x80, 0x3B, 0xC2, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x03, 0x02, 0x0F, 0xF0, 0xFF, 0x04, 0x0C, 0x20, 0x11, 0x00, 0x48,
  0x02, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05,
  0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x44, 0x0C, 0x3F,
  0x80, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0xFF,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x0F, 0xFA, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x00, 0x60, 0x03,
  0xFC, 0x0C, 0x02, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x7F, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x20, 0x01, 0x30, 0x01, 0x10,
  0x01, 0x0C, 0x01, 0x03, 0xFE, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1F, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x4F, 0xC0, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x99, 0xC0,
  0x80, 0x30, 0x0A, 0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0x84, 0x20, 0x84,
  0x11, 0x02, 0x20, 0x48, 0x0B, 0x01, 0x50, 0x32, 0x04, 0x20, 0x84, 0x10,
  0x42, 0x08, 0x40, 0x88, 0x11, 0x01, 0x20, 0x24, 0x02, 0x80, 0x50, 0x06,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xE0, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xD0, 0x00, 0x5A, 0x00, 0x0B, 0x40, 0x01, 0x68,
  0x00, 0x4C, 0x80, 0x09, 0x90, 0x01, 0x32, 0x00, 0x46, 0x20, 0x08, 0xC4,
  0x01, 0x18, 0x80, 0x63, 0x08, 0x08, 0x61, 0x01, 0x0C, 0x20, 0x21, 0x84,
  0x08, 0x30, 0x41, 0x06, 0x08, 0x20, 0xC1, 0x08, 0x18, 0x11, 0x03, 0x02,
  0x20, 0x60, 0x48, 0x0C, 0x05, 0x01, 0x80, 0xA0, 0x30, 0x1C, 0x06, 0x03,
  0x00, 0x80, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x40, 0x1A, 0x00, 0xC8, 0x06,
  0x40, 0x33, 0x01, 0x88, 0x0C, 0x40, 0x61, 0x03, 0x08, 0x18, 0x20, 0xC1,
  0x06, 0x04, 0x30, 0x21, 0x81, 0x0C, 0x04, 0x60, 0x23, 0x00, 0x98, 0x04,
  0xC0, 0x16, 0x00, 0xB0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x02, 0x01, 0x00,
  0x1D, 0xC0, 0x60, 0x41, 0x80, 0x42, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x50, 0x01, 0x30, 0x02, 0x20, 0x04, 0x60, 0x10, 0x60,
  0x40, 0x7F, 0x00, 0xFE, 0x10, 0x32, 0x03, 0x40, 0x28, 0x05, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x40, 0x28, 0x0D, 0x03, 0x3F, 0xC4,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xC0, 0x60, 0x41, 0x80,
  0x42, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x01,
  0x20, 0x02, 0x20, 0x04, 0x60, 0x10, 0x60, 0x40, 0x7F, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0xFE, 0x08, 0x18,
  0x80, 0x48, 0x04, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06,
  0x80, 0x48, 0x04, 0x80, 0x88, 0x30, 0xFC, 0x08, 0x40, 0x82, 0x08, 0x20,
  0x81, 0x08, 0x10, 0x81, 0x88, 0x08, 0x80, 0xC8, 0x04, 0x80, 0x48, 0x02,
  0x80, 0x30, 0x02, 0x07, 0xBD, 0x80, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x0A, 0x02, 0x7F, 0x80, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x50,
  0x02, 0x40, 0x31, 0x03, 0x07, 0xF0, 0x80, 0x06, 0x00, 0x14, 0x00, 0x90,
  0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x42,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x02, 0x10, 0x08, 0x40,
  0x21, 0x00, 0x84, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x08, 0x01, 0x40, 0x18, 0x01,
  0x40, 0x18, 0x01, 0x40, 0x18, 0x01, 0x40, 0x14, 0x02, 0x40, 0x14, 0x02,
  0x20, 0x24, 0x02, 0x20, 0x24, 0x02, 0x20, 0x24, 0x06, 0x20, 0x22, 0x04,
  0x30, 0x22, 0x04, 0x10, 0x42, 0x04, 0x10, 0x42, 0x04, 0x10, 0x42, 0x08,
  0x10, 0x41, 0x08, 0x08, 0x41, 0x08, 0x08, 0xC1, 0x08, 0x08, 0x81, 0x08,
  0x08, 0x81, 0x10, 0x08, 0x80, 0x90, 0x04, 0x80, 0x90, 0x05, 0x80, 0x90,
  0x05, 0x00, 0xA0, 0x05, 0x00, 0xA0, 0x05, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x60, 0x12, 0x01, 0x20, 0x21, 0x02, 0x10, 0x41, 0x04,
  0x08, 0x40, 0x88, 0x08, 0x80, 0x58, 0x05, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x05, 0x00, 0x50, 0x04, 0x80, 0x88, 0x08, 0x81, 0x04, 0x10, 0x41, 0x04,
  0x20, 0x22, 0x02, 0x40, 0x24, 0x01, 0xC0, 0x10, 0x80, 0x14, 0x02, 0x40,
  0x24, 0x02, 0x20, 0x42, 0x04, 0x20, 0x41, 0x08, 0x10, 0x81, 0x08, 0x09,
  0x00, 0x90, 0x09, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x7F, 0xC0, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x03, 0xFF, 0x80, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x80, 0x08, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0xFE, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0xFE, 0x03, 0x00, 0x38, 0x01, 0x40, 0x19, 0x00, 0x88, 0x0C,
  0x20, 0x41, 0x06, 0x04, 0x20, 0x23, 0x00, 0x90, 0x05, 0x80, 0x18, 0x00,
  0x80, 0xFF, 0xFE, 0x86, 0x10, 0x41, 0x04, 0x3F, 0x88, 0x20, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC3, 0xD3, 0x05, 0x81, 0x40, 0x50,
  0x18, 0x06, 0x01, 0x40, 0x50, 0x34, 0x0C, 0xFD, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x13, 0xF2, 0x83, 0x60,
  0x2C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x0B, 0x01, 0x50, 0x49, 0xF0,
  0x1F, 0x98, 0x18, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x03, 0xF0, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x23,
  0xE4, 0x82, 0xA0, 0x34, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x0D, 0x01,
  0x90, 0x51, 0xF2, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x28, 0x05, 0x00, 0xA0,
  0x0C, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x81, 0x0F, 0xE0, 0x07, 0x84, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x7F, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x1F, 0xA4, 0x1D, 0x01, 0xA0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x40, 0x68, 0x0C, 0x82, 0x8F, 0x90, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x40, 0x47, 0xF0, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x27, 0xCA, 0x0B, 0x02, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x74, 0x00, 0x55,
  0x55, 0x55, 0x55, 0x55, 0x13, 0x10, 0x00, 0x00, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0xE0, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xE0, 0x50,
  0x48, 0x44, 0x22, 0x21, 0x30, 0x90, 0x58, 0x2A, 0x19, 0x08, 0x44, 0x22,
  0x11, 0x04, 0x82, 0x40, 0xA0, 0x50, 0x28, 0x08, 0xFF, 0xFF, 0xFF, 0xF8,
  0xBE, 0x1F, 0x50, 0x90, 0xF0, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x04,
  0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80,
  0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x10, 0x9F, 0x28, 0x2C, 0x0A, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x1F, 0x82, 0x0C, 0x40,
  0x44, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x40, 0x24, 0x04, 0x20,
  0xC1, 0xF8, 0x9F, 0x94, 0x1B, 0x01, 0x60, 0x28, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x58, 0x0A, 0x82, 0x4F, 0x88, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x1F, 0xA4, 0x15, 0x01, 0xA0, 0x38,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x40, 0x68, 0x0C, 0x82, 0x8F, 0x90, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x9F, 0x43,
  0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x00, 0x3F, 0x98, 0x24, 0x01, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x80, 0x28, 0x19, 0xFC, 0x20, 0x82, 0x08, 0x23, 0xF2, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x5C, 0x15,
  0xF9, 0x80, 0x28, 0x05, 0x01, 0x20, 0x24, 0x04, 0xC0, 0x88, 0x21, 0x04,
  0x20, 0x84, 0x10, 0x44, 0x08, 0x81, 0x10, 0x22, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x40, 0x18, 0x02, 0x00, 0x80, 0x60, 0x28, 0x0C, 0x05, 0x01, 0x80,
  0xA0, 0x30, 0x24, 0x0A, 0x04, 0x41, 0x20, 0x88, 0x24, 0x11, 0x04, 0x84,
  0x21, 0x10, 0x84, 0x22, 0x10, 0x44, 0x22, 0x08, 0x84, 0x41, 0x10, 0x90,
  0x24, 0x12, 0x02, 0x81, 0x40, 0x50, 0x28, 0x0A, 0x06, 0x01, 0x40, 0xC0,
  0x10, 0x18, 0x02, 0x01, 0x00, 0x80, 0x50, 0x24, 0x08, 0x86, 0x21, 0x04,
  0x41, 0x20, 0x48, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x12, 0x04, 0x82, 0x10,
  0x84, 0x40, 0x90, 0x28, 0x06, 0x01, 0x40, 0x34, 0x02, 0x40, 0x22, 0x02,
  0x20, 0x42, 0x04, 0x20, 0x41, 0x04, 0x10, 0x81, 0x08, 0x10, 0x80, 0x88,
  0x09, 0x00, 0x90, 0x09, 0x00, 0x50, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00,
  0xF0, 0x00, 0x7F, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0xFF, 0x03, 0x82,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x40, 0x60, 0xE0, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x08, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x01,
  0x83, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x20, 0xE0, 0x00, 0x3C, 0x0E, 0x18, 0x60, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_Thin38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 27, 7, 3, -27 },
  { 8, 7, 10, 11, 2, -27 },
  { 17, 14, 27, 16, 1, -27 },
  { 65, 13, 31, 15, 1, -29 },
  { 116, 18, 28, 22, 2, -28 },
  { 179, 14, 28, 15, 1, -28 },
  { 228, 2, 10, 6, 2, -27 },
  { 231, 6, 33, 10, 2, -27 },
  { 256, 6, 33, 10, 2, -27 },
  { 281, 9, 10, 13, 2, -29 },
  { 293, 13, 17, 15, 1, -22 },
  { 321, 4, 9, 7, 1, -4 },
  { 326, 8, 1, 10, 1, -11 },
  { 327, 2, 2, 7, 2, -2 },
  { 328, 11, 27, 12, 1, -27 },
  { 366, 11, 28, 15, 2, -28 },
  { 405, 6, 27, 15, 3, -27 },
  { 426, 11, 28, 15, 2, -28 },
  { 465, 12, 28, 15, 1, -28 },
  { 507, 14, 27, 15, 1, -27 },
  { 555, 11, 27, 15, 2, -27 },
  { 593, 11, 28, 15, 2, -27 },
  { 632, 11, 27, 15, 2, -27 },
  { 670, 13, 27, 15, 1, -27 },
  { 714, 11, 28, 15, 2, -28 },
  { 753, 2, 20, 7, 2, -20 },
  { 758, 4, 25, 7, 1, -20 },
  { 771, 13, 15, 15, 1, -21 },
  { 796, 13, 9, 15, 1, -18 },
  { 811, 13, 15, 15, 1, -21 },
  { 836, 8, 28, 10, 1, -28 },
  { 864, 19, 31, 23, 2, -27 },
  { 938, 14, 27, 14, 0, -27 },
  { 986, 12, 27, 16, 3, -27 },
  { 1027, 13, 28, 16, 2, -28 },
  { 1073, 13, 27, 18, 3, -27 },
  { 1117, 10, 27, 14, 3, -27 },
  { 1151, 10, 27, 13, 3, -27 },
  { 1185, 16, 28, 20, 2, -28 },
  { 1241, 13, 27, 18, 3, -27 },
  { 1285, 6, 27, 8, 1, -27 },
  { 1306, 6, 34, 7, -2, -27 },
  { 1332, 11, 27, 14, 3, -27 },
  { 1370, 9, 27, 13, 3, -27 },
  { 1401, 19, 27, 25, 3, -27 },
  { 1466, 13, 27, 19, 3, -27 },
  { 1510, 15, 28, 19, 2, -28 },
  { 1563, 11, 27, 15, 3, -27 },
  { 1601, 15, 34, 19, 2, -28 },
  { 1665, 12, 27, 15, 3, -27 },
  { 1706, 11, 28, 15, 2, -28 },
  { 1745, 12, 27, 13, 0, -27 },
  { 1786, 13, 27, 18, 3, -27 },
  { 1830, 14, 27, 14, 0, -27 },
  { 1878, 24, 27, 25, 0, -27 },
  { 1959, 12, 27, 13, 0, -27 },
  { 2000, 12, 27, 12, 0, -27 },
  { 2041, 11, 27, 12, 1, -27 },
  { 2079, 7, 33, 12, 3, -27 },
  { 2108, 11, 27, 12, 1, -27 },
  { 2146, 7, 33, 12, 1, -27 },
  { 2175, 13, 13, 15, 1, -27 },
  { 2197, 15, 1, 15, 0, 3 },
  { 2199, 5, 6, 9, 2, -29 },
  { 2203, 10, 20, 14, 1, -20 },
  { 2228, 11, 29, 16, 3, -29 },
  { 2268, 9, 20, 12, 2, -20 },
  { 2291, 11, 29, 16, 2, -29 },
  { 2331, 11, 20, 14, 2, -20 },
  { 2359, 9, 29, 8, 0, -29 },
  { 2392, 11, 29, 16, 2, -20 },
  { 2432, 10, 29, 16, 3, -29 },
  { 2469, 2, 28, 7, 2, -28 },
  { 2476, 4, 37, 7, 0, -28 },
  { 2495, 9, 29, 12, 3, -29 },
  { 2528, 1, 29, 6, 3, -29 },
  { 2532, 17, 20, 23, 3, -20 },
  { 2575, 10, 20, 16, 3, -20 },
  { 2600, 12, 20, 15, 2, -20 },
  { 2630, 11, 29, 16, 3, -20 },
  { 2670, 11, 29, 16, 2, -20 },
  { 2710, 7, 20, 10, 3, -20 },
  { 2728, 10, 20, 12, 1, -20 },
  { 2753, 6, 25, 8, 1, -25 },
  { 2772, 10, 20, 16, 3, -20 },
  { 2797, 11, 20, 11, 0, -20 },
  { 2825, 19, 20, 19, 0, -20 },
  { 2873, 10, 20, 12, 1, -20 },
  { 2898, 12, 29, 12, 0, -20 },
  { 2942, 8, 20, 10, 1, -20 },
  { 2962, 9, 33, 13, 2, -27 },
  { 3000, 1, 38, 14, 7, -29 },
  { 3005, 9, 33, 13, 2, -27 },
  { 3043, 13, 3, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Thin38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN38PT7B_H_
