#ifndef _NOTOSANS_EXTRACONDENSED_THIN22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0x99, 0x99, 0x99, 0x11, 0x08, 0x84, 0x82, 0x41, 0x23,
  0xFC, 0x48, 0x44, 0x22, 0x11, 0x3F, 0xC4, 0x82, 0x41, 0x20, 0x90, 0x48,
  0x10, 0x71, 0x54, 0x89, 0x12, 0x24, 0x48, 0x60, 0x30, 0x50, 0x91, 0x22,
  0x44, 0xCA, 0x78, 0x20, 0x61, 0x12, 0x22, 0x44, 0x49, 0x09, 0x21, 0x24,
  0x25, 0x24, 0xAA, 0x96, 0x2D, 0x44, 0x28, 0x85, 0x11, 0x22, 0x24, 0x44,
  0x91, 0x0E, 0x30, 0x91, 0x22, 0x44, 0x89, 0x0C, 0x10, 0x51, 0x26, 0x2C,
  0x58, 0x50, 0xA1, 0xBD, 0xFC, 0x12, 0x24, 0x48, 0x88, 0x88, 0x88, 0x88,
  0x44, 0x42, 0x30, 0x84, 0x42, 0x22, 0x11, 0x11, 0x11, 0x12, 0x22, 0x44,
  0x80, 0x21, 0x3A, 0x65, 0x44, 0x10, 0x20, 0x40, 0x81, 0x1F, 0xC4, 0x08,
  0x10, 0x20, 0x5A, 0x80, 0xF0, 0xC0, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08,
  0x20, 0x84, 0x10, 0x42, 0x08, 0x20, 0x38, 0x89, 0x14, 0x28, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x91, 0x1C, 0x2E, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x79, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x41,
  0x02, 0x08, 0x20, 0x7F, 0x79, 0x08, 0x10, 0x10, 0x20, 0x81, 0x3C, 0x08,
  0x08, 0x08, 0x10, 0x20, 0x41, 0x7C, 0x02, 0x04, 0x04, 0x0A, 0x0A, 0x12,
  0x12, 0x22, 0x22, 0x42, 0x42, 0xFF, 0x02, 0x02, 0x02, 0x02, 0x7D, 0x02,
  0x04, 0x08, 0x10, 0x2C, 0x64, 0x04, 0x04, 0x08, 0x10, 0x20, 0x41, 0x7C,
  0x1C, 0x41, 0x02, 0x08, 0x10, 0x2E, 0x62, 0x85, 0x06, 0x0C, 0x18, 0x30,
  0x51, 0x3C, 0xFE, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x92, 0x18, 0x28,
  0x8A, 0x0C, 0x18, 0x30, 0x61, 0x3C, 0x38, 0x8A, 0x14, 0x28, 0x30, 0x60,
  0xC1, 0x84, 0xF4, 0x08, 0x20, 0x40, 0x82, 0x78, 0xB0, 0x00, 0x03, 0x50,
  0x00, 0x05, 0xA8, 0x06, 0x30, 0x86, 0x08, 0x0C, 0x06, 0x02, 0x02, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x80, 0xC0, 0x60, 0x30, 0x61, 0x0C, 0x20, 0x80,
  0xF0, 0x42, 0x10, 0x84, 0x22, 0x21, 0x08, 0x40, 0x00, 0x04, 0x0F, 0x02,
  0x10, 0x81, 0x20, 0x24, 0x03, 0x1E, 0x62, 0x4C, 0x89, 0x91, 0x32, 0x26,
  0x44, 0xC8, 0x98, 0xB3, 0x09, 0x90, 0x02, 0x00, 0x20, 0x03, 0xE0, 0x08,
  0x18, 0x18, 0x14, 0x14, 0x24, 0x24, 0x24, 0x22, 0x3E, 0x42, 0x42, 0x41,
  0x81, 0x81, 0x81, 0xF9, 0x0A, 0x14, 0x28, 0x50, 0xA1, 0x7C, 0x85, 0x0A,
  0x0C, 0x18, 0x30, 0x61, 0x7C, 0x1F, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x1F, 0xF1, 0x12, 0x14,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xA1, 0x7C, 0xFC,
  0x21, 0x08, 0x42, 0x1F, 0x84, 0x21, 0x08, 0x42, 0x1F, 0xFC, 0x21, 0x08,
  0x42, 0x10, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x1F, 0x10, 0x50, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x83, 0xC0, 0x60, 0x30, 0x14, 0x0A, 0x04, 0x82,
  0x3F, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xE9, 0x24, 0x92, 0x49, 0x24, 0x97, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0xF0, 0x86, 0x18, 0xA4, 0x92, 0x8A, 0x30, 0xA2,
  0x89, 0x24, 0x8A, 0x28, 0x61, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x1F, 0x80, 0x30, 0x0E, 0x01, 0xE0, 0x3C, 0x0B, 0x81, 0x68,
  0x2D, 0x09, 0xA1, 0x32, 0x26, 0x48, 0xC9, 0x19, 0x23, 0x14, 0x63, 0x0C,
  0x21, 0x83, 0x06, 0x0E, 0x1C, 0x34, 0x68, 0xC9, 0x93, 0x16, 0x2C, 0x38,
  0x70, 0xE0, 0xC1, 0x1E, 0x10, 0x90, 0x48, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x09, 0x04, 0x7C, 0xF2, 0x28, 0x61,
  0x86, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x82, 0x08, 0x20, 0x1E, 0x10, 0x90,
  0x48, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A,
  0x09, 0x04, 0x74, 0x04, 0x01, 0x00, 0x80, 0x20, 0xF2, 0x28, 0x61, 0x86,
  0x18, 0x62, 0xF2, 0x49, 0x22, 0x8A, 0x28, 0x61, 0x3C, 0x82, 0x04, 0x08,
  0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x10, 0x20, 0x41, 0x7C, 0xFE, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xBE, 0x81, 0x81, 0x81, 0x41, 0x42, 0x42, 0x42, 0x42, 0x24, 0x24,
  0x24, 0x24, 0x18, 0x18, 0x18, 0x10, 0x81, 0x06, 0x04, 0x18, 0x30, 0x50,
  0xC1, 0x43, 0x09, 0x0A, 0x24, 0x48, 0x91, 0x22, 0x24, 0x88, 0x92, 0x42,
  0x45, 0x0A, 0x14, 0x18, 0x50, 0x61, 0x81, 0x82, 0x04, 0x08, 0x42, 0x85,
  0x11, 0x22, 0x45, 0x06, 0x08, 0x10, 0x30, 0xA1, 0x24, 0x48, 0x90, 0xC1,
  0x83, 0x05, 0x12, 0x24, 0x45, 0x0A, 0x14, 0x30, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0xFC, 0x20, 0x82, 0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x82,
  0x08, 0x3F, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0,
  0x82, 0x08, 0x20, 0x41, 0x02, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x81,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x08, 0x14,
  0x14, 0x24, 0x22, 0x42, 0x41, 0x81, 0xFF, 0x80, 0x89, 0x10, 0x70, 0x20,
  0x41, 0x04, 0xF4, 0x61, 0x86, 0x18, 0xDD, 0x82, 0x08, 0x20, 0x83, 0xE8,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0xF8, 0x3A, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x10, 0x70, 0x02, 0x04, 0x08, 0x10, 0x27, 0x51, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xA3, 0x7A, 0x39, 0x18, 0x61, 0x87, 0xF8,
  0x20, 0x82, 0x04, 0x0F, 0x19, 0x08, 0x42, 0x78, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x20, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05,
  0x1B, 0xD0, 0x20, 0x40, 0x82, 0xF8, 0x84, 0x21, 0x08, 0x7A, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x88, 0xE0, 0xAA, 0xAA, 0xAA, 0x68, 0x04, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x2C, 0x84, 0x21, 0x08, 0x46, 0x52, 0xA6, 0x31,
  0x4A, 0x4A, 0x51, 0x88, 0xFF, 0xFF, 0x80, 0xF3, 0xA3, 0x18, 0x86, 0x21,
  0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18, 0x86, 0x21, 0xF4, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x10, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x05, 0x11, 0xC0, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x7E, 0x82, 0x08, 0x20, 0x80, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x05, 0x1B, 0xD0, 0x20, 0x40, 0x81, 0x02, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x7C, 0x21, 0x08, 0x20, 0xC1, 0x08, 0x43, 0xE0, 0x44,
  0xF4, 0x44, 0x44, 0x44, 0x44, 0x43, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0xF0, 0x86, 0x18, 0x51, 0x45, 0x24, 0x8A, 0x28, 0xC1, 0x04, 0x84,
  0x30, 0x86, 0x10, 0xA5, 0x14, 0xA4, 0x94, 0x92, 0x51, 0x4A, 0x31, 0x86,
  0x30, 0xC2, 0x08, 0x40, 0x82, 0x89, 0x11, 0x42, 0x82, 0x04, 0x14, 0x28,
  0x89, 0x14, 0x30, 0x82, 0x85, 0x12, 0x24, 0x44, 0x8A, 0x14, 0x28, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x10, 0xE0, 0xF1, 0x12, 0x22, 0x44, 0x48, 0x8F,
  0x08, 0x88, 0x42, 0x10, 0x84, 0x26, 0x08, 0x42, 0x10, 0x84, 0x21, 0x06,
  0xFF, 0xFF, 0xFC, 0xC1, 0x08, 0x42, 0x10, 0x84, 0x10, 0xC4, 0x22, 0x10,
  0x84, 0x21, 0x38, 0x63, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_Thin22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 16, 4, 2, -16 },
  { 3, 4, 6, 6, 1, -16 },
  { 6, 9, 16, 9, 0, -16 },
  { 24, 7, 18, 9, 1, -17 },
  { 40, 11, 16, 13, 1, -16 },
  { 62, 7, 16, 8, 1, -16 },
  { 76, 1, 6, 4, 1, -16 },
  { 77, 4, 19, 6, 1, -16 },
  { 87, 4, 19, 6, 1, -16 },
  { 97, 5, 6, 7, 1, -17 },
  { 101, 7, 10, 9, 1, -13 },
  { 110, 2, 5, 4, 1, -2 },
  { 112, 4, 1, 6, 1, -7 },
  { 113, 2, 1, 4, 1, -1 },
  { 114, 6, 16, 7, 1, -16 },
  { 126, 7, 16, 9, 1, -16 },
  { 140, 3, 16, 9, 2, -16 },
  { 146, 7, 16, 9, 1, -16 },
  { 160, 7, 16, 9, 1, -16 },
  { 174, 8, 16, 9, 0, -16 },
  { 190, 7, 16, 9, 1, -16 },
  { 204, 7, 16, 9, 1, -16 },
  { 218, 7, 16, 9, 1, -16 },
  { 232, 7, 16, 9, 1, -16 },
  { 246, 7, 16, 9, 1, -16 },
  { 260, 2, 12, 4, 1, -12 },
  { 263, 2, 15, 4, 1, -12 },
  { 267, 7, 9, 9, 1, -12 },
  { 275, 7, 5, 9, 1, -10 },
  { 280, 7, 9, 9, 1, -12 },
  { 288, 5, 16, 6, 0, -16 },
  { 298, 11, 18, 13, 1, -16 },
  { 323, 8, 16, 8, 0, -16 },
  { 339, 7, 16, 9, 2, -16 },
  { 353, 8, 16, 9, 1, -16 },
  { 369, 7, 16, 10, 2, -16 },
  { 383, 5, 16, 8, 2, -16 },
  { 393, 5, 16, 8, 2, -16 },
  { 403, 9, 16, 11, 1, -16 },
  { 421, 7, 16, 11, 2, -16 },
  { 435, 3, 16, 5, 1, -16 },
  { 441, 3, 20, 4, -1, -16 },
  { 449, 6, 16, 8, 2, -16 },
  { 461, 5, 16, 8, 2, -16 },
  { 471, 11, 16, 14, 2, -16 },
  { 493, 7, 16, 11, 2, -16 },
  { 507, 9, 16, 11, 1, -16 },
  { 525, 6, 16, 9, 2, -16 },
  { 537, 9, 20, 11, 1, -16 },
  { 560, 6, 16, 9, 2, -16 },
  { 572, 7, 16, 9, 1, -16 },
  { 586, 7, 16, 7, 0, -16 },
  { 600, 7, 16, 11, 2, -16 },
  { 614, 8, 16, 8, 0, -16 },
  { 630, 14, 16, 14, 0, -16 },
  { 658, 7, 16, 7, 0, -16 },
  { 672, 7, 16, 7, 0, -16 },
  { 686, 6, 16, 7, 1, -16 },
  { 698, 4, 19, 7, 2, -16 },
  { 708, 6, 16, 7, 1, -16 },
  { 720, 4, 19, 7, 1, -16 },
  { 730, 8, 8, 9, 0, -16 },
  { 738, 9, 1, 9, 0, 2 },
  { 740, 3, 4, 5, 1, -17 },
  { 742, 6, 12, 8, 1, -12 },
  { 751, 6, 17, 9, 2, -17 },
  { 764, 5, 12, 7, 1, -12 },
  { 772, 7, 17, 9, 1, -17 },
  { 787, 6, 12, 8, 1, -12 },
  { 796, 5, 17, 5, 0, -17 },
  { 807, 7, 17, 9, 1, -12 },
  { 822, 5, 17, 9, 2, -17 },
  { 833, 2, 16, 4, 1, -16 },
  { 837, 3, 21, 4, 0, -16 },
  { 845, 5, 17, 7, 2, -17 },
  { 856, 1, 17, 4, 1, -17 },
  { 859, 10, 12, 13, 2, -12 },
  { 874, 5, 12, 9, 2, -12 },
  { 882, 7, 12, 9, 1, -12 },
  { 893, 6, 17, 9, 2, -12 },
  { 906, 7, 17, 9, 1, -12 },
  { 921, 4, 12, 6, 2, -12 },
  { 927, 5, 12, 7, 1, -12 },
  { 935, 4, 14, 5, 0, -14 },
  { 942, 5, 12, 9, 2, -12 },
  { 950, 6, 12, 6, 0, -12 },
  { 959, 11, 12, 11, 0, -12 },
  { 976, 7, 12, 7, 0, -12 },
  { 987, 7, 17, 7, 0, -12 },
  { 1002, 4, 12, 6, 1, -12 },
  { 1008, 5, 19, 8, 1, -16 },
  { 1020, 1, 22, 8, 4, -17 },
  { 1023, 5, 19, 8, 1, -16 },
  { 1035, 7, 2, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Thin22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN22PT7B_H_
