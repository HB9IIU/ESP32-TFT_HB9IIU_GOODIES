#ifndef _NOTOSANS_EXTRACONDENSED_THIN36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF0, 0xC0, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x10, 0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80,
  0x82, 0x02, 0x10, 0xFF, 0xFC, 0x21, 0x00, 0x84, 0x04, 0x10, 0x10, 0x40,
  0x41, 0x01, 0x04, 0x04, 0x10, 0x10, 0x43, 0xFF, 0xE1, 0x08, 0x04, 0x20,
  0x20, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x84, 0x00, 0x04,
  0x00, 0x40, 0x1F, 0xC6, 0x42, 0x44, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84,
  0x08, 0x40, 0x44, 0x06, 0x40, 0x34, 0x00, 0xC0, 0x07, 0x00, 0x4C, 0x04,
  0x60, 0x42, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x84,
  0x47, 0xF8, 0x04, 0x00, 0x40, 0x04, 0x00, 0x78, 0x08, 0x24, 0x04, 0x21,
  0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x11, 0x02, 0x08, 0x81, 0x04, 0x40,
  0x82, 0x40, 0x41, 0x20, 0x20, 0x93, 0x10, 0x92, 0x28, 0x49, 0x14, 0x25,
  0x05, 0x24, 0x82, 0x72, 0x41, 0x01, 0x20, 0x81, 0x10, 0x40, 0x88, 0x20,
  0x44, 0x10, 0x42, 0x08, 0x21, 0x04, 0x10, 0x82, 0x10, 0x22, 0x08, 0x11,
  0x04, 0x07, 0x00, 0x0E, 0x00, 0x88, 0x08, 0x40, 0x41, 0x02, 0x08, 0x10,
  0x40, 0x82, 0x04, 0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x18, 0x00, 0x80,
  0x0A, 0x00, 0x88, 0x08, 0x42, 0x41, 0x14, 0x08, 0xA0, 0x25, 0x01, 0x28,
  0x06, 0x40, 0x32, 0x01, 0x88, 0x1A, 0x60, 0x91, 0xF8, 0x40, 0xFF, 0xC0,
  0x04, 0x21, 0x04, 0x20, 0x86, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x82, 0x08, 0x10, 0x60, 0x81,
  0xC0, 0x80, 0x81, 0x81, 0x03, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x40, 0x81, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x60,
  0x81, 0x04, 0x10, 0x60, 0x08, 0x04, 0x02, 0x1D, 0x71, 0xC0, 0xC0, 0x90,
  0x84, 0x41, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x24, 0x96, 0x92, 0x80, 0xFF, 0xF0, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x00, 0x1E, 0x08, 0x46, 0x09,
  0x02, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14,
  0x09, 0x02, 0x21, 0x07, 0xC0, 0x04, 0x73, 0x59, 0xC6, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x1F, 0x0C, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03,
  0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x1F,
  0xFC, 0x1F, 0x0C, 0x12, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0xC1, 0xE0, 0x03, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x80, 0xCF,
  0xF0, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80,
  0x22, 0x00, 0x88, 0x06, 0x20, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x08, 0x20, 0x21, 0x00, 0x84, 0x02, 0x3F, 0xFF,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x7F,
  0x88, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x7F, 0x80, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x81, 0x9F, 0xC0, 0x07,
  0xC3, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x38, 0x58, 0xCC, 0x09, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x05, 0x00, 0x90, 0x12, 0x02, 0x60, 0x87, 0x60, 0x10,
  0x00, 0xFF, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x00, 0x0F, 0x83,
  0x0C, 0x20, 0x64, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x20, 0x22,
  0x04, 0x10, 0x80, 0xD0, 0x06, 0x00, 0x90, 0x30, 0xC2, 0x04, 0x40, 0x24,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x24, 0x02, 0x20, 0x41,
  0xF8, 0x1F, 0x06, 0x10, 0x81, 0x20, 0x24, 0x02, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0xC8, 0x28, 0xF9, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x30, 0x04, 0x01, 0x07,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x24, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x24, 0xB4, 0x94, 0x00, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00,
  0xC0, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C,
  0x00, 0x80, 0x00, 0x78, 0x86, 0x02, 0x02, 0x01, 0x01, 0x01, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x20, 0x01, 0xF0, 0x01, 0x83, 0x00, 0x80, 0x60,
  0x40, 0x08, 0x20, 0x01, 0x08, 0x00, 0x44, 0x00, 0x09, 0x01, 0x02, 0x41,
  0xB0, 0xB0, 0xC4, 0x18, 0x21, 0x06, 0x08, 0x41, 0x84, 0x10, 0x61, 0x04,
  0x18, 0x41, 0x06, 0x10, 0x41, 0x84, 0x10, 0x61, 0x04, 0x18, 0x43, 0x0A,
  0x08, 0xC2, 0x82, 0x49, 0x90, 0x73, 0xC4, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x20, 0x07, 0xF0, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x40, 0x04, 0x80, 0x12, 0x00, 0x48, 0x02,
  0x20, 0x08, 0x80, 0x21, 0x00, 0x84, 0x04, 0x10, 0x10, 0x40, 0x40, 0x81,
  0x02, 0x0F, 0xF8, 0x20, 0x20, 0x80, 0x42, 0x01, 0x08, 0x04, 0x40, 0x11,
  0x00, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A, 0x00, 0x30, 0xFC, 0x10, 0x32,
  0x03, 0x40, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x0A, 0x02,
  0x40, 0xCF, 0xE1, 0x03, 0x20, 0x14, 0x02, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x14, 0x02, 0x81, 0x9F, 0xE0, 0x07, 0xE0, 0x81,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x10, 0x7F,
  0xF8, 0x08, 0x30, 0x80, 0x88, 0x04, 0x80, 0x28, 0x02, 0x80, 0x28, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x0C,
  0x81, 0x8F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x0F, 0xFC, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x07,
  0xFE, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x00, 0x03, 0xF8, 0x18, 0x18, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x0F, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x2C, 0x00, 0x48, 0x00, 0x88, 0x01,
  0x08, 0x02, 0x0F, 0xF8, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFC, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x23, 0xF0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0xBE, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x88, 0x11, 0x04, 0x20,
  0x84, 0x20, 0x88, 0x11, 0x02, 0x40, 0x58, 0x0B, 0x01, 0xB0, 0x32, 0x04,
  0x60, 0x84, 0x10, 0x82, 0x08, 0x41, 0x08, 0x11, 0x02, 0x20, 0x24, 0x04,
  0x80, 0x50, 0x0C, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x05, 0xC0, 0x01, 0x68, 0x00, 0x5A, 0x00,
  0x26, 0x80, 0x09, 0x90, 0x02, 0x64, 0x01, 0x19, 0x00, 0x46, 0x20, 0x11,
  0x88, 0x04, 0x62, 0x02, 0x18, 0x40, 0x86, 0x10, 0x21, 0x84, 0x10, 0x61,
  0x04, 0x18, 0x21, 0x06, 0x08, 0x81, 0x82, 0x20, 0x60, 0x48, 0x18, 0x14,
  0x06, 0x05, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x80, 0x18, 0x01, 0xC0,
  0x1C, 0x01, 0xA0, 0x1A, 0x01, 0x90, 0x19, 0x01, 0x88, 0x18, 0x81, 0x88,
  0x18, 0x41, 0x84, 0x18, 0x21, 0x82, 0x18, 0x11, 0x81, 0x18, 0x09, 0x80,
  0x98, 0x09, 0x80, 0x58, 0x05, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x07,
  0xC0, 0x60, 0x82, 0x01, 0x08, 0x02, 0x40, 0x09, 0x00, 0x14, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x05,
  0x00, 0x22, 0x00, 0x88, 0x04, 0x10, 0x30, 0x3F, 0x80, 0xF8, 0x21, 0xC8,
  0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02,
  0x80, 0xA0, 0xCF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0xC0, 0x60, 0x83, 0x01, 0x08,
  0x02, 0x40, 0x09, 0x00, 0x14, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00, 0x22, 0x00, 0x88, 0x04,
  0x10, 0x30, 0x3F, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0xF8, 0x10, 0xE2, 0x02, 0x40, 0x48, 0x05, 0x00, 0xA0, 0x14,
  0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x48, 0x11, 0xFC, 0x21, 0x04, 0x20,
  0x84, 0x10, 0x42, 0x08, 0x40, 0x88, 0x11, 0x01, 0x20, 0x24, 0x02, 0x80,
  0x50, 0x04, 0x1F, 0x98, 0x14, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x81, 0xBF, 0xC0, 0xFF,
  0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x24, 0x02, 0x60, 0x43, 0xF8, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x24,
  0x01, 0x20, 0x09, 0x00, 0x44, 0x02, 0x20, 0x21, 0x01, 0x08, 0x08, 0x20,
  0x41, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x08, 0x80, 0x44, 0x02, 0x20,
  0x11, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x05, 0x00, 0x60, 0x0A, 0x01, 0x40, 0x24,
  0x02, 0x80, 0x48, 0x05, 0x00, 0x90, 0x0A, 0x01, 0x10, 0x14, 0x02, 0x20,
  0x44, 0x08, 0x40, 0x88, 0x10, 0x81, 0x10, 0x20, 0x82, 0x20, 0x41, 0x04,
  0x41, 0x02, 0x08, 0x42, 0x04, 0x20, 0x84, 0x08, 0x41, 0x08, 0x08, 0x82,
  0x10, 0x11, 0x04, 0x40, 0x22, 0x04, 0x80, 0x48, 0x09, 0x00, 0xD0, 0x12,
  0x00, 0xA0, 0x28, 0x01, 0x40, 0x50, 0x02, 0x80, 0x60, 0x06, 0x00, 0xC0,
  0x04, 0x01, 0x80, 0x40, 0x32, 0x02, 0x20, 0x22, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x80, 0x88, 0x09, 0x00, 0x50, 0x05, 0x00, 0x60, 0x02, 0x00, 0x60,
  0x05, 0x00, 0x50, 0x09, 0x00, 0x88, 0x10, 0x81, 0x08, 0x10, 0x42, 0x04,
  0x20, 0x44, 0x02, 0x40, 0x2C, 0x03, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x24,
  0x04, 0x40, 0x88, 0x21, 0x04, 0x10, 0x82, 0x20, 0x44, 0x04, 0x80, 0xA0,
  0x14, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0xFF, 0xC0, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x3F, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x40, 0x10, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x02, 0x00, 0x30, 0x01,
  0x40, 0x12, 0x00, 0x88, 0x08, 0x40, 0x41, 0x04, 0x08, 0x20, 0x22, 0x01,
  0x10, 0x0D, 0x00, 0x28, 0x01, 0x80, 0xFF, 0xFC, 0xC0, 0x81, 0x06, 0x0C,
  0x3F, 0x08, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x07, 0xC6,
  0x12, 0x05, 0x01, 0x40, 0x60, 0x18, 0x0E, 0x03, 0x40, 0xD0, 0x53, 0xE4,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x9F,
  0x14, 0x13, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x05, 0x00, 0xA0, 0x14, 0x02, 0xC0, 0x94, 0x12,
  0xFC, 0x00, 0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x07, 0xE0,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x1F,
  0x24, 0x15, 0x02, 0xA0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x40, 0xAC, 0x14,
  0xFC, 0x80, 0x3F, 0x08, 0x44, 0x0B, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x11, 0xF8, 0x02, 0x86, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x7F, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x3F, 0x2C,
  0x15, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x40, 0xAC, 0x14, 0xFC,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x13, 0x0C, 0x0E,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xBE, 0x50,
  0xB0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0xF0, 0x01, 0x55, 0x55,
  0x55, 0x55, 0x50, 0x33, 0x00, 0x00, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90,
  0xB0, 0xB0, 0xC8, 0x88, 0x88, 0x84, 0x84, 0x82, 0x82, 0x82, 0x81, 0x81,
  0xFF, 0xFF, 0xFF, 0xE0, 0xBE, 0x3E, 0xC1, 0x43, 0xC1, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0xBF, 0x70, 0xB0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x3F, 0x0C, 0x11, 0x01, 0x40, 0x28, 0x05, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x14, 0x02, 0x40, 0x4C, 0x10, 0xFC, 0x00, 0x9F, 0x14, 0x13, 0x02, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x14, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0xC0, 0x94, 0x32, 0xFC, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00, 0x1F, 0x24, 0x15,
  0x02, 0xA0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x40, 0xAC, 0x14, 0xFC, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0xBE,
  0x8C, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x00, 0x3F, 0xA0, 0x10, 0x10, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x06, 0x00, 0x80, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x9F, 0x80,
  0x20, 0x82, 0x08, 0x43, 0xF2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x05, 0x03, 0x40, 0xD8, 0x53, 0xE4, 0x80, 0x50, 0x14, 0x05, 0x01, 0x40,
  0x90, 0x22, 0x08, 0x82, 0x21, 0x08, 0x41, 0x10, 0x44, 0x12, 0x04, 0x80,
  0xA0, 0x28, 0x0C, 0x03, 0x00, 0x40, 0x80, 0x40, 0x50, 0x30, 0x14, 0x0C,
  0x05, 0x02, 0x82, 0x40, 0xA0, 0x88, 0x28, 0x22, 0x12, 0x08, 0x84, 0x84,
  0x21, 0x11, 0x08, 0x44, 0x41, 0x11, 0x10, 0x48, 0x44, 0x12, 0x0A, 0x04,
  0x82, 0x80, 0xA0, 0xA0, 0x30, 0x28, 0x0C, 0x0A, 0x03, 0x01, 0x00, 0xC0,
  0x40, 0x80, 0xD0, 0x24, 0x10, 0x84, 0x23, 0x08, 0x81, 0x20, 0x50, 0x0C,
  0x02, 0x00, 0xC0, 0x50, 0x12, 0x08, 0x82, 0x11, 0x04, 0x40, 0xA0, 0x28,
  0x0C, 0x40, 0x28, 0x05, 0x01, 0x10, 0x22, 0x04, 0x40, 0x88, 0x20, 0x84,
  0x10, 0x82, 0x10, 0x44, 0x04, 0x80, 0x90, 0x12, 0x02, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x02,
  0x02, 0x40, 0x20, 0x00, 0x7E, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x41, 0x03, 0xF8, 0x01, 0x83, 0x02,
  0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x41, 0xC0, 0xE0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x18, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x18, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x0F, 0x07, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0xC1, 0x00, 0x7C, 0x18, 0x33, 0x80, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 26, 7, 3, -26 },
  { 5, 6, 10, 11, 2, -26 },
  { 13, 14, 26, 15, 1, -26 },
  { 59, 12, 29, 14, 1, -27 },
  { 103, 17, 26, 21, 2, -26 },
  { 159, 13, 26, 14, 1, -26 },
  { 202, 1, 10, 6, 2, -26 },
  { 204, 6, 32, 9, 2, -26 },
  { 228, 7, 32, 9, 1, -26 },
  { 256, 9, 9, 12, 2, -27 },
  { 267, 12, 17, 14, 1, -21 },
  { 293, 3, 9, 6, 1, -4 },
  { 297, 8, 1, 9, 1, -10 },
  { 298, 2, 2, 6, 2, -2 },
  { 299, 10, 26, 12, 1, -26 },
  { 332, 10, 26, 14, 2, -26 },
  { 365, 6, 26, 14, 3, -26 },
  { 385, 11, 26, 14, 1, -26 },
  { 421, 11, 26, 14, 1, -26 },
  { 457, 14, 26, 14, 0, -26 },
  { 503, 11, 26, 14, 2, -26 },
  { 539, 11, 27, 14, 2, -26 },
  { 577, 10, 26, 14, 2, -26 },
  { 610, 12, 26, 14, 1, -26 },
  { 649, 11, 26, 14, 1, -26 },
  { 685, 2, 19, 6, 2, -19 },
  { 690, 3, 24, 6, 1, -19 },
  { 699, 12, 15, 14, 1, -20 },
  { 722, 12, 9, 14, 1, -17 },
  { 736, 12, 15, 14, 1, -20 },
  { 759, 8, 26, 9, 1, -26 },
  { 785, 18, 29, 22, 2, -26 },
  { 851, 14, 26, 14, 0, -26 },
  { 897, 11, 26, 15, 3, -26 },
  { 933, 12, 26, 15, 2, -26 },
  { 972, 12, 26, 17, 3, -26 },
  { 1011, 9, 26, 14, 3, -26 },
  { 1041, 9, 26, 13, 3, -26 },
  { 1071, 15, 26, 19, 2, -26 },
  { 1120, 12, 26, 18, 3, -26 },
  { 1159, 6, 26, 8, 1, -26 },
  { 1179, 6, 32, 7, -2, -26 },
  { 1203, 11, 26, 14, 3, -26 },
  { 1239, 9, 26, 12, 3, -26 },
  { 1269, 18, 26, 23, 3, -26 },
  { 1328, 12, 26, 18, 3, -26 },
  { 1367, 14, 26, 18, 2, -26 },
  { 1413, 10, 26, 14, 3, -26 },
  { 1446, 14, 32, 18, 2, -26 },
  { 1502, 11, 26, 15, 3, -26 },
  { 1538, 10, 26, 14, 2, -26 },
  { 1571, 12, 26, 12, 0, -26 },
  { 1610, 12, 26, 18, 3, -26 },
  { 1649, 13, 26, 13, 0, -26 },
  { 1692, 23, 26, 23, 0, -26 },
  { 1767, 12, 26, 12, 0, -26 },
  { 1806, 11, 26, 11, 0, -26 },
  { 1842, 10, 26, 12, 1, -26 },
  { 1875, 7, 32, 11, 3, -26 },
  { 1903, 10, 26, 12, 1, -26 },
  { 1936, 7, 32, 11, 1, -26 },
  { 1964, 13, 13, 14, 1, -26 },
  { 1986, 14, 1, 14, 0, 3 },
  { 1988, 6, 5, 8, 1, -27 },
  { 1992, 10, 19, 13, 1, -19 },
  { 2016, 11, 27, 15, 3, -27 },
  { 2054, 9, 19, 11, 2, -19 },
  { 2076, 11, 27, 15, 2, -27 },
  { 2114, 10, 19, 14, 2, -19 },
  { 2138, 9, 28, 8, 0, -28 },
  { 2170, 11, 28, 15, 2, -19 },
  { 2209, 9, 27, 15, 3, -27 },
  { 2240, 2, 26, 6, 2, -26 },
  { 2247, 4, 35, 6, 0, -26 },
  { 2265, 8, 27, 12, 3, -27 },
  { 2292, 1, 27, 6, 3, -27 },
  { 2296, 16, 19, 22, 3, -19 },
  { 2334, 9, 19, 15, 3, -19 },
  { 2356, 11, 19, 15, 2, -19 },
  { 2383, 11, 27, 15, 3, -19 },
  { 2421, 11, 27, 15, 2, -19 },
  { 2459, 6, 19, 9, 3, -19 },
  { 2474, 9, 19, 11, 1, -19 },
  { 2496, 6, 24, 8, 1, -24 },
  { 2514, 10, 19, 15, 2, -19 },
  { 2538, 10, 19, 11, 0, -19 },
  { 2562, 18, 19, 18, 0, -19 },
  { 2605, 10, 19, 11, 1, -19 },
  { 2629, 11, 28, 11, 0, -19 },
  { 2668, 7, 19, 9, 1, -19 },
  { 2685, 9, 32, 12, 2, -26 },
  { 2721, 1, 36, 14, 6, -27 },
  { 2726, 9, 32, 12, 2, -26 },
  { 2762, 12, 3, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Thin36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN36PT7B_H_
