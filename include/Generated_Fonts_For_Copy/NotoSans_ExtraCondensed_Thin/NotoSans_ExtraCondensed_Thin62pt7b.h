#ifndef _NOTOSANS_EXTRACONDENSED_THIN62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin62pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x6F, 0xF6, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x00, 0x40, 0x30, 0x00, 0x40,
  0x30, 0x00, 0x40, 0x30, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x20, 0x00, 0xC0,
  0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x20, 0x00, 0x80,
  0x60, 0x00, 0x80, 0x60, 0x00, 0x80, 0x60, 0x00, 0x80, 0x60, 0x3F, 0xFF,
  0xFF, 0x01, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01, 0x80,
  0x40, 0x01, 0x00, 0x40, 0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00,
  0x80, 0x02, 0x00, 0x80, 0x02, 0x00, 0x80, 0xFF, 0xFF, 0xFE, 0x02, 0x01,
  0x80, 0x02, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x01,
  0x00, 0x06, 0x01, 0x00, 0x04, 0x01, 0x00, 0x04, 0x03, 0x00, 0x04, 0x03,
  0x00, 0x04, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x02,
  0x00, 0x0C, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x0E, 0x20, 0xF0, 0xE1,
  0x01, 0x06, 0x08, 0x00, 0x60, 0x40, 0x02, 0x02, 0x00, 0x30, 0x10, 0x01,
  0x80, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x20, 0x03, 0x01, 0x00, 0x18, 0x08,
  0x00, 0xC0, 0x40, 0x02, 0x02, 0x00, 0x18, 0x10, 0x00, 0x60, 0x80, 0x03,
  0x84, 0x00, 0x0E, 0x20, 0x00, 0x1D, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x13, 0x80, 0x00, 0x87, 0x00, 0x04, 0x1C, 0x00,
  0x20, 0x70, 0x01, 0x01, 0x80, 0x08, 0x06, 0x00, 0x40, 0x30, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0xC0, 0x08, 0x06, 0x00, 0x40, 0x60, 0x02, 0x03, 0x30, 0x10, 0x71,
  0xF0, 0x8F, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x18, 0x03, 0x0C, 0x00, 0x40, 0x18, 0x10, 0x03, 0x00,
  0x60, 0x60, 0x0C, 0x01, 0x01, 0x80, 0x20, 0x0C, 0x02, 0x01, 0x80, 0x30,
  0x08, 0x06, 0x00, 0xC0, 0x30, 0x10, 0x03, 0x00, 0xC0, 0xC0, 0x08, 0x03,
  0x03, 0x00, 0x20, 0x0C, 0x08, 0x00, 0x80, 0x30, 0x60, 0x02, 0x00, 0xC1,
  0x80, 0x08, 0x03, 0x04, 0x00, 0x20, 0x0C, 0x30, 0x00, 0x80, 0x30, 0xC0,
  0x02, 0x00, 0xC2, 0x00, 0x0C, 0x03, 0x18, 0x7C, 0x30, 0x08, 0x63, 0x18,
  0xC0, 0x21, 0x08, 0x33, 0x00, 0x8C, 0x60, 0x44, 0x06, 0x31, 0x01, 0x98,
  0x18, 0x8C, 0x06, 0x60, 0x46, 0x30, 0x08, 0xC3, 0x18, 0xC0, 0x21, 0xF8,
  0x42, 0x00, 0x83, 0xC3, 0x08, 0x02, 0x00, 0x0C, 0x20, 0x0C, 0x00, 0x20,
  0x80, 0x30, 0x01, 0x82, 0x00, 0xC0, 0x06, 0x08, 0x03, 0x00, 0x10, 0x20,
  0x0C, 0x00, 0xC0, 0x80, 0x30, 0x03, 0x02, 0x00, 0xC0, 0x08, 0x08, 0x03,
  0x00, 0x60, 0x20, 0x08, 0x01, 0x80, 0xC0, 0x20, 0x04, 0x03, 0x00, 0x80,
  0x10, 0x0C, 0x06, 0x00, 0xC0, 0x10, 0x18, 0x02, 0x00, 0x60, 0x40, 0x08,
  0x01, 0x83, 0x00, 0x60, 0x03, 0x18, 0x01, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x61, 0x80, 0x03, 0x03,
  0x00, 0x08, 0x0C, 0x00, 0x20, 0x10, 0x01, 0x80, 0x40, 0x06, 0x01, 0x00,
  0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x02, 0x01, 0x00, 0x08,
  0x04, 0x00, 0x20, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x02, 0x00, 0x06, 0x18,
  0x00, 0x18, 0x40, 0x00, 0x23, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x68, 0x00, 0x03, 0x30, 0x00, 0x18, 0x60, 0x00, 0xC1,
  0x80, 0x03, 0x03, 0x01, 0x98, 0x04, 0x06, 0x60, 0x18, 0x19, 0x00, 0x20,
  0x4C, 0x00, 0xC1, 0x30, 0x01, 0x04, 0xC0, 0x06, 0x33, 0x00, 0x0C, 0xCC,
  0x00, 0x12, 0x30, 0x00, 0x78, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x10, 0x00, 0x78, 0x60, 0x03, 0x20, 0x80, 0x0C, 0xC3, 0x00, 0x61,
  0x87, 0x07, 0x06, 0x0F, 0xF0, 0x0C, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0xE0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x10, 0x20, 0xDC, 0x47, 0x07, 0xF8, 0x03, 0x80,
  0x05, 0x00, 0x19, 0x00, 0x63, 0x00, 0x82, 0x02, 0x02, 0x0C, 0x02, 0x10,
  0x04, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x18, 0xC6, 0x31, 0x88, 0xC6, 0x31, 0x18, 0xC4, 0x60,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x38, 0x30, 0x06,
  0x03, 0x01, 0x80, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x00, 0x0C, 0x60,
  0x01, 0x8C, 0x00, 0x11, 0x80, 0x03, 0x20, 0x00, 0x64, 0x00, 0x0D, 0x80,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00,
  0x01, 0x60, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00,
  0x05, 0x80, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x06, 0xC0, 0x00, 0xC8, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x08, 0x40, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x08, 0x18, 0x03, 0x03, 0x00, 0x40, 0x30, 0x18, 0x03, 0x8E,
  0x00, 0x3F, 0x80, 0x00, 0xC0, 0xF0, 0x7C, 0x3B, 0x1C, 0xCC, 0x36, 0x0F,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x03, 0xF0,
  0x00, 0xFF, 0xC0, 0x78, 0x07, 0x02, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0xE0, 0x1C, 0x70, 0x01,
  0xC4, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x31, 0x00, 0x0C, 0x38, 0x07, 0x03,
  0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0xD0, 0x00, 0x01,
  0x20, 0x00, 0x06, 0x40, 0x00, 0x08, 0x80, 0x00, 0x31, 0x00, 0x00, 0x42,
  0x00, 0x01, 0x84, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x10, 0x00, 0x10, 0x20,
  0x00, 0x60, 0x40, 0x00, 0x80, 0x80, 0x03, 0x01, 0x00, 0x04, 0x02, 0x00,
  0x18, 0x04, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x30, 0x01, 0x00, 0x60, 0x02, 0x01, 0x80,
  0x04, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x20, 0x60, 0x00,
  0x40, 0xC0, 0x00, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0xFF, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x7F, 0xE0,
  0x7E, 0x0F, 0x04, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x10, 0x01, 0xC3, 0x80, 0xF0, 0x3F, 0xF8, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x0E, 0x02, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x07, 0xE0, 0x63,
  0xFF, 0x0C, 0xC0, 0x71, 0xB0, 0x02, 0x3C, 0x00, 0x67, 0x00, 0x04, 0xE0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x00,
  0x01, 0xA0, 0x00, 0x24, 0x00, 0x04, 0xC0, 0x01, 0x98, 0x00, 0x31, 0x00,
  0x06, 0x30, 0x01, 0x86, 0x00, 0x30, 0x60, 0x0C, 0x06, 0x03, 0x00, 0x7F,
  0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0,
  0x0E, 0x03, 0x01, 0x80, 0x18, 0x10, 0x00, 0xC3, 0x00, 0x04, 0x20, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x02, 0x60, 0x00, 0x26, 0x00,
  0x06, 0x20, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x41, 0x80, 0x0C, 0x18,
  0x01, 0x80, 0xC0, 0x38, 0x06, 0x07, 0x00, 0x38, 0xC0, 0x01, 0xF8, 0x00,
  0x07, 0x00, 0x01, 0xF8, 0x00, 0x30, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0x30,
  0x18, 0x01, 0x83, 0x00, 0x0C, 0x20, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x20,
  0x00, 0x63, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x70, 0x07, 0xFE, 0x00,
  0x06, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x30, 0x18, 0x0C, 0x01, 0x81,
  0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0x23, 0x00, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x34, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xB0,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x01, 0xC8, 0x00, 0x39, 0x80, 0x0F, 0x18,
  0x03, 0x63, 0x80, 0xCC, 0x1F, 0xF1, 0x81, 0xFC, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x10, 0x1C, 0x03, 0xFE,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x18, 0xE3, 0xC6, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x21, 0x86, 0x10, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x81,
  0xFF, 0x8C, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01,
  0xE0, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x1E, 0x01, 0x8C,
  0x01, 0xFE, 0x01, 0x10, 0x07, 0x04, 0x03, 0x60, 0x0C, 0x08, 0x06, 0xC0,
  0x30, 0x10, 0x0D, 0x80, 0x40, 0x20, 0x1A, 0x01, 0x80, 0x40, 0x34, 0x03,
  0x00, 0x80, 0x68, 0x04, 0x03, 0x00, 0x70, 0x08, 0x06, 0x00, 0xE0, 0x30,
  0x0C, 0x01, 0xC0, 0x60, 0x18, 0x03, 0x80, 0xC0, 0x30, 0x07, 0x01, 0x80,
  0x60, 0x0E, 0x03, 0x00, 0xC0, 0x3C, 0x06, 0x01, 0x80, 0x78, 0x0C, 0x03,
  0x00, 0xF0, 0x18, 0x06, 0x01, 0xA0, 0x30, 0x1C, 0x03, 0x40, 0x20, 0x28,
  0x04, 0x80, 0x60, 0x50, 0x19, 0x80, 0xC1, 0xB0, 0x33, 0x00, 0xC2, 0x60,
  0xC6, 0x01, 0xFC, 0x7F, 0x0C, 0x00, 0xF0, 0x7C, 0x08, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x06,
  0x40, 0x00, 0x0C, 0x80, 0x00, 0x11, 0x00, 0x00, 0x23, 0x00, 0x00, 0xC6,
  0x00, 0x01, 0x84, 0x00, 0x03, 0x08, 0x00, 0x04, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x30, 0x20, 0x00, 0x60, 0x40, 0x00, 0x80, 0xC0, 0x01, 0x01, 0x80,
  0x06, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x10, 0x06, 0x00, 0x20, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x04, 0x00, 0x60, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x60, 0x01, 0x00, 0x80, 0x03, 0x03, 0x00,
  0x06, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x08, 0x10, 0x00, 0x18, 0x60, 0x00,
  0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x42, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x98, 0x00, 0x03, 0x30, 0x00, 0x02, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x10, 0xFF, 0xF8, 0x10, 0x07, 0xC2, 0x00,
  0x0C, 0x40, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x01, 0xA0, 0x00, 0x34, 0x00,
  0x06, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00,
  0x0D, 0x00, 0x01, 0xA0, 0x00, 0x34, 0x00, 0x04, 0x80, 0x01, 0x90, 0x00,
  0x62, 0x00, 0x1C, 0x40, 0x0F, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x20, 0x01,
  0xC4, 0x00, 0x0C, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x01, 0x40, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xA0, 0x00, 0x34, 0x00, 0x0C, 0x80, 0x03, 0x90, 0x00, 0xE3, 0xFF, 0xF8,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x70, 0x06, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x02, 0x01, 0xE0, 0x30, 0x03,
  0xFF, 0x00, 0x03, 0x80, 0xFF, 0xF0, 0x04, 0x03, 0xE0, 0x20, 0x03, 0x81,
  0x00, 0x06, 0x08, 0x00, 0x18, 0x40, 0x00, 0x62, 0x00, 0x03, 0x10, 0x00,
  0x0C, 0x80, 0x00, 0x64, 0x00, 0x01, 0x20, 0x00, 0x0D, 0x00, 0x00, 0x68,
  0x00, 0x03, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00,
  0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x19,
  0x00, 0x00, 0xC8, 0x00, 0x04, 0x40, 0x00, 0x62, 0x00, 0x06, 0x10, 0x00,
  0x30, 0x80, 0x07, 0x04, 0x00, 0x70, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x0E, 0x00, 0x78, 0x06, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x1C, 0x00, 0x0C, 0x03, 0xC0, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xF0, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0x86, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x1F, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x03,
  0xBF, 0xC7, 0xC0, 0x80, 0x00, 0xD0, 0x00, 0x32, 0x00, 0x0C, 0x40, 0x01,
  0x88, 0x00, 0x61, 0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0xC0, 0x80, 0x18,
  0x10, 0x06, 0x02, 0x00, 0x80, 0x40, 0x30, 0x08, 0x0C, 0x01, 0x01, 0x80,
  0x20, 0x60, 0x04, 0x08, 0x00, 0x83, 0x00, 0x10, 0xC0, 0x02, 0x18, 0x00,
  0x46, 0x00, 0x08, 0xE0, 0x01, 0x34, 0x00, 0x2C, 0xC0, 0x05, 0x08, 0x00,
  0xE1, 0x80, 0x18, 0x10, 0x02, 0x03, 0x00, 0x40, 0x20, 0x08, 0x06, 0x01,
  0x00, 0x40, 0x20, 0x0C, 0x04, 0x00, 0x80, 0x80, 0x18, 0x10, 0x01, 0x02,
  0x00, 0x30, 0x40, 0x02, 0x08, 0x00, 0x61, 0x00, 0x04, 0x20, 0x00, 0xC4,
  0x00, 0x08, 0x80, 0x01, 0x90, 0x00, 0x12, 0x00, 0x03, 0x40, 0x00, 0x30,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7D, 0x00,
  0x00, 0x00, 0xFB, 0x00, 0x00, 0x01, 0x76, 0x00, 0x00, 0x06, 0xE4, 0x00,
  0x00, 0x0D, 0xCC, 0x00, 0x00, 0x13, 0x98, 0x00, 0x00, 0x67, 0x10, 0x00,
  0x00, 0xCE, 0x20, 0x00, 0x01, 0x9C, 0x60, 0x00, 0x02, 0x38, 0xC0, 0x00,
  0x0C, 0x70, 0x80, 0x00, 0x18, 0xE1, 0x80, 0x00, 0x21, 0xC3, 0x00, 0x00,
  0xC3, 0x82, 0x00, 0x01, 0x87, 0x06, 0x00, 0x02, 0x0E, 0x0C, 0x00, 0x0C,
  0x1C, 0x08, 0x00, 0x18, 0x38, 0x18, 0x00, 0x30, 0x70, 0x30, 0x00, 0x40,
  0xE0, 0x60, 0x01, 0x81, 0xC0, 0x40, 0x03, 0x03, 0x80, 0xC0, 0x04, 0x07,
  0x01, 0x80, 0x18, 0x0E, 0x01, 0x00, 0x30, 0x1C, 0x03, 0x00, 0x40, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x04, 0x03, 0x00, 0xE0, 0x0C, 0x04, 0x01, 0xC0,
  0x18, 0x18, 0x03, 0x80, 0x30, 0x30, 0x07, 0x00, 0x20, 0x60, 0x0E, 0x00,
  0x60, 0x80, 0x1C, 0x00, 0xC3, 0x00, 0x38, 0x00, 0x86, 0x00, 0x70, 0x01,
  0x88, 0x00, 0xE0, 0x03, 0x30, 0x01, 0xC0, 0x02, 0x60, 0x03, 0x80, 0x06,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x30, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x40, 0x00,
  0x1B, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x60, 0x00, 0x31, 0x00, 0x01, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x20, 0x00,
  0xC1, 0x80, 0x06, 0x04, 0x00, 0x30, 0x30, 0x01, 0x80, 0x80, 0x0C, 0x06,
  0x00, 0x60, 0x30, 0x03, 0x00, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x30, 0x02, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x00, 0x40, 0xC0, 0x03, 0x06, 0x00, 0x08, 0x30,
  0x00, 0x61, 0x80, 0x01, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x26, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x30,
  0x00, 0x02, 0x18, 0x00, 0x01, 0x88, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x88, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x0C,
  0x00, 0x78, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0,
  0x40, 0x7C, 0x20, 0x03, 0x90, 0x00, 0xC8, 0x00, 0x34, 0x00, 0x0A, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x68, 0x00, 0x34, 0x00, 0x32, 0x00, 0x71, 0xFF,
  0xF0, 0xFF, 0xC0, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x02,
  0x18, 0x00, 0x01, 0x88, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x40, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x88, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x30, 0x80, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x08, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x38,
  0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0xFF, 0xE0, 0x10, 0x1F, 0x02, 0x00, 0x38, 0x40, 0x03,
  0x08, 0x00, 0x31, 0x00, 0x03, 0x20, 0x00, 0x64, 0x00, 0x0C, 0x80, 0x00,
  0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x68, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x24, 0x00, 0x0C, 0x80, 0x01, 0x90, 0x00, 0x32, 0x00, 0x0C,
  0x40, 0x01, 0x88, 0x00, 0x61, 0x00, 0x38, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0x80, 0xC0, 0x10, 0x08, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x03, 0x01,
  0x00, 0x60, 0x20, 0x06, 0x04, 0x00, 0xC0, 0x80, 0x0C, 0x10, 0x01, 0x82,
  0x00, 0x10, 0x40, 0x03, 0x08, 0x00, 0x21, 0x00, 0x06, 0x20, 0x00, 0xC4,
  0x00, 0x0C, 0x80, 0x01, 0x90, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x30,
  0x01, 0xFC, 0x01, 0xFF, 0xE1, 0xC0, 0x0C, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC8, 0x00,
  0x73, 0x80, 0x78, 0x7F, 0xF8, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0x98, 0x00,
  0x02, 0x60, 0x00, 0x19, 0x80, 0x00, 0x62, 0x00, 0x01, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x70, 0x03, 0x80, 0xF0, 0x3C, 0x00, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x09, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x20, 0xC0, 0x00, 0x40, 0x80, 0x01,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x04, 0x06, 0x00, 0x08, 0x04, 0x00, 0x30,
  0x08, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x20, 0x01, 0x00, 0x40, 0x02,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x08, 0x00, 0x10,
  0x30, 0x00, 0x20, 0x60, 0x00, 0x60, 0x80, 0x00, 0xC1, 0x00, 0x00, 0x86,
  0x00, 0x01, 0x0C, 0x00, 0x03, 0x18, 0x00, 0x06, 0x20, 0x00, 0x04, 0xC0,
  0x00, 0x09, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x40, 0x00, 0x18, 0x00, 0x02, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x20, 0x00,
  0x3C, 0x00, 0x06, 0x20, 0x00, 0x3C, 0x00, 0x04, 0x30, 0x00, 0x24, 0x00,
  0x0C, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x10,
  0x00, 0x66, 0x00, 0x08, 0x18, 0x00, 0x66, 0x00, 0x18, 0x18, 0x00, 0x42,
  0x00, 0x18, 0x18, 0x00, 0xC2, 0x00, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x08, 0x00, 0xC3, 0x00, 0x10, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x0C, 0x00,
  0x81, 0x00, 0x30, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x04, 0x01, 0x81, 0x80,
  0x20, 0x04, 0x01, 0x81, 0x80, 0x20, 0x06, 0x01, 0x81, 0x80, 0x60, 0x06,
  0x01, 0x00, 0x80, 0x60, 0x06, 0x03, 0x00, 0x80, 0x60, 0x02, 0x03, 0x00,
  0xC0, 0x40, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0xC0, 0xC0,
  0x03, 0x02, 0x00, 0x40, 0xC0, 0x03, 0x06, 0x00, 0x40, 0x80, 0x01, 0x06,
  0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x01, 0x84, 0x00, 0x21, 0x80, 0x01, 0x8C, 0x00, 0x21, 0x00, 0x00,
  0x8C, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x33, 0x00, 0x00, 0xC8, 0x00, 0x13, 0x00, 0x00, 0x48, 0x00, 0x12, 0x00,
  0x00, 0x58, 0x00, 0x16, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x64, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x41, 0x80,
  0x18, 0x30, 0x03, 0x02, 0x00, 0x40, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x80,
  0xC0, 0x18, 0x18, 0x03, 0x02, 0x00, 0x20, 0xC0, 0x06, 0x18, 0x00, 0x42,
  0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x80, 0x01, 0xB0,
  0x00, 0x32, 0x00, 0x04, 0x60, 0x01, 0x8C, 0x00, 0x20, 0x80, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x20, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x60, 0x0C,
  0x0C, 0x01, 0x81, 0x00, 0x10, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x04,
  0x60, 0x00, 0xC8, 0x00, 0x1B, 0x00, 0x01, 0x60, 0x00, 0x30, 0xC0, 0x00,
  0x34, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x04, 0x20, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x00, 0x81, 0x00, 0x18, 0x18, 0x01, 0x81, 0x80, 0x10, 0x08,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x40, 0x60, 0x06, 0x06, 0x00,
  0x60, 0x40, 0x02, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x11, 0x80,
  0x01, 0x98, 0x00, 0x19, 0x00, 0x00, 0xB0, 0x00, 0x0B, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0xFF, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x46, 0x00, 0x03, 0x18, 0x00, 0x08, 0x30, 0x00, 0x60, 0xC0,
  0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x00, 0x40, 0x30, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x03, 0xC0, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x07, 0xF8, 0x3E, 0x1C, 0x10, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x0F, 0x01, 0xFF, 0x07, 0x01,
  0x1C, 0x01, 0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x07,
  0x60, 0x05, 0x30, 0x0D, 0x38, 0x19, 0x0F, 0xF1, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC1, 0xFC, 0x0C,
  0x78, 0xE0, 0xCC, 0x03, 0x0D, 0x80, 0x18, 0xD0, 0x00, 0x8F, 0x00, 0x0C,
  0xE0, 0x00, 0x4E, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00,
  0x02, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0, 0x00, 0x6E,
  0x00, 0x06, 0xE0, 0x00, 0x4F, 0x00, 0x0C, 0xD0, 0x00, 0x8D, 0x80, 0x18,
  0xCC, 0x03, 0x0C, 0x60, 0xE0, 0xC3, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xFE,
  0x0F, 0x0C, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x01, 0x03, 0xFE,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0xFE, 0x18, 0x78, 0xE3, 0x1C, 0x06, 0x63, 0x00, 0x6C, 0xC0, 0x07, 0x90,
  0x00, 0x76, 0x00, 0x0E, 0xC0, 0x00, 0xD0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00,
  0x03, 0x60, 0x00, 0xEC, 0x00, 0x1C, 0x80, 0x06, 0x98, 0x00, 0x91, 0x80,
  0x22, 0x18, 0x1C, 0x41, 0xFE, 0x08, 0x0E, 0x00, 0x03, 0xF8, 0x03, 0x8F,
  0x01, 0xC0, 0x60, 0x60, 0x08, 0x30, 0x03, 0x08, 0x00, 0x46, 0x00, 0x19,
  0x80, 0x06, 0x40, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x08, 0x38, 0x0E, 0x03, 0xFE, 0x00, 0x3C,
  0x00, 0x01, 0xFC, 0x0C, 0x20, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x07, 0xFC, 0x3F, 0xF0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x03, 0xF8, 0x21, 0xE3, 0xC4, 0x70, 0x0D, 0x8C, 0x00, 0xB3, 0x00, 0x1E,
  0x40, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x03, 0x40, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x68,
  0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x72, 0x00, 0x16, 0x60, 0x06, 0xC6,
  0x01, 0x98, 0x60, 0x63, 0x07, 0xF8, 0x60, 0x18, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC8, 0x00, 0x30, 0xC0,
  0x0C, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x0F, 0xE1, 0x8E, 0x38, 0xCC, 0x06, 0x6C, 0x01, 0xB4, 0x00, 0xDE, 0x00,
  0x2E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x7F, 0xF0,
  0x00, 0x00, 0x04, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x06, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x83, 0x06, 0x0C, 0x13, 0xE7, 0x80, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30,
  0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0x80, 0xC1, 0x80, 0xC3, 0x00,
  0xC2, 0x00, 0xC7, 0x00, 0xCF, 0x00, 0xCD, 0x80, 0xD9, 0x80, 0xD0, 0x80,
  0xF0, 0xC0, 0xE0, 0x40, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x20, 0xC0, 0x30,
  0xC0, 0x10, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x08, 0xC0, 0x0C, 0xC0, 0x04,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC3, 0xF0, 0x1F, 0xC6, 0x70, 0xC1,
  0xC7, 0x32, 0x03, 0x18, 0x0D, 0xA0, 0x08, 0x80, 0x6D, 0x00, 0x68, 0x01,
  0xF0, 0x01, 0x40, 0x0F, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x08, 0xC3, 0xF8, 0x63, 0x87, 0x33, 0x01,
  0x9B, 0x00, 0x6D, 0x00, 0x17, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xF8, 0x01, 0xE3, 0xC0, 0x70, 0x0C,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x32, 0x00, 0x06,
  0x40, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x40, 0x00, 0x48, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00, 0x63,
  0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0xC0, 0x70, 0x70, 0x07, 0xFC, 0x00,
  0x0C, 0x00, 0xC1, 0xFC, 0x18, 0xF1, 0xC3, 0x30, 0x0C, 0x6C, 0x00, 0xCD,
  0x80, 0x09, 0xA0, 0x01, 0xBC, 0x00, 0x17, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0B, 0x80, 0x03, 0x78, 0x00, 0x6D, 0x00, 0x09, 0xB0,
  0x03, 0x33, 0x00, 0xC6, 0x38, 0x70, 0xC3, 0xFC, 0x18, 0x0C, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x20, 0xE3, 0xC4, 0x30,
  0x19, 0x8C, 0x01, 0xB3, 0x00, 0x1E, 0x60, 0x01, 0xD8, 0x00, 0x3B, 0x00,
  0x07, 0x40, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00,
  0x73, 0x00, 0x16, 0x60, 0x06, 0xC6, 0x01, 0x98, 0x70, 0x63, 0x07, 0xF8,
  0x60, 0x1C, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xC3, 0xFC,
  0x7E, 0xCC, 0x0C, 0x80, 0xD8, 0x0D, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x07, 0xF8, 0x3C, 0x3C, 0xC0, 0x0B, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xA0, 0x03, 0x78, 0x1C,
  0x3F, 0xF0, 0x0E, 0x00, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x61, 0x07,
  0xE0, 0x30, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xA8,
  0x00, 0x56, 0x00, 0x6B, 0x00, 0x24, 0xC0, 0x32, 0x70, 0x71, 0x1F, 0xF0,
  0x81, 0x80, 0x00, 0xC0, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x09, 0x80, 0x06,
  0x60, 0x01, 0x88, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC1, 0x00, 0x20, 0x60, 0x08, 0x18, 0x06, 0x06, 0x01, 0x80, 0x80,
  0x40, 0x30, 0x10, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x40, 0x80, 0x10, 0x20,
  0x06, 0x18, 0x01, 0x86, 0x00, 0x21, 0x80, 0x08, 0x40, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x13, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x01, 0xE0, 0x02, 0x40, 0x07, 0x80,
  0x09, 0x00, 0x1A, 0x00, 0x66, 0x00, 0x48, 0x01, 0x98, 0x01, 0x30, 0x06,
  0x60, 0x0C, 0xC0, 0x10, 0x80, 0x33, 0x00, 0x42, 0x00, 0xC4, 0x03, 0x0C,
  0x02, 0x10, 0x0C, 0x30, 0x08, 0x60, 0x20, 0x40, 0x61, 0x80, 0x81, 0x01,
  0x86, 0x06, 0x06, 0x06, 0x08, 0x18, 0x18, 0x10, 0x20, 0x60, 0x60, 0xC0,
  0xC1, 0x00, 0x83, 0x03, 0x04, 0x02, 0x0C, 0x0C, 0x30, 0x0C, 0x20, 0x10,
  0xC0, 0x30, 0x80, 0x62, 0x00, 0x46, 0x01, 0x88, 0x01, 0x18, 0x06, 0x20,
  0x06, 0x60, 0x09, 0x80, 0x19, 0x00, 0x26, 0x00, 0x64, 0x00, 0xD0, 0x00,
  0xB0, 0x03, 0x40, 0x02, 0xC0, 0x0D, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01,
  0xB0, 0x00, 0xC8, 0x00, 0xC6, 0x00, 0x61, 0x00, 0x60, 0xC0, 0x30, 0x60,
  0x10, 0x18, 0x18, 0x0C, 0x08, 0x03, 0x0C, 0x01, 0x86, 0x00, 0x46, 0x00,
  0x33, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x58, 0x00, 0x64, 0x00, 0x33, 0x00, 0x30, 0x80, 0x18, 0x60, 0x18,
  0x30, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x01, 0x02, 0x00, 0xC3, 0x00, 0x21,
  0x00, 0x19, 0x80, 0x04, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xD0,
  0x00, 0x36, 0x00, 0x09, 0x80, 0x02, 0x60, 0x01, 0x88, 0x00, 0x63, 0x00,
  0x10, 0xC0, 0x04, 0x30, 0x03, 0x04, 0x00, 0xC1, 0x80, 0x20, 0x60, 0x08,
  0x18, 0x06, 0x02, 0x01, 0x80, 0xC0, 0x40, 0x30, 0x10, 0x0C, 0x0C, 0x01,
  0x03, 0x00, 0x60, 0x80, 0x18, 0x20, 0x06, 0x18, 0x00, 0x86, 0x00, 0x31,
  0x00, 0x0C, 0x40, 0x03, 0x30, 0x00, 0x4C, 0x00, 0x1A, 0x00, 0x06, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x7F, 0xF3, 0xFF,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x01, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x0F, 0xC0, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x0B, 0x07, 0x00,
  0xF0, 0x0E, 0x0D, 0x00, 0x1F, 0xC0, 0x00, 0x30, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Thin62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 44, 12, 4, -44 },
  { 23, 10, 16, 18, 4, -44 },
  { 43, 24, 44, 26, 1, -44 },
  { 175, 21, 51, 24, 2, -47 },
  { 309, 30, 46, 35, 3, -45 },
  { 482, 22, 46, 24, 2, -45 },
  { 609, 2, 16, 10, 4, -44 },
  { 613, 11, 54, 16, 3, -44 },
  { 688, 11, 54, 16, 2, -44 },
  { 763, 15, 16, 21, 3, -47 },
  { 793, 21, 28, 25, 2, -36 },
  { 867, 5, 14, 11, 2, -6 },
  { 876, 13, 2, 16, 2, -18 },
  { 880, 3, 4, 11, 4, -4 },
  { 882, 17, 44, 20, 2, -44 },
  { 976, 19, 45, 24, 3, -45 },
  { 1083, 10, 44, 24, 5, -44 },
  { 1138, 20, 45, 24, 2, -45 },
  { 1251, 19, 46, 24, 2, -45 },
  { 1361, 23, 45, 24, 1, -45 },
  { 1491, 19, 45, 24, 3, -44 },
  { 1598, 19, 46, 24, 3, -45 },
  { 1708, 18, 44, 24, 3, -44 },
  { 1807, 20, 46, 24, 2, -45 },
  { 1922, 19, 46, 24, 2, -45 },
  { 2032, 3, 33, 11, 4, -33 },
  { 2045, 6, 41, 11, 2, -33 },
  { 2076, 21, 26, 25, 2, -35 },
  { 2145, 21, 15, 25, 2, -29 },
  { 2185, 21, 26, 25, 2, -35 },
  { 2254, 14, 45, 16, 1, -45 },
  { 2333, 31, 51, 37, 3, -45 },
  { 2531, 23, 44, 23, 0, -44 },
  { 2658, 19, 44, 27, 5, -44 },
  { 2763, 21, 46, 26, 3, -45 },
  { 2884, 21, 44, 29, 5, -44 },
  { 3000, 16, 44, 24, 5, -44 },
  { 3088, 16, 44, 22, 5, -44 },
  { 3176, 26, 46, 32, 3, -45 },
  { 3326, 20, 44, 30, 5, -44 },
  { 3436, 9, 44, 14, 2, -44 },
  { 3486, 10, 55, 12, -3, -44 },
  { 3555, 19, 44, 24, 5, -44 },
  { 3660, 15, 44, 21, 5, -44 },
  { 3743, 31, 44, 40, 5, -44 },
  { 3914, 21, 44, 31, 5, -44 },
  { 4030, 25, 46, 32, 3, -45 },
  { 4174, 17, 44, 24, 5, -44 },
  { 4268, 25, 56, 32, 3, -45 },
  { 4443, 19, 44, 25, 5, -44 },
  { 4548, 18, 46, 24, 3, -45 },
  { 4652, 20, 44, 21, 0, -44 },
  { 4762, 22, 45, 30, 4, -44 },
  { 4886, 23, 44, 23, 0, -44 },
  { 5013, 40, 44, 40, 0, -44 },
  { 5233, 19, 44, 21, 1, -44 },
  { 5338, 20, 44, 20, 0, -44 },
  { 5448, 17, 44, 20, 2, -44 },
  { 5542, 12, 54, 19, 5, -44 },
  { 5623, 17, 44, 20, 2, -44 },
  { 5717, 12, 54, 19, 2, -44 },
  { 5798, 22, 21, 24, 1, -44 },
  { 5856, 24, 1, 24, 0, 6 },
  { 5859, 9, 9, 14, 2, -47 },
  { 5870, 16, 34, 23, 2, -33 },
  { 5938, 20, 48, 26, 4, -47 },
  { 6058, 15, 34, 19, 3, -33 },
  { 6122, 19, 48, 26, 3, -47 },
  { 6236, 18, 34, 24, 3, -33 },
  { 6313, 14, 47, 13, 1, -47 },
  { 6396, 19, 48, 26, 3, -33 },
  { 6510, 17, 47, 25, 4, -47 },
  { 6610, 3, 45, 11, 4, -45 },
  { 6627, 7, 60, 11, 0, -45 },
  { 6680, 16, 47, 20, 4, -47 },
  { 6774, 2, 47, 10, 4, -47 },
  { 6786, 29, 33, 38, 4, -33 },
  { 6906, 17, 33, 25, 4, -33 },
  { 6977, 19, 34, 25, 3, -33 },
  { 7058, 19, 47, 26, 4, -33 },
  { 7170, 19, 47, 26, 3, -33 },
  { 7282, 12, 33, 16, 4, -33 },
  { 7332, 15, 34, 19, 2, -33 },
  { 7396, 11, 42, 13, 1, -41 },
  { 7454, 17, 34, 25, 4, -33 },
  { 7527, 18, 33, 18, 0, -33 },
  { 7602, 30, 33, 32, 1, -33 },
  { 7726, 17, 33, 19, 1, -33 },
  { 7797, 18, 48, 20, 1, -33 },
  { 7905, 13, 33, 16, 2, -33 },
  { 7959, 15, 54, 21, 3, -44 },
  { 8061, 2, 62, 23, 11, -47 },
  { 8077, 15, 54, 21, 3, -44 },
  { 8179, 21, 5, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Thin62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN62PT7B_H_
