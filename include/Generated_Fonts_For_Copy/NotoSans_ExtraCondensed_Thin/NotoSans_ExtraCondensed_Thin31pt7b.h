#ifndef _NOTOSANS_EXTRACONDENSED_THIN31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin31pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x40, 0xF0, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x08, 0x40, 0x88, 0x08, 0x81, 0x08, 0x10, 0x81, 0x08, 0xFF, 0xF1, 0x08,
  0x10, 0x81, 0x08, 0x11, 0x01, 0x10, 0x21, 0x02, 0x10, 0xFF, 0xE2, 0x10,
  0x21, 0x02, 0x10, 0x21, 0x02, 0x20, 0x22, 0x04, 0x20, 0x08, 0x02, 0x01,
  0xF1, 0xA2, 0x48, 0x22, 0x08, 0x82, 0x20, 0x88, 0x22, 0x04, 0x80, 0xA0,
  0x18, 0x03, 0x80, 0x98, 0x22, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x62,
  0x2F, 0xF0, 0x20, 0x08, 0x02, 0x00, 0x38, 0x10, 0x88, 0x41, 0x10, 0x84,
  0x21, 0x08, 0x44, 0x10, 0x88, 0x20, 0x90, 0x42, 0x40, 0x84, 0x99, 0x09,
  0x49, 0x12, 0x8A, 0x29, 0x12, 0x94, 0x22, 0x28, 0x40, 0x90, 0x81, 0x21,
  0x02, 0x42, 0x08, 0x84, 0x11, 0x08, 0x21, 0x10, 0x82, 0x21, 0x03, 0x80,
  0x1C, 0x04, 0x40, 0x88, 0x11, 0x02, 0x20, 0x44, 0x08, 0x81, 0x10, 0x14,
  0x03, 0x00, 0x60, 0x14, 0x04, 0x41, 0x08, 0xA0, 0x94, 0x12, 0x81, 0x50,
  0x12, 0x02, 0x40, 0xA4, 0x14, 0x7C, 0x40, 0xFF, 0x18, 0x88, 0x44, 0x22,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x04, 0x21, 0x04, 0x20,
  0x82, 0xC1, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10,
  0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x08, 0x21, 0x0C, 0x00, 0x08, 0x08,
  0x08, 0xCB, 0x3C, 0x18, 0x24, 0x62, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x43, 0xFF, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x29, 0x24, 0xA0, 0xFC, 0xF0, 0x01, 0x80, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x08, 0x04, 0x00, 0x1F, 0x08, 0x42, 0x09, 0x02, 0x40,
  0x90, 0x24, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14,
  0x05, 0x01, 0x40, 0x90, 0x24, 0x08, 0x82, 0x21, 0x07, 0x80, 0x08, 0xCB,
  0x90, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x7E, 0x10, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x40, 0x3F, 0xF0, 0x7F, 0x20, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x83, 0xC0, 0x0C, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x3F, 0x80, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81, 0x08, 0x10,
  0x82, 0x08, 0x20, 0x84, 0x08, 0x40, 0x88, 0x08, 0xFF, 0xF0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x7F, 0x90, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x1F, 0x80, 0x18, 0x02, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x81, 0x1F, 0x80, 0x1F, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x98, 0x53, 0x30, 0x50, 0x28, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x24, 0x11, 0xF0, 0xFF, 0xC0,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x00, 0x3F, 0x10, 0x24, 0x09, 0x01, 0x40, 0x50, 0x14, 0x09, 0x02,
  0x21, 0x06, 0x80, 0xC0, 0x48, 0x21, 0x10, 0x28, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x05, 0x01, 0x40, 0x8F, 0xC0, 0x3E, 0x10, 0x44, 0x0A, 0x02, 0x80,
  0xA0, 0x28, 0x06, 0x01, 0x80, 0x60, 0x34, 0x0D, 0x05, 0x32, 0x43, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x1F, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x68, 0x00, 0x00, 0x00, 0x00, 0x4A, 0x4A, 0x40, 0x00, 0x40,
  0x60, 0x60, 0x60, 0x60, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x0C, 0x0C, 0x04, 0x06, 0x02,
  0x03, 0x00, 0xF8, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0x21, 0x04, 0x20,
  0x82, 0x08, 0x20, 0x00, 0x00, 0x61, 0x80, 0x07, 0xE0, 0x30, 0x20, 0x80,
  0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x70, 0xC3, 0x21, 0x84, 0x43,
  0x10, 0x86, 0x21, 0x0C, 0x42, 0x18, 0x84, 0x31, 0x08, 0x62, 0x10, 0xC4,
  0x21, 0x88, 0xC5, 0x0B, 0x5A, 0x08, 0x42, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x0C, 0x10, 0x07, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0xA0,
  0x09, 0x00, 0x90, 0x09, 0x01, 0x10, 0x10, 0x81, 0x08, 0x10, 0x82, 0x08,
  0x3F, 0xC2, 0x04, 0x20, 0x44, 0x04, 0x40, 0x44, 0x02, 0x40, 0x24, 0x02,
  0x80, 0x28, 0x01, 0xFF, 0x20, 0x28, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x02, 0x80, 0xA0, 0x4F, 0xE2, 0x06, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x02, 0x81, 0xBF, 0x80, 0x0F, 0xCC, 0x02, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x03, 0xF0, 0xFE,
  0x10, 0x22, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50, 0x0A,
  0x01, 0x40, 0x48, 0x11, 0xFC, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x0F, 0xE1, 0x01, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x1F, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x01, 0x10, 0x10, 0xFF, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x7C, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x80, 0xA0,
  0x28, 0x12, 0x08, 0x82, 0x21, 0x08, 0x42, 0x20, 0x90, 0x24, 0x0B, 0x03,
  0x20, 0xC8, 0x21, 0x08, 0x42, 0x08, 0x82, 0x20, 0x48, 0x12, 0x02, 0x80,
  0xA0, 0x10, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xA0, 0x05, 0xA0, 0x05, 0xA0, 0x05,
  0x90, 0x09, 0x90, 0x09, 0x90, 0x09, 0x88, 0x09, 0x88, 0x11, 0x88, 0x11,
  0x84, 0x11, 0x84, 0x21, 0x84, 0x21, 0x84, 0x21, 0x82, 0x41, 0x82, 0x41,
  0x82, 0x41, 0x81, 0x41, 0x81, 0x81, 0x81, 0x81, 0xC0, 0x38, 0x06, 0x80,
  0xD0, 0x19, 0x03, 0x20, 0x64, 0x0C, 0x41, 0x88, 0x30, 0x86, 0x10, 0xC1,
  0x18, 0x23, 0x04, 0x60, 0x4C, 0x09, 0x80, 0xB0, 0x16, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x40, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x28, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x40, 0x24, 0x02, 0x20, 0x41, 0xF8,
  0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x50, 0xCE, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x00, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x02, 0x40, 0x24, 0x02, 0x20, 0x41, 0xF8, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80,
  0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x33, 0xF0, 0x84, 0x21, 0x08,
  0x22, 0x08, 0x82, 0x20, 0x48, 0x12, 0x02, 0x80, 0xA0, 0x10, 0x1F, 0x98,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01,
  0xBF, 0x80, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x22, 0x0C, 0x3E,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x11, 0x02,
  0x20, 0x84, 0x10, 0x82, 0x08, 0x41, 0x10, 0x22, 0x04, 0x40, 0x88, 0x09,
  0x01, 0x40, 0x28, 0x05, 0x00, 0x60, 0x08, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x40, 0x60, 0x24, 0x06, 0x02, 0x40, 0x60, 0x24, 0x09, 0x02, 0x40,
  0x90, 0x22, 0x09, 0x04, 0x20, 0x90, 0x42, 0x09, 0x04, 0x21, 0x08, 0x41,
  0x10, 0x88, 0x11, 0x08, 0x81, 0x10, 0x88, 0x11, 0x08, 0x81, 0x20, 0x48,
  0x0A, 0x05, 0x00, 0xA0, 0x50, 0x0A, 0x05, 0x00, 0xA0, 0x50, 0x0C, 0x06,
  0x00, 0x40, 0x20, 0x40, 0x48, 0x22, 0x08, 0x82, 0x11, 0x04, 0x41, 0x20,
  0x28, 0x0A, 0x01, 0x00, 0x40, 0x30, 0x0A, 0x02, 0x81, 0x20, 0x44, 0x21,
  0x08, 0x42, 0x09, 0x02, 0x40, 0xA0, 0x10, 0x80, 0x60, 0x24, 0x09, 0x02,
  0x41, 0x08, 0x42, 0x10, 0x88, 0x12, 0x04, 0x81, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0xFF, 0xFC, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x3E, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10,
  0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x0C, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0xC0,
  0x04, 0x01, 0x40, 0x28, 0x09, 0x01, 0x10, 0x42, 0x08, 0x22, 0x04, 0x40,
  0x50, 0x0C, 0xFF, 0xF0, 0x82, 0x08, 0x21, 0x80, 0x08, 0x62, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x1F, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x43,
  0x7D, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x30, 0xB3,
  0x30, 0x2C, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xB0, 0x2A, 0x12, 0x78, 0x0E, 0x11, 0x20, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x1F,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x39, 0x31, 0x48,
  0x34, 0x0D, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05,
  0x01, 0x40, 0x50, 0x32, 0x14, 0x79, 0x0C, 0x19, 0x88, 0x48, 0x14, 0x0A,
  0x06, 0x03, 0x01, 0xFF, 0xC0, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x41,
  0x1F, 0x80, 0x0E, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0xFC, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x0E,
  0x0C, 0x52, 0x0D, 0x01, 0x40, 0x50, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x40, 0x50, 0x14, 0x0C, 0x85, 0x1E, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x09, 0x8C, 0x1C, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x18, 0xB2, 0x60, 0xB0, 0x50, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xE0, 0x0A,
  0xAA, 0xAA, 0xAA, 0xA0, 0x32, 0x00, 0x00, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0xE8, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0xB0, 0xB0, 0xC8,
  0x88, 0x84, 0x84, 0x84, 0x82, 0x82, 0x81, 0xFF, 0xFF, 0xFF, 0x1C, 0x11,
  0x44, 0x9B, 0x0A, 0x16, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0,
  0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x40, 0xC0, 0x81, 0x81, 0x02, 0x0C, 0x59, 0xB0, 0x58, 0x28, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x0E, 0x0C, 0x42, 0x09, 0x02, 0x40, 0x50, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x50, 0x14, 0x08, 0x82, 0x1F, 0x00,
  0x0C, 0x2C, 0xCA, 0x0B, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xB0, 0x2C, 0x0A, 0x84, 0x9E, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x06, 0x04, 0x52, 0x0D, 0x03, 0x40,
  0x50, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x50, 0x14,
  0x0C, 0x85, 0x1E, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x0A, 0xDA, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x80, 0x0C, 0x63, 0x40, 0x80, 0x80, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x02,
  0x02, 0x01, 0x01, 0x01, 0x82, 0xFC, 0x42, 0x10, 0x8F, 0xA1, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x70, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x7D, 0x80,
  0xC0, 0x50, 0x48, 0x24, 0x12, 0x08, 0x88, 0x44, 0x22, 0x11, 0x05, 0x02,
  0x81, 0x40, 0xA0, 0x20, 0x10, 0x81, 0x83, 0x41, 0x82, 0x41, 0x82, 0x41,
  0x82, 0x42, 0x42, 0x42, 0x44, 0x22, 0x44, 0x22, 0x44, 0x22, 0x44, 0x24,
  0x24, 0x14, 0x28, 0x14, 0x28, 0x14, 0x28, 0x14, 0x18, 0x08, 0x10, 0x08,
  0x10, 0x81, 0x42, 0x42, 0x24, 0x24, 0x28, 0x18, 0x10, 0x18, 0x28, 0x24,
  0x24, 0x42, 0x42, 0x81, 0x81, 0x40, 0xA0, 0x50, 0x24, 0x12, 0x11, 0x08,
  0x84, 0x22, 0x12, 0x09, 0x04, 0x81, 0x40, 0xC0, 0x60, 0x30, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x82, 0x80, 0x80, 0xFC, 0x10, 0x82, 0x08,
  0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x3F, 0x0E, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x18, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x80,
  0xC2, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x43, 0x00,
  0x78, 0x61, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 22, 6, 2, -22 },
  { 7, 5, 8, 9, 2, -22 },
  { 12, 12, 22, 13, 1, -22 },
  { 45, 10, 26, 12, 1, -24 },
  { 78, 15, 22, 18, 1, -22 },
  { 120, 11, 22, 12, 1, -22 },
  { 151, 1, 8, 5, 2, -22 },
  { 152, 5, 27, 8, 2, -22 },
  { 169, 6, 27, 8, 1, -22 },
  { 190, 8, 8, 11, 1, -24 },
  { 198, 10, 14, 12, 1, -18 },
  { 216, 3, 7, 5, 1, -3 },
  { 219, 6, 1, 8, 1, -9 },
  { 220, 2, 2, 6, 2, -2 },
  { 221, 9, 22, 10, 1, -22 },
  { 246, 10, 22, 12, 1, -22 },
  { 274, 5, 22, 12, 2, -22 },
  { 288, 10, 22, 12, 1, -22 },
  { 316, 10, 22, 12, 1, -22 },
  { 344, 12, 22, 12, 0, -22 },
  { 377, 10, 22, 12, 1, -22 },
  { 405, 9, 22, 12, 2, -22 },
  { 430, 10, 22, 12, 1, -22 },
  { 458, 10, 22, 12, 1, -22 },
  { 486, 10, 22, 12, 1, -22 },
  { 514, 2, 16, 6, 2, -16 },
  { 518, 3, 20, 5, 1, -16 },
  { 526, 10, 12, 12, 1, -17 },
  { 541, 10, 8, 12, 1, -15 },
  { 551, 10, 12, 12, 1, -17 },
  { 566, 6, 22, 8, 1, -22 },
  { 583, 15, 25, 19, 2, -22 },
  { 630, 12, 22, 12, 0, -22 },
  { 663, 10, 22, 13, 2, -22 },
  { 691, 10, 22, 13, 2, -22 },
  { 719, 11, 22, 15, 2, -22 },
  { 750, 8, 22, 12, 2, -22 },
  { 772, 8, 22, 11, 2, -22 },
  { 794, 12, 22, 16, 2, -22 },
  { 827, 11, 22, 15, 2, -22 },
  { 858, 5, 22, 7, 1, -22 },
  { 872, 4, 27, 6, -1, -22 },
  { 886, 10, 22, 12, 2, -22 },
  { 914, 8, 22, 11, 2, -22 },
  { 936, 16, 22, 20, 2, -22 },
  { 980, 11, 22, 16, 2, -22 },
  { 1011, 12, 22, 16, 2, -22 },
  { 1044, 9, 22, 12, 2, -22 },
  { 1069, 12, 27, 16, 2, -22 },
  { 1110, 10, 22, 13, 2, -22 },
  { 1138, 10, 22, 12, 1, -22 },
  { 1166, 10, 22, 10, 0, -22 },
  { 1194, 11, 22, 15, 2, -22 },
  { 1225, 11, 22, 11, 0, -22 },
  { 1256, 20, 22, 20, 0, -22 },
  { 1311, 10, 22, 10, 0, -22 },
  { 1339, 10, 22, 10, 0, -22 },
  { 1367, 8, 22, 10, 1, -22 },
  { 1389, 5, 27, 9, 3, -22 },
  { 1406, 9, 22, 10, 1, -22 },
  { 1431, 6, 27, 9, 1, -22 },
  { 1452, 11, 10, 12, 1, -22 },
  { 1466, 12, 1, 12, 0, 3 },
  { 1468, 5, 5, 7, 1, -24 },
  { 1472, 8, 17, 11, 1, -17 },
  { 1489, 10, 24, 13, 2, -24 },
  { 1519, 8, 17, 10, 1, -17 },
  { 1536, 10, 24, 13, 1, -24 },
  { 1566, 9, 17, 12, 1, -17 },
  { 1586, 7, 24, 7, 0, -24 },
  { 1607, 10, 25, 13, 1, -17 },
  { 1639, 9, 24, 13, 2, -24 },
  { 1666, 2, 22, 5, 2, -22 },
  { 1672, 4, 30, 5, 0, -22 },
  { 1687, 8, 24, 10, 2, -24 },
  { 1711, 1, 24, 5, 2, -24 },
  { 1714, 15, 17, 19, 2, -17 },
  { 1746, 9, 17, 13, 2, -17 },
  { 1766, 10, 17, 13, 1, -17 },
  { 1788, 10, 24, 13, 2, -17 },
  { 1818, 10, 24, 13, 1, -17 },
  { 1848, 6, 17, 8, 2, -17 },
  { 1861, 8, 17, 10, 1, -17 },
  { 1878, 5, 20, 6, 1, -20 },
  { 1891, 8, 16, 13, 2, -16 },
  { 1907, 9, 16, 9, 0, -16 },
  { 1925, 16, 16, 16, 0, -16 },
  { 1957, 8, 16, 10, 1, -16 },
  { 1973, 9, 24, 10, 0, -16 },
  { 2000, 6, 16, 8, 1, -16 },
  { 2012, 7, 27, 11, 2, -22 },
  { 2036, 1, 32, 12, 5, -24 },
  { 2040, 7, 27, 11, 2, -22 },
  { 2064, 10, 2, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Thin31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN31PT7B_H_
