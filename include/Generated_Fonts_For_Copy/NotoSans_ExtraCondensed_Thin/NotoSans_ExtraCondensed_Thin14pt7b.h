#ifndef _NOTOSANS_EXTRACONDENSED_THIN14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x40, 0xFF, 0x28, 0xA2, 0x9F, 0x49, 0x4F, 0x94, 0x51, 0x40,
  0x23, 0xE9, 0x4A, 0x30, 0xC5, 0x29, 0x7C, 0x40, 0xCA, 0xAB, 0x2C, 0xAF,
  0xD3, 0x4D, 0x55, 0x30, 0x72, 0x94, 0xA2, 0x32, 0x73, 0x8B, 0xC0, 0xF0,
  0x6A, 0xAA, 0xA9, 0xA5, 0x55, 0x5A, 0x5D, 0x50, 0x21, 0x09, 0xF2, 0x10,
  0xE0, 0xE0, 0x80, 0x11, 0x12, 0x22, 0x44, 0x48, 0xE9, 0x99, 0x99, 0x99,
  0x9E, 0x75, 0x55, 0x50, 0xE1, 0x11, 0x12, 0x44, 0x8F, 0xE1, 0x11, 0x62,
  0x11, 0x1E, 0x10, 0x8C, 0x65, 0x2A, 0x5F, 0x10, 0x80, 0xE8, 0x88, 0xE1,
  0x11, 0x1E, 0x68, 0x88, 0xF9, 0x99, 0x9F, 0xF1, 0x22, 0x24, 0x44, 0x48,
  0x74, 0x62, 0x93, 0x2A, 0x31, 0x8B, 0xC0, 0xE9, 0x99, 0x9F, 0x11, 0x2E,
  0x82, 0x83, 0x80, 0x09, 0xB0, 0x83, 0x04, 0xF8, 0x01, 0xF0, 0xC1, 0x06,
  0x32, 0x60, 0xE4, 0x92, 0x92, 0x08, 0x79, 0x0A, 0x4D, 0x5A, 0xB9, 0x72,
  0xD5, 0x95, 0x01, 0xE0, 0x21, 0x14, 0xA5, 0x3D, 0x31, 0x8C, 0x40, 0xF9,
  0x99, 0xE9, 0x99, 0x9F, 0x78, 0x88, 0x88, 0x88, 0x87, 0xF4, 0x63, 0x18,
  0xC6, 0x31, 0x97, 0x00, 0xF8, 0x88, 0xE8, 0x88, 0x8F, 0xF8, 0x88, 0x8F,
  0x88, 0x88, 0x7E, 0x08, 0x20, 0x82, 0x78, 0x61, 0x85, 0xF0, 0x8C, 0x63,
  0x1F, 0xC6, 0x31, 0x8C, 0x40, 0xEA, 0xAA, 0xB0, 0x24, 0x92, 0x49, 0x24,
  0xF0, 0x99, 0xAC, 0xCC, 0xAA, 0x99, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x83,
  0x06, 0x1E, 0x3C, 0x75, 0x6A, 0xD5, 0x93, 0x24, 0x8C, 0x73, 0x9A, 0xD6,
  0x73, 0x8C, 0x40, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x8B, 0x80, 0xE9, 0x99,
  0x9E, 0x88, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x8B, 0x84, 0x30, 0xE9,
  0x99, 0x9E, 0xA9, 0x99, 0xF8, 0x88, 0x42, 0x11, 0x1E, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x00, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8B, 0x80, 0x8C,
  0x63, 0x15, 0x29, 0x4A, 0x21, 0x00, 0x88, 0xC4, 0x62, 0x32, 0x95, 0x52,
  0xA9, 0x54, 0xAA, 0x22, 0x11, 0x00, 0x8A, 0x94, 0xC2, 0x11, 0x4A, 0x94,
  0x40, 0x99, 0x55, 0x62, 0x22, 0x22, 0x71, 0x12, 0x22, 0x44, 0x4F, 0xF2,
  0x49, 0x24, 0x92, 0x70, 0x84, 0x44, 0x22, 0x21, 0x11, 0xE4, 0x92, 0x49,
  0x24, 0xF0, 0x21, 0x94, 0x98, 0x80, 0xFC, 0xA4, 0xC4, 0x9F, 0x6F, 0x88,
  0x8E, 0x99, 0x99, 0x99, 0xF0, 0x72, 0x49, 0x27, 0x11, 0x17, 0x99, 0x99,
  0x99, 0xF0, 0x69, 0x99, 0xE8, 0x8F, 0x29, 0x74, 0x92, 0x49, 0x00, 0x69,
  0x99, 0x99, 0x9F, 0x11, 0xF0, 0x88, 0x8E, 0x99, 0x99, 0x99, 0x90, 0x9F,
  0xC0, 0x41, 0x55, 0x55, 0xC0, 0x92, 0x4B, 0xB6, 0xB6, 0x80, 0xFF, 0xE0,
  0x6D, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0x69, 0x99, 0x99, 0x99, 0x69,
  0x99, 0x99, 0x9F, 0x69, 0x99, 0x99, 0x9F, 0x88, 0x80, 0x69, 0x99, 0x99,
  0x9F, 0x11, 0x10, 0xF2, 0x49, 0x20, 0x78, 0x84, 0x21, 0x1F, 0x5D, 0x24,
  0x92, 0x60, 0x99, 0x99, 0x99, 0xF0, 0x99, 0x96, 0x66, 0x40, 0x93, 0x26,
  0xAB, 0x66, 0xCC, 0x91, 0x00, 0x95, 0x22, 0x65, 0x90, 0x99, 0x55, 0x62,
  0x22, 0x4C, 0x64, 0xA4, 0xB8, 0x69, 0x24, 0xA2, 0x49, 0x30, 0xFF, 0xFC,
  0x89, 0x24, 0x9A, 0x49, 0x60, 0x64, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 2, 4, 4, 1, -10 },
  { 4, 6, 10, 6, 0, -10 },
  { 12, 5, 12, 6, 0, -11 },
  { 20, 6, 10, 8, 1, -10 },
  { 28, 5, 10, 5, 0, -10 },
  { 35, 1, 4, 2, 1, -10 },
  { 36, 2, 12, 4, 1, -10 },
  { 39, 2, 12, 4, 1, -10 },
  { 42, 3, 4, 5, 1, -11 },
  { 44, 5, 6, 6, 0, -8 },
  { 48, 1, 3, 2, 1, -1 },
  { 49, 3, 1, 4, 0, -4 },
  { 50, 1, 1, 3, 1, -1 },
  { 51, 4, 10, 5, 0, -10 },
  { 56, 4, 10, 6, 1, -10 },
  { 61, 2, 10, 6, 1, -10 },
  { 64, 4, 10, 6, 1, -10 },
  { 69, 4, 10, 6, 1, -10 },
  { 74, 5, 10, 6, 0, -10 },
  { 81, 4, 10, 6, 1, -10 },
  { 86, 4, 10, 6, 1, -10 },
  { 91, 4, 10, 6, 1, -10 },
  { 96, 5, 10, 6, 0, -10 },
  { 103, 4, 10, 6, 1, -10 },
  { 108, 1, 7, 3, 1, -7 },
  { 109, 1, 9, 2, 1, -7 },
  { 111, 5, 6, 6, 0, -8 },
  { 115, 5, 4, 6, 0, -7 },
  { 118, 5, 6, 6, 0, -8 },
  { 122, 3, 10, 4, 0, -10 },
  { 126, 7, 11, 8, 1, -10 },
  { 136, 5, 10, 5, 0, -10 },
  { 143, 4, 10, 6, 1, -10 },
  { 148, 4, 10, 6, 1, -10 },
  { 153, 5, 10, 7, 1, -10 },
  { 160, 4, 10, 5, 1, -10 },
  { 165, 4, 10, 5, 1, -10 },
  { 170, 6, 10, 7, 1, -10 },
  { 178, 5, 10, 7, 1, -10 },
  { 185, 2, 10, 3, 1, -10 },
  { 188, 3, 12, 3, -1, -10 },
  { 193, 4, 10, 5, 1, -10 },
  { 198, 4, 10, 5, 1, -10 },
  { 203, 7, 10, 9, 1, -10 },
  { 212, 5, 10, 7, 1, -10 },
  { 219, 5, 10, 7, 1, -10 },
  { 226, 4, 10, 6, 1, -10 },
  { 231, 5, 12, 7, 1, -10 },
  { 239, 4, 10, 6, 1, -10 },
  { 244, 4, 10, 5, 1, -10 },
  { 249, 5, 10, 5, 0, -10 },
  { 256, 5, 10, 7, 1, -10 },
  { 263, 5, 10, 5, 0, -10 },
  { 270, 9, 10, 9, 0, -10 },
  { 282, 5, 10, 5, 0, -10 },
  { 289, 4, 10, 4, 0, -10 },
  { 294, 4, 10, 5, 0, -10 },
  { 299, 3, 12, 4, 1, -10 },
  { 304, 4, 10, 5, 0, -10 },
  { 309, 3, 12, 4, 0, -10 },
  { 314, 5, 5, 6, 0, -10 },
  { 318, 6, 1, 5, 0, 1 },
  { 319, 2, 3, 3, 1, -11 },
  { 320, 3, 8, 5, 1, -8 },
  { 323, 4, 11, 6, 1, -11 },
  { 329, 3, 8, 4, 1, -8 },
  { 332, 4, 11, 6, 1, -11 },
  { 338, 4, 8, 5, 1, -8 },
  { 342, 3, 11, 3, 0, -11 },
  { 347, 4, 11, 6, 1, -8 },
  { 353, 4, 11, 6, 1, -11 },
  { 359, 1, 10, 2, 1, -10 },
  { 361, 2, 13, 2, 0, -10 },
  { 365, 3, 11, 5, 1, -11 },
  { 370, 1, 11, 2, 1, -11 },
  { 372, 7, 8, 9, 1, -8 },
  { 379, 4, 8, 6, 1, -8 },
  { 383, 4, 8, 6, 1, -8 },
  { 387, 4, 11, 6, 1, -8 },
  { 393, 4, 11, 6, 1, -8 },
  { 399, 3, 7, 4, 1, -7 },
  { 402, 4, 8, 4, 0, -8 },
  { 406, 3, 9, 3, 0, -9 },
  { 410, 4, 7, 6, 1, -7 },
  { 414, 4, 7, 4, 0, -7 },
  { 418, 7, 7, 7, 0, -7 },
  { 425, 4, 7, 4, 0, -7 },
  { 429, 4, 10, 4, 0, -7 },
  { 434, 3, 7, 4, 0, -7 },
  { 437, 3, 12, 5, 1, -10 },
  { 442, 1, 14, 5, 2, -11 },
  { 444, 3, 12, 5, 1, -10 },
  { 449, 5, 2, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Thin14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN14PT7B_H_
