#ifndef _NOTOSANS_EXTRACONDENSED_THIN42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFD, 0x55, 0x55, 0x54, 0x01, 0xF0, 0x87, 0x0E, 0x1C,
  0x38, 0x50, 0xA1, 0x42, 0x85, 0x0A, 0x10, 0x02, 0x08, 0x02, 0x08, 0x04,
  0x08, 0x04, 0x08, 0x04, 0x08, 0x04, 0x08, 0x04, 0x08, 0x04, 0x10, 0x04,
  0x10, 0x7F, 0xFF, 0x04, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08,
  0x10, 0x08, 0x10, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x18,
  0x20, 0x10, 0x20, 0x10, 0x20, 0x10, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x10, 0x40, 0x20, 0x40, 0x02, 0x00, 0x08, 0x00, 0x38,
  0x07, 0xBC, 0x32, 0x09, 0x88, 0x04, 0x20, 0x30, 0x80, 0x82, 0x02, 0x08,
  0x08, 0x20, 0x10, 0x80, 0x42, 0x01, 0x88, 0x03, 0x20, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x26, 0x00, 0x84, 0x02, 0x08, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x02, 0x1B, 0x88, 0xC1,
  0xFC, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3C, 0x02, 0x04, 0x20, 0x20,
  0x42, 0x02, 0x08, 0x30, 0x40, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x08,
  0x08, 0x10, 0x80, 0x81, 0x08, 0x08, 0x11, 0x00, 0x81, 0x10, 0x08, 0x11,
  0x00, 0x81, 0x23, 0xC8, 0x12, 0x42, 0xC2, 0x24, 0x24, 0x24, 0x41, 0x42,
  0x48, 0x13, 0xC4, 0x81, 0x00, 0x88, 0x10, 0x08, 0x81, 0x00, 0x88, 0x10,
  0x10, 0x81, 0x01, 0x08, 0x10, 0x10, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x04, 0x10, 0x40, 0x42, 0x04, 0x04, 0x20, 0x40, 0x3C, 0x0F, 0x80,
  0x31, 0x00, 0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0x08,
  0x20, 0x10, 0x40, 0x20, 0x80, 0x22, 0x00, 0x44, 0x00, 0x50, 0x00, 0xC0,
  0x03, 0x80, 0x09, 0x00, 0x21, 0x00, 0x42, 0x09, 0x02, 0x12, 0x04, 0x24,
  0x04, 0x50, 0x08, 0xA0, 0x09, 0x40, 0x0C, 0x80, 0x18, 0x80, 0x31, 0x00,
  0xE3, 0x01, 0x22, 0x04, 0x43, 0xF0, 0x40, 0xFF, 0xE0, 0x02, 0x08, 0x30,
  0x41, 0x02, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x18, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81, 0x03, 0x02, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x80, 0x81, 0x81, 0x03, 0x02, 0x06,
  0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x60, 0x81, 0x06, 0x08, 0x30, 0x41,
  0x02, 0x08, 0x00, 0x04, 0x01, 0x00, 0x40, 0x10, 0xE5, 0xC7, 0x80, 0xC0,
  0x48, 0x11, 0x08, 0x44, 0x08, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x2D, 0xA4, 0xB4, 0x80, 0xFF, 0x80, 0xBC,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x0F, 0x80, 0x82,
  0x08, 0x18, 0x40, 0x44, 0x02, 0x20, 0x09, 0x00, 0x58, 0x02, 0x80, 0x14,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x05, 0x00, 0x28, 0x01, 0x60, 0x09, 0x00, 0x48, 0x02,
  0x40, 0x12, 0x01, 0x08, 0x08, 0x40, 0xC1, 0x04, 0x07, 0xC0, 0x02, 0x1C,
  0x69, 0x96, 0x38, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x3F, 0x86, 0x06, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x7F, 0xFC, 0x3F, 0x8C, 0x0C, 0x80, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x18, 0x1E,
  0x00, 0x18, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x80, 0xCF, 0xF8, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x48,
  0x01, 0x90, 0x02, 0x20, 0x0C, 0x40, 0x10, 0x80, 0x61, 0x00, 0x82, 0x01,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x41, 0x00, 0x82, 0x01,
  0x08, 0x02, 0x10, 0x04, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x7F, 0xE2, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x09, 0xF0, 0x70, 0x60, 0x00, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0xC8, 0x0C, 0x3F, 0xC0, 0x07, 0xE0, 0x60,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x08, 0xFC, 0x48, 0x32, 0x80, 0x98, 0x02, 0xC0,
  0x16, 0x00, 0xA0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x78, 0x03,
  0x40, 0x12, 0x00, 0x90, 0x04, 0x40, 0x43, 0x06, 0x0E, 0xE0, 0x08, 0x00,
  0xFF, 0xF0, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x1F, 0xC1, 0x03,
  0x10, 0x08, 0x80, 0x2C, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x40, 0x12,
  0x00, 0x98, 0x08, 0x60, 0x81, 0x88, 0x07, 0x80, 0x1C, 0x03, 0x30, 0x30,
  0x43, 0x01, 0x10, 0x05, 0x00, 0x28, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x04, 0x80, 0x62, 0x06, 0x0F, 0xE0, 0x1F, 0x82,
  0x0C, 0x40, 0x64, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x34, 0x03, 0x60, 0x53,
  0xF9, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x01, 0x87, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x02,
  0xF0, 0x6D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xB6, 0x92, 0xD2, 0x00,
  0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x00, 0xFE,
  0x41, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40,
  0x20, 0x20, 0x30, 0x10, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0x01, 0x80, 0x00, 0xFE, 0x00,
  0x18, 0x18, 0x01, 0x80, 0x20, 0x10, 0x00, 0x81, 0x80, 0x06, 0x08, 0x00,
  0x10, 0xC0, 0x00, 0x44, 0x00, 0x02, 0x60, 0x18, 0x12, 0x03, 0xF0, 0xD0,
  0x21, 0x82, 0x83, 0x0C, 0x14, 0x10, 0x40, 0xE0, 0x82, 0x07, 0x04, 0x10,
  0x30, 0x40, 0x81, 0x82, 0x04, 0x0C, 0x10, 0x20, 0x60, 0x81, 0x03, 0x04,
  0x08, 0x1C, 0x30, 0x40, 0xE0, 0x86, 0x0D, 0x04, 0x28, 0x48, 0x33, 0x46,
  0x40, 0xF1, 0xE2, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x8E, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x0C, 0x20, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x18, 0x10, 0x10,
  0x08, 0x1F, 0xF8, 0x10, 0x08, 0x30, 0x08, 0x20, 0x0C, 0x20, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x40, 0x06, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80,
  0x02, 0x80, 0x01, 0xFF, 0x84, 0x03, 0x20, 0x0D, 0x00, 0x28, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x05, 0x00, 0x28, 0x02,
  0x40, 0xE3, 0xFE, 0x10, 0x0C, 0x80, 0x14, 0x00, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00,
  0x68, 0x06, 0x7F, 0xC0, 0x03, 0xFC, 0x18, 0x10, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x06, 0x04, 0x0F, 0xF0, 0xFF, 0x01, 0x01,
  0x82, 0x00, 0x84, 0x00, 0x88, 0x01, 0x90, 0x01, 0x20, 0x03, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00, 0x32, 0x00, 0x44,
  0x01, 0x08, 0x0C, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x3F, 0xF4, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xFF, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x01, 0xFF, 0x03, 0x00, 0xC3, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x28, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x40, 0x01, 0x20, 0x00, 0x98,
  0x00, 0x44, 0x00, 0x21, 0x00, 0x10, 0x60, 0x08, 0x1F, 0xF8, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x10, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x23, 0xF0, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x2F, 0x80, 0x80,
  0x1C, 0x01, 0xA0, 0x09, 0x00, 0x88, 0x04, 0x40, 0x42, 0x06, 0x10, 0x20,
  0x82, 0x04, 0x10, 0x21, 0x01, 0x18, 0x08, 0x80, 0x4C, 0x02, 0x60, 0x14,
  0x80, 0xC4, 0x06, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x42, 0x02,
  0x10, 0x08, 0x80, 0x44, 0x01, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x04,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0xFF, 0xC0, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE8,
  0x00, 0x07, 0x40, 0x00, 0x7A, 0x00, 0x02, 0xD8, 0x00, 0x16, 0x40, 0x01,
  0xB2, 0x00, 0x09, 0x90, 0x00, 0x4C, 0x40, 0x02, 0x62, 0x00, 0x23, 0x10,
  0x01, 0x18, 0x40, 0x08, 0xC2, 0x00, 0x86, 0x10, 0x04, 0x30, 0xC0, 0x21,
  0x82, 0x03, 0x0C, 0x10, 0x10, 0x60, 0xC0, 0x83, 0x02, 0x04, 0x18, 0x10,
  0x40, 0xC0, 0x82, 0x06, 0x02, 0x10, 0x30, 0x11, 0x01, 0x80, 0x88, 0x0C,
  0x06, 0x40, 0x60, 0x16, 0x03, 0x00, 0xA0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x04, 0xC0, 0x03, 0x80, 0x06, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x32, 0x00,
  0x64, 0x00, 0xC4, 0x01, 0x88, 0x03, 0x08, 0x06, 0x10, 0x0C, 0x10, 0x18,
  0x20, 0x30, 0x60, 0x60, 0x40, 0xC0, 0x81, 0x80, 0x83, 0x01, 0x06, 0x01,
  0x0C, 0x02, 0x18, 0x06, 0x30, 0x04, 0x60, 0x08, 0xC0, 0x09, 0x80, 0x13,
  0x00, 0x16, 0x00, 0x2C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x07, 0xF0,
  0x06, 0x06, 0x04, 0x01, 0x06, 0x00, 0x42, 0x00, 0x31, 0x00, 0x09, 0x00,
  0x04, 0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80,
  0x02, 0x20, 0x01, 0x10, 0x01, 0x8C, 0x00, 0x83, 0x00, 0xC0, 0xC0, 0xC0,
  0x3F, 0x80, 0xFF, 0x08, 0x1C, 0x80, 0x68, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0x80,
  0x68, 0x0C, 0xFF, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07,
  0xF0, 0x06, 0x06, 0x04, 0x01, 0x06, 0x00, 0x42, 0x00, 0x31, 0x00, 0x09,
  0x00, 0x04, 0x80, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06,
  0x80, 0x02, 0x20, 0x01, 0x10, 0x01, 0x8C, 0x00, 0x83, 0x00, 0x80, 0xC0,
  0xC0, 0x3F, 0x80, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0xFF, 0x04, 0x0E, 0x20, 0x19, 0x00,
  0x48, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x05,
  0x00, 0x28, 0x02, 0x40, 0x12, 0x03, 0x1F, 0xF0, 0x82, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x08, 0x08, 0x40, 0x42, 0x03, 0x10, 0x08, 0x80, 0x64, 0x01,
  0x20, 0x0D, 0x00, 0x28, 0x01, 0x40, 0x04, 0x1F, 0xF1, 0x80, 0x98, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x48, 0x04, 0x7F, 0xC0, 0xFF, 0xFC, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00,
  0x98, 0x02, 0x30, 0x30, 0x7F, 0x80, 0x80, 0x03, 0x00, 0x05, 0x00, 0x0A,
  0x00, 0x34, 0x00, 0x48, 0x00, 0x98, 0x01, 0x10, 0x02, 0x20, 0x08, 0x40,
  0x10, 0x80, 0x20, 0x80, 0x41, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x30, 0x10, 0x40, 0x20, 0x80, 0x21, 0x00, 0x46, 0x00, 0x88, 0x01,
  0x10, 0x02, 0x20, 0x02, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x28, 0x00, 0x80, 0x0D, 0x00, 0x38,
  0x01, 0x20, 0x05, 0x00, 0x24, 0x00, 0xA0, 0x04, 0xC0, 0x14, 0x00, 0x88,
  0x02, 0x80, 0x31, 0x00, 0xD8, 0x04, 0x20, 0x11, 0x00, 0x84, 0x02, 0x20,
  0x10, 0xC0, 0x44, 0x06, 0x08, 0x08, 0x80, 0x81, 0x01, 0x18, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0xC1, 0x04, 0x18, 0x08, 0x20, 0x82,
  0x01, 0x04, 0x18, 0x40, 0x21, 0x01, 0x08, 0x06, 0x20, 0x21, 0x00, 0x44,
  0x04, 0x40, 0x08, 0x80, 0x88, 0x01, 0x10, 0x19, 0x00, 0x24, 0x01, 0x20,
  0x06, 0x80, 0x2C, 0x00, 0x50, 0x05, 0x00, 0x0A, 0x00, 0xA0, 0x01, 0x40,
  0x14, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x20, 0x00, 0x60, 0x09, 0x00,
  0x4C, 0x06, 0x20, 0x21, 0x01, 0x0C, 0x10, 0x20, 0x81, 0x0C, 0x04, 0x40,
  0x22, 0x01, 0x20, 0x05, 0x00, 0x28, 0x01, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x80, 0x34, 0x01, 0x20, 0x08, 0x80, 0x84, 0x04, 0x30, 0x60, 0x82, 0x04,
  0x10, 0x31, 0x00, 0x88, 0x04, 0xC0, 0x34, 0x00, 0xE0, 0x04, 0x80, 0x0E,
  0x00, 0x50, 0x04, 0x80, 0x26, 0x01, 0x10, 0x10, 0x80, 0x86, 0x04, 0x10,
  0x40, 0x82, 0x06, 0x10, 0x11, 0x00, 0x88, 0x06, 0x40, 0x14, 0x00, 0xA0,
  0x07, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x7F,
  0xE0, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x0F, 0xE0, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x01, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xE0, 0x01,
  0x00, 0x07, 0x00, 0x0A, 0x00, 0x32, 0x00, 0x44, 0x01, 0x8C, 0x02, 0x08,
  0x0C, 0x18, 0x10, 0x10, 0x60, 0x30, 0x80, 0x23, 0x00, 0x64, 0x00, 0x58,
  0x00, 0xC0, 0xFF, 0xFF, 0x80, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x04,
  0x0F, 0xE4, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x1C, 0x79, 0x20, 0x50, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xD0, 0x53, 0xF4, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x10, 0x27, 0xF1, 0x60, 0xCA,
  0x02, 0x60, 0x0B, 0x00, 0x58, 0x02, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xF0, 0x05,
  0x80, 0x2C, 0x01, 0x50, 0x12, 0xC1, 0x93, 0xF8, 0x01, 0x03, 0xF1, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x00,
  0xFC, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x10, 0x47, 0xF2, 0x60, 0xD2, 0x02, 0xA0, 0x0D,
  0x00, 0x78, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x06, 0x80, 0x34, 0x01,
  0xB0, 0x14, 0xC1, 0x23, 0xF1, 0x02, 0x01, 0xF8, 0x30, 0x42, 0x02, 0x40,
  0x24, 0x02, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x03, 0x02, 0x0F, 0xE0, 0x07, 0xC3, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x0F, 0xF0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x02, 0x00, 0xFE, 0x4C,
  0x1A, 0xC0, 0x54, 0x01, 0xA0, 0x0F, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1E,
  0x00, 0xD0, 0x06, 0x80, 0x56, 0x02, 0x98, 0x24, 0x7E, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x88, 0x18,
  0x3F, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x42, 0x7E, 0x58, 0x2A, 0x07, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xF0, 0x00,
  0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0xDC, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x0E, 0x02, 0x81, 0x20,
  0xC8, 0x22, 0x10, 0x84, 0x22, 0x09, 0x82, 0x60, 0xA4, 0x29, 0x0C, 0x42,
  0x08, 0x82, 0x20, 0x48, 0x12, 0x06, 0x80, 0xA0, 0x28, 0x06, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x06, 0x02, 0x09, 0xF8, 0xFC, 0xA0, 0x90, 0x6C, 0x05,
  0x02, 0xC0, 0x60, 0x2C, 0x06, 0x03, 0x80, 0x60, 0x18, 0x04, 0x01, 0x80,
  0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18,
  0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01,
  0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40,
  0x10, 0x02, 0x13, 0xB2, 0xC1, 0x50, 0x3C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x02, 0x00, 0xFE,
  0x0C, 0x18, 0xC0, 0x64, 0x01, 0x20, 0x0B, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x90, 0x04, 0x80, 0x22, 0x02, 0x18, 0x30, 0x7F, 0x00, 0x02,
  0x04, 0xFE, 0x2C, 0x19, 0x40, 0x4C, 0x01, 0x60, 0x0B, 0x00, 0x50, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1E, 0x00, 0xB0, 0x05, 0x80, 0x6A, 0x02, 0x58, 0x22, 0x7E,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x02, 0x00, 0xFE, 0x4C, 0x1A, 0x40, 0x54,
  0x01, 0xA0, 0x0F, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1E, 0x00, 0xD0, 0x06,
  0x80, 0x52, 0x02, 0x98, 0x24, 0x7E, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x9F,
  0xB0, 0xA0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x04, 0x0F, 0xF4,
  0x0A, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xA0,
  0x6F, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x3F, 0x90, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0xC0, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xE0, 0x56, 0x1A, 0x7E, 0x40, 0xC0, 0x14,
  0x01, 0x40, 0x24, 0x02, 0x40, 0x22, 0x02, 0x20, 0x62, 0x04, 0x20, 0x43,
  0x04, 0x10, 0xC1, 0x08, 0x10, 0x81, 0x88, 0x09, 0x80, 0x90, 0x09, 0x00,
  0x90, 0x05, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0x30, 0x0A, 0x01, 0x80,
  0x50, 0x0C, 0x06, 0x80, 0xE0, 0x26, 0x05, 0x81, 0x10, 0x24, 0x08, 0x81,
  0x20, 0x44, 0x09, 0x04, 0x20, 0xC8, 0x20, 0x84, 0x61, 0x04, 0x21, 0x08,
  0x21, 0x08, 0xC1, 0x08, 0x44, 0x08, 0x82, 0x20, 0x24, 0x09, 0x01, 0x20,
  0x48, 0x09, 0x02, 0x80, 0x58, 0x14, 0x01, 0x80, 0xA0, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x80, 0xC0, 0x28, 0x0D, 0x81, 0x10, 0x62, 0x08,
  0x21, 0x04, 0x40, 0x48, 0x0A, 0x00, 0xC0, 0x10, 0x03, 0x00, 0xA0, 0x16,
  0x04, 0x40, 0x8C, 0x20, 0x84, 0x11, 0x81, 0x20, 0x2C, 0x03, 0x00, 0x40,
  0x40, 0x0A, 0x00, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x82, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x40, 0x12,
  0x00, 0x90, 0x04, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x1E, 0x00, 0x7F, 0x80, 0xC0, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x06, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x30,
  0x10, 0x08, 0x0C, 0x07, 0xFC, 0x01, 0xC0, 0xC0, 0x40, 0x10, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x0C, 0x0E, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x60, 0x0F, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x06,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x00, 0xC0, 0x1C, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x81, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0xFC,
  0x06, 0x06, 0x34, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 30, 8, 3, -30 },
  { 9, 7, 11, 12, 3, -30 },
  { 19, 16, 30, 18, 1, -30 },
  { 79, 14, 34, 17, 1, -32 },
  { 139, 20, 30, 24, 2, -30 },
  { 214, 15, 30, 16, 1, -30 },
  { 271, 1, 11, 7, 3, -30 },
  { 273, 7, 37, 11, 2, -30 },
  { 306, 7, 37, 11, 2, -30 },
  { 339, 10, 11, 14, 2, -32 },
  { 353, 15, 19, 17, 1, -24 },
  { 389, 3, 9, 7, 2, -4 },
  { 393, 9, 1, 11, 1, -12 },
  { 395, 2, 3, 8, 3, -3 },
  { 396, 12, 30, 14, 1, -30 },
  { 441, 13, 30, 17, 2, -30 },
  { 490, 7, 30, 17, 3, -30 },
  { 517, 13, 30, 17, 2, -30 },
  { 566, 12, 30, 17, 2, -30 },
  { 611, 15, 30, 17, 1, -30 },
  { 668, 13, 30, 17, 2, -30 },
  { 717, 13, 31, 17, 2, -30 },
  { 768, 12, 30, 17, 2, -30 },
  { 813, 13, 30, 17, 2, -30 },
  { 862, 12, 30, 17, 2, -30 },
  { 907, 2, 22, 8, 3, -22 },
  { 913, 3, 27, 7, 2, -22 },
  { 924, 15, 17, 17, 1, -23 },
  { 956, 15, 10, 17, 1, -20 },
  { 975, 15, 17, 17, 1, -23 },
  { 1007, 9, 30, 11, 1, -30 },
  { 1041, 21, 34, 25, 2, -30 },
  { 1131, 16, 30, 16, 0, -30 },
  { 1191, 13, 30, 18, 3, -30 },
  { 1240, 14, 30, 17, 2, -30 },
  { 1293, 15, 30, 20, 3, -30 },
  { 1350, 11, 30, 16, 3, -30 },
  { 1392, 11, 30, 15, 3, -30 },
  { 1434, 17, 30, 22, 2, -30 },
  { 1498, 14, 30, 20, 3, -30 },
  { 1551, 6, 30, 9, 2, -30 },
  { 1574, 7, 37, 8, -2, -30 },
  { 1607, 13, 30, 16, 3, -30 },
  { 1656, 11, 30, 14, 3, -30 },
  { 1698, 21, 30, 27, 3, -30 },
  { 1777, 15, 30, 21, 3, -30 },
  { 1834, 17, 30, 21, 2, -30 },
  { 1898, 12, 30, 17, 3, -30 },
  { 1943, 17, 37, 21, 2, -30 },
  { 2022, 13, 30, 17, 3, -30 },
  { 2071, 13, 30, 16, 2, -30 },
  { 2120, 14, 30, 14, 0, -30 },
  { 2173, 14, 30, 20, 3, -30 },
  { 2226, 15, 30, 15, 0, -30 },
  { 2283, 27, 30, 27, 0, -30 },
  { 2385, 13, 30, 14, 0, -30 },
  { 2434, 13, 30, 13, 0, -30 },
  { 2483, 12, 30, 14, 1, -30 },
  { 2528, 7, 37, 13, 4, -30 },
  { 2561, 12, 30, 14, 1, -30 },
  { 2606, 7, 37, 13, 2, -30 },
  { 2639, 15, 14, 17, 1, -30 },
  { 2666, 17, 1, 16, 0, 4 },
  { 2669, 6, 7, 9, 2, -32 },
  { 2675, 10, 23, 15, 2, -23 },
  { 2704, 13, 32, 18, 3, -32 },
  { 2756, 10, 23, 13, 2, -23 },
  { 2785, 13, 32, 18, 2, -32 },
  { 2837, 12, 23, 16, 2, -23 },
  { 2872, 10, 32, 9, 0, -32 },
  { 2912, 13, 33, 18, 2, -23 },
  { 2966, 11, 32, 17, 3, -32 },
  { 3010, 2, 30, 7, 3, -30 },
  { 3018, 5, 40, 7, 0, -30 },
  { 3043, 10, 32, 14, 3, -32 },
  { 3083, 1, 32, 7, 3, -32 },
  { 3087, 20, 23, 26, 3, -23 },
  { 3145, 11, 23, 17, 3, -23 },
  { 3177, 13, 23, 17, 2, -23 },
  { 3215, 13, 33, 18, 3, -23 },
  { 3269, 13, 33, 18, 2, -23 },
  { 3323, 8, 22, 11, 3, -22 },
  { 3345, 10, 23, 13, 2, -23 },
  { 3374, 7, 28, 9, 1, -28 },
  { 3399, 11, 22, 17, 3, -22 },
  { 3430, 12, 22, 12, 0, -22 },
  { 3463, 21, 22, 22, 0, -22 },
  { 3521, 11, 22, 13, 1, -22 },
  { 3552, 13, 32, 13, 0, -22 },
  { 3604, 9, 22, 11, 1, -22 },
  { 3629, 10, 37, 15, 2, -30 },
  { 3676, 1, 42, 16, 7, -32 },
  { 3682, 10, 37, 15, 2, -30 },
  { 3729, 15, 4, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Thin42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN42PT7B_H_
