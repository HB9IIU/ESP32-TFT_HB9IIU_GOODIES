#ifndef _NOTOSANS_EXTRACONDENSED_THIN56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin56pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x80, 0x00, 0x05, 0xFF, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x00, 0x80, 0x40, 0x02,
  0x03, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x30, 0x01, 0x80, 0x80, 0x06, 0x02,
  0x00, 0x18, 0x08, 0x00, 0x60, 0x20, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00,
  0x10, 0x18, 0x00, 0x40, 0x60, 0x7F, 0xFF, 0xFC, 0x0C, 0x06, 0x00, 0x30,
  0x10, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x10,
  0x00, 0x80, 0x40, 0x02, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x60, 0x30, 0x01,
  0x80, 0x80, 0x06, 0x02, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x01, 0x00,
  0x80, 0x04, 0x02, 0x00, 0x10, 0x18, 0x00, 0x40, 0x60, 0x03, 0x01, 0x80,
  0x0C, 0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00, 0x08,
  0x04, 0x00, 0x20, 0x30, 0x00, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x0F, 0xFE, 0x07, 0x21, 0xE3,
  0x08, 0x11, 0x82, 0x00, 0x40, 0x80, 0x30, 0x20, 0x0C, 0x08, 0x02, 0x02,
  0x00, 0x80, 0x80, 0x20, 0x20, 0x08, 0x08, 0x03, 0x02, 0x00, 0xC0, 0x80,
  0x18, 0x20, 0x06, 0x08, 0x00, 0xE2, 0x00, 0x1C, 0x80, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x9C, 0x00, 0x23, 0x80, 0x08, 0x30, 0x02,
  0x06, 0x00, 0x80, 0x80, 0x20, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x00, 0x80, 0xC0, 0x20, 0x68,
  0x08, 0x33, 0x82, 0x18, 0x7F, 0xFC, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x02,
  0x01, 0x84, 0x00, 0xC0, 0x20, 0xC0, 0x10, 0x04, 0x08, 0x02, 0x01, 0x81,
  0x80, 0xC0, 0x20, 0x30, 0x10, 0x04, 0x02, 0x02, 0x00, 0x80, 0x40, 0xC0,
  0x10, 0x08, 0x10, 0x02, 0x01, 0x02, 0x00, 0x40, 0x20, 0xC0, 0x08, 0x04,
  0x18, 0x01, 0x00, 0x82, 0x00, 0x20, 0x10, 0xC0, 0x04, 0x02, 0x18, 0x00,
  0x80, 0x42, 0x04, 0x10, 0x08, 0xC7, 0xE2, 0x01, 0x18, 0x86, 0x40, 0x62,
  0x30, 0x4C, 0x0C, 0xC4, 0x08, 0x81, 0x19, 0x81, 0x98, 0x62, 0x30, 0x13,
  0x08, 0xC4, 0x02, 0x3F, 0x18, 0x80, 0x41, 0x02, 0x10, 0x08, 0x00, 0x42,
  0x01, 0x00, 0x18, 0x40, 0x20, 0x02, 0x08, 0x06, 0x00, 0x41, 0x00, 0xC0,
  0x18, 0x20, 0x10, 0x02, 0x04, 0x02, 0x00, 0x40, 0x80, 0x40, 0x18, 0x10,
  0x08, 0x02, 0x02, 0x01, 0x00, 0x40, 0x60, 0x20, 0x18, 0x0C, 0x0C, 0x02,
  0x00, 0x81, 0x00, 0x40, 0x18, 0x20, 0x18, 0x01, 0x08, 0x02, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x80, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x0C, 0x30, 0x00,
  0x81, 0x00, 0x18, 0x10, 0x01, 0x01, 0x80, 0x10, 0x18, 0x01, 0x00, 0x80,
  0x10, 0x08, 0x01, 0x00, 0x80, 0x10, 0x18, 0x01, 0x01, 0x80, 0x18, 0x18,
  0x00, 0x81, 0x00, 0x08, 0x30, 0x00, 0xC2, 0x00, 0x04, 0x60, 0x00, 0x6C,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x98, 0x00, 0x10,
  0x80, 0x03, 0x0C, 0x02, 0x60, 0x40, 0x44, 0x02, 0x04, 0xC0, 0x30, 0x4C,
  0x01, 0x04, 0x80, 0x18, 0x48, 0x00, 0x8C, 0x80, 0x0C, 0xC8, 0x00, 0x48,
  0x80, 0x07, 0x88, 0x00, 0x30, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x40, 0x06,
  0x86, 0x00, 0xCC, 0x20, 0x18, 0x43, 0x83, 0x06, 0x0F, 0xE0, 0x30, 0x10,
  0x00, 0xFF, 0xFC, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30,
  0x18, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x02, 0x00, 0x80, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0,
  0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x41, 0x05, 0xC9,
  0xC3, 0xF8, 0x02, 0x00, 0x28, 0x02, 0x20, 0x31, 0x83, 0x06, 0x10, 0x11,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x01, 0xFF, 0xFF, 0xC0,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x18, 0xC4, 0x23, 0x18, 0xC4, 0x63, 0x10, 0x8C,
  0x00, 0xFF, 0xFF, 0xFF, 0xDB, 0xE0, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x07, 0xF0, 0x0C, 0x18, 0x18, 0x08, 0x30, 0x0C,
  0x20, 0x04, 0x60, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02,
  0x20, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x18, 0x08, 0x0C, 0x38, 0x07, 0xE0,
  0x00, 0x81, 0xC1, 0xA1, 0x91, 0x89, 0x85, 0x83, 0x81, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x0F,
  0xF8, 0x0E, 0x07, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0x00, 0x0F, 0xF8, 0x0C, 0x07, 0x1C, 0x00, 0xC4, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1A, 0x00, 0x19,
  0xC0, 0x38, 0x3F, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00,
  0x48, 0x00, 0x06, 0x40, 0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x10, 0x80,
  0x01, 0x84, 0x00, 0x08, 0x20, 0x00, 0xC1, 0x00, 0x04, 0x08, 0x00, 0x60,
  0x40, 0x02, 0x02, 0x00, 0x30, 0x10, 0x01, 0x00, 0x80, 0x18, 0x04, 0x00,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x06, 0x00, 0x40, 0x20, 0x02,
  0x03, 0x00, 0x10, 0x10, 0x00, 0x81, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x7F,
  0xFF, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x7F, 0xFE, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xCF, 0xC0, 0x7F, 0xF8, 0x10, 0x07, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC4, 0x00,
  0xE3, 0x01, 0xC0, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x01, 0xFE, 0x03, 0x81,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x87, 0xF0, 0x4E, 0x0E, 0x24, 0x01,
  0x14, 0x00, 0xCA, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x02, 0xC0,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x05, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0x42, 0x00, 0x61, 0x80, 0x20, 0x60, 0x70, 0x1F, 0xF0, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x07, 0xF8, 0x03, 0x03, 0x81, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01,
  0x18, 0x00, 0x66, 0x00, 0x19, 0x80, 0x02, 0x40, 0x00, 0x98, 0x00, 0x26,
  0x00, 0x19, 0x80, 0x06, 0x20, 0x01, 0x0C, 0x00, 0xC1, 0x80, 0x60, 0x30,
  0x30, 0x06, 0x18, 0x00, 0xCC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x06, 0x38,
  0x03, 0x03, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x64,
  0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x09, 0x80, 0x06, 0x20, 0x01,
  0x0C, 0x00, 0xC1, 0xC0, 0xE0, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x03, 0xF8, 0x03, 0x06, 0x02, 0x00, 0x83, 0x00, 0x61, 0x00, 0x11, 0x80,
  0x0C, 0x80, 0x02, 0x40, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00,
  0xD0, 0x00, 0x68, 0x00, 0x36, 0x00, 0x29, 0x00, 0x14, 0xC0, 0x12, 0x30,
  0x1B, 0x0F, 0xF1, 0x80, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x40, 0xE0, 0x3F,
  0xC0, 0x07, 0x00, 0x00, 0xDB, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x6F, 0x80, 0x31, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4,
  0x63, 0x10, 0x8C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x07, 0xF8, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x10,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x08, 0x10, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x62, 0x00, 0x38, 0x06, 0x60, 0x0F, 0xE0,
  0x26, 0x01, 0x82, 0x02, 0x40, 0x30, 0x20, 0x24, 0x06, 0x06, 0x03, 0xC0,
  0x60, 0x60, 0x3C, 0x04, 0x06, 0x03, 0xC0, 0x40, 0x60, 0x3C, 0x0C, 0x06,
  0x03, 0xC0, 0xC0, 0x60, 0x3C, 0x0C, 0x06, 0x03, 0xC0, 0xC0, 0x60, 0x3C,
  0x08, 0x06, 0x03, 0xC0, 0x80, 0x60, 0x3C, 0x0C, 0x06, 0x03, 0xC0, 0xC0,
  0x60, 0x3C, 0x0C, 0x0E, 0x02, 0xC0, 0xC0, 0xA0, 0x2C, 0x04, 0x0A, 0x06,
  0xC0, 0x61, 0xA0, 0x44, 0x06, 0x13, 0x0C, 0x40, 0x3F, 0x1F, 0x86, 0x00,
  0xC0, 0x60, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x10, 0x00, 0x1E, 0x1F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x14,
  0x00, 0x00, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0x64, 0x00, 0x02, 0x20, 0x00,
  0x11, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x41, 0x00, 0x02, 0x08,
  0x00, 0x10, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x08, 0x00, 0x40, 0x40, 0x02,
  0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x20, 0x00, 0x81, 0x00, 0x04, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x86, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xFF, 0xF0, 0x30, 0x3F, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0xC0,
  0x01, 0x30, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00,
  0x2C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x4C, 0x00, 0x13,
  0x00, 0x0C, 0xC0, 0x06, 0x30, 0x03, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xC0,
  0x0E, 0x30, 0x00, 0xCC, 0x00, 0x13, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x03, 0x30, 0x01, 0x8C, 0x07, 0xC3, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x1F,
  0xF8, 0x0E, 0x03, 0x83, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0xFF, 0xC0, 0x01, 0xC0,
  0xFF, 0xC0, 0x18, 0x1F, 0x03, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x31,
  0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x0B,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xB0,
  0x00, 0x16, 0x00, 0x06, 0xC0, 0x00, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60,
  0x01, 0x8C, 0x00, 0x61, 0x80, 0x38, 0x30, 0x7E, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF, 0xF7, 0xFF,
  0xEC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xB0, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xE0, 0x07,
  0x00, 0x78, 0x18, 0x00, 0x20, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x58, 0x00, 0x00, 0xB0, 0x00,
  0x01, 0x20, 0x00, 0x02, 0x60, 0x00, 0x04, 0x40, 0x00, 0x08, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x20, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x80, 0xE0, 0x0F,
  0x00, 0x7F, 0xF8, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x06, 0x06, 0xFE, 0x1E, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00,
  0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x43, 0x00, 0x61, 0x80, 0x20, 0xC0,
  0x30, 0x60, 0x30, 0x30, 0x10, 0x18, 0x18, 0x0C, 0x08, 0x06, 0x0C, 0x03,
  0x0C, 0x01, 0x84, 0x00, 0xC6, 0x00, 0x62, 0x00, 0x33, 0x80, 0x1B, 0x40,
  0x0D, 0x30, 0x07, 0x88, 0x03, 0x86, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x60,
  0x60, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0x61,
  0x80, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0x36, 0x00, 0x1B, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x05, 0xF0, 0x00, 0x00, 0x5D, 0x00,
  0x00, 0x0D, 0xD0, 0x00, 0x00, 0x9D, 0x80, 0x00, 0x09, 0xC8, 0x00, 0x01,
  0x9C, 0x80, 0x00, 0x19, 0xCC, 0x00, 0x01, 0x1C, 0x40, 0x00, 0x31, 0xC4,
  0x00, 0x03, 0x1C, 0x60, 0x00, 0x21, 0xC6, 0x00, 0x02, 0x1C, 0x20, 0x00,
  0x61, 0xC3, 0x00, 0x04, 0x1C, 0x30, 0x00, 0x41, 0xC1, 0x00, 0x0C, 0x1C,
  0x10, 0x00, 0xC1, 0xC1, 0x80, 0x08, 0x1C, 0x08, 0x01, 0x81, 0xC0, 0x80,
  0x18, 0x1C, 0x0C, 0x01, 0x01, 0xC0, 0xC0, 0x30, 0x1C, 0x04, 0x03, 0x01,
  0xC0, 0x60, 0x20, 0x1C, 0x06, 0x02, 0x01, 0xC0, 0x20, 0x60, 0x1C, 0x02,
  0x06, 0x01, 0xC0, 0x30, 0x40, 0x1C, 0x01, 0x0C, 0x01, 0xC0, 0x10, 0xC0,
  0x1C, 0x01, 0x88, 0x01, 0xC0, 0x19, 0x80, 0x1C, 0x00, 0x98, 0x01, 0xC0,
  0x0D, 0x00, 0x1C, 0x00, 0xD0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xD0,
  0x00, 0x3D, 0x80, 0x03, 0xD8, 0x00, 0x3C, 0x80, 0x03, 0xCC, 0x00, 0x3C,
  0x40, 0x03, 0xC6, 0x00, 0x3C, 0x20, 0x03, 0xC3, 0x00, 0x3C, 0x10, 0x03,
  0xC1, 0x80, 0x3C, 0x18, 0x03, 0xC0, 0x80, 0x3C, 0x0C, 0x03, 0xC0, 0x40,
  0x3C, 0x06, 0x03, 0xC0, 0x20, 0x3C, 0x03, 0x03, 0xC0, 0x10, 0x3C, 0x01,
  0x03, 0xC0, 0x18, 0x3C, 0x00, 0x83, 0xC0, 0x0C, 0x3C, 0x00, 0x43, 0xC0,
  0x06, 0x3C, 0x00, 0x23, 0xC0, 0x03, 0x3C, 0x00, 0x33, 0xC0, 0x01, 0x3C,
  0x00, 0x1B, 0xC0, 0x00, 0x9C, 0x00, 0x0D, 0xC0, 0x00, 0x5C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x1C,
  0x06, 0x00, 0x70, 0x06, 0x00, 0x80, 0x06, 0x03, 0x00, 0x06, 0x0C, 0x00,
  0x04, 0x18, 0x00, 0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x11, 0x80, 0x00,
  0x32, 0x00, 0x00, 0x64, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xB0, 0x00, 0x01,
  0x60, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x01, 0x90, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x08, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0x81, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x80, 0x30, 0x03, 0x80, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0xC1, 0xF0, 0xC0, 0x1C,
  0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x18,
  0xFF, 0xF0, 0xFF, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0x06, 0x00, 0x70,
  0x06, 0x00, 0x80, 0x06, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x18, 0x00,
  0x0C, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x11, 0x80, 0x00, 0x32, 0x00, 0x00,
  0x64, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x02,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x90, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x08, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x81, 0x80, 0x03,
  0x01, 0x80, 0x0C, 0x03, 0x80, 0x30, 0x03, 0x80, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0xFF, 0xC0, 0x30, 0xFC, 0x0C, 0x01, 0xC3,
  0x00, 0x18, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x04, 0xC0,
  0x01, 0x30, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01, 0x30, 0x00,
  0x4C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00, 0xC3,
  0x00, 0x60, 0xC1, 0xF0, 0x3F, 0xF0, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0x40, 0x30, 0x18, 0x0C, 0x02, 0x03, 0x00, 0xC0, 0xC0, 0x10, 0x30, 0x06,
  0x0C, 0x00, 0x83, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x08, 0xC0, 0x03, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x03, 0x00,
  0x70, 0x03, 0xFF, 0x83, 0x80, 0xE3, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x19, 0xC0, 0x38,
  0x7F, 0xF8, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0x30, 0x00,
  0x63, 0x00, 0x08, 0x70, 0x03, 0x07, 0x01, 0xC0, 0x3F, 0xE0, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x64,
  0x00, 0x02, 0x30, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x20, 0x00,
  0x61, 0x80, 0x02, 0x0C, 0x00, 0x10, 0x20, 0x01, 0x81, 0x00, 0x0C, 0x0C,
  0x00, 0x40, 0x60, 0x02, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x40, 0x30, 0x02, 0x01, 0x00, 0x18,
  0x08, 0x00, 0xC0, 0x40, 0x02, 0x06, 0x00, 0x10, 0x30, 0x00, 0xC1, 0x00,
  0x06, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x86, 0x00, 0x04, 0x20, 0x00, 0x31,
  0x00, 0x00, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x24, 0x00, 0x01, 0xA0, 0x00,
  0x0D, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x34, 0x00, 0x06, 0x00, 0x03, 0x40, 0x00, 0x60, 0x00, 0x26,
  0x00, 0x06, 0x00, 0x02, 0x60, 0x00, 0xF0, 0x00, 0x66, 0x00, 0x0F, 0x00,
  0x06, 0x20, 0x00, 0xD0, 0x00, 0x62, 0x00, 0x09, 0x00, 0x04, 0x30, 0x00,
  0x90, 0x00, 0x43, 0x00, 0x19, 0x80, 0x0C, 0x10, 0x01, 0x98, 0x00, 0xC1,
  0x00, 0x18, 0x80, 0x08, 0x10, 0x01, 0x08, 0x00, 0x81, 0x80, 0x10, 0x80,
  0x18, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x80, 0x30, 0xC0, 0x18, 0x08, 0x03,
  0x0C, 0x01, 0x00, 0xC0, 0x20, 0x40, 0x10, 0x0C, 0x02, 0x04, 0x03, 0x00,
  0xC0, 0x60, 0x60, 0x30, 0x04, 0x06, 0x06, 0x02, 0x00, 0x40, 0x60, 0x60,
  0x20, 0x06, 0x04, 0x02, 0x02, 0x00, 0x60, 0x40, 0x20, 0x60, 0x06, 0x0C,
  0x03, 0x06, 0x00, 0x20, 0xC0, 0x30, 0x40, 0x02, 0x0C, 0x03, 0x04, 0x00,
  0x30, 0x80, 0x10, 0xC0, 0x03, 0x08, 0x01, 0x0C, 0x00, 0x11, 0x80, 0x18,
  0x80, 0x01, 0x18, 0x01, 0x88, 0x00, 0x19, 0x80, 0x18, 0x80, 0x01, 0x90,
  0x00, 0x98, 0x00, 0x19, 0x00, 0x09, 0x80, 0x00, 0x90, 0x00, 0xD0, 0x00,
  0x0B, 0x00, 0x0D, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x60, 0x01,
  0xB0, 0x00, 0x88, 0x00, 0xC6, 0x00, 0x61, 0x00, 0x20, 0x80, 0x30, 0x60,
  0x10, 0x10, 0x08, 0x0C, 0x0C, 0x06, 0x04, 0x01, 0x06, 0x00, 0xC3, 0x00,
  0x61, 0x00, 0x11, 0x80, 0x0C, 0x80, 0x02, 0x40, 0x01, 0x60, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x05, 0x80, 0x06,
  0x40, 0x02, 0x30, 0x03, 0x18, 0x01, 0x04, 0x00, 0x83, 0x00, 0xC1, 0x80,
  0x40, 0x40, 0x60, 0x30, 0x20, 0x18, 0x10, 0x04, 0x18, 0x03, 0x08, 0x00,
  0x8C, 0x00, 0x46, 0x00, 0x32, 0x00, 0x0B, 0x00, 0x05, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x24, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x08, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x08, 0x10, 0x06, 0x06, 0x01, 0x81, 0x80, 0x40,
  0x20, 0x30, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0x41, 0x80, 0x18, 0x60, 0x06,
  0x10, 0x00, 0x8C, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x01, 0x60, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xC0, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x07,
  0x00, 0x00, 0x50, 0x00, 0x0D, 0x80, 0x00, 0x88, 0x00, 0x18, 0xC0, 0x01,
  0x04, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x18, 0x18, 0x01, 0x81, 0x80, 0x08, 0x30, 0x00, 0xC3, 0x00, 0x04,
  0x60, 0x00, 0x66, 0x00, 0x02, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x07,
  0xE0, 0x7C, 0xE0, 0x80, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x0F, 0xC1, 0xF9, 0x8E, 0x03, 0x30, 0x06, 0xC0, 0x0D, 0x80, 0x1A, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1D,
  0x00, 0x3B, 0x00, 0xB3, 0x03, 0x63, 0xFC, 0xC0, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x1F, 0x82, 0x3C, 0xE1, 0x30, 0x18, 0x90, 0x06, 0x50, 0x01,
  0xA8, 0x00, 0xD8, 0x00, 0x2C, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x17, 0x00, 0x1A, 0x80, 0x0D, 0x60, 0x0C, 0x98,
  0x06, 0x46, 0x0E, 0x21, 0xFC, 0x00, 0x10, 0x00, 0x03, 0xF8, 0x78, 0xC7,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x83, 0xFC, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x3F, 0x0C, 0x38, 0xE6, 0x30, 0x1B, 0x30, 0x05, 0xB0,
  0x01, 0xD8, 0x00, 0xE8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x15, 0x80, 0x0A, 0x40, 0x09,
  0x30, 0x0C, 0x8C, 0x0C, 0x43, 0xFC, 0x20, 0x20, 0x00, 0x07, 0xE0, 0x0E,
  0x70, 0x18, 0x18, 0x30, 0x0C, 0x60, 0x04, 0x60, 0x06, 0x40, 0x02, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x02, 0x1C, 0x0E, 0x07, 0xF8, 0x00, 0x40, 0x01,
  0xE0, 0x7F, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xF8, 0xFF, 0x81, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x00, 0x07, 0xE0, 0x87, 0x3C, 0x46, 0x03, 0x26, 0x00,
  0xB6, 0x00, 0x3B, 0x00, 0x1D, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x40, 0x03, 0xB0, 0x01, 0xC8,
  0x01, 0x66, 0x01, 0xB1, 0x81, 0x98, 0x7F, 0x8C, 0x06, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x80, 0x0C, 0x70, 0x0C, 0x0F, 0xFC, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x7C, 0x23, 0xDE, 0x4C, 0x0C, 0x90, 0x0D, 0x40, 0x0A,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x5B,
  0xE0, 0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xC0, 0x04, 0x30, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x82, 0x1B, 0xC4, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x68, 0x01, 0x20,
  0x0C, 0x80, 0x22, 0x01, 0x88, 0x0C, 0x20, 0x20, 0x81, 0x82, 0x04, 0x08,
  0x30, 0x21, 0x80, 0x84, 0x02, 0x38, 0x09, 0xA0, 0x24, 0x80, 0xB3, 0x02,
  0x84, 0x0C, 0x18, 0x30, 0x20, 0x80, 0xC2, 0x03, 0x08, 0x04, 0x20, 0x18,
  0x80, 0x22, 0x00, 0xC8, 0x03, 0x20, 0x04, 0x80, 0x1A, 0x00, 0x28, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x87, 0xC0, 0x7E, 0x23, 0x1C,
  0x39, 0xC9, 0x01, 0x18, 0x1A, 0xC0, 0x64, 0x02, 0xA0, 0x0A, 0x00, 0xF0,
  0x02, 0x80, 0x3C, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x83, 0xE1, 0x1C,
  0x72, 0x60, 0x34, 0x80, 0x6A, 0x00, 0x54, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x07, 0xE0, 0x07, 0x3C, 0x06, 0x03,
  0x06, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x19, 0x00, 0x0D, 0x80, 0x02, 0xC0,
  0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x05, 0x80, 0x02, 0x40, 0x03, 0x30,
  0x01, 0x08, 0x01, 0x86, 0x00, 0x81, 0xC1, 0xC0, 0x7F, 0x80, 0x03, 0x00,
  0x83, 0xF0, 0x47, 0x9C, 0x26, 0x03, 0x12, 0x00, 0xCB, 0x00, 0x25, 0x00,
  0x1B, 0x80, 0x05, 0x80, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x05, 0x80, 0x02, 0xA0, 0x03, 0x50, 0x01, 0x2C, 0x01, 0x93, 0x00, 0x88,
  0xC1, 0xC4, 0x3F, 0x82, 0x06, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x07, 0xE0, 0x87, 0xBC,
  0x46, 0x03, 0x26, 0x00, 0xB2, 0x00, 0x3B, 0x00, 0x1D, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x40,
  0x03, 0xB0, 0x01, 0xC8, 0x01, 0x66, 0x01, 0xB1, 0xC1, 0x98, 0x7F, 0x8C,
  0x02, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x83, 0xE3, 0xF9, 0x82, 0x40, 0xB0, 0x28, 0x0A,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0xE0, 0x79, 0xE3, 0x00, 0x98,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0xA0, 0x06, 0xE0, 0x71, 0xFF, 0x80, 0x70,
  0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xFF, 0xFF,
  0xC4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0F, 0xC0,
  0x40, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x0B,
  0x80, 0x15, 0x00, 0x6B, 0x01, 0x93, 0x06, 0x23, 0xF8, 0x40, 0x80, 0x00,
  0xC0, 0x01, 0x40, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x60, 0x06,
  0x20, 0x06, 0x20, 0x04, 0x30, 0x04, 0x30, 0x0C, 0x10, 0x0C, 0x10, 0x08,
  0x18, 0x08, 0x18, 0x08, 0x08, 0x18, 0x08, 0x18, 0x08, 0x10, 0x0C, 0x10,
  0x04, 0x30, 0x04, 0x30, 0x04, 0x20, 0x06, 0x20, 0x06, 0x60, 0x02, 0x60,
  0x02, 0x40, 0x03, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x80, 0x04, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x05,
  0x00, 0x2C, 0x00, 0xA0, 0x04, 0x80, 0x14, 0x00, 0x90, 0x06, 0xC0, 0x33,
  0x00, 0xD8, 0x06, 0x60, 0x11, 0x00, 0x84, 0x02, 0x20, 0x10, 0x80, 0x44,
  0x02, 0x10, 0x18, 0xC0, 0xC3, 0x03, 0x18, 0x10, 0x60, 0x41, 0x02, 0x04,
  0x08, 0x20, 0x40, 0x83, 0x06, 0x18, 0x18, 0x60, 0xC3, 0x03, 0x08, 0x08,
  0x40, 0x21, 0x01, 0x08, 0x04, 0x20, 0x21, 0x00, 0x8C, 0x06, 0x60, 0x19,
  0x80, 0xCC, 0x03, 0x20, 0x09, 0x00, 0x24, 0x01, 0x20, 0x04, 0x80, 0x2C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06,
  0x20, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30,
  0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0x40, 0x04, 0x60, 0x0C, 0x20,
  0x08, 0x30, 0x18, 0x10, 0x18, 0x18, 0x30, 0x08, 0x30, 0x0C, 0x20, 0x0C,
  0x60, 0x06, 0x40, 0x06, 0xC0, 0x03, 0xC0, 0x01, 0x40, 0x03, 0x40, 0x03,
  0x40, 0x02, 0x60, 0x02, 0x20, 0x06, 0x20, 0x06, 0x20, 0x04, 0x30, 0x04,
  0x10, 0x0C, 0x10, 0x0C, 0x10, 0x08, 0x18, 0x08, 0x18, 0x18, 0x08, 0x18,
  0x08, 0x10, 0x0C, 0x10, 0x0C, 0x30, 0x04, 0x30, 0x04, 0x20, 0x06, 0x20,
  0x06, 0x60, 0x02, 0x60, 0x02, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x01, 0xFF, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x3F, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x1F, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x2C, 0x78, 0x06, 0x01, 0x83, 0x40, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 40, 11, 4, -40 },
  { 16, 9, 14, 16, 4, -40 },
  { 32, 22, 40, 24, 1, -40 },
  { 142, 18, 46, 22, 2, -43 },
  { 246, 27, 42, 32, 3, -41 },
  { 388, 20, 42, 22, 2, -41 },
  { 493, 1, 14, 9, 4, -40 },
  { 495, 9, 49, 15, 3, -40 },
  { 551, 10, 49, 15, 2, -40 },
  { 613, 13, 15, 19, 3, -43 },
  { 638, 19, 26, 22, 2, -33 },
  { 700, 5, 13, 10, 2, -6 },
  { 709, 12, 2, 15, 1, -16 },
  { 712, 3, 4, 10, 4, -4 },
  { 714, 16, 40, 18, 1, -40 },
  { 794, 16, 41, 22, 3, -41 },
  { 876, 9, 40, 22, 4, -40 },
  { 921, 17, 41, 22, 2, -41 },
  { 1009, 17, 42, 22, 2, -41 },
  { 1099, 21, 40, 22, 1, -40 },
  { 1204, 17, 41, 22, 3, -40 },
  { 1292, 17, 41, 22, 3, -40 },
  { 1380, 17, 40, 22, 2, -40 },
  { 1465, 18, 41, 22, 2, -40 },
  { 1558, 17, 42, 22, 2, -41 },
  { 1648, 3, 30, 10, 4, -30 },
  { 1660, 5, 37, 10, 2, -30 },
  { 1684, 19, 23, 22, 2, -31 },
  { 1739, 19, 13, 22, 2, -26 },
  { 1770, 19, 23, 22, 2, -31 },
  { 1825, 12, 41, 15, 1, -41 },
  { 1887, 28, 45, 34, 3, -40 },
  { 2045, 21, 40, 21, 0, -40 },
  { 2150, 18, 40, 24, 4, -40 },
  { 2240, 19, 42, 23, 3, -41 },
  { 2340, 19, 40, 26, 4, -40 },
  { 2435, 15, 40, 21, 4, -40 },
  { 2510, 15, 40, 20, 4, -40 },
  { 2585, 23, 42, 29, 3, -41 },
  { 2706, 19, 40, 27, 4, -40 },
  { 2801, 8, 40, 12, 2, -40 },
  { 2841, 9, 50, 10, -3, -40 },
  { 2898, 17, 40, 21, 4, -40 },
  { 2983, 14, 40, 19, 4, -40 },
  { 3053, 28, 40, 37, 4, -40 },
  { 3193, 20, 40, 28, 4, -40 },
  { 3293, 23, 42, 29, 3, -41 },
  { 3414, 16, 40, 22, 4, -40 },
  { 3494, 23, 51, 29, 3, -41 },
  { 3641, 18, 40, 23, 4, -40 },
  { 3731, 17, 42, 22, 2, -41 },
  { 3821, 18, 40, 19, 0, -40 },
  { 3911, 19, 41, 27, 4, -40 },
  { 4009, 21, 40, 21, 0, -40 },
  { 4114, 36, 40, 36, 0, -40 },
  { 4294, 17, 40, 19, 1, -40 },
  { 4379, 18, 40, 18, 0, -40 },
  { 4469, 15, 40, 18, 2, -40 },
  { 4544, 10, 49, 17, 5, -40 },
  { 4606, 16, 40, 18, 1, -40 },
  { 4686, 10, 49, 17, 2, -40 },
  { 4748, 20, 19, 22, 1, -40 },
  { 4796, 22, 2, 22, 0, 5 },
  { 4802, 8, 9, 13, 2, -43 },
  { 4811, 15, 31, 21, 2, -30 },
  { 4870, 17, 44, 24, 4, -43 },
  { 4964, 13, 31, 18, 3, -30 },
  { 5015, 17, 44, 24, 3, -43 },
  { 5109, 16, 31, 21, 3, -30 },
  { 5171, 12, 43, 12, 1, -43 },
  { 5236, 17, 44, 24, 3, -30 },
  { 5330, 15, 43, 23, 4, -43 },
  { 5411, 3, 41, 10, 4, -41 },
  { 5427, 6, 55, 10, 0, -41 },
  { 5469, 14, 43, 18, 4, -43 },
  { 5545, 1, 43, 9, 4, -43 },
  { 5551, 26, 30, 34, 4, -30 },
  { 5649, 15, 30, 23, 4, -30 },
  { 5706, 17, 31, 23, 3, -30 },
  { 5772, 17, 43, 24, 4, -30 },
  { 5864, 17, 43, 24, 3, -30 },
  { 5956, 10, 30, 15, 4, -30 },
  { 5994, 14, 31, 17, 2, -30 },
  { 6049, 10, 38, 12, 1, -37 },
  { 6097, 15, 31, 23, 4, -30 },
  { 6156, 16, 30, 16, 0, -30 },
  { 6216, 27, 30, 29, 1, -30 },
  { 6318, 16, 30, 18, 1, -30 },
  { 6378, 16, 44, 18, 1, -30 },
  { 6466, 11, 30, 14, 2, -30 },
  { 6508, 14, 49, 19, 3, -40 },
  { 6594, 1, 57, 21, 10, -43 },
  { 6602, 13, 49, 19, 3, -40 },
  { 6682, 19, 4, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Thin56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN56PT7B_H_
