#ifndef _NOTOSANS_EXTRACONDENSED_THIN26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x60, 0x99, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x22,
  0x04, 0x40, 0x88, 0x22, 0x1F, 0xF8, 0x88, 0x11, 0x02, 0x20, 0x44, 0x08,
  0x8F, 0xFC, 0x22, 0x08, 0x81, 0x10, 0x22, 0x04, 0x40, 0x88, 0x00, 0x10,
  0x18, 0x77, 0x90, 0x90, 0x90, 0x90, 0x90, 0x90, 0x70, 0x18, 0x14, 0x13,
  0x11, 0x11, 0x11, 0x11, 0x11, 0xD6, 0x38, 0x10, 0x10, 0x30, 0x42, 0x42,
  0x22, 0x21, 0x11, 0x08, 0x88, 0x44, 0x82, 0x24, 0x11, 0x24, 0x8A, 0xD4,
  0x54, 0x92, 0xA2, 0x69, 0x10, 0x50, 0x82, 0x84, 0x22, 0x21, 0x11, 0x08,
  0x88, 0x84, 0x84, 0x1C, 0x38, 0x12, 0x11, 0x08, 0x84, 0x42, 0x20, 0x90,
  0x50, 0x10, 0x18, 0x14, 0x11, 0x18, 0x4C, 0x2A, 0x0D, 0x06, 0x83, 0x42,
  0x9E, 0x20, 0xFE, 0x08, 0x84, 0x42, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x42, 0x10, 0x42, 0x08, 0x60, 0x82, 0x10, 0x42, 0x08, 0x42, 0x10,
  0x42, 0x10, 0x84, 0x42, 0x10, 0x88, 0x42, 0x22, 0x00, 0x10, 0x22, 0x4B,
  0xE3, 0x05, 0x11, 0x00, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x55, 0xA0, 0xF8, 0xC0, 0x02, 0x04,
  0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20,
  0x81, 0x02, 0x00, 0x1C, 0x22, 0x42, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x42, 0x3C, 0x13, 0x59,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x10, 0x3C, 0xC2, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x40, 0xFF, 0x7C, 0x82, 0x02, 0x01, 0x01, 0x01, 0x01, 0x02, 0x04,
  0x38, 0x06, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x01, 0x00,
  0xC0, 0x30, 0x14, 0x05, 0x02, 0x40, 0x90, 0x44, 0x11, 0x08, 0x42, 0x11,
  0x04, 0x41, 0x20, 0x47, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x10, 0x7E, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xFC, 0x02, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x02, 0xFC, 0x0E, 0x10, 0x20, 0x40, 0x40, 0x40, 0x80,
  0x88, 0xB6, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C,
  0xFF, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x3C, 0x42, 0x41, 0x81, 0x81,
  0x81, 0x41, 0x22, 0x14, 0x18, 0x24, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x3E, 0x3C, 0x42, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x43, 0x3D, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x78, 0xC0, 0x0C, 0x50,
  0x00, 0x01, 0x56, 0x80, 0x00, 0x81, 0x81, 0x03, 0x06, 0x04, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x20,
  0x00, 0x7A, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0x41, 0x08, 0x20, 0x82,
  0x00, 0x00, 0x82, 0x00, 0x07, 0x80, 0x42, 0x04, 0x08, 0x40, 0x24, 0x00,
  0xA0, 0x85, 0x0A, 0x28, 0x91, 0x88, 0x8C, 0x44, 0x62, 0x23, 0x11, 0x18,
  0x88, 0xC4, 0x46, 0x26, 0x28, 0xEE, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x00, 0xF8, 0x00, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x12, 0x04, 0x81, 0x20,
  0x48, 0x22, 0x08, 0x42, 0x10, 0xFC, 0x41, 0x10, 0x24, 0x09, 0x02, 0x80,
  0xA0, 0x18, 0x04, 0xF8, 0x86, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0x84,
  0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x0F, 0x08,
  0x48, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x02, 0x01, 0x00, 0x80, 0x20, 0x08, 0x03, 0xE0, 0xE8, 0x42, 0x20, 0x90,
  0x28, 0x14, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x05, 0x02, 0x81, 0x41, 0x3F, 0x00, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0xFA, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF8, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF4, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x00, 0x07, 0xC3, 0x04, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x07, 0xC0, 0x18, 0x02, 0x80, 0x50,
  0x0A, 0x01, 0x20, 0x22, 0x04, 0x3F, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x44, 0x44, 0xF0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x2C, 0x81, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0xA0, 0xA0,
  0xE0, 0x90, 0x90, 0x88, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F,
  0xC0, 0x80, 0x0C, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xD0, 0x16, 0x80,
  0xB4, 0x05, 0x90, 0x4C, 0x82, 0x64, 0x13, 0x11, 0x18, 0x88, 0xC4, 0x46,
  0x24, 0x30, 0xA1, 0x85, 0x0C, 0x28, 0x60, 0x82, 0x80, 0xC0, 0x70, 0x38,
  0x1A, 0x0D, 0x06, 0x43, 0x21, 0x88, 0xC4, 0x62, 0x30, 0x98, 0x4C, 0x16,
  0x0B, 0x03, 0x81, 0xC0, 0x60, 0x20, 0x0F, 0x02, 0x10, 0x81, 0x20, 0x24,
  0x04, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x80, 0x50, 0x0A, 0x02, 0x40, 0x44, 0x10, 0x7C, 0x00, 0xF1, 0x1A, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x0B, 0xE4, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x00, 0x0F, 0x02, 0x10, 0x81, 0x20, 0x24, 0x04, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x80, 0x50, 0x0A, 0x02,
  0x40, 0x44, 0x10, 0x7C, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0xF0, 0x8C,
  0x82, 0x82, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0xF8, 0x88, 0x88, 0x84,
  0x84, 0x84, 0x82, 0x82, 0x81, 0x1E, 0x61, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0xFC,
  0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0x20, 0x8F, 0x80, 0x80, 0x60, 0x28, 0x09,
  0x02, 0x40, 0x90, 0x44, 0x11, 0x04, 0x21, 0x08, 0x42, 0x20, 0x88, 0x12,
  0x04, 0x81, 0x40, 0x50, 0x0C, 0x03, 0x00, 0x80, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x48, 0x30, 0x24, 0x14, 0x12, 0x0A, 0x09, 0x05, 0x08, 0x84,
  0x84, 0x22, 0x42, 0x11, 0x11, 0x08, 0x88, 0x84, 0x44, 0x81, 0x42, 0x40,
  0xA1, 0x20, 0x50, 0x50, 0x28, 0x28, 0x14, 0x18, 0x04, 0x0C, 0x02, 0x02,
  0x00, 0x41, 0x41, 0x41, 0x22, 0x22, 0x12, 0x14, 0x14, 0x08, 0x08, 0x14,
  0x14, 0x14, 0x22, 0x22, 0x22, 0x41, 0x41, 0x81, 0x81, 0x81, 0x41, 0x42,
  0x42, 0x22, 0x24, 0x24, 0x14, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0xFE, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x03, 0xF8, 0xFC, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x81,
  0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0x01,
  0x02, 0x04, 0x04, 0x08, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x04, 0x03, 0x00, 0xA0, 0x48,
  0x11, 0x08, 0x42, 0x09, 0x02, 0xC0, 0x40, 0xFF, 0xC0, 0x84, 0x21, 0x78,
  0x08, 0x08, 0x10, 0x20, 0x43, 0xB1, 0x83, 0x06, 0x0C, 0x18, 0x6F, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC, 0x1E, 0x41, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x07, 0xC0, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x43, 0x3D, 0x3C, 0x42, 0x42, 0x81, 0x81, 0x81, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3E, 0x1C, 0x82, 0x08, 0x20, 0x8F,
  0x88, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3D, 0x43,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3D,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x7C, 0x81, 0x02, 0x04, 0x08, 0x10, 0x2E,
  0x62, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10,
  0xC7, 0xFF, 0xE0, 0x24, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0xC0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x62, 0x8A, 0x4A, 0x28, 0xE2, 0x49,
  0x22, 0x8A, 0x28, 0x61, 0xFF, 0xFF, 0xF0, 0xB8, 0xEC, 0x51, 0x86, 0x18,
  0x21, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18,
  0x41, 0x84, 0x18, 0x41, 0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x40, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3E, 0xBC, 0xC2, 0x82, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xBE,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x7E, 0x08, 0x20, 0x81,
  0x02, 0x06, 0x04, 0x10, 0x41, 0x07, 0xE0, 0x44, 0x4F, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x44, 0x70, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x6F, 0x40, 0x83, 0x06, 0x0A, 0x14, 0x28, 0x91, 0x12,
  0x24, 0x50, 0xA0, 0xC1, 0x82, 0x00, 0x82, 0x0C, 0x10, 0x50, 0xC2, 0x86,
  0x14, 0x51, 0x22, 0x89, 0x12, 0x44, 0x92, 0x28, 0xA1, 0x45, 0x0A, 0x28,
  0x30, 0xC1, 0x04, 0x08, 0x20, 0x41, 0x42, 0x22, 0x24, 0x24, 0x18, 0x08,
  0x18, 0x18, 0x24, 0x24, 0x42, 0x42, 0xC1, 0x81, 0x41, 0x41, 0x42, 0x42,
  0x22, 0x22, 0x24, 0x24, 0x14, 0x14, 0x18, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x20, 0xE0, 0xF8, 0x42, 0x21, 0x10, 0x84, 0x42, 0x11, 0x08, 0x7C,
  0x06, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x87, 0x02, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x70,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x38, 0x00, 0xF8, 0xC3,
  0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Thin26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 19, 5, 2, -19 },
  { 4, 4, 7, 8, 2, -19 },
  { 8, 11, 19, 11, 0, -19 },
  { 35, 8, 22, 10, 1, -20 },
  { 57, 13, 19, 15, 1, -19 },
  { 88, 9, 19, 10, 1, -19 },
  { 110, 1, 7, 4, 2, -19 },
  { 111, 5, 23, 7, 1, -19 },
  { 126, 5, 23, 7, 1, -19 },
  { 141, 7, 7, 9, 1, -20 },
  { 148, 9, 12, 10, 1, -15 },
  { 162, 2, 6, 5, 1, -3 },
  { 164, 5, 1, 7, 1, -8 },
  { 165, 1, 2, 5, 2, -2 },
  { 166, 7, 19, 9, 1, -19 },
  { 183, 8, 19, 10, 1, -19 },
  { 202, 4, 19, 10, 2, -19 },
  { 212, 8, 19, 10, 1, -19 },
  { 231, 8, 19, 10, 1, -19 },
  { 250, 10, 19, 10, 0, -19 },
  { 274, 8, 19, 10, 1, -19 },
  { 293, 8, 19, 10, 1, -19 },
  { 312, 8, 19, 10, 1, -19 },
  { 331, 8, 19, 10, 1, -19 },
  { 350, 8, 19, 10, 1, -19 },
  { 369, 1, 14, 5, 2, -14 },
  { 371, 2, 17, 5, 1, -14 },
  { 376, 9, 11, 10, 1, -15 },
  { 389, 9, 6, 10, 1, -12 },
  { 396, 9, 11, 10, 1, -15 },
  { 409, 6, 19, 7, 0, -19 },
  { 424, 13, 21, 16, 1, -19 },
  { 459, 10, 19, 10, 0, -19 },
  { 483, 8, 19, 11, 2, -19 },
  { 502, 9, 19, 11, 1, -19 },
  { 524, 9, 19, 12, 2, -19 },
  { 546, 7, 19, 10, 2, -19 },
  { 563, 7, 19, 9, 2, -19 },
  { 580, 11, 19, 14, 1, -19 },
  { 607, 9, 19, 13, 2, -19 },
  { 629, 4, 19, 6, 1, -19 },
  { 639, 4, 24, 5, -1, -19 },
  { 651, 8, 19, 10, 2, -19 },
  { 670, 6, 19, 9, 2, -19 },
  { 685, 13, 19, 17, 2, -19 },
  { 716, 9, 19, 13, 2, -19 },
  { 738, 11, 19, 13, 1, -19 },
  { 765, 7, 19, 10, 2, -19 },
  { 782, 11, 23, 13, 1, -19 },
  { 814, 8, 19, 11, 2, -19 },
  { 833, 8, 19, 10, 1, -19 },
  { 852, 9, 19, 9, 0, -19 },
  { 874, 9, 19, 13, 2, -19 },
  { 896, 10, 19, 10, 0, -19 },
  { 920, 17, 19, 17, 0, -19 },
  { 961, 8, 19, 9, 0, -19 },
  { 980, 8, 19, 8, 0, -19 },
  { 999, 7, 19, 8, 1, -19 },
  { 1016, 5, 23, 8, 2, -19 },
  { 1031, 7, 19, 9, 1, -19 },
  { 1048, 5, 23, 8, 1, -19 },
  { 1063, 10, 9, 10, 0, -19 },
  { 1075, 10, 1, 10, 0, 2 },
  { 1077, 4, 4, 6, 1, -20 },
  { 1079, 7, 14, 10, 1, -14 },
  { 1092, 8, 20, 11, 2, -20 },
  { 1112, 7, 14, 8, 1, -14 },
  { 1125, 8, 20, 11, 1, -20 },
  { 1145, 8, 14, 10, 1, -14 },
  { 1159, 6, 20, 5, 0, -20 },
  { 1174, 8, 20, 11, 1, -14 },
  { 1194, 7, 20, 11, 2, -20 },
  { 1212, 1, 19, 5, 2, -19 },
  { 1215, 3, 25, 5, 0, -19 },
  { 1225, 6, 20, 8, 2, -20 },
  { 1240, 1, 20, 4, 2, -20 },
  { 1243, 12, 14, 16, 2, -14 },
  { 1264, 7, 14, 11, 2, -14 },
  { 1277, 8, 14, 10, 1, -14 },
  { 1291, 8, 20, 11, 2, -14 },
  { 1311, 8, 20, 11, 1, -14 },
  { 1331, 5, 14, 7, 2, -14 },
  { 1340, 6, 14, 8, 1, -14 },
  { 1351, 4, 17, 5, 1, -17 },
  { 1360, 7, 14, 11, 2, -14 },
  { 1373, 7, 14, 8, 0, -14 },
  { 1386, 13, 14, 13, 0, -14 },
  { 1409, 8, 14, 8, 0, -14 },
  { 1423, 8, 20, 8, 0, -14 },
  { 1443, 5, 14, 7, 1, -14 },
  { 1452, 7, 23, 9, 1, -19 },
  { 1473, 1, 26, 10, 4, -20 },
  { 1477, 7, 23, 9, 1, -19 },
  { 1498, 9, 2, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Thin26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN26PT7B_H_
