#ifndef _NOTOSANS_EXTRACONDENSED_THIN29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin29pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x02, 0xC0, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x10, 0x82, 0x10, 0x42, 0x08, 0x41, 0x08, 0x22, 0x3F, 0xF8, 0x88, 0x11,
  0x04, 0x20, 0x84, 0x10, 0x82, 0x11, 0xFF, 0x88, 0x81, 0x10, 0x22, 0x04,
  0x41, 0x08, 0x21, 0x04, 0x20, 0x08, 0x03, 0x03, 0xB9, 0x20, 0x88, 0x22,
  0x08, 0x82, 0x20, 0x88, 0x12, 0x03, 0x80, 0x30, 0x0A, 0x02, 0x40, 0x88,
  0x21, 0x08, 0x42, 0x10, 0x88, 0x22, 0xFF, 0x02, 0x00, 0x80, 0x20, 0x30,
  0x21, 0x20, 0x84, 0x44, 0x21, 0x10, 0x84, 0x42, 0x12, 0x08, 0x48, 0x21,
  0x20, 0x85, 0x32, 0x15, 0x24, 0x54, 0x52, 0x51, 0x32, 0x44, 0x09, 0x10,
  0x24, 0x41, 0x11, 0x04, 0x44, 0x11, 0x10, 0x84, 0x42, 0x11, 0x08, 0x38,
  0x1C, 0x09, 0x04, 0x21, 0x08, 0x42, 0x10, 0x82, 0x20, 0x90, 0x24, 0x06,
  0x03, 0x01, 0x20, 0x44, 0x61, 0x18, 0x26, 0x0A, 0x81, 0xA0, 0x48, 0x19,
  0x0A, 0x3C, 0x40, 0xFF, 0x08, 0x44, 0x22, 0x11, 0x08, 0x42, 0x21, 0x08,
  0x42, 0x10, 0x42, 0x10, 0x82, 0x10, 0x42, 0x08, 0x40, 0x82, 0x08, 0x41,
  0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x44, 0x21, 0x10, 0x84,
  0x44, 0x00, 0x10, 0x10, 0x93, 0x7C, 0x18, 0x24, 0x46, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x55, 0x68, 0xFC, 0xC0, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x1C, 0x11, 0x10, 0x48, 0x24, 0x0A, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x81, 0x40, 0xA0, 0x90,
  0x44, 0x21, 0xE0, 0x08, 0xCA, 0x98, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x80, 0x3C, 0x21, 0x80, 0x40, 0x20, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x10, 0x08, 0x0F, 0xF8, 0x3C, 0x61, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x03, 0x0F, 0x00, 0x60, 0x10, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x2F, 0xE0, 0x00, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x28,
  0x09, 0x01, 0x20, 0x44, 0x08, 0x82, 0x10, 0x42, 0x10, 0x42, 0x08, 0x81,
  0x10, 0x27, 0xFF, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x7F, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0x00, 0x40, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x2F, 0xE0, 0x0F, 0x08,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x8C, 0x59, 0xB0, 0x58, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x40, 0xA0, 0x50, 0x24, 0x23, 0xE0, 0xFF, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00, 0x1E, 0x10,
  0x90, 0x28, 0x18, 0x0E, 0x05, 0x02, 0x82, 0x22, 0x0E, 0x07, 0x04, 0x44,
  0x14, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x23, 0xE0, 0x1C, 0x31,
  0x10, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x68, 0x33,
  0xE8, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x47, 0xC0, 0xC0, 0x06,
  0x68, 0x00, 0x00, 0x00, 0x02, 0x92, 0x52, 0x00, 0x00, 0xC0, 0xC0, 0xC0,
  0x40, 0x60, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x02, 0x00, 0x79,
  0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x10, 0x00, 0x00, 0x01, 0x03, 0x00, 0x07, 0x80, 0x61, 0x82, 0x01, 0x08,
  0x04, 0x40, 0x09, 0x00, 0x28, 0x38, 0x61, 0x11, 0x88, 0x86, 0x22, 0x18,
  0x88, 0x62, 0x21, 0x88, 0x86, 0x22, 0x18, 0x88, 0x62, 0x21, 0x89, 0x4A,
  0x18, 0xC8, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x8C, 0x01, 0xC0,
  0x04, 0x01, 0x80, 0x28, 0x05, 0x00, 0xA0, 0x14, 0x04, 0x40, 0x88, 0x11,
  0x02, 0x20, 0x82, 0x10, 0x43, 0xF8, 0x41, 0x10, 0x12, 0x02, 0x40, 0x48,
  0x0A, 0x01, 0x40, 0x18, 0x02, 0xFC, 0x41, 0xA0, 0x50, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0x41, 0x3F, 0x90, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x2F, 0xE0, 0x0F, 0x98, 0x08, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x01, 0xF8, 0xFC, 0x20, 0x88, 0x12, 0x02, 0x80, 0xA0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xA0, 0x28, 0x12, 0x0C, 0xFC, 0x00, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x0F, 0xC2, 0x04, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x28, 0x05, 0x00, 0x90, 0x11, 0xFE, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xFE, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0xF2, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0xF0, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E, 0x80, 0xC0,
  0xA0, 0x90, 0x48, 0x44, 0x22, 0x21, 0x20, 0x90, 0x50, 0x2C, 0x1A, 0x08,
  0x84, 0x42, 0x11, 0x08, 0x82, 0x41, 0x20, 0x50, 0x28, 0x08, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x0F, 0xE0, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x5A, 0x00, 0xB4, 0x01, 0x68, 0x02, 0xC8, 0x09, 0x90, 0x13, 0x20, 0x26,
  0x20, 0x8C, 0x41, 0x18, 0x82, 0x31, 0x08, 0x61, 0x10, 0xC2, 0x21, 0x84,
  0x83, 0x05, 0x06, 0x0A, 0x0C, 0x14, 0x18, 0x10, 0x20, 0x80, 0x70, 0x1C,
  0x06, 0x81, 0xA0, 0x64, 0x19, 0x06, 0x41, 0x88, 0x62, 0x18, 0x46, 0x11,
  0x82, 0x60, 0x98, 0x16, 0x05, 0x81, 0x60, 0x38, 0x0E, 0x01, 0x80, 0x40,
  0x1F, 0x04, 0x11, 0x01, 0x20, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x09, 0x01, 0x10, 0x41, 0xF0, 0xF8, 0x43, 0x20, 0x50, 0x28, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0x40, 0xA0, 0x9F, 0x88, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x28, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x09, 0x01, 0x10, 0x41, 0xF0, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0xF8, 0x43, 0x20, 0x50, 0x28, 0x0C, 0x06,
  0x03, 0x02, 0x81, 0x40, 0xA1, 0x9F, 0x08, 0x84, 0x22, 0x11, 0x04, 0x82,
  0x40, 0xA0, 0x50, 0x18, 0x08, 0x1F, 0x10, 0x50, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x18, 0x03, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x2F, 0xE0, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x09, 0x02, 0x3F, 0x00, 0x80,
  0x30, 0x0A, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x21, 0x04, 0x20, 0x84,
  0x10, 0x84, 0x10, 0x81, 0x10, 0x22, 0x04, 0x80, 0x90, 0x0A, 0x01, 0x40,
  0x30, 0x06, 0x00, 0x40, 0x80, 0x40, 0x30, 0x08, 0x0A, 0x01, 0x01, 0x20,
  0x60, 0x24, 0x0A, 0x04, 0x81, 0x40, 0x90, 0x28, 0x21, 0x09, 0x04, 0x21,
  0x20, 0x84, 0x22, 0x10, 0x84, 0x44, 0x10, 0x88, 0x81, 0x21, 0x10, 0x24,
  0x22, 0x04, 0x82, 0x40, 0x90, 0x50, 0x12, 0x0A, 0x01, 0x81, 0x40, 0x30,
  0x28, 0x06, 0x02, 0x00, 0xC0, 0x40, 0x40, 0xA0, 0x48, 0x24, 0x22, 0x10,
  0x90, 0x48, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x90, 0x48, 0x44,
  0x21, 0x10, 0x90, 0x28, 0x18, 0x08, 0x80, 0xC0, 0x50, 0x28, 0x24, 0x11,
  0x08, 0x88, 0x44, 0x12, 0x0A, 0x05, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xFF, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x80, 0x80, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08,
  0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0xF8, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F,
  0xC0, 0x08, 0x03, 0x01, 0x40, 0x48, 0x22, 0x08, 0x44, 0x11, 0x02, 0x80,
  0xA0, 0x10, 0xFF, 0xE0, 0x84, 0x21, 0x08, 0x66, 0x02, 0x01, 0x01, 0x01,
  0x01, 0x0F, 0x31, 0x41, 0x81, 0x81, 0x81, 0x83, 0x83, 0x7D, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x71, 0x44, 0xC1, 0x40, 0xA0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x2C, 0x15, 0xF0, 0x0E,
  0x11, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x1E, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x22, 0x65,
  0x41, 0xA0, 0x50, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50,
  0x28, 0x14, 0x19, 0xF4, 0x0C, 0x19, 0x10, 0x48, 0x24, 0x0C, 0x06, 0x03,
  0xFF, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x82, 0x3E, 0x1E, 0x20,
  0x81, 0x02, 0x04, 0x08, 0x7C, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0x08, 0x19, 0x50, 0x68, 0x14, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x14, 0x0A, 0x05, 0x06, 0x7D,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x09, 0xF8, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x9C, 0xA2, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0xFF, 0xF8, 0x24, 0x00, 0x09,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0xC2, 0x85, 0x12, 0x24, 0x8A, 0x16, 0x34, 0x44, 0x89, 0x12,
  0x14, 0x28, 0x30, 0x40, 0xFF, 0xFF, 0xFC, 0x10, 0x62, 0x92, 0x6C, 0x30,
  0xA0, 0xC1, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08,
  0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0x1C,
  0xA2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x08, 0x19, 0x90, 0x48, 0x14, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x14, 0x0A, 0x04, 0x84, 0x7C, 0x1C, 0x51, 0x30,
  0x58, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E,
  0x0B, 0x05, 0x7C, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x08,
  0x19, 0x50, 0x68, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x14, 0x0A, 0x04, 0x86, 0x7D, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x1D, 0x71, 0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x0C,
  0xC6, 0x04, 0x08, 0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x10, 0x20, 0x60,
  0xFE, 0x42, 0x10, 0x8F, 0xA1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x0E, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x83, 0x83, 0x7D, 0x81, 0x81, 0x41, 0x41, 0x42, 0x42, 0x22, 0x22,
  0x24, 0x24, 0x14, 0x14, 0x18, 0x18, 0x08, 0x81, 0x02, 0x82, 0x09, 0x0A,
  0x12, 0x14, 0x24, 0x28, 0x48, 0x51, 0x08, 0x92, 0x12, 0x24, 0x24, 0x48,
  0x48, 0x90, 0x51, 0x40, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x02, 0x08, 0x00,
  0x41, 0xA0, 0x88, 0x84, 0x41, 0x40, 0xA0, 0x20, 0x10, 0x14, 0x0A, 0x08,
  0x84, 0x42, 0x12, 0x0B, 0x06, 0x40, 0xA0, 0x50, 0x48, 0x22, 0x11, 0x08,
  0x88, 0x44, 0x12, 0x09, 0x05, 0x02, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x07, 0x00, 0xFC, 0x20, 0x82, 0x10, 0x41, 0x08,
  0x21, 0x04, 0x10, 0x82, 0x0F, 0xC0, 0x0E, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x0C, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x08, 0x18, 0x04, 0xFF, 0xFF, 0xFF, 0xF8, 0xE0, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x07, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x30, 0xC0, 0xF8,
  0x60, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 5, 8, 9, 2, -21 },
  { 12, 11, 21, 12, 1, -21 },
  { 41, 10, 24, 11, 1, -22 },
  { 71, 14, 21, 17, 1, -21 },
  { 108, 10, 21, 11, 1, -21 },
  { 135, 1, 8, 5, 2, -21 },
  { 136, 5, 26, 8, 1, -21 },
  { 153, 5, 26, 8, 1, -21 },
  { 170, 8, 7, 10, 1, -22 },
  { 177, 10, 13, 12, 1, -17 },
  { 194, 2, 7, 5, 1, -3 },
  { 196, 6, 1, 8, 1, -8 },
  { 197, 1, 2, 5, 2, -2 },
  { 198, 8, 21, 10, 1, -21 },
  { 219, 9, 21, 11, 1, -21 },
  { 243, 5, 21, 11, 2, -21 },
  { 257, 9, 21, 11, 1, -21 },
  { 281, 9, 21, 11, 1, -21 },
  { 305, 11, 21, 11, 0, -21 },
  { 334, 9, 21, 11, 1, -21 },
  { 358, 9, 21, 11, 1, -21 },
  { 382, 9, 21, 11, 1, -21 },
  { 406, 9, 21, 11, 1, -21 },
  { 430, 9, 21, 11, 1, -21 },
  { 454, 1, 15, 5, 2, -15 },
  { 456, 3, 19, 5, 1, -15 },
  { 464, 10, 12, 12, 1, -16 },
  { 479, 10, 7, 12, 1, -14 },
  { 488, 10, 12, 12, 1, -16 },
  { 503, 7, 21, 8, 0, -21 },
  { 522, 14, 24, 17, 2, -21 },
  { 564, 11, 21, 11, 0, -21 },
  { 593, 9, 21, 12, 2, -21 },
  { 617, 9, 21, 12, 2, -21 },
  { 641, 10, 21, 14, 2, -21 },
  { 668, 8, 21, 11, 2, -21 },
  { 689, 8, 21, 10, 2, -21 },
  { 710, 11, 21, 15, 2, -21 },
  { 739, 10, 21, 14, 2, -21 },
  { 766, 4, 21, 6, 1, -21 },
  { 777, 4, 26, 5, -1, -21 },
  { 790, 9, 21, 11, 2, -21 },
  { 814, 7, 21, 10, 2, -21 },
  { 833, 15, 21, 19, 2, -21 },
  { 873, 10, 21, 15, 2, -21 },
  { 900, 11, 21, 15, 2, -21 },
  { 929, 9, 21, 11, 2, -21 },
  { 953, 11, 26, 15, 2, -21 },
  { 989, 9, 21, 12, 2, -21 },
  { 1013, 9, 21, 11, 1, -21 },
  { 1037, 10, 21, 10, 0, -21 },
  { 1064, 10, 21, 14, 2, -21 },
  { 1091, 11, 21, 11, 0, -21 },
  { 1120, 19, 21, 19, 0, -21 },
  { 1170, 9, 21, 10, 0, -21 },
  { 1194, 9, 21, 9, 0, -21 },
  { 1218, 8, 21, 9, 1, -21 },
  { 1239, 6, 26, 9, 2, -21 },
  { 1259, 8, 21, 9, 1, -21 },
  { 1280, 5, 26, 9, 1, -21 },
  { 1297, 10, 10, 11, 1, -21 },
  { 1310, 11, 1, 11, 0, 3 },
  { 1312, 4, 4, 7, 1, -22 },
  { 1314, 8, 16, 11, 1, -16 },
  { 1330, 9, 22, 12, 2, -22 },
  { 1355, 8, 16, 9, 1, -16 },
  { 1371, 9, 22, 12, 1, -22 },
  { 1396, 9, 16, 11, 1, -16 },
  { 1414, 7, 22, 6, 0, -22 },
  { 1434, 9, 23, 12, 1, -16 },
  { 1460, 8, 22, 12, 2, -22 },
  { 1482, 1, 21, 5, 2, -21 },
  { 1485, 3, 28, 5, 0, -21 },
  { 1496, 7, 22, 9, 2, -22 },
  { 1516, 1, 22, 5, 2, -22 },
  { 1519, 14, 16, 18, 2, -16 },
  { 1547, 8, 16, 12, 2, -16 },
  { 1563, 9, 16, 12, 1, -16 },
  { 1581, 9, 23, 12, 2, -16 },
  { 1607, 9, 23, 12, 1, -16 },
  { 1633, 5, 16, 8, 2, -16 },
  { 1643, 7, 16, 9, 1, -16 },
  { 1657, 5, 19, 6, 1, -19 },
  { 1669, 8, 15, 12, 2, -15 },
  { 1684, 8, 15, 9, 0, -15 },
  { 1699, 15, 15, 15, 0, -15 },
  { 1728, 9, 15, 9, 0, -15 },
  { 1745, 9, 22, 9, 0, -15 },
  { 1770, 6, 15, 7, 1, -15 },
  { 1782, 7, 26, 10, 2, -21 },
  { 1805, 1, 29, 11, 5, -22 },
  { 1809, 8, 26, 10, 1, -21 },
  { 1835, 10, 2, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Thin29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN29PT7B_H_
