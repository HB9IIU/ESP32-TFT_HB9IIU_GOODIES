#ifndef _NOTOSANS_EXTRACONDENSED_THIN19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE4, 0xB6, 0xDA, 0x12, 0x12, 0x14, 0x24, 0x7F, 0x24, 0x24,
  0x24, 0x24, 0xFE, 0x24, 0x28, 0x48, 0x48, 0x33, 0xAA, 0x28, 0xA2, 0x86,
  0x0C, 0x28, 0x92, 0x49, 0xA9, 0xC2, 0x00, 0x42, 0x51, 0x25, 0x12, 0x89,
  0x44, 0xCA, 0x6B, 0x59, 0x4C, 0x8A, 0x45, 0x22, 0x92, 0x49, 0x1C, 0x21,
  0x49, 0x24, 0x51, 0x42, 0x18, 0x96, 0x58, 0xE2, 0x8F, 0xD0, 0xF8, 0x25,
  0x29, 0x24, 0x92, 0x48, 0x92, 0x20, 0x91, 0x22, 0x49, 0x24, 0x92, 0x92,
  0x80, 0x27, 0xC9, 0xA0, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0xF0,
  0xF8, 0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x84, 0x10, 0x42,
  0x00, 0x31, 0x28, 0xA1, 0x86, 0x18, 0x61, 0x86, 0x18, 0x62, 0x89, 0xC0,
  0x13, 0xD1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x72, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x10, 0x82, 0x10, 0x83, 0xF0, 0x72, 0x20, 0x81, 0x08, 0x27, 0x04,
  0x08, 0x10, 0x41, 0x0B, 0xC0, 0x04, 0x18, 0x30, 0xA1, 0x44, 0x89, 0x22,
  0x45, 0x0B, 0xF8, 0x20, 0x40, 0x80, 0xFA, 0x08, 0x20, 0x82, 0x0F, 0x02,
  0x04, 0x10, 0x41, 0x0B, 0xC0, 0x39, 0x04, 0x20, 0x82, 0x8D, 0xA1, 0x86,
  0x18, 0x61, 0x89, 0xE0, 0xFC, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x82,
  0x10, 0x41, 0x00, 0x72, 0x28, 0x61, 0x85, 0x23, 0x14, 0x8A, 0x18, 0x61,
  0x85, 0xE0, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x78, 0x42, 0x10, 0xF8, 0x80,
  0x40, 0x80, 0xF0, 0x04, 0x23, 0x30, 0x81, 0x81, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x81, 0x03, 0x02, 0x0C, 0x46, 0x20, 0xE0, 0x82, 0x10, 0x88, 0x44,
  0x22, 0x10, 0x00, 0x20, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x8C, 0xA4, 0x99,
  0x26, 0x49, 0xA2, 0x65, 0x19, 0x4A, 0x2C, 0x80, 0x10, 0x02, 0x00, 0x78,
  0x10, 0x20, 0xA1, 0x42, 0x85, 0x09, 0x22, 0x7C, 0x89, 0x0C, 0x18, 0x30,
  0x40, 0xFA, 0x18, 0x61, 0x86, 0x1F, 0xA1, 0x86, 0x18, 0x61, 0x87, 0xE0,
  0x1D, 0x84, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x40, 0xF0, 0xF1,
  0x1A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x28, 0x5F, 0x00,
  0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84, 0x21, 0x08, 0x7C, 0xFC, 0x21, 0x08,
  0x42, 0x1F, 0x84, 0x21, 0x08, 0x40, 0x1E, 0x21, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x87, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3F, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xD5, 0x55, 0x55,
  0x70, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x86, 0x18, 0xA4, 0x92,
  0x8A, 0x38, 0x92, 0x48, 0xA2, 0x86, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x7C, 0x80, 0x70, 0x1C, 0x07, 0x03, 0xA0, 0xE8, 0x5A,
  0x16, 0x45, 0x92, 0x64, 0x98, 0xA6, 0x29, 0x8C, 0x61, 0x10, 0x83, 0x87,
  0x0D, 0x1A, 0x32, 0x64, 0xC9, 0x8B, 0x16, 0x1C, 0x38, 0x30, 0x40, 0x3C,
  0x42, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42,
  0x3C, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x20, 0x82, 0x00,
  0x3C, 0x42, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x42, 0x34, 0x08, 0x04, 0x06, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x7E, 0x92,
  0x48, 0xA2, 0x86, 0x10, 0x7A, 0x08, 0x20, 0x82, 0x06, 0x04, 0x08, 0x10,
  0x41, 0x0B, 0xC0, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x14, 0x27, 0x80, 0x83, 0x06, 0x0C, 0x24, 0x48, 0x91, 0x22, 0x28, 0x50,
  0xA1, 0x41, 0x02, 0x00, 0x82, 0x18, 0x21, 0x86, 0x18, 0x61, 0x46, 0x14,
  0x52, 0x49, 0x24, 0x92, 0x29, 0x22, 0x94, 0x28, 0xC3, 0x0C, 0x30, 0xC1,
  0x08, 0x85, 0x14, 0x4A, 0x28, 0xC1, 0x04, 0x30, 0xA4, 0x92, 0x46, 0x10,
  0x86, 0x18, 0x52, 0x49, 0x23, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x80, 0xF8,
  0x44, 0x21, 0x10, 0x88, 0x42, 0x21, 0x08, 0x7C, 0xF2, 0x49, 0x24, 0x92,
  0x49, 0x24, 0xE0, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x40, 0x82,
  0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x10, 0x30, 0xA1,
  0x24, 0x48, 0x60, 0x80, 0xFE, 0x91, 0x80, 0xF0, 0x42, 0x17, 0xC6, 0x31,
  0x8F, 0xC0, 0x82, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x87,
  0xE0, 0x7C, 0x21, 0x08, 0x42, 0x10, 0x83, 0xC0, 0x04, 0x10, 0x41, 0x7E,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x74, 0x63, 0x1F, 0xC2, 0x10,
  0x83, 0xC0, 0x12, 0x44, 0x4E, 0x44, 0x44, 0x44, 0x44, 0x40, 0x7E, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x41, 0x06, 0x27, 0x00, 0x84, 0x21,
  0x0F, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC4, 0xCF, 0xFC, 0x50, 0x55, 0x55,
  0x55, 0x58, 0x84, 0x21, 0x08, 0xCA, 0x94, 0xE5, 0x25, 0x28, 0xC4, 0xFF,
  0xFC, 0xFF, 0xC4, 0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4,
  0x40, 0xFC, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x40, 0x7A, 0x28, 0x61, 0x86,
  0x18, 0x61, 0x89, 0xE0, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0xC6, 0xE8,
  0x20, 0x82, 0x00, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x41,
  0x04, 0x10, 0xFC, 0x88, 0x88, 0x88, 0x88, 0xF8, 0x88, 0x42, 0x11, 0x1F,
  0x44, 0xF4, 0x44, 0x44, 0x44, 0x47, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8B,
  0xC0, 0x8C, 0x62, 0x94, 0xA9, 0x46, 0x21, 0x00, 0x88, 0x63, 0x28, 0xC9,
  0x32, 0x54, 0x94, 0xA5, 0x30, 0xCC, 0x21, 0x08, 0x40, 0x45, 0x24, 0x8C,
  0x10, 0xC3, 0x12, 0x4A, 0x10, 0x85, 0x14, 0x92, 0x48, 0xA3, 0x0C, 0x10,
  0x42, 0x08, 0x20, 0x8C, 0x00, 0xE4, 0x94, 0xA4, 0x9C, 0x19, 0x08, 0x42,
  0x10, 0x84, 0xC2, 0x08, 0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF, 0xE0, 0xC1,
  0x08, 0x42, 0x10, 0x84, 0x19, 0x08, 0x42, 0x10, 0x84, 0xC0, 0x42, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 14, 4, 1, -14 },
  { 3, 3, 5, 6, 1, -14 },
  { 5, 8, 14, 8, 0, -14 },
  { 19, 6, 15, 7, 1, -14 },
  { 31, 9, 14, 11, 1, -14 },
  { 47, 6, 14, 7, 1, -14 },
  { 58, 1, 5, 3, 1, -14 },
  { 59, 3, 17, 5, 1, -14 },
  { 66, 3, 17, 5, 1, -14 },
  { 73, 5, 4, 6, 1, -14 },
  { 76, 6, 9, 8, 1, -11 },
  { 83, 1, 4, 3, 1, -2 },
  { 84, 5, 1, 5, 0, -6 },
  { 85, 1, 1, 3, 1, -1 },
  { 86, 6, 14, 6, 0, -14 },
  { 97, 6, 14, 7, 1, -14 },
  { 108, 4, 14, 7, 1, -14 },
  { 115, 6, 14, 7, 1, -14 },
  { 126, 6, 14, 7, 1, -14 },
  { 137, 7, 14, 7, 0, -14 },
  { 150, 6, 14, 7, 1, -14 },
  { 161, 6, 14, 7, 1, -14 },
  { 172, 6, 14, 7, 1, -14 },
  { 183, 6, 14, 7, 1, -14 },
  { 194, 5, 14, 7, 1, -14 },
  { 203, 1, 10, 3, 1, -10 },
  { 205, 1, 12, 3, 1, -10 },
  { 207, 6, 8, 8, 1, -11 },
  { 213, 6, 5, 8, 1, -9 },
  { 217, 6, 8, 8, 1, -11 },
  { 223, 5, 14, 5, 0, -14 },
  { 232, 10, 16, 11, 1, -14 },
  { 252, 7, 14, 7, 0, -14 },
  { 265, 6, 14, 8, 1, -14 },
  { 276, 6, 14, 8, 1, -14 },
  { 287, 7, 14, 9, 1, -14 },
  { 300, 5, 14, 7, 1, -14 },
  { 309, 5, 14, 7, 1, -14 },
  { 318, 8, 14, 10, 1, -14 },
  { 332, 7, 14, 9, 1, -14 },
  { 345, 2, 14, 4, 1, -14 },
  { 349, 3, 17, 4, -1, -14 },
  { 356, 6, 14, 7, 1, -14 },
  { 367, 5, 14, 6, 1, -14 },
  { 376, 10, 14, 12, 1, -14 },
  { 394, 7, 14, 10, 1, -14 },
  { 407, 8, 14, 10, 1, -14 },
  { 421, 6, 14, 8, 1, -14 },
  { 432, 8, 17, 10, 1, -14 },
  { 449, 6, 14, 8, 1, -14 },
  { 460, 6, 14, 7, 1, -14 },
  { 471, 6, 14, 6, 0, -14 },
  { 482, 7, 14, 9, 1, -14 },
  { 495, 7, 14, 7, 0, -14 },
  { 508, 12, 14, 12, 0, -14 },
  { 529, 6, 14, 6, 0, -14 },
  { 540, 6, 14, 6, 0, -14 },
  { 551, 5, 14, 6, 1, -14 },
  { 560, 3, 17, 6, 2, -14 },
  { 567, 6, 14, 6, 0, -14 },
  { 578, 3, 17, 6, 1, -14 },
  { 585, 7, 7, 8, 0, -14 },
  { 592, 7, 1, 7, 0, 1 },
  { 593, 3, 3, 4, 1, -15 },
  { 595, 5, 10, 7, 1, -10 },
  { 602, 6, 14, 8, 1, -14 },
  { 613, 5, 10, 6, 1, -10 },
  { 620, 6, 14, 8, 1, -14 },
  { 631, 5, 10, 7, 1, -10 },
  { 638, 4, 15, 4, 0, -15 },
  { 646, 6, 15, 8, 1, -10 },
  { 658, 5, 14, 8, 1, -14 },
  { 667, 1, 14, 3, 1, -14 },
  { 669, 2, 19, 3, 0, -14 },
  { 674, 5, 14, 6, 1, -14 },
  { 683, 1, 14, 3, 1, -14 },
  { 685, 9, 10, 12, 1, -10 },
  { 697, 5, 10, 8, 1, -10 },
  { 704, 6, 10, 8, 1, -10 },
  { 712, 6, 14, 8, 1, -10 },
  { 723, 6, 14, 8, 1, -10 },
  { 734, 4, 10, 5, 1, -10 },
  { 739, 4, 10, 6, 1, -10 },
  { 744, 4, 12, 4, 0, -12 },
  { 750, 5, 10, 8, 1, -10 },
  { 757, 5, 10, 6, 0, -10 },
  { 764, 10, 10, 10, 0, -10 },
  { 777, 6, 10, 6, 0, -10 },
  { 785, 6, 15, 6, 0, -10 },
  { 797, 3, 10, 5, 1, -10 },
  { 801, 5, 17, 7, 1, -14 },
  { 812, 1, 19, 7, 3, -14 },
  { 815, 5, 17, 7, 1, -14 },
  { 826, 6, 2, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Thin19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN19PT7B_H_
