#ifndef _NOTOSANS_EXTRACONDENSED_THIN21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE2, 0x99, 0x99, 0x90, 0x12, 0x09, 0x04, 0x82, 0x47, 0xF8,
  0x90, 0x88, 0x44, 0x24, 0x7F, 0x89, 0x04, 0x82, 0x41, 0x21, 0x10, 0x20,
  0xFA, 0x85, 0x0A, 0x14, 0x28, 0x30, 0x10, 0x50, 0x91, 0x12, 0x24, 0x6B,
  0x38, 0x20, 0x61, 0x24, 0x89, 0x22, 0x48, 0x94, 0x25, 0x09, 0x5A, 0x59,
  0x6A, 0x42, 0x90, 0xA4, 0x49, 0x12, 0x44, 0x92, 0x18, 0x70, 0x91, 0x22,
  0x44, 0x8A, 0x08, 0x30, 0x91, 0x26, 0x2C, 0x68, 0x51, 0x5C, 0x80, 0xF8,
  0x12, 0x44, 0x48, 0x88, 0x88, 0x88, 0x88, 0x44, 0x23, 0x89, 0x12, 0x49,
  0x24, 0x92, 0x4A, 0x50, 0x21, 0x3E, 0x45, 0x80, 0x10, 0x20, 0x40, 0x8F,
  0xE2, 0x04, 0x08, 0x10, 0x6A, 0x80, 0xF0, 0x80, 0x04, 0x20, 0x84, 0x10,
  0x42, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x00, 0x79, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0x13, 0x80, 0x2E, 0x92, 0x49, 0x24,
  0x92, 0x48, 0xF8, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x42, 0x08, 0x42,
  0x0F, 0xC0, 0xF8, 0x10, 0x41, 0x04, 0x10, 0x9E, 0x04, 0x10, 0x41, 0x04,
  0x1F, 0x80, 0x04, 0x04, 0x0C, 0x0C, 0x14, 0x14, 0x24, 0x24, 0x44, 0x44,
  0x84, 0x7F, 0x04, 0x04, 0x04, 0x7E, 0x08, 0x20, 0x82, 0x0F, 0x81, 0x04,
  0x10, 0x41, 0x04, 0x1F, 0x80, 0x3D, 0x04, 0x20, 0x82, 0x0F, 0xA1, 0x86,
  0x18, 0x61, 0x85, 0x17, 0x80, 0xFC, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10,
  0x42, 0x08, 0x21, 0x04, 0x00, 0x79, 0x0A, 0x14, 0x28, 0x48, 0x8E, 0x18,
  0x49, 0x0A, 0x0C, 0x18, 0x30, 0x9E, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x7C, 0x10, 0x41, 0x04, 0x2F, 0x00, 0x80, 0x20, 0xC0, 0x00, 0x1A,
  0xA0, 0x02, 0x18, 0xC2, 0x08, 0x08, 0x0C, 0x06, 0x02, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x80, 0x80, 0xC0, 0x60, 0x21, 0x8C, 0x20, 0x80, 0xF0, 0x42,
  0x10, 0x84, 0x44, 0x21, 0x08, 0x00, 0x00, 0x80, 0x1F, 0x04, 0x11, 0x01,
  0x20, 0x28, 0x65, 0x14, 0x64, 0x8C, 0x91, 0x92, 0x32, 0x46, 0x48, 0xC9,
  0x28, 0xD8, 0x80, 0x10, 0x01, 0x00, 0x1E, 0x00, 0x10, 0x18, 0x18, 0x28,
  0x24, 0x24, 0x24, 0x24, 0x7E, 0x42, 0x42, 0x42, 0x81, 0x81, 0x81, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0xBE, 0x86, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x3E,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x04, 0x07,
  0x80, 0xF1, 0x1A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x28,
  0x51, 0x3C, 0x00, 0xFC, 0x21, 0x08, 0x42, 0x1F, 0x84, 0x21, 0x08, 0x43,
  0xE0, 0xFC, 0x21, 0x08, 0x42, 0x1F, 0x84, 0x21, 0x08, 0x42, 0x00, 0x1F,
  0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x0E, 0x80, 0xC0, 0x60, 0x30,
  0x14, 0x09, 0x04, 0x7E, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0x80, 0xE9, 0x24, 0x92, 0x49, 0x24, 0xB8,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x27, 0x00, 0x86, 0x29, 0x24, 0xA2,
  0x8C, 0x30, 0xA2, 0x89, 0x24, 0x8A, 0x28, 0x40, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x80, 0x60, 0x18, 0x0F, 0x03, 0xC0,
  0xF0, 0x5A, 0x16, 0x85, 0xA2, 0x64, 0x99, 0x26, 0x49, 0x94, 0x63, 0x18,
  0x84, 0x83, 0x06, 0x0E, 0x1C, 0x34, 0x68, 0xC9, 0x93, 0x16, 0x2C, 0x38,
  0x70, 0x60, 0x80, 0x3E, 0x20, 0x90, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x24, 0x12, 0x08, 0xF8, 0xF2, 0x28, 0x61, 0x86,
  0x18, 0xA2, 0xF2, 0x08, 0x20, 0x82, 0x08, 0x00, 0x3E, 0x20, 0x90, 0x50,
  0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x24, 0x12, 0x08,
  0xF8, 0x08, 0x04, 0x01, 0x00, 0x80, 0xF2, 0x28, 0x61, 0x86, 0x18, 0xB4,
  0xA2, 0x49, 0x22, 0x8A, 0x18, 0x40, 0x7E, 0x08, 0x20, 0x82, 0x04, 0x0C,
  0x08, 0x10, 0x41, 0x04, 0x1F, 0x80, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x9E, 0x00, 0x81, 0x81,
  0x82, 0x42, 0x42, 0x42, 0x44, 0x44, 0x24, 0x24, 0x28, 0x28, 0x18, 0x18,
  0x10, 0x82, 0x0C, 0x10, 0x60, 0xC2, 0x86, 0x14, 0x50, 0xA2, 0x89, 0x12,
  0x48, 0x92, 0x24, 0x91, 0x44, 0x8A, 0x28, 0x50, 0xC1, 0x86, 0x08, 0x30,
  0x41, 0x00, 0x42, 0x89, 0x11, 0x22, 0x85, 0x04, 0x08, 0x10, 0x50, 0xA2,
  0x24, 0x48, 0xA0, 0x80, 0x83, 0x09, 0x12, 0x24, 0x85, 0x0A, 0x18, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0xF8, 0x42, 0x21, 0x08, 0x84, 0x22,
  0x11, 0x08, 0x43, 0xE0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0x84, 0x20, 0x84, 0x20, 0x84, 0x20, 0x84, 0x20, 0x84, 0x20, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x18, 0x14, 0x24,
  0x22, 0x42, 0xC1, 0xFF, 0x88, 0x80, 0x78, 0x42, 0x10, 0xBE, 0x31, 0x8C,
  0x7E, 0x81, 0x02, 0x04, 0x08, 0x17, 0xB0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x71, 0x5E, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x82, 0x1E, 0x04, 0x10,
  0x41, 0x05, 0xF8, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5F, 0x7A, 0x18,
  0x61, 0x87, 0xE8, 0x20, 0x81, 0x03, 0xC0, 0x39, 0x10, 0x84, 0x79, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x17, 0xC1, 0x04, 0x10, 0x7E, 0x82, 0x08, 0x20, 0x82, 0xEC, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x8F, 0xFE, 0x40, 0x55, 0x55, 0x55, 0x57,
  0x82, 0x08, 0x20, 0x82, 0x28, 0xA4, 0xA2, 0x8D, 0x24, 0x92, 0x28, 0xA1,
  0xFF, 0xFF, 0xBB, 0xF1, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11,
  0x84, 0x61, 0x18, 0x44, 0xBF, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x40, 0x79, 0x0A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x09, 0xE0, 0xBD,
  0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x8A, 0xF4, 0x08, 0x10, 0x20,
  0x40, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC1, 0x04, 0x10,
  0x41, 0xBC, 0x88, 0x88, 0x88, 0x88, 0x80, 0xFC, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x7C, 0x44, 0x4F, 0x44, 0x44, 0x44, 0x44, 0x43, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x86, 0x18, 0x52, 0x49, 0x24, 0x8C,
  0x30, 0xC1, 0x00, 0x84, 0x30, 0x89, 0x29, 0x25, 0x24, 0xA4, 0x94, 0x94,
  0xA1, 0x8C, 0x31, 0x86, 0x20, 0x84, 0x00, 0x45, 0x12, 0x8A, 0x10, 0x43,
  0x0A, 0x49, 0x18, 0x40, 0x85, 0x14, 0x51, 0x48, 0xA2, 0x8A, 0x30, 0x41,
  0x04, 0x20, 0x82, 0x30, 0xF1, 0x22, 0x24, 0x48, 0x88, 0xF0, 0x19, 0x08,
  0x42, 0x10, 0x84, 0x46, 0x08, 0x42, 0x10, 0x84, 0x20, 0xC0, 0xFF, 0xFF,
  0xF8, 0xC1, 0x08, 0x42, 0x10, 0x84, 0x10, 0xC8, 0x42, 0x10, 0x84, 0x27,
  0x00, 0xFE,
};

const GFXglyph NotoSans_ExtraCondensed_Thin21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 15, 4, 2, -15 },
  { 3, 4, 5, 6, 1, -15 },
  { 6, 9, 15, 9, 0, -15 },
  { 23, 7, 17, 8, 1, -16 },
  { 38, 10, 15, 12, 1, -15 },
  { 57, 7, 15, 8, 1, -15 },
  { 71, 1, 5, 3, 1, -15 },
  { 72, 4, 18, 6, 1, -15 },
  { 81, 3, 18, 6, 1, -15 },
  { 88, 5, 5, 7, 1, -16 },
  { 92, 7, 9, 8, 1, -12 },
  { 100, 2, 5, 4, 1, -2 },
  { 102, 4, 1, 6, 1, -6 },
  { 103, 1, 1, 4, 1, -1 },
  { 104, 6, 15, 7, 1, -15 },
  { 116, 6, 15, 8, 1, -15 },
  { 128, 3, 15, 8, 2, -15 },
  { 134, 6, 15, 8, 1, -15 },
  { 146, 6, 15, 8, 1, -15 },
  { 158, 8, 15, 8, 0, -15 },
  { 173, 6, 15, 8, 1, -15 },
  { 185, 6, 15, 8, 1, -15 },
  { 197, 6, 15, 8, 1, -15 },
  { 209, 7, 15, 8, 1, -15 },
  { 223, 6, 15, 8, 1, -15 },
  { 235, 1, 11, 4, 1, -11 },
  { 237, 2, 14, 4, 1, -11 },
  { 241, 7, 9, 8, 1, -12 },
  { 249, 7, 5, 8, 1, -10 },
  { 254, 7, 9, 8, 1, -12 },
  { 262, 5, 15, 6, 0, -15 },
  { 272, 11, 17, 13, 1, -15 },
  { 296, 8, 15, 8, 0, -15 },
  { 311, 6, 15, 9, 2, -15 },
  { 323, 7, 15, 9, 1, -15 },
  { 337, 7, 15, 10, 2, -15 },
  { 351, 5, 15, 8, 2, -15 },
  { 361, 5, 15, 7, 2, -15 },
  { 371, 9, 15, 11, 1, -15 },
  { 388, 7, 15, 10, 2, -15 },
  { 402, 3, 15, 5, 1, -15 },
  { 408, 3, 19, 4, -1, -15 },
  { 416, 6, 15, 8, 2, -15 },
  { 428, 5, 15, 7, 2, -15 },
  { 438, 10, 15, 14, 2, -15 },
  { 457, 7, 15, 11, 2, -15 },
  { 471, 9, 15, 11, 1, -15 },
  { 488, 6, 15, 8, 2, -15 },
  { 500, 9, 19, 11, 1, -15 },
  { 522, 6, 15, 8, 2, -15 },
  { 534, 6, 15, 8, 1, -15 },
  { 546, 7, 15, 7, 0, -15 },
  { 560, 7, 15, 10, 2, -15 },
  { 574, 8, 15, 8, 0, -15 },
  { 589, 13, 15, 14, 0, -15 },
  { 614, 7, 15, 7, 0, -15 },
  { 628, 7, 15, 7, 0, -15 },
  { 642, 5, 15, 7, 1, -15 },
  { 652, 4, 18, 6, 2, -15 },
  { 661, 5, 15, 7, 1, -15 },
  { 671, 4, 18, 6, 1, -15 },
  { 680, 8, 7, 8, 0, -15 },
  { 687, 8, 1, 8, 0, 2 },
  { 688, 3, 3, 5, 1, -16 },
  { 690, 5, 11, 8, 1, -11 },
  { 697, 7, 16, 9, 1, -16 },
  { 711, 5, 11, 7, 1, -11 },
  { 718, 6, 16, 9, 1, -16 },
  { 730, 6, 11, 8, 1, -11 },
  { 739, 5, 16, 4, 0, -16 },
  { 749, 6, 16, 9, 1, -11 },
  { 761, 6, 16, 9, 1, -16 },
  { 773, 1, 15, 4, 1, -15 },
  { 775, 2, 20, 4, 0, -15 },
  { 780, 6, 16, 7, 1, -16 },
  { 792, 1, 16, 4, 1, -16 },
  { 794, 10, 11, 13, 1, -11 },
  { 808, 6, 11, 9, 1, -11 },
  { 817, 7, 11, 8, 1, -11 },
  { 827, 7, 16, 9, 1, -11 },
  { 841, 6, 16, 9, 1, -11 },
  { 853, 4, 11, 6, 1, -11 },
  { 859, 5, 11, 7, 1, -11 },
  { 866, 4, 14, 4, 0, -14 },
  { 873, 6, 11, 9, 1, -11 },
  { 882, 6, 11, 6, 0, -11 },
  { 891, 11, 11, 11, 0, -11 },
  { 907, 6, 11, 7, 0, -11 },
  { 916, 6, 16, 7, 0, -11 },
  { 928, 4, 11, 5, 1, -11 },
  { 934, 5, 18, 7, 1, -15 },
  { 946, 1, 21, 8, 3, -16 },
  { 949, 5, 18, 7, 1, -15 },
  { 961, 7, 1, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Thin21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN21PT7B_H_
