#ifndef _NOTOSANS_EXTRACONDENSED_THIN12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFF, 0x32, 0x95, 0xF5, 0x2B, 0xEA, 0x50, 0x7A, 0xAA,
  0x63, 0x33, 0xE2, 0x96, 0xB5, 0xCF, 0xD5, 0x6B, 0x58, 0x22, 0x94, 0xC4,
  0x56, 0x52, 0xF8, 0xF0, 0x6A, 0xAA, 0xA4, 0x89, 0x12, 0x49, 0x4A, 0x00,
  0x5F, 0x00, 0x22, 0xF2, 0x22, 0xE0, 0xE0, 0x80, 0x11, 0x22, 0x24, 0x44,
  0x80, 0x56, 0xDB, 0x6D, 0xE0, 0x75, 0x55, 0x40, 0x61, 0x11, 0x12, 0x24,
  0xF0, 0x69, 0x11, 0x61, 0x11, 0xF0, 0x10, 0x8C, 0xA5, 0x4B, 0xE2, 0x10,
  0xF2, 0x46, 0x49, 0xE0, 0x72, 0x6B, 0x6D, 0xE0, 0xE4, 0x94, 0x94, 0x80,
  0x69, 0x95, 0x25, 0x99, 0x70, 0x69, 0x99, 0x97, 0x11, 0x60, 0x04, 0x07,
  0x12, 0xC6, 0x10, 0xF0, 0xF0, 0x86, 0x12, 0xC0, 0xC4, 0x94, 0x90, 0x40,
  0x72, 0x28, 0x6D, 0xD7, 0x5D, 0x6A, 0x81, 0xC0, 0x21, 0x18, 0xA5, 0x3A,
  0x51, 0x88, 0xE9, 0x99, 0xE9, 0x99, 0xE0, 0x78, 0x88, 0x88, 0x88, 0x70,
  0xE9, 0x99, 0x99, 0x99, 0xE0, 0xF2, 0x4F, 0x24, 0xE0, 0xF2, 0x4F, 0x24,
  0x80, 0x74, 0x21, 0x09, 0x46, 0x31, 0x78, 0x99, 0x99, 0xF9, 0x99, 0x90,
  0xD5, 0x55, 0xC0, 0x55, 0x55, 0x5C, 0x9A, 0xAC, 0x8C, 0xAA, 0x90, 0x92,
  0x49, 0x24, 0xE0, 0x86, 0x18, 0xE3, 0xCF, 0x3B, 0x6D, 0xA4, 0x99, 0x9D,
  0xDB, 0xB9, 0x90, 0x69, 0x99, 0x99, 0x99, 0xF0, 0xD6, 0xDB, 0xA4, 0x80,
  0x69, 0x99, 0x99, 0x99, 0xD2, 0x10, 0xCA, 0x99, 0xAC, 0xAA, 0x90, 0x78,
  0x88, 0x61, 0x11, 0xF0, 0xF4, 0x44, 0x44, 0x44, 0x40, 0x99, 0x99, 0x99,
  0x99, 0xF0, 0x99, 0x99, 0x55, 0x62, 0x20, 0x91, 0x91, 0x91, 0x9A, 0x5A,
  0x6A, 0x64, 0x24, 0x44, 0x99, 0x62, 0x22, 0x69, 0x90, 0x99, 0xA6, 0x44,
  0x44, 0x40, 0xF1, 0x22, 0x24, 0x48, 0xF0, 0xEA, 0xAA, 0xAC, 0x88, 0x44,
  0x42, 0x22, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x23, 0x15, 0x28, 0x80,
  0xF8, 0xD0, 0x71, 0x79, 0x9F, 0x88, 0xCA, 0x99, 0x99, 0xE0, 0xF2, 0x49,
  0xC0, 0x25, 0xDB, 0x6D, 0xE0, 0xF7, 0xC9, 0xC0, 0x6B, 0x24, 0x92, 0x40,
  0xF6, 0xDB, 0xC9, 0xE0, 0x93, 0x5B, 0x6D, 0xA0, 0x9F, 0x80, 0x9F, 0xF0,
  0x92, 0xED, 0x35, 0xA0, 0xFF, 0x80, 0xFD, 0x6B, 0x5A, 0xD4, 0xF6, 0xDB,
  0x40, 0xF6, 0xDB, 0xC0, 0xE9, 0x99, 0x9E, 0x88, 0x80, 0xF6, 0xDB, 0xC9,
  0x20, 0xEA, 0xA0, 0xF1, 0x13, 0xC0, 0x65, 0x55, 0xB6, 0xDB, 0xC0, 0xB6,
  0xB4, 0x80, 0xA6, 0x5B, 0x55, 0x49, 0x20, 0xB6, 0x44, 0x69, 0x99, 0x66,
  0x44, 0x44, 0x80, 0x65, 0x29, 0xC0, 0x2A, 0x49, 0x24, 0x91, 0x80, 0xFF,
  0xF0, 0x89, 0x24, 0xD2, 0x4A, 0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 2, 1, -9 },
  { 3, 2, 4, 4, 1, -9 },
  { 4, 5, 9, 5, 0, -9 },
  { 10, 4, 10, 5, 0, -9 },
  { 15, 5, 9, 7, 1, -9 },
  { 21, 5, 9, 5, 0, -9 },
  { 27, 1, 4, 2, 0, -9 },
  { 28, 2, 11, 3, 1, -9 },
  { 31, 3, 11, 3, 0, -9 },
  { 36, 3, 3, 4, 1, -9 },
  { 38, 4, 6, 5, 0, -7 },
  { 41, 1, 3, 2, 0, -1 },
  { 42, 3, 1, 3, 0, -4 },
  { 43, 1, 1, 2, 1, -1 },
  { 44, 4, 9, 4, 0, -9 },
  { 49, 3, 9, 5, 1, -9 },
  { 53, 2, 9, 5, 1, -9 },
  { 56, 4, 9, 5, 0, -9 },
  { 61, 4, 9, 5, 0, -9 },
  { 66, 5, 9, 5, 0, -9 },
  { 72, 3, 9, 5, 1, -9 },
  { 76, 3, 9, 5, 1, -9 },
  { 80, 3, 9, 5, 1, -9 },
  { 84, 4, 9, 5, 0, -9 },
  { 89, 4, 9, 5, 0, -9 },
  { 94, 1, 6, 2, 1, -6 },
  { 95, 1, 8, 2, 0, -6 },
  { 96, 4, 5, 5, 0, -7 },
  { 99, 4, 3, 5, 0, -6 },
  { 101, 4, 5, 5, 0, -7 },
  { 104, 3, 9, 3, 0, -9 },
  { 108, 6, 10, 7, 1, -9 },
  { 116, 5, 9, 5, 0, -9 },
  { 122, 4, 9, 5, 1, -9 },
  { 127, 4, 9, 5, 1, -9 },
  { 132, 4, 9, 6, 1, -9 },
  { 137, 3, 9, 5, 1, -9 },
  { 141, 3, 9, 4, 1, -9 },
  { 145, 5, 9, 6, 1, -9 },
  { 151, 4, 9, 6, 1, -9 },
  { 156, 2, 9, 3, 0, -9 },
  { 159, 2, 11, 2, -1, -9 },
  { 162, 4, 9, 5, 1, -9 },
  { 167, 3, 9, 4, 1, -9 },
  { 171, 6, 9, 8, 1, -9 },
  { 178, 4, 9, 6, 1, -9 },
  { 183, 4, 9, 6, 1, -9 },
  { 188, 3, 9, 5, 1, -9 },
  { 192, 4, 11, 6, 1, -9 },
  { 198, 4, 9, 5, 1, -9 },
  { 203, 4, 9, 5, 0, -9 },
  { 208, 4, 9, 4, 0, -9 },
  { 213, 4, 9, 6, 1, -9 },
  { 218, 4, 9, 4, 0, -9 },
  { 223, 8, 9, 8, 0, -9 },
  { 232, 4, 9, 4, 0, -9 },
  { 237, 4, 9, 4, 0, -9 },
  { 242, 4, 9, 4, 0, -9 },
  { 247, 2, 11, 4, 1, -9 },
  { 250, 4, 9, 4, 0, -9 },
  { 255, 3, 11, 4, 0, -9 },
  { 260, 5, 5, 5, 0, -9 },
  { 264, 5, 1, 5, 0, 1 },
  { 265, 2, 2, 3, 0, -9 },
  { 266, 4, 6, 4, 0, -6 },
  { 269, 4, 9, 5, 1, -9 },
  { 274, 3, 6, 4, 1, -6 },
  { 277, 3, 9, 5, 1, -9 },
  { 281, 3, 6, 5, 1, -6 },
  { 284, 3, 9, 3, 0, -9 },
  { 288, 3, 9, 5, 1, -6 },
  { 292, 3, 9, 5, 1, -9 },
  { 296, 1, 9, 2, 1, -9 },
  { 298, 1, 12, 2, 0, -9 },
  { 300, 3, 9, 4, 1, -9 },
  { 304, 1, 9, 2, 1, -9 },
  { 306, 5, 6, 7, 1, -6 },
  { 310, 3, 6, 5, 1, -6 },
  { 313, 3, 6, 5, 1, -6 },
  { 316, 4, 9, 5, 1, -6 },
  { 321, 3, 9, 5, 1, -6 },
  { 325, 2, 6, 3, 1, -6 },
  { 327, 3, 6, 4, 0, -6 },
  { 330, 2, 8, 3, 0, -8 },
  { 332, 3, 6, 5, 1, -6 },
  { 335, 3, 6, 4, 0, -6 },
  { 338, 6, 6, 6, 0, -6 },
  { 343, 4, 6, 4, 0, -6 },
  { 346, 4, 9, 4, 0, -6 },
  { 351, 3, 6, 3, 0, -6 },
  { 354, 3, 11, 4, 1, -9 },
  { 359, 1, 12, 5, 2, -9 },
  { 361, 3, 11, 4, 1, -9 },
  { 366, 4, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Thin12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN12PT7B_H_
