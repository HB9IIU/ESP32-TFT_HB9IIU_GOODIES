#ifndef _NOTOSANS_EXTRACONDENSED_THIN45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin45pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x00,
  0xBE, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x02,
  0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20,
  0x18, 0x30, 0x0C, 0x10, 0x04, 0x08, 0x3F, 0xFF, 0xC1, 0x02, 0x00, 0x81,
  0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20, 0x18, 0x30, 0x08, 0x10, 0x04,
  0x08, 0x02, 0x04, 0x01, 0x02, 0x0F, 0xFF, 0xF0, 0x40, 0x80, 0x20, 0x40,
  0x10, 0x20, 0x18, 0x30, 0x08, 0x10, 0x04, 0x08, 0x02, 0x04, 0x01, 0x02,
  0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0F,
  0x00, 0xFB, 0xC3, 0x10, 0x4C, 0x20, 0x10, 0x40, 0x20, 0x80, 0xC1, 0x01,
  0x82, 0x03, 0x04, 0x02, 0x08, 0x04, 0x10, 0x0C, 0x20, 0x0C, 0x40, 0x0C,
  0x80, 0x0D, 0x00, 0x06, 0x00, 0x07, 0x00, 0x09, 0x80, 0x11, 0x80, 0x20,
  0x80, 0x41, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0xA0, 0x43, 0x78, 0x9C, 0x1F, 0xC0, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0xD8, 0x06, 0x06, 0x20,
  0x10, 0x10, 0x40, 0x40, 0x41, 0x03, 0x03, 0x04, 0x08, 0x08, 0x18, 0x20,
  0x20, 0x21, 0x80, 0x80, 0x84, 0x02, 0x02, 0x10, 0x08, 0x08, 0xC0, 0x20,
  0x22, 0x00, 0x80, 0x88, 0x02, 0x06, 0x63, 0x88, 0x19, 0x13, 0x30, 0x44,
  0x84, 0x41, 0x32, 0x09, 0x04, 0x88, 0x26, 0x22, 0x40, 0x8F, 0x99, 0x03,
  0x08, 0x44, 0x0C, 0x01, 0x10, 0x10, 0x0C, 0x40, 0x40, 0x21, 0x01, 0x00,
  0x84, 0x04, 0x06, 0x10, 0x10, 0x10, 0x40, 0xC0, 0x41, 0x02, 0x01, 0x06,
  0x08, 0x08, 0x08, 0x20, 0x20, 0x20, 0x80, 0x80, 0xC4, 0x04, 0x01, 0xF0,
  0x02, 0x00, 0x0F, 0xC0, 0x08, 0x40, 0x10, 0x60, 0x10, 0x20, 0x10, 0x20,
  0x10, 0x20, 0x10, 0x20, 0x10, 0x20, 0x10, 0x20, 0x18, 0x60, 0x08, 0x40,
  0x08, 0x40, 0x04, 0x80, 0x05, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x19, 0x00,
  0x31, 0x00, 0x20, 0x82, 0x60, 0x82, 0x40, 0x42, 0x40, 0x62, 0x40, 0x22,
  0xC0, 0x32, 0xC0, 0x14, 0xC0, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0x40, 0x14,
  0x20, 0x32, 0x30, 0x63, 0x1F, 0xC1, 0xFF, 0xE0, 0x03, 0x02, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x02, 0x03, 0xC0,
  0x40, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x40, 0xC0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x1E, 0x4E, 0x3E, 0x01, 0x80,
  0x50, 0x11, 0x04, 0x11, 0x81, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x24, 0x96,
  0x92, 0xD2, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x3F, 0x01, 0x86, 0x0C, 0x0C, 0x20, 0x10, 0x80, 0x44, 0x01, 0x90, 0x02,
  0x40, 0x09, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0x80, 0x0A, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x2C, 0x00, 0xB0, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x98, 0x06, 0x20,
  0x10, 0x80, 0x43, 0x02, 0x06, 0x18, 0x0F, 0xC0, 0x03, 0x05, 0x0D, 0x11,
  0x21, 0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x00, 0xFF, 0x0C, 0x06, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xFF, 0xFC, 0x06, 0x01, 0xFE, 0x30, 0x19, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x01, 0x80, 0x30, 0x1F, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0xD0, 0x0C, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x50, 0x00, 0x50, 0x00, 0x90, 0x00, 0x90, 0x01, 0x10,
  0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x04, 0x10, 0x08, 0x10,
  0x08, 0x10, 0x18, 0x10, 0x10, 0x10, 0x30, 0x10, 0x20, 0x10, 0x60, 0x10,
  0x40, 0x10, 0xC0, 0x10, 0x80, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x7F, 0xF1, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0xFF,
  0x0E, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x10, 0x00, 0xCC, 0x06, 0x1F, 0xE0, 0x03, 0xF0, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC3, 0x03, 0x3F, 0x89, 0x03, 0x28, 0x04,
  0xA0, 0x0B, 0x00, 0x2C, 0x00, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x40, 0x0D, 0x00, 0x34, 0x00, 0x90, 0x02, 0x20, 0x18, 0x80,
  0x41, 0x03, 0x03, 0xF8, 0x03, 0x80, 0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x02, 0x00,
  0x7F, 0x83, 0x03, 0x18, 0x04, 0x40, 0x09, 0x00, 0x2C, 0x00, 0xB0, 0x02,
  0xC0, 0x09, 0x00, 0x24, 0x00, 0x98, 0x06, 0x20, 0x30, 0x41, 0x80, 0xCC,
  0x01, 0xC0, 0x07, 0x80, 0x23, 0x03, 0x06, 0x08, 0x04, 0x40, 0x1B, 0x00,
  0x28, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0F, 0x00, 0x26, 0x01, 0x8C, 0x0C, 0x1F, 0xE0, 0x06, 0x00, 0xFE, 0x0C,
  0x18, 0xC0, 0x44, 0x01, 0x60, 0x0A, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x03, 0x40, 0x1A,
  0x01, 0xC8, 0x0A, 0x3B, 0x90, 0x70, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x30,
  0x7F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x6D, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x12, 0x4B, 0x49, 0x69, 0x00, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x08, 0x3F, 0xC8, 0x18, 0x02, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0x03, 0x80, 0x18, 0x01, 0x80, 0x20, 0x01, 0x00,
  0x80, 0x01, 0x03, 0x00, 0x03, 0x04, 0x00, 0x02, 0x18, 0x00, 0x06, 0x20,
  0x00, 0x04, 0x40, 0x7E, 0x09, 0x81, 0x84, 0x12, 0x06, 0x18, 0x34, 0x08,
  0x30, 0x68, 0x10, 0x60, 0x50, 0x60, 0xC0, 0xA0, 0x81, 0x81, 0xC1, 0x02,
  0x03, 0x82, 0x04, 0x07, 0x04, 0x08, 0x0E, 0x08, 0x10, 0x1C, 0x10, 0x20,
  0x68, 0x20, 0x40, 0x90, 0x41, 0x81, 0x20, 0xC2, 0x82, 0x40, 0x85, 0x0C,
  0x81, 0x93, 0x31, 0x01, 0xC3, 0xC3, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04,
  0x40, 0x02, 0x20, 0x03, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x41, 0x00,
  0x60, 0xC0, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x06, 0x07, 0xFF,
  0x02, 0x00, 0x81, 0x00, 0x41, 0x80, 0x20, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x02, 0x10, 0x01, 0x18, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x12, 0x00, 0x0B,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0x82, 0x01, 0x88, 0x03, 0x20, 0x04, 0x80,
  0x1A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x01, 0xA0,
  0x04, 0x80, 0x32, 0x01, 0x88, 0x3C, 0x3F, 0xF0, 0x80, 0x62, 0x00, 0x48,
  0x01, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0xC8, 0x0E, 0x3F, 0xE0,
  0x00, 0x20, 0x03, 0xFF, 0x06, 0x02, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x07, 0x01, 0x01, 0xFE, 0xFF, 0x01, 0x01, 0x82, 0x00, 0x84,
  0x00, 0x88, 0x01, 0x90, 0x01, 0x20, 0x03, 0x40, 0x02, 0x80, 0x05, 0x00,
  0x0A, 0x00, 0x14, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xA0,
  0x01, 0x40, 0x02, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x24, 0x00, 0xC8, 0x03,
  0x10, 0x0C, 0x20, 0x70, 0x7F, 0x80, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x07, 0xFE, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x07, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0xFF, 0xD0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x00, 0x1C,
  0x00, 0x3F, 0xF0, 0x0C, 0x03, 0x82, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0xFF, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02,
  0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x60, 0x00, 0x24, 0x00, 0x04,
  0x80, 0x00, 0x98, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x43, 0x00, 0x08,
  0x18, 0x03, 0x01, 0xFF, 0x80, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x3F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x60, 0xA3, 0x7C,
  0x80, 0x1C, 0x01, 0xA0, 0x09, 0x00, 0x88, 0x04, 0x40, 0x42, 0x06, 0x10,
  0x20, 0x82, 0x04, 0x10, 0x21, 0x01, 0x18, 0x08, 0x80, 0x48, 0x02, 0xC0,
  0x15, 0x00, 0xE8, 0x06, 0x20, 0x21, 0x01, 0x04, 0x08, 0x20, 0x40, 0x82,
  0x04, 0x10, 0x10, 0x80, 0x84, 0x02, 0x20, 0x11, 0x00, 0x48, 0x02, 0x40,
  0x0A, 0x00, 0x50, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0x70, 0x00, 0x05, 0xE0, 0x00, 0x16, 0x80, 0x00,
  0xDA, 0x00, 0x02, 0x6C, 0x00, 0x09, 0x90, 0x00, 0x66, 0x40, 0x01, 0x19,
  0x00, 0x04, 0x62, 0x00, 0x11, 0x88, 0x00, 0x86, 0x20, 0x02, 0x18, 0xC0,
  0x08, 0x61, 0x00, 0x61, 0x84, 0x01, 0x06, 0x18, 0x04, 0x18, 0x20, 0x30,
  0x60, 0x80, 0x81, 0x83, 0x02, 0x06, 0x04, 0x18, 0x18, 0x10, 0x40, 0x60,
  0x41, 0x01, 0x81, 0x84, 0x06, 0x02, 0x30, 0x18, 0x08, 0x80, 0x60, 0x32,
  0x01, 0x80, 0x58, 0x06, 0x01, 0x40, 0x18, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1A, 0x00, 0x34, 0x00, 0x64,
  0x00, 0xC8, 0x01, 0x88, 0x03, 0x10, 0x06, 0x30, 0x0C, 0x20, 0x18, 0x40,
  0x30, 0x40, 0x60, 0x80, 0xC0, 0x81, 0x81, 0x03, 0x03, 0x06, 0x02, 0x0C,
  0x06, 0x18, 0x04, 0x30, 0x08, 0x60, 0x08, 0xC0, 0x11, 0x80, 0x13, 0x00,
  0x26, 0x00, 0x6C, 0x00, 0x58, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x00, 0xE0, 0x00, 0x7F, 0x80, 0x30, 0x18, 0x0C, 0x01, 0x81, 0x00, 0x10,
  0x60, 0x03, 0x08, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0xC8, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0xB0, 0x00, 0x16,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x24,
  0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x4C,
  0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0x43, 0x00, 0x18, 0x20, 0x02, 0x02,
  0x00, 0xC0, 0x60, 0x30, 0x03, 0xF8, 0x00, 0xFF, 0x08, 0x1C, 0x80, 0x68,
  0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x28, 0x06, 0x81, 0xCF, 0xF0, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x80,
  0x30, 0x18, 0x0C, 0x01, 0x81, 0x00, 0x10, 0x60, 0x03, 0x08, 0x00, 0x21,
  0x00, 0x04, 0x40, 0x00, 0xC8, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x24,
  0x00, 0x04, 0x80, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x04, 0x80, 0x00, 0x90,
  0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x4C, 0x00, 0x18, 0x80, 0x02, 0x10,
  0x00, 0x43, 0x00, 0x18, 0x20, 0x02, 0x02, 0x00, 0xC0, 0x60, 0x30, 0x03,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0xFF, 0x04, 0x0E,
  0x20, 0x19, 0x00, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12, 0x01, 0x90, 0x18, 0xFF,
  0x87, 0xF0, 0x20, 0x81, 0x06, 0x08, 0x10, 0x40, 0x82, 0x02, 0x10, 0x10,
  0x80, 0x44, 0x02, 0x20, 0x19, 0x00, 0x48, 0x03, 0x40, 0x0A, 0x00, 0x70,
  0x01, 0x01, 0x00, 0x3F, 0xE3, 0x00, 0x98, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x03, 0x20, 0x18, 0xFF, 0xC0, 0xFF,
  0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x18,
  0x18, 0x0F, 0xF0, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40,
  0x02, 0x40, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x04, 0x30,
  0x04, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x18, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x08, 0x10, 0x08, 0x10, 0x04, 0x10, 0x04, 0x30, 0x04, 0x20, 0x04,
  0x20, 0x06, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x01,
  0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x02, 0x00, 0x1A, 0x00,
  0x10, 0x00, 0xD0, 0x01, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x24, 0x00, 0x50,
  0x01, 0x30, 0x02, 0x80, 0x18, 0x80, 0x14, 0x00, 0x84, 0x01, 0xB0, 0x04,
  0x20, 0x08, 0x80, 0x21, 0x80, 0x44, 0x01, 0x0C, 0x02, 0x20, 0x18, 0x20,
  0x11, 0x00, 0x81, 0x01, 0x8C, 0x04, 0x08, 0x08, 0x20, 0x20, 0x60, 0x41,
  0x03, 0x01, 0x02, 0x08, 0x10, 0x08, 0x10, 0x40, 0x80, 0x41, 0x83, 0x04,
  0x02, 0x08, 0x08, 0x20, 0x18, 0x40, 0x43, 0x00, 0x42, 0x02, 0x10, 0x02,
  0x10, 0x10, 0x80, 0x11, 0x80, 0xC4, 0x00, 0xC8, 0x02, 0x60, 0x06, 0x40,
  0x12, 0x00, 0x12, 0x00, 0x90, 0x00, 0x90, 0x04, 0x80, 0x05, 0x80, 0x24,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x30, 0x01, 0x80, 0x20, 0x04, 0x80, 0x13, 0x00, 0x84, 0x02, 0x10, 0x18,
  0x20, 0x40, 0x81, 0x03, 0x0C, 0x04, 0x20, 0x10, 0x80, 0x64, 0x00, 0x90,
  0x02, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x24,
  0x01, 0x90, 0x04, 0x40, 0x10, 0x80, 0x82, 0x02, 0x08, 0x18, 0x10, 0x40,
  0x41, 0x01, 0x88, 0x02, 0x20, 0x09, 0x80, 0x34, 0x00, 0x70, 0x01, 0x80,
  0x05, 0x00, 0x34, 0x00, 0x90, 0x02, 0x20, 0x18, 0x80, 0x42, 0x01, 0x04,
  0x0C, 0x10, 0x20, 0x40, 0x80, 0x86, 0x02, 0x10, 0x08, 0x40, 0x11, 0x00,
  0x48, 0x01, 0x20, 0x02, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x7F, 0xF0, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x01, 0x80, 0x01,
  0xC0, 0x03, 0x40, 0x02, 0x40, 0x06, 0x20, 0x04, 0x20, 0x0C, 0x10, 0x08,
  0x10, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x40,
  0x02, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x40,
  0x1F, 0x8C, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x87, 0xD3, 0x02, 0xC0, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x80, 0xD0, 0x29, 0xF9, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0xFC, 0x26, 0x08, 0xB0, 0x12, 0x80, 0x6C, 0x00, 0xB0,
  0x02, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0B,
  0x00, 0x2A, 0x01, 0xA8, 0x04, 0x98, 0x22, 0x3F, 0x00, 0x07, 0xE3, 0x84,
  0x40, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x7F, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0xFC, 0x46, 0x19, 0x30, 0x14, 0x80, 0x54, 0x00, 0xD0, 0x03, 0x40, 0x0F,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x40, 0x0D, 0x00, 0x36, 0x01,
  0x48, 0x05, 0x30, 0x24, 0x3F, 0x10, 0x0F, 0x80, 0xC3, 0x0C, 0x08, 0x40,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03,
  0xFF, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x41, 0xFE, 0x07, 0xE1, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x03, 0xFC,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x0F, 0xC4, 0x61, 0x93,
  0x01, 0x48, 0x05, 0x40, 0x0D, 0x00, 0x34, 0x00, 0xF0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0F, 0x00, 0x34, 0x00, 0xD0, 0x03, 0x60, 0x14, 0x80, 0x51, 0x02,
  0x43, 0xF1, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x06, 0x80, 0x31, 0xC7, 0x81, 0xF8, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x8F, 0xC9, 0x86, 0xB0, 0x2A, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0xC6,
  0x00, 0x00, 0x00, 0x00, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x62, 0x10,
  0xAD, 0xC0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x01, 0xC0, 0x28, 0x09, 0x03, 0x20, 0x44, 0x18,
  0x82, 0x10, 0x82, 0x30, 0x44, 0x09, 0x41, 0x28, 0x29, 0x86, 0x10, 0xC2,
  0x10, 0x22, 0x04, 0x40, 0xC8, 0x09, 0x01, 0x20, 0x14, 0x02, 0x80, 0x70,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x8F, 0x83, 0xE4, 0x86, 0x21, 0xA8,
  0x12, 0x05, 0x40, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x8F, 0xC9, 0x86,
  0xB0, 0x2A, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x0F, 0xC0, 0x61,
  0x82, 0x01, 0x18, 0x06, 0x40, 0x09, 0x00, 0x24, 0x00, 0xF0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x05, 0x00, 0x34, 0x00, 0x90, 0x02, 0x60, 0x08, 0x80, 0x41,
  0x03, 0x03, 0xF8, 0x8F, 0xC2, 0x61, 0x8B, 0x01, 0x28, 0x06, 0xA0, 0x0B,
  0x00, 0x2C, 0x00, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xB0, 0x02, 0xA0, 0x1A, 0xC0, 0x49, 0x82, 0x23, 0xF0, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x00, 0x0F, 0xC4, 0x61, 0x93, 0x01, 0x48, 0x05, 0x60, 0x0D,
  0x00, 0x34, 0x00, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x34, 0x00,
  0xD0, 0x03, 0x60, 0x14, 0x80, 0x51, 0x06, 0x43, 0xF1, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x8F, 0x99, 0x90, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x1F, 0x8C, 0x09, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x20, 0x04, 0x01, 0xA0, 0x27, 0xF8,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0xFF, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x30, 0x10, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03,
  0xC0, 0x34, 0x05, 0x60, 0xD3, 0xF9, 0x80, 0x0A, 0x00, 0xD0, 0x04, 0x80,
  0x24, 0x01, 0x30, 0x18, 0x80, 0x84, 0x04, 0x20, 0x21, 0x81, 0x04, 0x18,
  0x20, 0x81, 0x04, 0x0C, 0x20, 0x23, 0x01, 0x10, 0x08, 0x80, 0x44, 0x01,
  0x60, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x1C, 0x00, 0x40, 0xC0, 0x10, 0x06,
  0x80, 0x30, 0x09, 0x00, 0x60, 0x12, 0x01, 0x40, 0x26, 0x02, 0x80, 0x44,
  0x05, 0x01, 0x08, 0x09, 0x02, 0x10, 0x32, 0x04, 0x20, 0x44, 0x08, 0x20,
  0x88, 0x30, 0x41, 0x18, 0x40, 0x82, 0x10, 0x81, 0x0C, 0x21, 0x03, 0x10,
  0x42, 0x02, 0x20, 0x88, 0x04, 0x41, 0x90, 0x09, 0x81, 0x20, 0x12, 0x02,
  0x40, 0x14, 0x05, 0x80, 0x28, 0x0A, 0x00, 0x50, 0x1C, 0x00, 0xA0, 0x18,
  0x01, 0x80, 0x30, 0x01, 0x00, 0x60, 0xC0, 0x14, 0x03, 0x60, 0x22, 0x06,
  0x20, 0x41, 0x04, 0x10, 0x81, 0x88, 0x09, 0x00, 0xD0, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x09, 0x00, 0x98, 0x18, 0x81, 0x08, 0x30, 0x42, 0x04,
  0x60, 0x24, 0x02, 0xC0, 0x38, 0x01, 0x40, 0x05, 0x00, 0x22, 0x00, 0x88,
  0x02, 0x20, 0x08, 0x80, 0x41, 0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0x80,
  0x82, 0x02, 0x08, 0x08, 0x20, 0x21, 0x00, 0x44, 0x01, 0x10, 0x04, 0x40,
  0x12, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x02, 0x60, 0x0E, 0x00, 0x00, 0x7F, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x0C,
  0x03, 0xFF, 0x00, 0xE0, 0x60, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x80, 0x60, 0x70, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x60, 0x06, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0x03, 0x00, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x06, 0x00, 0x30, 0x18, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x30, 0x3C, 0x00, 0x1C, 0x00, 0x67, 0x01,
  0xC0, 0xC6, 0x80, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_Thin45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 32, 9, 3, -32 },
  { 13, 7, 11, 13, 3, -32 },
  { 23, 17, 32, 19, 1, -32 },
  { 91, 15, 37, 18, 1, -34 },
  { 161, 22, 33, 26, 2, -33 },
  { 252, 16, 33, 17, 1, -33 },
  { 318, 1, 11, 7, 3, -32 },
  { 320, 8, 39, 12, 2, -32 },
  { 359, 8, 39, 12, 2, -32 },
  { 398, 11, 11, 15, 2, -34 },
  { 414, 16, 20, 18, 1, -26 },
  { 454, 3, 11, 8, 2, -5 },
  { 459, 10, 1, 12, 1, -13 },
  { 461, 2, 3, 8, 3, -3 },
  { 462, 13, 32, 15, 1, -32 },
  { 514, 14, 33, 18, 2, -33 },
  { 572, 8, 32, 18, 3, -32 },
  { 604, 14, 33, 18, 2, -33 },
  { 662, 13, 33, 18, 2, -33 },
  { 716, 16, 32, 18, 1, -32 },
  { 780, 14, 32, 18, 2, -32 },
  { 836, 14, 33, 18, 2, -32 },
  { 894, 13, 32, 18, 2, -32 },
  { 946, 14, 33, 18, 2, -33 },
  { 1004, 13, 33, 18, 2, -33 },
  { 1058, 2, 24, 8, 3, -24 },
  { 1064, 3, 30, 8, 2, -24 },
  { 1076, 16, 18, 18, 1, -25 },
  { 1112, 16, 11, 18, 1, -21 },
  { 1134, 16, 18, 18, 1, -25 },
  { 1170, 10, 33, 12, 1, -33 },
  { 1212, 23, 36, 27, 2, -32 },
  { 1316, 17, 32, 17, 0, -32 },
  { 1384, 14, 32, 19, 4, -32 },
  { 1440, 16, 33, 19, 2, -33 },
  { 1506, 15, 32, 21, 4, -32 },
  { 1566, 11, 32, 17, 4, -32 },
  { 1610, 11, 32, 16, 4, -32 },
  { 1654, 19, 33, 23, 2, -33 },
  { 1733, 14, 32, 22, 4, -32 },
  { 1789, 6, 32, 10, 2, -32 },
  { 1813, 7, 40, 8, -2, -32 },
  { 1848, 13, 32, 17, 4, -32 },
  { 1900, 10, 32, 15, 4, -32 },
  { 1940, 22, 32, 29, 4, -32 },
  { 2028, 15, 32, 23, 4, -32 },
  { 2088, 19, 33, 23, 2, -33 },
  { 2167, 12, 32, 18, 4, -32 },
  { 2215, 19, 41, 23, 2, -33 },
  { 2313, 13, 32, 18, 4, -32 },
  { 2365, 14, 33, 18, 2, -33 },
  { 2423, 15, 32, 15, 0, -32 },
  { 2483, 16, 32, 22, 3, -32 },
  { 2547, 16, 32, 16, 0, -32 },
  { 2611, 29, 32, 29, 0, -32 },
  { 2727, 14, 32, 15, 0, -32 },
  { 2783, 14, 32, 14, 0, -32 },
  { 2839, 13, 32, 15, 1, -32 },
  { 2891, 8, 39, 14, 4, -32 },
  { 2930, 13, 32, 15, 1, -32 },
  { 2982, 8, 39, 14, 2, -32 },
  { 3021, 16, 15, 18, 1, -32 },
  { 3051, 18, 1, 18, 0, 4 },
  { 3054, 6, 7, 10, 2, -34 },
  { 3060, 11, 24, 16, 2, -24 },
  { 3093, 14, 34, 19, 3, -34 },
  { 3153, 11, 24, 14, 2, -24 },
  { 3186, 14, 34, 19, 2, -34 },
  { 3246, 13, 24, 17, 2, -24 },
  { 3285, 11, 34, 10, 0, -34 },
  { 3332, 14, 35, 19, 2, -24 },
  { 3394, 12, 34, 18, 3, -34 },
  { 3445, 2, 33, 8, 3, -33 },
  { 3454, 5, 44, 8, 0, -33 },
  { 3482, 11, 34, 15, 3, -34 },
  { 3529, 1, 34, 8, 3, -34 },
  { 3534, 21, 24, 27, 3, -24 },
  { 3597, 12, 24, 18, 3, -24 },
  { 3633, 14, 24, 18, 2, -24 },
  { 3675, 14, 34, 19, 3, -24 },
  { 3735, 14, 34, 19, 2, -24 },
  { 3795, 8, 24, 12, 3, -24 },
  { 3819, 11, 24, 14, 2, -24 },
  { 3852, 8, 30, 9, 1, -30 },
  { 3882, 12, 24, 18, 3, -24 },
  { 3918, 13, 24, 13, 0, -24 },
  { 3957, 23, 24, 23, 0, -24 },
  { 4026, 12, 24, 14, 1, -24 },
  { 4062, 14, 35, 14, 0, -24 },
  { 4124, 10, 24, 12, 1, -24 },
  { 4154, 11, 39, 16, 2, -32 },
  { 4208, 1, 45, 17, 8, -34 },
  { 4214, 11, 39, 16, 2, -32 },
  { 4268, 16, 4, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Thin45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN45PT7B_H_
