#ifndef _NOTOSANS_EXTRACONDENSED_THIN59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin59pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xA4,
  0x92, 0x00, 0x00, 0x1F, 0xFC, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x02, 0x00, 0xC0,
  0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x08, 0x04,
  0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20, 0x01, 0x80, 0x40,
  0x03, 0x00, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x07, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC0, 0x40, 0x20, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x06,
  0x01, 0x00, 0x0C, 0x02, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x30, 0x00, 0x80, 0x60, 0x01, 0x00, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02,
  0x00, 0x18, 0x04, 0x07, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0xC0, 0x02, 0x01, 0x80, 0x04, 0x02, 0x00, 0x08, 0x04, 0x00,
  0x10, 0x08, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x20, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x80, 0x04, 0x03, 0x00, 0x08, 0x06, 0x00, 0x10, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x39,
  0x87, 0x8C, 0x30, 0x23, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x03, 0x03,
  0x00, 0x60, 0x60, 0x08, 0x0C, 0x01, 0x01, 0x80, 0x20, 0x30, 0x06, 0x06,
  0x00, 0xC0, 0xC0, 0x08, 0x18, 0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x8C,
  0x00, 0x1D, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1B,
  0x80, 0x03, 0x1C, 0x00, 0x61, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0x80, 0x30,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x10, 0x06, 0x06, 0x80, 0xC1,
  0x9E, 0x18, 0xE0, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x80,
  0x21, 0x80, 0x18, 0x06, 0x0C, 0x01, 0x80, 0x40, 0x40, 0x10, 0x0C, 0x04,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x02, 0x00, 0x80, 0x60, 0x20,
  0x08, 0x06, 0x06, 0x00, 0x80, 0x20, 0x40, 0x08, 0x02, 0x04, 0x00, 0x80,
  0x20, 0xC0, 0x08, 0x02, 0x08, 0x00, 0x80, 0x20, 0x80, 0x08, 0x02, 0x18,
  0x00, 0x80, 0x21, 0x00, 0x08, 0x06, 0x10, 0x70, 0x80, 0x63, 0x1D, 0x8C,
  0x06, 0x21, 0x04, 0xC0, 0x42, 0x30, 0x6C, 0x04, 0x62, 0x02, 0x40, 0xC4,
  0x60, 0x26, 0x0C, 0x46, 0x03, 0x31, 0x8C, 0x40, 0x33, 0xF0, 0x84, 0x03,
  0x0E, 0x08, 0x40, 0x30, 0x01, 0x84, 0x01, 0x00, 0x10, 0x40, 0x10, 0x01,
  0x04, 0x01, 0x00, 0x30, 0x40, 0x10, 0x03, 0x04, 0x01, 0x00, 0x20, 0x40,
  0x10, 0x06, 0x04, 0x03, 0x00, 0x60, 0x40, 0x30, 0x04, 0x04, 0x03, 0x00,
  0xC0, 0x60, 0x30, 0x0C, 0x06, 0x02, 0x00, 0x80, 0x20, 0x20, 0x18, 0x02,
  0x06, 0x01, 0x80, 0x30, 0x60, 0x10, 0x01, 0x8C, 0x03, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x20, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0x04, 0x00, 0x10,
  0x30, 0x00, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80,
  0x10, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x00, 0x80,
  0x80, 0x04, 0x04, 0x00, 0x30, 0x60, 0x01, 0x82, 0x00, 0x04, 0x30, 0x00,
  0x31, 0x00, 0x00, 0x98, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x32, 0x00, 0x03, 0x18, 0x00, 0x30, 0x40, 0x01, 0x01, 0x01, 0x98,
  0x0C, 0x0C, 0x80, 0x20, 0x4C, 0x01, 0x82, 0x60, 0x04, 0x13, 0x00, 0x30,
  0x90, 0x00, 0x8C, 0x80, 0x06, 0x44, 0x00, 0x12, 0x20, 0x00, 0x71, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xE1, 0x00, 0x0D, 0x0C, 0x00, 0xCC,
  0x30, 0x0C, 0x20, 0xC1, 0xC1, 0x83, 0xFC, 0x06, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x20, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80,
  0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0xE0, 0x04, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xC0, 0x30, 0x04, 0x03, 0x80, 0x00, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x02, 0x04, 0x17, 0x13, 0x83, 0x78, 0x03, 0x00, 0x0E, 0x00,
  0x48, 0x02, 0x10, 0x10, 0x20, 0xC0, 0xC6, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x23, 0x18,
  0x84, 0x60, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0xFC, 0x03, 0x07, 0x03, 0x01, 0x81, 0x00, 0x61,
  0x80, 0x10, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x01, 0x20, 0x00, 0x90, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x40, 0x01, 0xA0,
  0x00, 0xD8, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x08,
  0x30, 0x0C, 0x1C, 0x0C, 0x07, 0x0C, 0x00, 0xFC, 0x00, 0x01, 0x81, 0xC1,
  0xA1, 0x91, 0x89, 0x87, 0x83, 0x81, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x01, 0xE0, 0x07,
  0xFE, 0x07, 0x80, 0xE0, 0x80, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xE0,
  0x07, 0xFE, 0x03, 0x80, 0xE3, 0x80, 0x1C, 0x40, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x80, 0x07, 0x3C, 0x03, 0x83, 0xFF, 0x80, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40,
  0x00, 0x0D, 0x00, 0x00, 0x24, 0x00, 0x01, 0x90, 0x00, 0x04, 0x40, 0x00,
  0x31, 0x00, 0x00, 0xC4, 0x00, 0x06, 0x10, 0x00, 0x18, 0x40, 0x00, 0xC1,
  0x00, 0x03, 0x04, 0x00, 0x18, 0x10, 0x00, 0x60, 0x40, 0x03, 0x01, 0x00,
  0x0C, 0x04, 0x00, 0x60, 0x10, 0x01, 0x80, 0x40, 0x04, 0x01, 0x00, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x40, 0x10, 0x01, 0x00, 0xC0, 0x04,
  0x02, 0x00, 0x10, 0x18, 0x00, 0x40, 0x40, 0x01, 0x03, 0x00, 0x04, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFE, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x37,
  0xFC, 0x0F, 0xE7, 0xC1, 0x00, 0x38, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x62, 0x00, 0x30, 0xE0, 0x38, 0x1F, 0xFC, 0x00, 0x20, 0x00, 0x01, 0xFF,
  0x00, 0xE0, 0x40, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC1, 0xE0,
  0x31, 0xFE, 0x0C, 0xC0, 0xE3, 0x40, 0x08, 0xF0, 0x03, 0x28, 0x00, 0x4E,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x90, 0x00, 0x24, 0x00, 0x09, 0x80, 0x06, 0x60, 0x01, 0x88, 0x00, 0x43,
  0x00, 0x30, 0x60, 0x18, 0x1C, 0x0C, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x38, 0x18,
  0x0C, 0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x08, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0x4C, 0x00, 0x09, 0x80, 0x01, 0x30, 0x00, 0x66, 0x00, 0x0C,
  0x40, 0x01, 0x8C, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x01, 0x80, 0xC0,
  0x1C, 0x30, 0x00, 0xDC, 0x00, 0x0E, 0x00, 0x03, 0x60, 0x00, 0xC6, 0x00,
  0x70, 0x70, 0x18, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0x66,
  0x00, 0x04, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x06, 0xC0, 0x00, 0x98,
  0x00, 0x31, 0x80, 0x0C, 0x18, 0x03, 0x81, 0xC0, 0xE0, 0x1F, 0xF0, 0x00,
  0x20, 0x00, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x30,
  0x03, 0x08, 0x00, 0x46, 0x00, 0x19, 0x80, 0x06, 0x40, 0x00, 0x90, 0x00,
  0x24, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0xC8, 0x00, 0x53, 0x00, 0x1C, 0x40, 0x0B, 0x18, 0x0C, 0xC3, 0xFE,
  0x30, 0x1E, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x08, 0x1C,
  0x03, 0xFE, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x6F, 0xF8, 0x39, 0xCE, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x31, 0x88,
  0xC6, 0x31, 0x18, 0xC4, 0x23, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x03, 0xFE, 0x30, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x04, 0x02, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x04,
  0x20, 0x07, 0xF0, 0x19, 0x80, 0x38, 0xC0, 0x66, 0x01, 0x81, 0x01, 0x98,
  0x04, 0x04, 0x02, 0x40, 0x30, 0x10, 0x09, 0x00, 0x80, 0xC0, 0x2C, 0x06,
  0x03, 0x00, 0xB0, 0x18, 0x0C, 0x03, 0xC0, 0x40, 0x30, 0x0F, 0x01, 0x00,
  0xC0, 0x3C, 0x04, 0x03, 0x00, 0xF0, 0x10, 0x0C, 0x03, 0xC0, 0x40, 0x30,
  0x0F, 0x01, 0x00, 0xC0, 0x2C, 0x04, 0x03, 0x00, 0xB0, 0x10, 0x0C, 0x02,
  0xC0, 0x40, 0x30, 0x1B, 0x01, 0x81, 0xC0, 0x6C, 0x06, 0x05, 0x01, 0x90,
  0x18, 0x14, 0x0C, 0x40, 0x30, 0xD8, 0x31, 0x80, 0xE6, 0x31, 0x86, 0x01,
  0xF0, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x08, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1A, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x84,
  0x00, 0x02, 0x18, 0x00, 0x18, 0x60, 0x00, 0x60, 0x80, 0x01, 0x82, 0x00,
  0x04, 0x08, 0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x00, 0x08,
  0x04, 0x00, 0x20, 0x18, 0x01, 0x80, 0x60, 0x06, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x0C, 0x03, 0x00, 0x30, 0x0F, 0xFF, 0xC0, 0x30, 0x01, 0x00,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x00, 0x81, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x42, 0x00, 0x01,
  0x08, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x24, 0x00, 0x00, 0x90,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x10, 0xFF, 0xF0, 0x20, 0x1F,
  0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x68, 0x00, 0x1A,
  0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x06, 0x80,
  0x01, 0xA0, 0x00, 0x68, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x01,
  0x88, 0x01, 0xC3, 0xFF, 0xC0, 0xFF, 0xF8, 0x20, 0x03, 0x88, 0x00, 0x32,
  0x00, 0x04, 0x80, 0x01, 0xA0, 0x00, 0x28, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x32,
  0x00, 0x38, 0x80, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFE,
  0x01, 0xC0, 0x30, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x10, 0x1E, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0xFF, 0xE0, 0x08,
  0x0F, 0x80, 0x80, 0x1C, 0x08, 0x00, 0x60, 0x80, 0x03, 0x08, 0x00, 0x18,
  0x80, 0x01, 0x88, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00,
  0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x06,
  0x80, 0x00, 0x68, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00,
  0x88, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x06, 0x08, 0x01,
  0xC0, 0x83, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x07, 0xFF, 0xEF, 0xFF, 0xD0, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0xFF,
  0xFC, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x03, 0x07, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x30, 0x00, 0x01, 0x10, 0x00, 0x01, 0x18, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01, 0x03, 0x80, 0x01, 0x00,
  0xE0, 0x0F, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x80, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x7F, 0xC0,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0xF1, 0xDF, 0xC0, 0x80,
  0x01, 0xC0, 0x01, 0xA0, 0x01, 0x90, 0x00, 0xC8, 0x00, 0xC4, 0x00, 0x42,
  0x00, 0x61, 0x00, 0x60, 0x80, 0x30, 0x40, 0x30, 0x20, 0x10, 0x10, 0x18,
  0x08, 0x18, 0x04, 0x0C, 0x02, 0x0C, 0x01, 0x04, 0x00, 0x86, 0x00, 0x46,
  0x00, 0x23, 0x00, 0x13, 0x80, 0x09, 0x60, 0x05, 0x90, 0x03, 0x8C, 0x01,
  0x82, 0x00, 0xC1, 0x80, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x08, 0x06,
  0x04, 0x01, 0x02, 0x00, 0xC1, 0x00, 0x20, 0x80, 0x18, 0x40, 0x04, 0x20,
  0x03, 0x10, 0x00, 0x88, 0x00, 0x64, 0x00, 0x12, 0x00, 0x0D, 0x00, 0x02,
  0x80, 0x01, 0xC0, 0x00, 0x40, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFA, 0x00, 0x00,
  0x07, 0xD8, 0x00, 0x00, 0x2E, 0xC0, 0x00, 0x01, 0x72, 0x00, 0x00, 0x1B,
  0x90, 0x00, 0x00, 0xDC, 0xC0, 0x00, 0x04, 0xE2, 0x00, 0x00, 0x67, 0x10,
  0x00, 0x03, 0x38, 0xC0, 0x00, 0x11, 0xC6, 0x00, 0x01, 0x8E, 0x10, 0x00,
  0x0C, 0x70, 0xC0, 0x00, 0x43, 0x86, 0x00, 0x06, 0x1C, 0x10, 0x00, 0x30,
  0xE0, 0xC0, 0x01, 0x07, 0x06, 0x00, 0x08, 0x38, 0x10, 0x00, 0xC1, 0xC0,
  0x80, 0x06, 0x0E, 0x06, 0x00, 0x20, 0x70, 0x30, 0x03, 0x03, 0x80, 0x80,
  0x18, 0x1C, 0x06, 0x00, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x00, 0x80, 0x60,
  0x38, 0x06, 0x02, 0x01, 0xC0, 0x30, 0x10, 0x0E, 0x00, 0x81, 0x80, 0x70,
  0x04, 0x0C, 0x03, 0x80, 0x30, 0x40, 0x1C, 0x01, 0x86, 0x00, 0xE0, 0x04,
  0x30, 0x07, 0x00, 0x31, 0x00, 0x38, 0x01, 0x98, 0x01, 0xC0, 0x04, 0xC0,
  0x0E, 0x00, 0x34, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xA0, 0x00, 0x1B, 0x00, 0x01, 0x90, 0x00, 0x19, 0x80, 0x01,
  0x88, 0x00, 0x18, 0xC0, 0x01, 0x84, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00,
  0x18, 0x20, 0x01, 0x83, 0x00, 0x18, 0x10, 0x01, 0x81, 0x80, 0x18, 0x08,
  0x01, 0x80, 0xC0, 0x18, 0x04, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x20, 0x18, 0x03, 0x01, 0x80, 0x10, 0x18, 0x01, 0x81, 0x80, 0x08, 0x18,
  0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x41, 0x80, 0x06, 0x18, 0x00, 0x21,
  0x80, 0x03, 0x18, 0x00, 0x11, 0x80, 0x01, 0x98, 0x00, 0x09, 0x80, 0x00,
  0xD8, 0x00, 0x0D, 0x80, 0x00, 0x58, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x80, 0xE0, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x08, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0xFF, 0xC0, 0x81, 0xF0, 0x80, 0x1C, 0x80, 0x0C, 0x80, 0x06, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x38, 0xFF, 0xF0, 0xFF,
  0x80, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x80, 0xC0, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x08, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00,
  0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00,
  0x0C, 0x10, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x08, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0xFF, 0xC0, 0x20, 0x7C, 0x08, 0x01, 0xC2, 0x00,
  0x30, 0x80, 0x06, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x04, 0x80, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48,
  0x00, 0x12, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x00, 0x88, 0x00, 0x62, 0x00,
  0x30, 0x80, 0x18, 0x3F, 0xFC, 0x0F, 0xF8, 0x02, 0x06, 0x00, 0x80, 0xC0,
  0x20, 0x30, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x20, 0x20, 0x0C, 0x08,
  0x01, 0x02, 0x00, 0x60, 0x80, 0x08, 0x20, 0x03, 0x08, 0x00, 0xC2, 0x00,
  0x18, 0x80, 0x06, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x06, 0x80, 0x01,
  0xA0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0xE0, 0x1C, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x80, 0x07, 0x3C,
  0x03, 0x87, 0xFF, 0x80, 0x0E, 0x00, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x14, 0x00, 0x01, 0x40,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x22, 0x00, 0x06, 0x30, 0x00, 0x41,
  0x80, 0x0C, 0x0E, 0x03, 0x80, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x24, 0x00, 0x01, 0x90, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x42, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x20, 0x00, 0x30, 0xC0,
  0x00, 0x83, 0x00, 0x02, 0x04, 0x00, 0x18, 0x10, 0x00, 0x60, 0x60, 0x01,
  0x01, 0x80, 0x04, 0x02, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x30, 0x02, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x06, 0x00, 0x60,
  0x10, 0x01, 0x80, 0x40, 0x02, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x20,
  0x00, 0xC0, 0x80, 0x01, 0x06, 0x00, 0x04, 0x18, 0x00, 0x18, 0x40, 0x00,
  0x61, 0x00, 0x00, 0x8C, 0x00, 0x02, 0x30, 0x00, 0x08, 0x80, 0x00, 0x32,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0x60, 0x00, 0x05, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0D, 0x00,
  0x00, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x00, 0x00, 0x98, 0x00, 0x1C, 0x00,
  0x06, 0x60, 0x00, 0x78, 0x00, 0x19, 0x80, 0x01, 0xE0, 0x00, 0x62, 0x00,
  0x07, 0x80, 0x01, 0x0C, 0x00, 0x12, 0x00, 0x04, 0x30, 0x00, 0x48, 0x00,
  0x30, 0xC0, 0x03, 0x30, 0x00, 0xC1, 0x00, 0x0C, 0xC0, 0x03, 0x04, 0x00,
  0x33, 0x00, 0x08, 0x18, 0x00, 0x84, 0x00, 0x60, 0x60, 0x02, 0x10, 0x01,
  0x81, 0x80, 0x18, 0x60, 0x06, 0x02, 0x00, 0x61, 0x80, 0x10, 0x08, 0x01,
  0x86, 0x00, 0x40, 0x30, 0x04, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x20, 0x0C,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x04, 0x03, 0x03, 0x00, 0x80, 0x18, 0x0C,
  0x0C, 0x02, 0x00, 0x60, 0x20, 0x10, 0x18, 0x01, 0x80, 0x80, 0x40, 0x60,
  0x02, 0x06, 0x01, 0x81, 0x00, 0x08, 0x18, 0x06, 0x04, 0x00, 0x30, 0x60,
  0x18, 0x30, 0x00, 0xC1, 0x00, 0x20, 0xC0, 0x03, 0x04, 0x00, 0x83, 0x00,
  0x04, 0x30, 0x03, 0x08, 0x00, 0x10, 0xC0, 0x0C, 0x20, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x01, 0x88, 0x00, 0x46, 0x00, 0x06, 0x20, 0x01, 0x10, 0x00,
  0x09, 0x80, 0x06, 0x40, 0x00, 0x36, 0x00, 0x19, 0x00, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x03, 0x40, 0x00, 0xB0, 0x00, 0x05, 0x00, 0x02, 0x80, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0xC8, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x06, 0x10,
  0x01, 0x06, 0x00, 0xC1, 0x80, 0x20, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x01,
  0x00, 0x60, 0xC0, 0x18, 0x20, 0x02, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x00,
  0x04, 0xC0, 0x01, 0xB0, 0x00, 0x68, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x01, 0x30, 0x00, 0xC4,
  0x00, 0x21, 0x00, 0x18, 0x60, 0x06, 0x08, 0x01, 0x03, 0x00, 0xC0, 0xC0,
  0x20, 0x10, 0x18, 0x06, 0x06, 0x01, 0x81, 0x00, 0x20, 0xC0, 0x0C, 0x20,
  0x03, 0x18, 0x00, 0x46, 0x00, 0x19, 0x00, 0x06, 0xC0, 0x00, 0xA0, 0x00,
  0x30, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x00, 0x03, 0x30, 0x00, 0x42, 0x00,
  0x18, 0x40, 0x03, 0x0C, 0x00, 0x40, 0x80, 0x18, 0x10, 0x03, 0x03, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x03, 0x00, 0xC0, 0x40, 0x08, 0x08, 0x01, 0x03,
  0x00, 0x30, 0x40, 0x02, 0x08, 0x00, 0x43, 0x00, 0x0C, 0x40, 0x00, 0x88,
  0x00, 0x13, 0x00, 0x03, 0x40, 0x00, 0x28, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x03, 0xFF, 0x80, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0xFF, 0xE0,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x90, 0x00, 0x0C, 0xC0, 0x00, 0x42,
  0x00, 0x06, 0x18, 0x00, 0x60, 0x40, 0x03, 0x03, 0x00, 0x30, 0x08, 0x01,
  0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x07, 0x80,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x0F, 0xF8, 0x38,
  0x1C, 0x20, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x3F, 0x03, 0xFB, 0x0E, 0x03, 0x18, 0x03, 0x30, 0x03, 0x60, 0x03, 0x40,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x40, 0x07, 0x60, 0x0B, 0x60, 0x1B, 0x30, 0x33, 0x1F, 0xE3, 0x01,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x38, 0x0C, 0x7F, 0xC3, 0x30,
  0x38, 0xD8, 0x03, 0x34, 0x00, 0x4F, 0x00, 0x1B, 0x80, 0x02, 0xE0, 0x00,
  0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x0B, 0x80, 0x06, 0xF0, 0x01, 0xB4, 0x00, 0xCD,
  0x80, 0x63, 0x38, 0x38, 0x87, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x70, 0x0F,
  0xF0, 0xE0, 0x46, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x41, 0xFF, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x78, 0x30, 0x7F, 0x8C, 0x30, 0x33, 0x18, 0x06, 0xCC, 0x00, 0xF2,
  0x00, 0x1D, 0x80, 0x07, 0x40, 0x01, 0xD0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x1D, 0x80,
  0x07, 0x60, 0x03, 0x4C, 0x00, 0x93, 0x00, 0x64, 0x70, 0x71, 0x07, 0xF8,
  0x40, 0x20, 0x00, 0x01, 0xC0, 0x03, 0xF8, 0x07, 0x07, 0x03, 0x01, 0x83,
  0x00, 0x61, 0x00, 0x11, 0x80, 0x0C, 0x80, 0x06, 0x40, 0x01, 0x60, 0x00,
  0xB0, 0x00, 0x58, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x38, 0x1C, 0x0F, 0xF8, 0x00,
  0x60, 0x00, 0x01, 0xF8, 0x3C, 0xC1, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x03, 0xFF, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xFE, 0x11, 0xC0, 0xC4, 0x60,
  0x1B, 0x30, 0x03, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xD0, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x0F, 0x30, 0x02, 0xC4, 0x01, 0x31,
  0xC1, 0xCC, 0x1F, 0xC3, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x31, 0x00, 0x18, 0x78, 0x3C, 0x07, 0xFC, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC1, 0xE0, 0xC7, 0xF8, 0xCC, 0x0C, 0xD8, 0x06, 0xD0, 0x06,
  0xF0, 0x02, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x5F, 0xF0, 0x00, 0x00, 0x04, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00, 0x04,
  0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x5C,
  0xF0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x03, 0x60, 0x0C, 0xC0, 0x11, 0x80, 0x63, 0x01,
  0x86, 0x03, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x61, 0x80, 0xC3, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x78, 0x0D, 0xB0, 0x1A, 0x20, 0x3C, 0x60, 0x70,
  0x40, 0xC0, 0xC1, 0x81, 0x83, 0x01, 0x06, 0x03, 0x0C, 0x02, 0x18, 0x06,
  0x30, 0x04, 0x60, 0x08, 0xC0, 0x19, 0x80, 0x13, 0x00, 0x36, 0x00, 0x2C,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0x80, 0x0E, 0x08, 0x7F, 0x03, 0xF8, 0x8C, 0x18, 0x60,
  0xC9, 0x00, 0x88, 0x06, 0xB0, 0x0D, 0x80, 0x6A, 0x00, 0x50, 0x02, 0xA0,
  0x07, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0x01, 0xE0, 0x87, 0xF8, 0x8C, 0x0C,
  0x98, 0x06, 0x90, 0x06, 0xA0, 0x03, 0xA0, 0x03, 0xA0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0xC0,
  0x01, 0xFE, 0x01, 0xC0, 0xE0, 0x40, 0x18, 0x30, 0x03, 0x18, 0x00, 0x46,
  0x00, 0x19, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0x90, 0x00, 0x66, 0x00, 0x18, 0x80,
  0x04, 0x30, 0x03, 0x06, 0x01, 0x80, 0xC0, 0xC0, 0x1F, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x21, 0xFF, 0x08, 0xE0, 0xE2, 0x60, 0x0C, 0x90, 0x03,
  0x2C, 0x00, 0x6A, 0x00, 0x1A, 0x80, 0x02, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xB8, 0x00, 0x2E,
  0x00, 0x1B, 0xC0, 0x04, 0xD0, 0x03, 0x36, 0x01, 0x8C, 0xE0, 0xC3, 0x1F,
  0xE0, 0xC0, 0x40, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0xFE, 0x10, 0xC0, 0xC4, 0x60, 0x19, 0x30, 0x03, 0xC8, 0x00, 0x76, 0x00,
  0x1D, 0x00, 0x07, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x0F,
  0x30, 0x02, 0xC6, 0x01, 0x31, 0xC1, 0xCC, 0x1F, 0xE3, 0x00, 0xC0, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x90, 0xFE, 0x30, 0xC4, 0x0D, 0x01,
  0xA0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x03, 0xC0, 0x7F, 0xF3, 0x80, 0xC8, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0E, 0x00, 0x6E, 0x03, 0x1F, 0xF8, 0x07, 0x00, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xFF, 0xE3,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0xF0, 0x18, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x05, 0x40, 0x05,
  0x60, 0x09, 0x60, 0x19, 0x38, 0x31, 0x1F, 0xE1, 0x03, 0x00, 0xC0, 0x01,
  0xA0, 0x00, 0xD0, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x31, 0x00, 0x18, 0x80,
  0x08, 0x60, 0x04, 0x30, 0x06, 0x08, 0x03, 0x04, 0x01, 0x03, 0x00, 0x81,
  0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x18, 0x10, 0x0C, 0x18, 0x06, 0x0C,
  0x01, 0x06, 0x00, 0x82, 0x00, 0x63, 0x00, 0x31, 0x80, 0x08, 0xC0, 0x04,
  0x40, 0x03, 0x20, 0x01, 0xB0, 0x00, 0x58, 0x00, 0x28, 0x00, 0x14, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xB0,
  0x01, 0xC0, 0x05, 0x80, 0x0E, 0x00, 0x64, 0x00, 0xD0, 0x03, 0x20, 0x06,
  0x80, 0x11, 0x80, 0x36, 0x00, 0x8C, 0x01, 0x30, 0x0C, 0x20, 0x08, 0x80,
  0x61, 0x00, 0xC4, 0x03, 0x08, 0x06, 0x20, 0x10, 0x60, 0x21, 0x80, 0x83,
  0x01, 0x0C, 0x0C, 0x08, 0x18, 0x20, 0x60, 0x40, 0xC1, 0x02, 0x03, 0x06,
  0x08, 0x10, 0x18, 0x20, 0x60, 0x80, 0x41, 0x03, 0x0C, 0x02, 0x18, 0x08,
  0x60, 0x10, 0xC0, 0x42, 0x00, 0xC6, 0x03, 0x10, 0x06, 0x20, 0x19, 0x80,
  0x11, 0x00, 0xCC, 0x00, 0x98, 0x02, 0x40, 0x06, 0xC0, 0x12, 0x00, 0x34,
  0x00, 0xD0, 0x00, 0xA0, 0x07, 0x80, 0x05, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0xC0, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x03, 0x30,
  0x01, 0x88, 0x01, 0x86, 0x00, 0xC1, 0x00, 0xC0, 0xC0, 0x60, 0x20, 0x20,
  0x18, 0x30, 0x0C, 0x10, 0x03, 0x18, 0x01, 0x88, 0x00, 0x4C, 0x00, 0x36,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xA0, 0x00,
  0x98, 0x00, 0xC4, 0x00, 0x63, 0x00, 0x60, 0x80, 0x30, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x08, 0x06, 0x0C, 0x01, 0x04, 0x00, 0xC6, 0x00, 0x22, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x26,
  0x00, 0x31, 0x00, 0x18, 0xC0, 0x08, 0x60, 0x04, 0x30, 0x06, 0x08, 0x03,
  0x06, 0x01, 0x03, 0x00, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x20, 0x18,
  0x10, 0x0C, 0x18, 0x02, 0x0C, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x63, 0x00,
  0x11, 0x80, 0x08, 0x80, 0x06, 0x40, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x50,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x17, 0x00,
  0x0F, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0xFF, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x16, 0x1C, 0x01, 0xC0, 0x70,
  0x68, 0x01, 0xFC, 0x00, 0x02, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Thin59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 42, 11, 4, -42 },
  { 17, 9, 15, 17, 4, -42 },
  { 34, 23, 42, 25, 1, -42 },
  { 155, 19, 48, 23, 2, -45 },
  { 269, 28, 44, 34, 3, -43 },
  { 423, 21, 44, 23, 2, -43 },
  { 539, 2, 15, 10, 4, -42 },
  { 543, 10, 51, 16, 3, -42 },
  { 607, 11, 51, 16, 2, -42 },
  { 678, 14, 15, 20, 3, -45 },
  { 705, 20, 27, 24, 2, -34 },
  { 773, 5, 14, 10, 2, -6 },
  { 782, 12, 2, 16, 2, -17 },
  { 785, 3, 4, 11, 4, -4 },
  { 787, 17, 42, 19, 1, -42 },
  { 877, 17, 43, 23, 3, -43 },
  { 969, 9, 42, 23, 5, -42 },
  { 1017, 18, 43, 23, 2, -43 },
  { 1114, 18, 44, 23, 2, -43 },
  { 1213, 22, 42, 23, 1, -42 },
  { 1329, 18, 43, 23, 3, -42 },
  { 1426, 18, 43, 23, 3, -42 },
  { 1523, 17, 42, 23, 3, -42 },
  { 1613, 19, 44, 23, 2, -43 },
  { 1718, 18, 44, 23, 2, -43 },
  { 1817, 3, 31, 11, 4, -31 },
  { 1829, 5, 39, 10, 2, -31 },
  { 1854, 20, 24, 24, 2, -33 },
  { 1914, 20, 14, 24, 2, -28 },
  { 1949, 20, 24, 24, 2, -33 },
  { 2009, 13, 43, 16, 1, -43 },
  { 2079, 30, 47, 36, 3, -42 },
  { 2256, 22, 42, 22, 0, -42 },
  { 2372, 18, 42, 25, 5, -42 },
  { 2467, 20, 44, 24, 3, -43 },
  { 2577, 20, 42, 28, 5, -42 },
  { 2682, 15, 42, 22, 5, -42 },
  { 2761, 15, 42, 21, 5, -42 },
  { 2840, 24, 44, 31, 3, -43 },
  { 2972, 19, 42, 29, 5, -42 },
  { 3072, 9, 42, 13, 2, -42 },
  { 3120, 9, 52, 11, -3, -42 },
  { 3179, 17, 42, 22, 5, -42 },
  { 3269, 14, 42, 20, 5, -42 },
  { 3343, 29, 42, 38, 5, -42 },
  { 3496, 20, 42, 30, 5, -42 },
  { 3601, 24, 44, 30, 3, -43 },
  { 3733, 16, 42, 23, 5, -42 },
  { 3817, 24, 53, 30, 3, -43 },
  { 3976, 18, 42, 24, 5, -42 },
  { 4071, 18, 44, 23, 2, -43 },
  { 4170, 19, 42, 20, 0, -42 },
  { 4270, 20, 43, 29, 4, -42 },
  { 4378, 22, 42, 22, 0, -42 },
  { 4494, 38, 42, 38, 0, -42 },
  { 4694, 18, 42, 20, 1, -42 },
  { 4789, 19, 42, 19, 0, -42 },
  { 4889, 16, 42, 19, 2, -42 },
  { 4973, 11, 51, 18, 5, -42 },
  { 5044, 17, 42, 19, 1, -42 },
  { 5134, 11, 51, 18, 2, -42 },
  { 5205, 21, 20, 23, 1, -42 },
  { 5258, 23, 2, 23, 0, 5 },
  { 5264, 9, 9, 13, 2, -45 },
  { 5275, 16, 33, 22, 2, -32 },
  { 5341, 18, 46, 25, 4, -45 },
  { 5445, 14, 33, 18, 3, -32 },
  { 5503, 18, 46, 25, 3, -45 },
  { 5607, 17, 33, 22, 3, -32 },
  { 5678, 13, 45, 12, 1, -45 },
  { 5752, 18, 46, 25, 3, -32 },
  { 5856, 16, 45, 24, 4, -45 },
  { 5946, 3, 43, 10, 4, -43 },
  { 5963, 7, 57, 10, 0, -43 },
  { 6013, 15, 45, 19, 4, -45 },
  { 6098, 2, 45, 10, 4, -45 },
  { 6110, 28, 32, 36, 4, -32 },
  { 6222, 16, 32, 24, 4, -32 },
  { 6286, 18, 33, 24, 3, -32 },
  { 6361, 18, 46, 25, 4, -32 },
  { 6465, 18, 46, 25, 3, -32 },
  { 6569, 11, 32, 15, 4, -32 },
  { 6613, 14, 33, 18, 2, -32 },
  { 6671, 11, 40, 12, 1, -39 },
  { 6726, 16, 32, 24, 4, -31 },
  { 6790, 17, 31, 17, 0, -31 },
  { 6856, 29, 31, 30, 1, -31 },
  { 6969, 17, 31, 19, 1, -31 },
  { 7035, 17, 45, 19, 1, -31 },
  { 7131, 12, 31, 15, 2, -31 },
  { 7178, 14, 51, 20, 3, -42 },
  { 7268, 2, 59, 22, 10, -45 },
  { 7283, 14, 51, 20, 3, -42 },
  { 7373, 20, 5, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Thin59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN59PT7B_H_
