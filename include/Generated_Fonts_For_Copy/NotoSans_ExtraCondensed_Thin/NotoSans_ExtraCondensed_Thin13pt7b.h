#ifndef _NOTOSANS_EXTRACONDENSED_THIN13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFC, 0x29, 0x5E, 0xA5, 0x7D, 0x4A, 0x50, 0x23, 0xE9,
  0x46, 0x18, 0xA5, 0x2F, 0x88, 0xD3, 0x4D, 0x3A, 0xF4, 0xD3, 0x55, 0x5C,
  0x72, 0x94, 0x46, 0x56, 0x72, 0x78, 0xE0, 0x6A, 0xAA, 0xA4, 0xA5, 0x55,
  0x68, 0x57, 0x00, 0x21, 0x09, 0xF2, 0x10, 0x68, 0xE0, 0x80, 0x11, 0x22,
  0x24, 0x44, 0x80, 0xE9, 0x99, 0x99, 0x99, 0xE0, 0x75, 0x55, 0x40, 0xE1,
  0x12, 0x24, 0x48, 0xF0, 0xF1, 0x11, 0x71, 0x11, 0xF0, 0x10, 0x8C, 0xA5,
  0x4B, 0xE2, 0x10, 0xE8, 0x8E, 0x11, 0x11, 0xE0, 0xE8, 0x8E, 0x99, 0x99,
  0xE0, 0xE4, 0x94, 0x94, 0x80, 0x74, 0x52, 0xA7, 0x46, 0x31, 0x70, 0xF6,
  0xDA, 0xC9, 0xE0, 0x82, 0x40, 0x06, 0x80, 0x1B, 0x30, 0x41, 0x80, 0xF8,
  0x3E, 0xC1, 0x82, 0x6C, 0x00, 0xE4, 0x94, 0x90, 0x40, 0x7A, 0x19, 0x6D,
  0xD7, 0x5D, 0x6A, 0x81, 0xE0, 0x23, 0x14, 0xA5, 0x5A, 0x31, 0x88, 0xF9,
  0x99, 0xF9, 0x99, 0xF0, 0xF8, 0x88, 0x88, 0x88, 0x70, 0xF9, 0x99, 0x99,
  0x99, 0xE0, 0xF2, 0x4F, 0x24, 0xE0, 0xF2, 0x4F, 0x24, 0x80, 0x7C, 0x21,
  0x09, 0xC6, 0x31, 0x78, 0x99, 0x99, 0xF9, 0x99, 0x90, 0xD5, 0x55, 0xC0,
  0x55, 0x55, 0x5C, 0x9A, 0xCC, 0xCA, 0xA9, 0x90, 0x92, 0x49, 0x24, 0xE0,
  0x86, 0x18, 0x73, 0xCE, 0xBA, 0xED, 0x94, 0x8C, 0x73, 0x9A, 0xD6, 0x73,
  0x88, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xF9, 0x99, 0xE8, 0x88, 0x80,
  0xF4, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x84, 0xF9, 0x99, 0xEA, 0xA9, 0x90,
  0xE8, 0x88, 0x61, 0x11, 0xE0, 0xF2, 0x22, 0x22, 0x22, 0x20, 0x99, 0x99,
  0x99, 0x99, 0xF0, 0x8C, 0x64, 0xA5, 0x29, 0x8C, 0x20, 0x89, 0x89, 0x99,
  0x59, 0x55, 0x56, 0x66, 0x22, 0x24, 0x95, 0x62, 0x26, 0x59, 0x90, 0x99,
  0x66, 0x22, 0x22, 0x20, 0x71, 0x22, 0x24, 0x48, 0xF0, 0xF2, 0x49, 0x24,
  0x93, 0x80, 0x84, 0x44, 0x22, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80,
  0x22, 0x95, 0x10, 0xF8, 0xC0, 0x71, 0x17, 0x99, 0xF0, 0x88, 0x8E, 0x99,
  0x99, 0x9E, 0xF2, 0x49, 0x38, 0x11, 0x1F, 0x99, 0x99, 0x9F, 0xF6, 0xE9,
  0x38, 0x69, 0x64, 0x92, 0x48, 0xF9, 0x99, 0x99, 0xF1, 0x1E, 0x92, 0x7B,
  0x6D, 0xB4, 0xBF, 0x80, 0x45, 0x55, 0x56, 0x92, 0x5D, 0xB6, 0xB4, 0xFF,
  0xC0, 0xFE, 0x5A, 0x69, 0xA6, 0x9A, 0x40, 0xF6, 0xDB, 0x68, 0xE9, 0x99,
  0x99, 0xE0, 0xE9, 0x99, 0x99, 0xE8, 0x88, 0xF9, 0x99, 0x99, 0xF1, 0x11,
  0xEA, 0xA8, 0x78, 0x86, 0x11, 0xF0, 0x4B, 0xA4, 0x92, 0x60, 0xB6, 0xDB,
  0x78, 0x99, 0x96, 0x64, 0x40, 0x93, 0x26, 0xD3, 0x66, 0xC9, 0x12, 0x00,
  0x95, 0x62, 0x66, 0x90, 0x99, 0x56, 0x62, 0x24, 0x4C, 0x64, 0xA5, 0x38,
  0x69, 0x25, 0x12, 0x49, 0x80, 0xFF, 0xF8, 0xC9, 0x24, 0x52, 0x4A, 0x00,
  0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Thin13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 4, 1, -9 },
  { 4, 5, 9, 6, 0, -9 },
  { 10, 5, 11, 5, 0, -10 },
  { 17, 6, 9, 7, 1, -9 },
  { 24, 5, 9, 5, 0, -9 },
  { 30, 1, 3, 2, 1, -9 },
  { 31, 2, 11, 3, 1, -9 },
  { 34, 2, 11, 3, 1, -9 },
  { 37, 3, 3, 4, 1, -10 },
  { 39, 5, 6, 5, 0, -8 },
  { 43, 2, 3, 2, 0, -1 },
  { 44, 3, 1, 3, 0, -4 },
  { 45, 1, 1, 2, 1, -1 },
  { 46, 4, 9, 4, 0, -9 },
  { 51, 4, 9, 5, 1, -9 },
  { 56, 2, 9, 5, 1, -9 },
  { 59, 4, 9, 5, 1, -9 },
  { 64, 4, 9, 5, 0, -9 },
  { 69, 5, 9, 5, 0, -9 },
  { 75, 4, 9, 5, 1, -9 },
  { 80, 4, 9, 5, 1, -9 },
  { 85, 3, 9, 5, 1, -9 },
  { 89, 5, 9, 5, 0, -9 },
  { 95, 3, 9, 5, 1, -9 },
  { 99, 1, 7, 2, 1, -7 },
  { 100, 2, 9, 2, 0, -7 },
  { 103, 5, 5, 5, 0, -7 },
  { 107, 5, 3, 5, 0, -6 },
  { 109, 5, 5, 5, 0, -7 },
  { 113, 3, 9, 3, 0, -9 },
  { 117, 6, 10, 8, 1, -9 },
  { 125, 5, 9, 5, 0, -9 },
  { 131, 4, 9, 6, 1, -9 },
  { 136, 4, 9, 5, 1, -9 },
  { 141, 4, 9, 6, 1, -9 },
  { 146, 3, 9, 5, 1, -9 },
  { 150, 3, 9, 5, 1, -9 },
  { 154, 5, 9, 7, 1, -9 },
  { 160, 4, 9, 6, 1, -9 },
  { 165, 2, 9, 3, 0, -9 },
  { 168, 2, 11, 2, -1, -9 },
  { 171, 4, 9, 5, 1, -9 },
  { 176, 3, 9, 4, 1, -9 },
  { 180, 6, 9, 8, 1, -9 },
  { 187, 5, 9, 7, 1, -9 },
  { 193, 5, 9, 7, 1, -9 },
  { 199, 4, 9, 5, 1, -9 },
  { 204, 5, 11, 7, 1, -9 },
  { 211, 4, 9, 5, 1, -9 },
  { 216, 4, 9, 5, 1, -9 },
  { 221, 4, 9, 4, 0, -9 },
  { 226, 4, 9, 6, 1, -9 },
  { 231, 5, 9, 5, 0, -9 },
  { 237, 8, 9, 8, 0, -9 },
  { 246, 4, 9, 4, 0, -9 },
  { 251, 4, 9, 4, 0, -9 },
  { 256, 4, 9, 4, 0, -9 },
  { 261, 3, 11, 4, 1, -9 },
  { 266, 4, 9, 4, 0, -9 },
  { 271, 3, 11, 4, 0, -9 },
  { 276, 5, 4, 5, 0, -9 },
  { 279, 5, 1, 5, 0, 1 },
  { 280, 1, 2, 3, 1, -10 },
  { 281, 4, 7, 5, 0, -7 },
  { 285, 4, 10, 6, 1, -10 },
  { 290, 3, 7, 4, 1, -7 },
  { 293, 4, 10, 6, 1, -10 },
  { 298, 3, 7, 5, 1, -7 },
  { 301, 3, 10, 3, 0, -10 },
  { 305, 4, 10, 5, 1, -7 },
  { 310, 3, 10, 5, 1, -10 },
  { 314, 1, 9, 2, 1, -9 },
  { 316, 2, 12, 2, 0, -9 },
  { 319, 3, 10, 4, 1, -10 },
  { 323, 1, 10, 2, 1, -10 },
  { 325, 6, 7, 8, 1, -7 },
  { 331, 3, 7, 5, 1, -7 },
  { 334, 4, 7, 5, 1, -7 },
  { 338, 4, 10, 6, 1, -7 },
  { 343, 4, 10, 5, 1, -7 },
  { 348, 2, 7, 3, 1, -7 },
  { 350, 4, 7, 4, 0, -7 },
  { 354, 3, 9, 3, 0, -9 },
  { 358, 3, 7, 5, 1, -7 },
  { 361, 4, 7, 4, 0, -7 },
  { 365, 7, 7, 7, 0, -7 },
  { 372, 4, 7, 4, 0, -7 },
  { 376, 4, 10, 4, 0, -7 },
  { 381, 3, 7, 3, 0, -7 },
  { 384, 3, 11, 5, 1, -9 },
  { 389, 1, 13, 5, 2, -10 },
  { 391, 3, 11, 5, 1, -9 },
  { 396, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Thin13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN13PT7B_H_
