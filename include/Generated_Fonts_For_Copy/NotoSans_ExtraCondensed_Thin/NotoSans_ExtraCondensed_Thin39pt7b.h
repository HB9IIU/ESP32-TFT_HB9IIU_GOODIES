#ifndef _NOTOSANS_EXTRACONDENSED_THIN39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin39pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x2F, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80,
  0x41, 0x00, 0x82, 0x01, 0x04, 0x04, 0x10, 0x7F, 0xFE, 0x10, 0x40, 0x20,
  0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0x10, 0x40,
  0x20, 0x83, 0xFF, 0xF0, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0x08,
  0x20, 0x10, 0x40, 0x41, 0x00, 0x82, 0x01, 0x04, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x3F, 0xC2, 0x21, 0x21, 0x01, 0x08, 0x10, 0x40, 0x82, 0x04,
  0x10, 0x20, 0x80, 0x84, 0x04, 0x20, 0x11, 0x00, 0x68, 0x00, 0xC0, 0x03,
  0x80, 0x16, 0x00, 0x8C, 0x04, 0x20, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41,
  0x02, 0x08, 0x10, 0xC0, 0x85, 0x84, 0xC3, 0xF8, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x38, 0x04, 0x08, 0x80, 0x82, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20,
  0x81, 0x04, 0x20, 0x20, 0x84, 0x04, 0x10, 0x80, 0x82, 0x20, 0x10, 0x44,
  0x02, 0x08, 0x80, 0x41, 0x33, 0xC8, 0x24, 0x89, 0x04, 0x90, 0x90, 0x94,
  0x12, 0x24, 0x82, 0x38, 0x90, 0x40, 0x12, 0x08, 0x04, 0x40, 0x80, 0x88,
  0x10, 0x11, 0x02, 0x04, 0x20, 0x80, 0x84, 0x10, 0x10, 0x82, 0x04, 0x10,
  0x40, 0x81, 0x08, 0x10, 0x22, 0x04, 0x03, 0xC0, 0x0F, 0x00, 0x42, 0x01,
  0x08, 0x08, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x04, 0x20, 0x10, 0x80,
  0x42, 0x00, 0x90, 0x02, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x20, 0x08, 0x80,
  0x41, 0x09, 0x04, 0x24, 0x08, 0xA0, 0x22, 0x80, 0x4A, 0x01, 0x48, 0x03,
  0x20, 0x0C, 0x40, 0x31, 0x01, 0x22, 0x08, 0x87, 0xC1, 0xFF, 0xC0, 0x06,
  0x08, 0x20, 0xC1, 0x04, 0x08, 0x10, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x20, 0x40, 0x81, 0x81, 0x02,
  0x02, 0x04, 0x04, 0x0C, 0x0C, 0x83, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08,
  0x20, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0x08,
  0x20, 0x84, 0x10, 0xC2, 0x18, 0x42, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0E,
  0x98, 0xF0, 0x30, 0x24, 0x22, 0x20, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x07, 0xFF, 0xC0,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x33, 0x22, 0x26, 0x44, 0xC0, 0xFF, 0xB8, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x00, 0x1F,
  0x03, 0x08, 0x20, 0x44, 0x04, 0x40, 0x64, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x40, 0x24, 0x06, 0x40,
  0x42, 0x04, 0x30, 0x81, 0xF0, 0x04, 0x31, 0x49, 0x46, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x3F, 0x0C, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x0F, 0xFF, 0x1F, 0x86, 0x04, 0xC0,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x20, 0x04, 0x00, 0x81, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x80,
  0x67, 0xF8, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x40, 0x05,
  0x00, 0x24, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x84, 0x02, 0x10, 0x10,
  0x40, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x41, 0x01, 0x08, 0x04, 0x20,
  0x10, 0xFF, 0xFC, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x7F, 0xC4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0xC0, 0xF3, 0x80, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x80, 0x8F, 0xF0, 0x07, 0xC0, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0xF0, 0xB0, 0xCA, 0x04, 0xC0, 0x28, 0x02, 0x80, 0x28, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x24, 0x02, 0x40, 0x24, 0x06,
  0x20, 0x41, 0x98, 0x04, 0x00, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x00, 0x0F, 0xC0, 0x83, 0x08,
  0x0C, 0xC0, 0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x60, 0x11, 0x01,
  0x84, 0x08, 0x11, 0x80, 0x58, 0x03, 0x80, 0x22, 0x02, 0x08, 0x20, 0x22,
  0x00, 0x90, 0x04, 0x80, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x28, 0x01, 0x40,
  0x13, 0x00, 0x8C, 0x08, 0x3F, 0x80, 0x1F, 0x04, 0x11, 0x01, 0x40, 0x28,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xD0, 0x1B, 0x05, 0x3F, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x3F, 0x00, 0xB8, 0x00, 0x00,
  0x00, 0x0B, 0x80, 0x23, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x32, 0x22, 0x64, 0x4C, 0x00, 0x08, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x00, 0xFC,
  0x82, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04,
  0x0C, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x30, 0x30, 0x01, 0xF8, 0x00, 0x30, 0x60, 0x0C, 0x03, 0x01, 0x80,
  0x18, 0x10, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x02, 0x40,
  0x78, 0x24, 0x08, 0x82, 0x41, 0x08, 0x2C, 0x30, 0x82, 0x82, 0x08, 0x28,
  0x20, 0x83, 0x82, 0x08, 0x18, 0x20, 0x83, 0x82, 0x08, 0x28, 0x20, 0x82,
  0x82, 0x08, 0x28, 0x20, 0x82, 0x82, 0x18, 0x2C, 0x31, 0x44, 0x41, 0xE6,
  0xC4, 0x04, 0x10, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x40, 0x07, 0xBC, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x06, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x90, 0x01, 0x10,
  0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x20, 0x80, 0x41, 0x00, 0x82, 0x03,
  0x04, 0x04, 0x0C, 0x08, 0x08, 0x1F, 0xF0, 0x60, 0x20, 0x80, 0x41, 0x00,
  0x42, 0x00, 0x84, 0x01, 0x10, 0x02, 0x20, 0x02, 0x40, 0x04, 0x80, 0x0A,
  0x00, 0x14, 0x00, 0x10, 0xFF, 0x08, 0x0C, 0x80, 0x68, 0x02, 0x80, 0x28,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x81, 0x8F,
  0xF0, 0x80, 0xC8, 0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0xCF, 0xF8, 0x03, 0xF8,
  0x60, 0x46, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x02, 0x07, 0xF0, 0xFE, 0x04, 0x0C, 0x20,
  0x11, 0x00, 0x48, 0x03, 0x40, 0x0A, 0x00, 0x50, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00, 0x50, 0x06, 0x80,
  0x24, 0x02, 0x20, 0x61, 0xFC, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xE8,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFE,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x03, 0xFC, 0x06, 0x03, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x3F, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x10, 0x01, 0x18, 0x01, 0x0C, 0x01, 0x03, 0xFE,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFE, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0xFC, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x3F, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x06, 0x27, 0x00, 0x80, 0x28,
  0x06, 0x80, 0x48, 0x08, 0x80, 0x88, 0x10, 0x83, 0x08, 0x20, 0x84, 0x08,
  0x40, 0x88, 0x09, 0x80, 0x90, 0x0A, 0x80, 0xA8, 0x0C, 0x40, 0x84, 0x08,
  0x60, 0x82, 0x08, 0x30, 0x81, 0x08, 0x18, 0x80, 0x88, 0x0C, 0x80, 0x48,
  0x06, 0x80, 0x28, 0x03, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xD0, 0x00,
  0x3A, 0x00, 0x07, 0x40, 0x01, 0x68, 0x00, 0x2C, 0x80, 0x05, 0x90, 0x01,
  0x32, 0x00, 0x26, 0x20, 0x04, 0xC4, 0x01, 0x18, 0x80, 0x23, 0x08, 0x04,
  0x61, 0x01, 0x8C, 0x20, 0x21, 0x86, 0x04, 0x30, 0x40, 0x86, 0x08, 0x20,
  0xC1, 0x04, 0x18, 0x10, 0x83, 0x02, 0x20, 0x60, 0x44, 0x0C, 0x04, 0x81,
  0x80, 0xB0, 0x30, 0x14, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x10, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x68, 0x01, 0xA0, 0x06, 0x40, 0x19, 0x00, 0x64, 0x01,
  0x88, 0x06, 0x20, 0x18, 0x40, 0x61, 0x01, 0x82, 0x06, 0x08, 0x18, 0x10,
  0x60, 0x41, 0x81, 0x06, 0x02, 0x18, 0x08, 0x60, 0x11, 0x80, 0x46, 0x00,
  0x98, 0x02, 0x60, 0x0D, 0x80, 0x16, 0x00, 0x58, 0x00, 0xE0, 0x03, 0x07,
  0xE0, 0x08, 0x10, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20,
  0x04, 0x10, 0x08, 0x18, 0x18, 0x07, 0xE0, 0xFC, 0x10, 0x72, 0x03, 0x40,
  0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x05, 0x01, 0xA0, 0x67, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x07, 0xE0,
  0x08, 0x10, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0xC0, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04,
  0x10, 0x08, 0x18, 0x18, 0x07, 0xE0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0xFE, 0x08, 0x38, 0x80,
  0xC8, 0x04, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x06, 0x80, 0x48, 0x08, 0xFF, 0x08, 0x40, 0x82, 0x08, 0x20, 0x83,
  0x08, 0x10, 0x81, 0x88, 0x08, 0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80,
  0x28, 0x01, 0x1F, 0xC2, 0x02, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x80, 0xCF, 0xF0, 0xFF, 0xF8, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x12, 0x00,
  0x88, 0x08, 0x3F, 0x80, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50, 0x03, 0x40,
  0x09, 0x00, 0x24, 0x00, 0x88, 0x02, 0x20, 0x10, 0x80, 0x42, 0x01, 0x04,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x08, 0x08, 0x40, 0x21, 0x00,
  0x84, 0x02, 0x10, 0x04, 0xC0, 0x12, 0x00, 0x48, 0x01, 0x20, 0x02, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x80, 0x08, 0x00, 0xE0, 0x04, 0x00, 0x50,
  0x03, 0x00, 0x68, 0x02, 0x80, 0x24, 0x01, 0x40, 0x12, 0x00, 0xA0, 0x08,
  0x80, 0x50, 0x04, 0x40, 0x2C, 0x04, 0x20, 0x22, 0x02, 0x10, 0x11, 0x01,
  0x08, 0x08, 0x80, 0x82, 0x04, 0x40, 0xC1, 0x02, 0x20, 0x40, 0x82, 0x08,
  0x20, 0x41, 0x04, 0x10, 0x30, 0x82, 0x08, 0x08, 0x41, 0x08, 0x04, 0x20,
  0x84, 0x02, 0x30, 0x22, 0x01, 0x10, 0x11, 0x00, 0x48, 0x08, 0x80, 0x24,
  0x04, 0x80, 0x12, 0x02, 0x40, 0x0B, 0x00, 0xA0, 0x05, 0x00, 0x50, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x19, 0x00,
  0x88, 0x04, 0x20, 0x41, 0x02, 0x08, 0x20, 0x21, 0x01, 0x08, 0x08, 0x80,
  0x24, 0x01, 0x20, 0x0E, 0x00, 0x30, 0x01, 0x00, 0x0C, 0x00, 0xA0, 0x05,
  0x00, 0x24, 0x02, 0x20, 0x11, 0x81, 0x04, 0x08, 0x20, 0x40, 0x84, 0x04,
  0x20, 0x22, 0x00, 0x90, 0x05, 0x80, 0x30, 0x80, 0x18, 0x01, 0x40, 0x34,
  0x02, 0x40, 0x22, 0x06, 0x20, 0x42, 0x04, 0x10, 0x41, 0x08, 0x10, 0x80,
  0x88, 0x09, 0x00, 0x90, 0x05, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x7F, 0xE0, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x80, 0x10, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x58, 0x01, 0x20, 0x08, 0x80,
  0x21, 0x01, 0x04, 0x04, 0x08, 0x20, 0x20, 0x80, 0x44, 0x01, 0x10, 0x02,
  0x80, 0x0C, 0xFF, 0xFE, 0x86, 0x10, 0x41, 0x04, 0x0F, 0x06, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x7C, 0x70, 0x90,
  0x14, 0x02, 0x80, 0x50, 0x1C, 0x03, 0xC0, 0x68, 0x0D, 0x02, 0xB0, 0x53,
  0xF2, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0xF0, 0xB0, 0x8A, 0x04, 0xC0, 0x2C, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x02, 0x80, 0x28, 0x02, 0xC0, 0x2C, 0x04, 0xA0, 0xC9, 0xF8, 0x0F, 0x8C,
  0x48, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x06, 0x01, 0xF8, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0xF1, 0x30, 0x92, 0x05, 0x40, 0x34, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x40, 0x34, 0x05, 0x20, 0xD1, 0xF9, 0x0F, 0x06, 0x31, 0x83, 0x20,
  0x24, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x80, 0x18, 0x21, 0xFC,
  0x07, 0x86, 0x42, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x3F, 0x24,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x0F, 0x13,
  0x09, 0x60, 0x54, 0x03, 0x40, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x34,
  0x03, 0x40, 0x52, 0x09, 0x1F, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x06, 0x80, 0xC7, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x23, 0xCB, 0x1A, 0x82, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0xB0, 0x02, 0xAA,
  0xAA, 0xAA, 0xAA, 0xAA, 0x13, 0x00, 0x00, 0x01, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xE0, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x50,
  0x68, 0x24, 0x22, 0x11, 0x10, 0x98, 0x48, 0x2A, 0x15, 0x0C, 0xC4, 0x22,
  0x11, 0x04, 0x82, 0x40, 0xA0, 0x50, 0x28, 0x0C, 0x04, 0xFF, 0xFF, 0xFF,
  0xFC, 0x9E, 0x0F, 0x28, 0x44, 0x6C, 0x0A, 0x0B, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18,
  0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02,
  0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80,
  0x40, 0x8F, 0x2C, 0x6A, 0x0F, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x40, 0x0F, 0x03, 0x0C, 0x60, 0x44, 0x02, 0x40, 0x28,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0xC0, 0x24, 0x02, 0x40, 0x62, 0x04, 0x1F, 0x80,
  0x8F, 0x0B, 0x08, 0xA0, 0x4C, 0x02, 0xC0, 0x28, 0x02, 0x80, 0x28, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02,
  0x80, 0x2C, 0x02, 0xC0, 0x4A, 0x0C, 0x9F, 0x88, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0x13, 0x09,
  0x20, 0x54, 0x03, 0x40, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x34, 0x03,
  0x40, 0x52, 0x09, 0x1F, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x8F, 0x66, 0x86, 0x0C, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x00, 0x1F, 0x0C, 0x34, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x0A, 0x02, 0x7F, 0x00, 0x20, 0x40, 0x81, 0x02, 0x1F, 0xC8, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x38, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x0D, 0x05, 0x7E, 0x40, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x34,
  0x04, 0x80, 0x88, 0x11, 0x06, 0x20, 0x84, 0x10, 0x42, 0x08, 0x41, 0x10,
  0x22, 0x02, 0x40, 0x48, 0x0A, 0x01, 0x40, 0x28, 0x03, 0x00, 0x40, 0x80,
  0x20, 0x14, 0x06, 0x02, 0x40, 0x60, 0x24, 0x06, 0x02, 0x40, 0x50, 0x22,
  0x09, 0x04, 0x20, 0x90, 0x42, 0x09, 0x04, 0x20, 0x90, 0x42, 0x08, 0x84,
  0x11, 0x08, 0x81, 0x10, 0x88, 0x11, 0x08, 0x81, 0x10, 0x88, 0x0B, 0x04,
  0x80, 0xA0, 0x50, 0x0A, 0x05, 0x00, 0xA0, 0x50, 0x0A, 0x05, 0x00, 0x40,
  0x20, 0x04, 0x02, 0x00, 0x80, 0x48, 0x09, 0x03, 0x30, 0x42, 0x18, 0x42,
  0x04, 0x40, 0x90, 0x0A, 0x01, 0x80, 0x10, 0x06, 0x00, 0xA0, 0x24, 0x04,
  0x41, 0x08, 0x21, 0x88, 0x11, 0x02, 0x40, 0x28, 0x06, 0x40, 0x14, 0x01,
  0x40, 0x22, 0x02, 0x20, 0x22, 0x02, 0x20, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x80, 0x88, 0x08, 0x80, 0x88, 0x09, 0x00, 0x50, 0x05, 0x00, 0x50,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x18, 0x0F, 0x00, 0x7F, 0x01, 0x01, 0x02, 0x02, 0x06,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x40, 0x80, 0xFF, 0x01, 0xC1, 0x80, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x70,
  0x38, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xC0, 0x18, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x03, 0x01, 0xC1,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x18, 0x70, 0x00, 0x7E, 0x0C, 0x18, 0xE0, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_Thin39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 28, 8, 3, -28 },
  { 8, 6, 10, 11, 3, -28 },
  { 16, 15, 28, 17, 1, -28 },
  { 69, 13, 32, 15, 1, -30 },
  { 121, 19, 28, 22, 2, -28 },
  { 188, 14, 28, 15, 1, -28 },
  { 237, 1, 10, 6, 3, -28 },
  { 239, 7, 34, 10, 2, -28 },
  { 269, 6, 34, 10, 2, -28 },
  { 295, 9, 10, 13, 2, -30 },
  { 307, 13, 18, 16, 1, -23 },
  { 337, 4, 9, 7, 1, -4 },
  { 342, 8, 1, 10, 1, -11 },
  { 343, 2, 3, 7, 3, -3 },
  { 344, 11, 28, 13, 1, -28 },
  { 383, 12, 28, 15, 2, -28 },
  { 425, 6, 28, 15, 3, -28 },
  { 446, 12, 28, 15, 2, -28 },
  { 488, 12, 28, 15, 1, -28 },
  { 530, 14, 28, 15, 1, -28 },
  { 579, 12, 28, 15, 2, -28 },
  { 621, 12, 29, 15, 2, -28 },
  { 665, 11, 28, 15, 2, -28 },
  { 704, 13, 28, 15, 1, -28 },
  { 750, 11, 28, 15, 2, -28 },
  { 789, 2, 21, 7, 3, -21 },
  { 795, 4, 26, 7, 1, -21 },
  { 808, 13, 16, 16, 1, -22 },
  { 834, 13, 9, 16, 1, -18 },
  { 849, 13, 16, 16, 1, -22 },
  { 875, 8, 28, 10, 1, -28 },
  { 903, 20, 32, 24, 2, -28 },
  { 983, 15, 28, 15, 0, -28 },
  { 1036, 12, 28, 17, 3, -28 },
  { 1078, 13, 28, 16, 2, -28 },
  { 1124, 13, 28, 18, 3, -28 },
  { 1170, 10, 28, 15, 3, -28 },
  { 1205, 10, 28, 14, 3, -28 },
  { 1240, 16, 28, 20, 2, -28 },
  { 1296, 13, 28, 19, 3, -28 },
  { 1342, 6, 28, 9, 1, -28 },
  { 1363, 6, 35, 7, -2, -28 },
  { 1390, 12, 28, 15, 3, -28 },
  { 1432, 10, 28, 13, 3, -28 },
  { 1467, 19, 28, 25, 3, -28 },
  { 1534, 14, 28, 20, 3, -28 },
  { 1583, 16, 28, 20, 2, -28 },
  { 1639, 11, 28, 15, 3, -28 },
  { 1678, 16, 35, 20, 2, -28 },
  { 1748, 12, 28, 16, 3, -28 },
  { 1790, 12, 28, 15, 2, -28 },
  { 1832, 13, 28, 13, 0, -28 },
  { 1878, 13, 28, 19, 3, -28 },
  { 1924, 14, 28, 14, 0, -28 },
  { 1973, 25, 28, 25, 0, -28 },
  { 2061, 13, 28, 13, 0, -28 },
  { 2107, 12, 28, 12, 0, -28 },
  { 2149, 11, 28, 13, 1, -28 },
  { 2188, 8, 34, 12, 3, -28 },
  { 2222, 11, 28, 13, 1, -28 },
  { 2261, 8, 34, 12, 1, -28 },
  { 2295, 14, 13, 15, 1, -28 },
  { 2318, 15, 1, 15, 0, 4 },
  { 2320, 5, 6, 9, 2, -30 },
  { 2324, 11, 21, 14, 1, -21 },
  { 2353, 12, 30, 17, 3, -30 },
  { 2398, 9, 21, 12, 2, -21 },
  { 2422, 12, 30, 17, 2, -30 },
  { 2467, 11, 21, 15, 2, -21 },
  { 2496, 9, 30, 8, 0, -30 },
  { 2530, 12, 30, 16, 2, -21 },
  { 2575, 10, 30, 16, 3, -30 },
  { 2613, 2, 28, 7, 3, -28 },
  { 2620, 4, 37, 7, 0, -28 },
  { 2639, 9, 30, 13, 3, -30 },
  { 2673, 1, 30, 7, 3, -30 },
  { 2677, 18, 21, 24, 3, -21 },
  { 2725, 10, 21, 16, 3, -21 },
  { 2752, 12, 21, 16, 2, -21 },
  { 2784, 12, 30, 17, 3, -21 },
  { 2829, 12, 30, 16, 2, -21 },
  { 2874, 7, 21, 10, 3, -21 },
  { 2893, 10, 21, 12, 1, -21 },
  { 2920, 7, 26, 8, 1, -26 },
  { 2943, 10, 21, 16, 3, -21 },
  { 2970, 11, 21, 11, 0, -21 },
  { 2999, 20, 21, 20, 0, -21 },
  { 3052, 11, 21, 12, 1, -21 },
  { 3081, 12, 30, 12, 0, -21 },
  { 3126, 8, 21, 10, 1, -21 },
  { 3147, 10, 34, 14, 2, -28 },
  { 3190, 1, 39, 15, 7, -30 },
  { 3195, 9, 34, 14, 2, -28 },
  { 3234, 13, 3, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_Thin39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN39PT7B_H_
