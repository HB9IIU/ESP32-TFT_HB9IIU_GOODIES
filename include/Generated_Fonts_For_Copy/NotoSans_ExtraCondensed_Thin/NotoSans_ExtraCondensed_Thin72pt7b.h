#ifndef _NOTOSANS_EXTRACONDENSED_THIN72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin72pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00,
  0x6F, 0xFF, 0xF0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x20, 0x04, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x03, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x01, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x10, 0x00, 0x18, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x30, 0x00, 0x10, 0x03, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x30, 0x02, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x20,
  0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0x90, 0xFC,
  0x1C, 0x10, 0x18, 0x18, 0x10, 0x00, 0x30, 0x10, 0x00, 0x70, 0x10, 0x00,
  0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00,
  0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x10, 0x00,
  0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0x60, 0x10, 0x00, 0x30, 0x10, 0x00,
  0x38, 0x10, 0x00, 0x1C, 0x10, 0x00, 0x0E, 0x10, 0x00, 0x03, 0x90, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x17, 0x80,
  0x00, 0x11, 0xC0, 0x00, 0x10, 0xF0, 0x00, 0x10, 0x38, 0x00, 0x10, 0x1C,
  0x00, 0x10, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x10, 0x06, 0x00, 0x10, 0x03,
  0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03,
  0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x03, 0x00, 0x10, 0x06,
  0x00, 0x10, 0x06, 0x00, 0x10, 0x0C, 0x80, 0x10, 0x18, 0xF0, 0x10, 0x70,
  0x7F, 0x97, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x03,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x30,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x08, 0x01, 0x80, 0x60, 0x01, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x06, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0x30, 0x03, 0x01, 0x00, 0x06, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x0C,
  0x0C, 0x00, 0x18, 0x01, 0x81, 0x00, 0x03, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x06, 0x0C, 0x00, 0x0C, 0x00, 0xC1, 0x01, 0x80, 0x80, 0x18, 0x60, 0xFC,
  0x10, 0x03, 0x0C, 0x30, 0xC3, 0x00, 0x61, 0x0C, 0x0C, 0x60, 0x08, 0x61,
  0x81, 0x8C, 0x03, 0x0C, 0x60, 0x19, 0x80, 0x61, 0x0C, 0x03, 0x18, 0x0C,
  0x61, 0x80, 0x63, 0x03, 0x0C, 0x20, 0x04, 0x30, 0xE1, 0x0C, 0x00, 0xC3,
  0xF8, 0x61, 0x80, 0x18, 0x3E, 0x0C, 0x30, 0x03, 0x00, 0x01, 0x06, 0x00,
  0x60, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x0C, 0x18, 0x01, 0x80, 0x01, 0x83,
  0x00, 0x30, 0x00, 0x60, 0x60, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x01,
  0x81, 0x80, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x60,
  0x01, 0x80, 0xC0, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x20, 0x04, 0x00, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x01, 0x81, 0x80, 0x0C,
  0x00, 0x30, 0x30, 0x01, 0x80, 0x03, 0x0C, 0x00, 0x60, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x00,
  0x60, 0x00, 0x40, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x10, 0xC0, 0x10, 0x04,
  0x60, 0x06, 0x01, 0x18, 0x00, 0x80, 0x46, 0x00, 0x30, 0x31, 0x00, 0x06,
  0x0C, 0xC0, 0x01, 0x83, 0x30, 0x00, 0x30, 0x8C, 0x00, 0x0C, 0x63, 0x00,
  0x01, 0x98, 0xC0, 0x00, 0x26, 0x30, 0x00, 0x0F, 0x0C, 0x00, 0x01, 0xC1,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x0F, 0x06, 0x00, 0x06,
  0x60, 0xC0, 0x01, 0x98, 0x38, 0x00, 0xC3, 0x07, 0x00, 0xE0, 0x40, 0xE0,
  0xF0, 0x18, 0x1F, 0xF0, 0x03, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x04, 0x04, 0x07,
  0xC1, 0x0F, 0x1E, 0x4E, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x02, 0x80, 0x01,
  0x30, 0x00, 0xC6, 0x00, 0x60, 0x80, 0x30, 0x10, 0x18, 0x06, 0x0C, 0x00,
  0xC1, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1C,
  0x61, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x0C, 0x30, 0xFF,
  0xFF, 0xFF, 0xFC, 0x5F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x30, 0x38, 0x01, 0x80, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x09, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0xC0, 0x06, 0x03, 0x00,
  0x18, 0x06, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x3E, 0x78, 0x00, 0x3F, 0x80,
  0x00, 0x60, 0x3C, 0x0F, 0x83, 0xB0, 0xE6, 0x38, 0xCE, 0x1B, 0x83, 0xC0,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0x38, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0xFC, 0x03, 0x80, 0x38, 0x38, 0x00, 0x70, 0xC0, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE3, 0x00, 0x07, 0x0F, 0x80, 0x78, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x30,
  0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80,
  0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xF0, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x60, 0x01, 0xFF, 0xFC, 0x07, 0xE0, 0x78, 0x08,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x30, 0xC0, 0x03, 0xC3, 0xE0,
  0x3C, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0x00, 0x78, 0x08, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0xFF, 0x03, 0x1F, 0x3E, 0x19, 0x80, 0x38, 0xD8, 0x00,
  0xC7, 0x80, 0x03, 0x2C, 0x00, 0x0D, 0x40, 0x00, 0x6E, 0x00, 0x03, 0x60,
  0x00, 0x0B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06,
  0xC0, 0x00, 0x26, 0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00,
  0x0C, 0x18, 0x00, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3C, 0x07, 0x00, 0xE0, 0x03, 0x01,
  0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x60, 0x60, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xE0, 0x0C,
  0x00, 0xE0, 0x70, 0x00, 0x61, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x38, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x1C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x18, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0x3C, 0x0F, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x70, 0x18, 0x00, 0xC0, 0xC0,
  0x01, 0x83, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x00,
  0xCC, 0x00, 0x01, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xD8, 0x00, 0x07, 0x60, 0x00, 0x3D, 0x80, 0x00, 0xB3, 0x00, 0x06, 0xCC,
  0x00, 0x12, 0x18, 0x00, 0xC8, 0x30, 0x0E, 0x60, 0x7F, 0xF1, 0x80, 0xFF,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x03, 0x03, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x38, 0xF3, 0xCF, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x1C, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x43,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0xF8, 0xE0, 0x1C, 0x40, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x07, 0xE0, 0x0C, 0x30, 0x01, 0xFF, 0x00, 0x66, 0x00,
  0x38, 0x30, 0x06, 0x60, 0x07, 0x03, 0x00, 0x66, 0x00, 0x60, 0x30, 0x06,
  0x60, 0x0C, 0x03, 0x00, 0x66, 0x00, 0xC0, 0x30, 0x03, 0xC0, 0x18, 0x03,
  0x00, 0x3C, 0x01, 0x80, 0x30, 0x03, 0xC0, 0x18, 0x03, 0x00, 0x3C, 0x01,
  0x80, 0x30, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x3C, 0x03, 0x00, 0x30, 0x03,
  0xC0, 0x30, 0x03, 0x00, 0x3C, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x30, 0x03,
  0x00, 0x3C, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x3C, 0x03,
  0x00, 0x70, 0x02, 0xC0, 0x30, 0x07, 0x00, 0x6C, 0x03, 0x00, 0x70, 0x06,
  0xC0, 0x10, 0x07, 0x00, 0x6C, 0x01, 0x80, 0x50, 0x06, 0xC0, 0x18, 0x0D,
  0x00, 0xCC, 0x01, 0x80, 0xD0, 0x0C, 0x60, 0x0C, 0x19, 0x81, 0x86, 0x00,
  0xE3, 0x8C, 0x38, 0x60, 0x07, 0xF0, 0xFF, 0x06, 0x00, 0x1C, 0x03, 0xC0,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60,
  0x04, 0x00, 0x08, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08, 0x30,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0x80, 0xFF, 0xFE, 0x02, 0x00, 0x7E, 0x08, 0x00, 0x1C, 0x20, 0x00, 0x38,
  0x80, 0x00, 0x72, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x06, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x80, 0x00,
  0x1A, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x32,
  0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x18, 0x80, 0x00, 0xE2, 0x00,
  0x07, 0x08, 0x00, 0x78, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x02, 0x00, 0x0E,
  0x08, 0x00, 0x0E, 0x20, 0x00, 0x1C, 0x80, 0x00, 0x32, 0x00, 0x00, 0x68,
  0x00, 0x01, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xA0,
  0x00, 0x06, 0x80, 0x00, 0x1A, 0x00, 0x00, 0xC8, 0x00, 0x07, 0x20, 0x00,
  0x38, 0x80, 0x03, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xF0, 0x07, 0x01, 0xC0, 0x01, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x01, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xE0, 0xFF, 0xF8, 0x00, 0x80, 0x7F, 0x00, 0x80, 0x07, 0x80, 0x80, 0x01,
  0xC0, 0x80, 0x00, 0xE0, 0x80, 0x00, 0x70, 0x80, 0x00, 0x38, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x1C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x1C, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x38, 0x80, 0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x00, 0xE0, 0x80, 0x03,
  0xC0, 0x80, 0x0F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xA0, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFA, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x70, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x87, 0x00, 0x00, 0x04, 0x1C,
  0x00, 0x00, 0x20, 0x70, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x08, 0x07, 0x00,
  0x01, 0xC0, 0x1F, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x0F, 0xCF, 0xFC, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x1D, 0x87, 0x3F, 0xC0, 0xC0,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0x20, 0x00, 0x19, 0x00, 0x01, 0x88, 0x00,
  0x0C, 0x40, 0x00, 0xC2, 0x00, 0x0C, 0x10, 0x00, 0x60, 0x80, 0x06, 0x04,
  0x00, 0x30, 0x20, 0x03, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x0C, 0x00, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x20,
  0x60, 0x01, 0x03, 0x00, 0x08, 0x30, 0x00, 0x43, 0x00, 0x02, 0x18, 0x00,
  0x11, 0xE0, 0x00, 0x9F, 0x00, 0x04, 0xCC, 0x00, 0x2C, 0x60, 0x01, 0x61,
  0x80, 0x0E, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x00, 0xC0, 0x20, 0x06, 0x01, 0x00, 0x18, 0x08, 0x00,
  0xC0, 0x40, 0x03, 0x02, 0x00, 0x18, 0x10, 0x00, 0x60, 0x80, 0x03, 0x04,
  0x00, 0x0C, 0x20, 0x00, 0x61, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x40, 0x00,
  0x32, 0x00, 0x01, 0x90, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x00, 0xDB, 0x00, 0x00, 0x00,
  0x1B, 0x60, 0x00, 0x00, 0x03, 0x64, 0x00, 0x00, 0x00, 0xCC, 0xC0, 0x00,
  0x00, 0x19, 0x98, 0x00, 0x00, 0x03, 0x33, 0x00, 0x00, 0x00, 0xC6, 0x30,
  0x00, 0x00, 0x18, 0xC6, 0x00, 0x00, 0x03, 0x18, 0xC0, 0x00, 0x00, 0x63,
  0x0C, 0x00, 0x00, 0x18, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x30, 0x00, 0x00,
  0x61, 0x83, 0x00, 0x00, 0x18, 0x30, 0x60, 0x00, 0x03, 0x06, 0x0C, 0x00,
  0x00, 0x60, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x18, 0x00, 0x03, 0x03, 0x03,
  0x00, 0x00, 0x60, 0x60, 0x60, 0x00, 0x08, 0x0C, 0x06, 0x00, 0x03, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x40,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x80, 0x06,
  0x0C, 0x00, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x00, 0x18, 0x60, 0x00, 0xC0,
  0x01, 0x8C, 0x00, 0x18, 0x00, 0x31, 0x80, 0x03, 0x00, 0x06, 0x30, 0x00,
  0x60, 0x00, 0x6C, 0x00, 0x0C, 0x00, 0x0D, 0x80, 0x01, 0x80, 0x01, 0xB0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0x80, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x1C, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x07, 0x30, 0x00, 0x03,
  0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x04, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x81, 0x80, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x0C,
  0x00, 0x38, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x07, 0x00,
  0x60, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x70,
  0x01, 0x80, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x08, 0x07,
  0x00, 0x06, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60,
  0x70, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x43, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x18, 0xE0, 0x00,
  0x06, 0x70, 0x00, 0x03, 0x38, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x08, 0x0F, 0xE0, 0x80, 0x07, 0x08,
  0x00, 0x38, 0x80, 0x00, 0xC8, 0x00, 0x0E, 0x80, 0x00, 0x68, 0x00, 0x06,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80,
  0x00, 0xE8, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x38, 0x80, 0x0F, 0x0F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0xFF, 0xF8, 0x02, 0x07, 0xF8, 0x08, 0x00, 0x70,
  0x20, 0x00, 0x60, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x88, 0x00, 0x06, 0x20,
  0x00, 0x18, 0x80, 0x00, 0x32, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00,
  0x0C, 0x80, 0x00, 0x32, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x0C,
  0x80, 0x00, 0x32, 0x00, 0x00, 0xC8, 0x00, 0x03, 0x20, 0x00, 0x18, 0x80,
  0x00, 0x62, 0x00, 0x03, 0x88, 0x00, 0x0C, 0x20, 0x00, 0x60, 0x80, 0x07,
  0x02, 0x00, 0x78, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x80, 0x60, 0x02,
  0x00, 0xC0, 0x08, 0x03, 0x00, 0x20, 0x06, 0x00, 0x80, 0x18, 0x02, 0x00,
  0x30, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x80, 0x80, 0x06, 0x02, 0x00, 0x18,
  0x08, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x80, 0x01, 0x82, 0x00, 0x06, 0x08,
  0x00, 0x0C, 0x20, 0x00, 0x30, 0x80, 0x00, 0x62, 0x00, 0x01, 0x88, 0x00,
  0x07, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x3A, 0x00, 0x00, 0x68, 0x00, 0x01,
  0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x70, 0x03, 0x87, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE3, 0x00, 0x07, 0x0F, 0xC0, 0xF8, 0x0F, 0xFF, 0xC0,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30,
  0xE0, 0x00, 0x30, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x03, 0xC0, 0x78,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x02, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x20, 0x00, 0x18, 0x0C,
  0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x30,
  0x06, 0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x08, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x01, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x40, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x38, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x68, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0xB0, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x06, 0x00, 0x03, 0x10,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x60, 0x60, 0x00, 0x61, 0x80,
  0x01, 0x80, 0x80, 0x01, 0x86, 0x00, 0x06, 0x03, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x60, 0x30, 0x00, 0x60, 0xC0, 0x03,
  0x00, 0xC0, 0x01, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x40, 0x06, 0x00,
  0x60, 0x03, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x00, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x01, 0x80, 0xC0,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0xC2, 0x00, 0x00, 0x63, 0x00, 0x03, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x2C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x0C, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x04,
  0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x19, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x61, 0x80, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0x60, 0x02, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x20, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x08,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x40, 0x02, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x04, 0x00, 0x08, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x40, 0x00,
  0x21, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x98, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFC,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0xFF, 0xF8, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF,
  0xFC, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x01, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x00, 0xF0, 0x03, 0xFF, 0x03, 0xE0, 0xF0, 0x40, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x01, 0xF0, 0x0F, 0xFC, 0x1F, 0x81, 0x0E, 0x00,
  0x46, 0x00, 0x13, 0x00, 0x05, 0x80, 0x01, 0x60, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x56, 0x00, 0x35, 0x80, 0x09, 0x30, 0x06,
  0x4E, 0x07, 0x10, 0xFF, 0x84, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x38, 0x03, 0x07, 0xFC, 0x0C, 0x78, 0x3C, 0x33,
  0x80, 0x30, 0xCC, 0x00, 0x63, 0x60, 0x00, 0xCD, 0x00, 0x03, 0x3C, 0x00,
  0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x00, 0xB8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xF0, 0x00, 0x33, 0x40, 0x00,
  0xCD, 0x80, 0x07, 0x33, 0x00, 0x18, 0xCE, 0x01, 0xC3, 0x1E, 0x1E, 0x0C,
  0x3F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x3C, 0x1C,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x30, 0x1F, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x38, 0x04, 0x07, 0xFC,
  0x10, 0x38, 0x38, 0x41, 0x80, 0x31, 0x0C, 0x00, 0x64, 0x60, 0x00, 0xD1,
  0x80, 0x03, 0x4C, 0x00, 0x05, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x36, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00,
  0x50, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x16, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x30,
  0x00, 0x14, 0xC0, 0x00, 0xD1, 0x80, 0x02, 0x47, 0x00, 0x19, 0x0E, 0x00,
  0xC4, 0x1E, 0x0E, 0x10, 0x3F, 0xF0, 0x40, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0xF0, 0x01, 0xE1, 0xE0, 0x1C, 0x03, 0x80, 0xC0, 0x0C, 0x0C, 0x00,
  0x30, 0x60, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x98,
  0x00, 0x04, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x68, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x20, 0x70, 0x03, 0x01, 0xE0,
  0xF8, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xFF, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0xFC, 0x10, 0x78, 0x3C, 0x43, 0x80, 0x31, 0x0C, 0x00, 0x64, 0x60, 0x00,
  0xD1, 0x80, 0x01, 0x4C, 0x00, 0x07, 0x30, 0x00, 0x1D, 0x80, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x34, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x01, 0xCC, 0x00, 0x05,
  0x30, 0x00, 0x14, 0xC0, 0x00, 0xD1, 0x80, 0x06, 0xC7, 0x00, 0x1B, 0x0E,
  0x00, 0xCC, 0x1E, 0x0E, 0x30, 0x3F, 0xF0, 0xC0, 0x1E, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x61, 0xC0, 0x07,
  0x03, 0xF1, 0xF8, 0x03, 0xFF, 0x80, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x18, 0x3F,
  0xC3, 0x1E, 0x1E, 0x67, 0x00, 0xCC, 0xC0, 0x0D, 0xB0, 0x01, 0xB4, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x08, 0xFF, 0xF4, 0x00, 0x00, 0x00, 0x12, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x20, 0x07, 0x07, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0xFC, 0xF8, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x03,
  0x80, 0xC0, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC7, 0x80,
  0x31, 0xE0, 0x0C, 0xCC, 0x03, 0x23, 0x00, 0xD8, 0xC0, 0x3C, 0x18, 0x0F,
  0x06, 0x03, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x04, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x30, 0xFF, 0x00, 0xFF,
  0x0C, 0x70, 0xE0, 0x70, 0xE3, 0x30, 0x0C, 0x30, 0x1C, 0xD8, 0x03, 0x18,
  0x03, 0x34, 0x00, 0x64, 0x00, 0x6F, 0x00, 0x1B, 0x00, 0x1B, 0x80, 0x02,
  0x80, 0x06, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x78, 0x18, 0x3F, 0xE3, 0x1E, 0x1E, 0x67, 0x00, 0xEC,
  0xC0, 0x0D, 0xB0, 0x01, 0xF4, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x08, 0x00,
  0x3C, 0x00, 0x03, 0xFE, 0x00, 0x1E, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xC0,
  0x07, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x90, 0x00, 0x01, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x80,
  0x00, 0x09, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xF0, 0x78,
  0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x02, 0x07, 0xFC, 0x08,
  0x78, 0x38, 0x21, 0x80, 0x30, 0xCC, 0x00, 0x63, 0x60, 0x00, 0xCD, 0x80,
  0x03, 0x3C, 0x00, 0x06, 0xF0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x00,
  0xB8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xF0, 0x00,
  0x33, 0x40, 0x00, 0xCD, 0x80, 0x06, 0x33, 0x00, 0x18, 0xCE, 0x01, 0xC3,
  0x1E, 0x0E, 0x0C, 0x1F, 0xF0, 0x30, 0x1E, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x10, 0x3C, 0x3C,
  0x41, 0x80, 0x31, 0x0C, 0x00, 0x64, 0x60, 0x00, 0xD1, 0x80, 0x03, 0x4C,
  0x00, 0x05, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x36, 0x00, 0x01, 0xCC, 0x00, 0x05, 0x30, 0x00, 0x14, 0xE0,
  0x00, 0xD1, 0x80, 0x06, 0x43, 0x00, 0x1B, 0x0E, 0x00, 0xCC, 0x1E, 0x0E,
  0x30, 0x1F, 0xF0, 0xC0, 0x1F, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x66, 0x0F, 0xF1, 0xE7, 0x8C, 0x0C, 0xC0, 0x64, 0x03,
  0x60, 0x1A, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x07, 0x83,
  0xE7, 0x00, 0x26, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xD0, 0x00, 0xEC, 0x00,
  0xE7, 0xC1, 0xE0, 0xFF, 0xE0, 0x0F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x0F, 0xFF, 0xFF, 0xF1,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xE1, 0x07, 0xF0, 0x1C, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x2E, 0x00, 0x05, 0x60,
  0x01, 0xAC, 0x00, 0x25, 0xC0, 0x0C, 0x9C, 0x03, 0x11, 0xC1, 0xC2, 0x1F,
  0xF0, 0x40, 0xF8, 0x00, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x60, 0x80, 0x02, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x04, 0x00, 0x60, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x80, 0x08, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x00, 0x41, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x02,
  0x20, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x14, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x26, 0x00, 0x0B, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0x98, 0x00,
  0x6C, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x06, 0x20, 0x01, 0x98, 0x01, 0x86,
  0x00, 0x23, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x18, 0x01, 0x8C, 0x00,
  0xC1, 0x00, 0x30, 0x80, 0x10, 0x30, 0x06, 0x18, 0x06, 0x06, 0x01, 0x83,
  0x00, 0xC0, 0xC0, 0x30, 0x60, 0x18, 0x18, 0x06, 0x0C, 0x03, 0x01, 0x00,
  0xC0, 0x80, 0x40, 0x30, 0x18, 0x18, 0x18, 0x06, 0x06, 0x03, 0x03, 0x00,
  0xC0, 0xC0, 0x60, 0x60, 0x08, 0x18, 0x0C, 0x08, 0x01, 0x83, 0x00, 0xC3,
  0x00, 0x30, 0x40, 0x18, 0x60, 0x06, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x08, 0x60, 0x0C, 0x20, 0x01, 0x8C, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x30, 0x00, 0x4C, 0x00, 0x64, 0x00,
  0x0D, 0x80, 0x04, 0x80, 0x01, 0xA0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x33, 0x00, 0x06,
  0x30, 0x00, 0x63, 0x80, 0x0E, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x01,
  0x80, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x60, 0x30, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0x98, 0x00, 0x0D, 0x80, 0x00,
  0xD8, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00,
  0x0D, 0x80, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x01,
  0x81, 0x80, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x04, 0x40, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0x86, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x10, 0x30,
  0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x02, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x40, 0x0C, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x66,
  0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x58, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x6E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x1C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x9E, 0x7C, 0x00, 0xF8, 0x07, 0x00, 0xF8, 0x01,
  0xF3, 0xE8, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 51, 14, 5, -51 },
  { 27, 11, 18, 21, 5, -51 },
  { 52, 28, 51, 31, 1, -51 },
  { 231, 24, 59, 28, 2, -55 },
  { 408, 35, 53, 41, 3, -52 },
  { 640, 26, 53, 28, 2, -52 },
  { 813, 2, 18, 12, 5, -51 },
  { 818, 12, 62, 19, 4, -51 },
  { 911, 12, 62, 19, 3, -51 },
  { 1004, 18, 19, 24, 3, -55 },
  { 1047, 25, 33, 29, 2, -42 },
  { 1151, 6, 16, 13, 3, -7 },
  { 1163, 15, 2, 19, 2, -21 },
  { 1167, 3, 5, 13, 5, -5 },
  { 1169, 20, 51, 24, 2, -51 },
  { 1297, 22, 52, 28, 3, -52 },
  { 1440, 11, 51, 28, 6, -51 },
  { 1511, 22, 52, 28, 3, -52 },
  { 1654, 22, 53, 28, 3, -52 },
  { 1800, 27, 52, 28, 1, -52 },
  { 1976, 22, 52, 28, 3, -51 },
  { 2119, 21, 53, 28, 4, -52 },
  { 2259, 22, 51, 28, 3, -51 },
  { 2400, 23, 53, 28, 3, -52 },
  { 2553, 22, 53, 28, 3, -52 },
  { 2699, 3, 38, 13, 5, -38 },
  { 2714, 6, 47, 13, 3, -38 },
  { 2750, 25, 29, 29, 2, -40 },
  { 2841, 25, 17, 29, 2, -34 },
  { 2895, 25, 29, 29, 2, -40 },
  { 2986, 16, 52, 19, 1, -52 },
  { 3090, 36, 59, 43, 4, -52 },
  { 3356, 27, 51, 27, 0, -51 },
  { 3529, 22, 51, 31, 6, -51 },
  { 3670, 24, 53, 30, 4, -52 },
  { 3829, 24, 51, 34, 6, -51 },
  { 3982, 18, 51, 27, 6, -51 },
  { 4097, 18, 51, 25, 6, -51 },
  { 4212, 29, 53, 37, 4, -52 },
  { 4405, 23, 51, 35, 6, -51 },
  { 4552, 10, 51, 16, 3, -51 },
  { 4616, 11, 64, 13, -3, -51 },
  { 4704, 21, 51, 27, 6, -51 },
  { 4838, 17, 51, 25, 6, -51 },
  { 4947, 35, 51, 47, 6, -51 },
  { 5171, 25, 51, 36, 6, -51 },
  { 5331, 29, 53, 37, 4, -52 },
  { 5524, 20, 51, 28, 6, -51 },
  { 5652, 29, 64, 37, 4, -52 },
  { 5884, 22, 51, 29, 6, -51 },
  { 6025, 22, 53, 28, 3, -52 },
  { 6171, 24, 51, 24, 0, -51 },
  { 6324, 25, 52, 35, 5, -51 },
  { 6487, 26, 51, 26, 0, -51 },
  { 6653, 46, 51, 47, 0, -51 },
  { 6947, 22, 51, 24, 1, -51 },
  { 7088, 23, 51, 23, 0, -51 },
  { 7235, 20, 51, 23, 2, -51 },
  { 7363, 13, 62, 22, 6, -51 },
  { 7464, 20, 51, 24, 2, -51 },
  { 7592, 13, 62, 22, 3, -51 },
  { 7693, 26, 24, 28, 1, -51 },
  { 7771, 28, 1, 28, 0, 7 },
  { 7775, 10, 11, 16, 3, -55 },
  { 7789, 18, 40, 26, 3, -39 },
  { 7879, 22, 56, 31, 5, -55 },
  { 8033, 18, 40, 23, 3, -39 },
  { 8123, 22, 56, 31, 3, -55 },
  { 8277, 21, 40, 27, 3, -39 },
  { 8382, 16, 55, 15, 1, -55 },
  { 8492, 22, 56, 30, 3, -39 },
  { 8646, 19, 55, 29, 5, -55 },
  { 8777, 3, 52, 13, 5, -52 },
  { 8797, 8, 69, 13, 0, -52 },
  { 8866, 18, 55, 23, 5, -55 },
  { 8990, 2, 55, 12, 5, -55 },
  { 9004, 34, 39, 44, 5, -39 },
  { 9170, 19, 39, 29, 5, -39 },
  { 9263, 23, 40, 29, 3, -39 },
  { 9378, 22, 56, 30, 5, -39 },
  { 9532, 22, 56, 30, 3, -39 },
  { 9686, 13, 39, 19, 5, -39 },
  { 9750, 17, 40, 22, 3, -39 },
  { 9835, 12, 48, 15, 2, -47 },
  { 9907, 19, 39, 29, 5, -38 },
  { 10000, 21, 38, 21, 0, -38 },
  { 10100, 35, 38, 37, 1, -38 },
  { 10267, 20, 38, 23, 1, -38 },
  { 10362, 21, 55, 23, 1, -38 },
  { 10507, 15, 38, 19, 2, -38 },
  { 10579, 17, 62, 25, 4, -51 },
  { 10711, 2, 72, 27, 13, -55 },
  { 10729, 17, 62, 25, 4, -51 },
  { 10861, 25, 5, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_Thin72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN72PT7B_H_
