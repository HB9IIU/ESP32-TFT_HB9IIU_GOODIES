#ifndef _NOTOSANS_EXTRACONDENSED_THIN11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xE8, 0x55, 0xF5, 0x5F, 0x66, 0x7A, 0xA4, 0x23, 0x3E, 0x20,
  0xEA, 0xCB, 0x2A, 0xF4, 0xD3, 0x4B, 0x66, 0x64, 0xAB, 0x9F, 0xE0, 0xFF,
  0xC0, 0x95, 0x55, 0x60, 0xCC, 0x22, 0xF2, 0x20, 0xC0, 0xE0, 0x80, 0x24,
  0x94, 0xA4, 0xD6, 0xDB, 0x6F, 0x75, 0x55, 0xE1, 0x11, 0x22, 0x4F, 0xE1,
  0x16, 0x11, 0x1F, 0x22, 0x55, 0x9F, 0x11, 0xD2, 0x62, 0x4F, 0xF2, 0x6B,
  0x6F, 0xF1, 0x22, 0x22, 0x44, 0x79, 0x96, 0x59, 0x97, 0x69, 0x99, 0x71,
  0x16, 0x84, 0x86, 0x3C, 0x43, 0xFF, 0xC3, 0x3C, 0xE4, 0xA4, 0x82, 0x74,
  0x6B, 0xB9, 0xEE, 0xF0, 0x70, 0x42, 0x66, 0xF9, 0x99, 0xF6, 0xFB, 0x6F,
  0x72, 0x49, 0x27, 0xE9, 0x99, 0x99, 0x9E, 0xF2, 0x79, 0x27, 0xF2, 0x4F,
  0x24, 0x78, 0x88, 0xB9, 0x9F, 0xB6, 0xFB, 0x6D, 0xD5, 0x57, 0x55, 0x55,
  0x70, 0xB7, 0x49, 0xAD, 0x92, 0x49, 0x27, 0x8C, 0x63, 0x1D, 0xEE, 0xB5,
  0x99, 0x9D, 0xDB, 0x99, 0xE9, 0x99, 0x99, 0x9E, 0xD6, 0xDD, 0x24, 0xE9,
  0x99, 0x99, 0x9E, 0x22, 0xD6, 0xDD, 0xAD, 0x78, 0x84, 0x21, 0x1F, 0xF4,
  0x44, 0x44, 0x44, 0x99, 0x99, 0x99, 0x9E, 0x99, 0x99, 0x66, 0x64, 0x93,
  0x26, 0x4D, 0x56, 0xCD, 0x91, 0x24, 0x96, 0x64, 0x46, 0xA9, 0xB6, 0xA4,
  0x92, 0xE4, 0xA4, 0xA7, 0xEA, 0xAA, 0xB0, 0x91, 0x24, 0x49, 0xD5, 0x55,
  0x70, 0x26, 0x59, 0xF0, 0xC0, 0x64, 0xFB, 0xC0, 0x93, 0xDB, 0x6F, 0xEA,
  0xB0, 0x11, 0x79, 0x99, 0x97, 0xD7, 0xC9, 0xC0, 0x6B, 0x24, 0x92, 0x79,
  0x99, 0x97, 0x11, 0x60, 0x93, 0xDB, 0x6D, 0xBF, 0xBF, 0xE0, 0xAF, 0xAF,
  0xFF, 0xDD, 0x6B, 0x5A, 0xD4, 0xF6, 0xDB, 0x40, 0x79, 0x99, 0x97, 0xF6,
  0xDB, 0xE4, 0x80, 0x79, 0x99, 0x97, 0x11, 0x10, 0xEA, 0xA0, 0x73, 0x13,
  0xC0, 0xBA, 0xAC, 0xB6, 0xDB, 0xC0, 0xB6, 0xD4, 0x80, 0xA6, 0x9B, 0xAE,
  0x49, 0x20, 0xAD, 0x27, 0x40, 0xB6, 0xB4, 0x92, 0x80, 0xE5, 0x29, 0xC0,
  0x6A, 0xAA, 0x90, 0xFF, 0xE0, 0xAA, 0x5A, 0xA0, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 2, 3, 3, 1, -8 },
  { 3, 4, 8, 5, 0, -8 },
  { 7, 4, 9, 4, 0, -8 },
  { 12, 6, 8, 6, 0, -8 },
  { 18, 4, 8, 4, 0, -8 },
  { 22, 1, 3, 2, 0, -8 },
  { 23, 1, 10, 3, 1, -8 },
  { 25, 2, 10, 3, 0, -8 },
  { 28, 3, 2, 4, 0, -8 },
  { 29, 4, 5, 4, 0, -6 },
  { 32, 1, 2, 2, 0, -1 },
  { 33, 3, 1, 3, 0, -3 },
  { 34, 1, 1, 2, 1, -1 },
  { 35, 3, 8, 4, 0, -8 },
  { 38, 3, 8, 4, 1, -8 },
  { 41, 2, 8, 4, 1, -8 },
  { 43, 4, 8, 4, 0, -8 },
  { 47, 4, 8, 4, 0, -8 },
  { 51, 4, 8, 4, 0, -8 },
  { 55, 3, 8, 4, 1, -8 },
  { 58, 3, 8, 4, 1, -8 },
  { 61, 4, 8, 4, 0, -8 },
  { 65, 4, 8, 4, 0, -8 },
  { 69, 4, 8, 4, 0, -8 },
  { 73, 1, 6, 2, 1, -6 },
  { 74, 1, 7, 2, 0, -6 },
  { 75, 4, 4, 4, 0, -6 },
  { 77, 4, 2, 4, 0, -5 },
  { 78, 4, 4, 4, 0, -6 },
  { 80, 3, 8, 3, 0, -8 },
  { 83, 5, 9, 7, 1, -8 },
  { 89, 4, 8, 4, 0, -8 },
  { 93, 3, 8, 5, 1, -8 },
  { 96, 3, 8, 5, 1, -8 },
  { 99, 4, 8, 5, 1, -8 },
  { 103, 3, 8, 4, 1, -8 },
  { 106, 3, 8, 4, 1, -8 },
  { 109, 4, 8, 6, 1, -8 },
  { 113, 3, 8, 5, 1, -8 },
  { 116, 2, 8, 2, 0, -8 },
  { 118, 2, 10, 2, -1, -8 },
  { 121, 3, 8, 4, 1, -8 },
  { 124, 3, 8, 4, 1, -8 },
  { 127, 5, 8, 7, 1, -8 },
  { 132, 4, 8, 6, 1, -8 },
  { 136, 4, 8, 6, 1, -8 },
  { 140, 3, 8, 4, 1, -8 },
  { 143, 4, 10, 6, 1, -8 },
  { 148, 3, 8, 4, 1, -8 },
  { 151, 4, 8, 4, 0, -8 },
  { 155, 4, 8, 4, 0, -8 },
  { 159, 4, 8, 5, 1, -8 },
  { 163, 4, 8, 4, 0, -8 },
  { 167, 7, 8, 7, 0, -8 },
  { 174, 4, 8, 4, 0, -8 },
  { 178, 3, 8, 3, 0, -8 },
  { 181, 3, 8, 4, 0, -8 },
  { 184, 2, 10, 3, 1, -8 },
  { 187, 3, 8, 4, 0, -8 },
  { 190, 2, 10, 3, 0, -8 },
  { 193, 4, 4, 4, 0, -8 },
  { 195, 4, 1, 4, 0, 1 },
  { 196, 2, 1, 2, 0, -8 },
  { 197, 3, 6, 4, 0, -6 },
  { 200, 3, 8, 5, 1, -8 },
  { 203, 2, 6, 3, 1, -6 },
  { 205, 4, 8, 5, 0, -8 },
  { 209, 3, 6, 4, 1, -6 },
  { 212, 3, 8, 2, 0, -8 },
  { 215, 4, 9, 5, 0, -6 },
  { 220, 3, 8, 4, 1, -8 },
  { 223, 1, 8, 2, 1, -8 },
  { 224, 1, 11, 2, 0, -8 },
  { 226, 2, 8, 4, 1, -8 },
  { 228, 1, 8, 2, 0, -8 },
  { 229, 5, 6, 7, 1, -6 },
  { 233, 3, 6, 4, 1, -6 },
  { 236, 4, 6, 4, 0, -6 },
  { 239, 3, 9, 5, 1, -6 },
  { 243, 4, 9, 5, 0, -6 },
  { 248, 2, 6, 3, 1, -6 },
  { 250, 3, 6, 3, 0, -6 },
  { 253, 2, 7, 2, 0, -7 },
  { 255, 3, 6, 4, 1, -6 },
  { 258, 3, 6, 3, 0, -6 },
  { 261, 6, 6, 6, 0, -6 },
  { 266, 3, 6, 3, 0, -6 },
  { 269, 3, 9, 3, 0, -6 },
  { 273, 3, 6, 3, 0, -6 },
  { 276, 2, 10, 4, 1, -8 },
  { 279, 1, 11, 4, 2, -8 },
  { 281, 2, 10, 4, 1, -8 },
  { 284, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Thin11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN11PT7B_H_
