#ifndef _NOTOSANS_EXTRACONDENSED_THIN61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin61pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x6E, 0xF6, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x00, 0x40, 0x30, 0x00, 0x40,
  0x30, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0,
  0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x60, 0x00, 0x80, 0x60, 0x00, 0x80,
  0x60, 0x00, 0x80, 0x60, 0x00, 0x80, 0x40, 0x01, 0x80, 0x40, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x00,
  0xC0, 0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x03, 0x00,
  0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x02, 0x00,
  0x80, 0x02, 0x01, 0x80, 0x02, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x06, 0x01, 0x00, 0x06, 0x01, 0x00, 0x06, 0x01, 0x00, 0x06, 0x01,
  0x00, 0x04, 0x03, 0x00, 0x04, 0x03, 0x00, 0x04, 0x03, 0x00, 0x04, 0x03,
  0x00, 0x04, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x02,
  0x00, 0x0C, 0x06, 0x00, 0x08, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x3F, 0xE0, 0x0F, 0xDF, 0x81, 0xC4, 0x1C, 0x30, 0x40,
  0x46, 0x04, 0x00, 0x60, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x40, 0x0C, 0x04,
  0x00, 0xC0, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x40, 0x0C, 0x04, 0x00, 0xC0,
  0x40, 0x06, 0x04, 0x00, 0x60, 0x40, 0x03, 0x04, 0x00, 0x18, 0x40, 0x00,
  0xE4, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x05, 0xC0,
  0x00, 0x47, 0x00, 0x04, 0x38, 0x00, 0x40, 0xC0, 0x04, 0x06, 0x00, 0x40,
  0x20, 0x04, 0x03, 0x00, 0x40, 0x30, 0x04, 0x03, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x04, 0x03, 0x00, 0x40, 0x20, 0x04, 0x06, 0x00,
  0x40, 0xC8, 0x04, 0x1C, 0xF0, 0x47, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x1F, 0x00, 0x04, 0x01, 0x8C, 0x00, 0x60, 0x08, 0x30, 0x03, 0x00, 0xC0,
  0x80, 0x10, 0x04, 0x06, 0x01, 0x80, 0x20, 0x30, 0x0C, 0x03, 0x01, 0x80,
  0x40, 0x18, 0x04, 0x06, 0x00, 0x80, 0x20, 0x30, 0x04, 0x01, 0x01, 0x00,
  0x20, 0x08, 0x18, 0x01, 0x00, 0x60, 0xC0, 0x08, 0x03, 0x04, 0x00, 0x40,
  0x18, 0x20, 0x02, 0x00, 0xC3, 0x00, 0x10, 0x06, 0x10, 0x00, 0x80, 0x30,
  0x80, 0x04, 0x01, 0x0C, 0x1C, 0x30, 0x08, 0x43, 0xF1, 0x80, 0x42, 0x30,
  0xCC, 0x06, 0x31, 0x03, 0x20, 0x31, 0x18, 0x19, 0x01, 0x88, 0xC0, 0x4C,
  0x08, 0xC4, 0x03, 0x20, 0xC4, 0x20, 0x19, 0xCC, 0x21, 0x00, 0xC7, 0xC3,
  0x08, 0x06, 0x00, 0x18, 0xC0, 0x10, 0x00, 0x86, 0x00, 0x80, 0x0C, 0x30,
  0x04, 0x00, 0x61, 0x80, 0x20, 0x02, 0x0C, 0x01, 0x00, 0x30, 0x60, 0x08,
  0x01, 0x83, 0x00, 0x40, 0x08, 0x18, 0x06, 0x00, 0xC0, 0x40, 0x30, 0x06,
  0x02, 0x01, 0x80, 0x20, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x40, 0x18, 0x06,
  0x02, 0x00, 0x80, 0x10, 0x30, 0x0C, 0x00, 0xC1, 0x00, 0x60, 0x03, 0x18,
  0x02, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x00, 0x1C,
  0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x60, 0x10,
  0x01, 0x80, 0x40, 0x06, 0x01, 0x00, 0x18, 0x04, 0x00, 0x60, 0x10, 0x01,
  0x80, 0x40, 0x02, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x30, 0x00, 0xC0,
  0x80, 0x01, 0x06, 0x00, 0x06, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x36, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xCC, 0x00, 0x06,
  0x10, 0x00, 0x10, 0x60, 0x00, 0xC0, 0x80, 0x46, 0x03, 0x01, 0x18, 0x04,
  0x04, 0x40, 0x18, 0x13, 0x00, 0x20, 0x4C, 0x00, 0xC3, 0x30, 0x01, 0x8C,
  0xC0, 0x02, 0x22, 0x00, 0x0C, 0x88, 0x00, 0x16, 0x30, 0x00, 0x70, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x04, 0x00, 0x1E, 0x18, 0x00, 0xC8, 0x60, 0x06,
  0x30, 0xC0, 0x38, 0x41, 0xC1, 0xC1, 0x83, 0xFC, 0x03, 0x01, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x18, 0x21, 0xCE, 0x4E, 0x07,
  0xE0, 0x03, 0x00, 0x05, 0x00, 0x11, 0x00, 0x43, 0x01, 0x83, 0x06, 0x02,
  0x18, 0x02, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x88,
  0xC6, 0x31, 0x18, 0xC4, 0x60, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xCF, 0x00,
  0xC0, 0xC0, 0x60, 0x18, 0x10, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x11, 0x80,
  0x06, 0x60, 0x01, 0x98, 0x00, 0x64, 0x00, 0x09, 0x00, 0x02, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x26,
  0x00, 0x09, 0x80, 0x06, 0x60, 0x01, 0x88, 0x00, 0x43, 0x00, 0x30, 0x40,
  0x0C, 0x18, 0x06, 0x03, 0x01, 0x80, 0x71, 0xC0, 0x0F, 0xE0, 0x00, 0xC0,
  0x70, 0x3C, 0x1B, 0x0C, 0xC6, 0x37, 0x0F, 0x83, 0xC0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x07, 0xF8, 0x03, 0xC3, 0x81, 0xC0, 0x1C,
  0x10, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xE7, 0x81, 0xC0, 0x1C, 0x70, 0x01, 0xC4,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x90, 0x00, 0x63, 0xC0, 0x38, 0x1F, 0xFE, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x16, 0x00, 0x00, 0xD8, 0x00, 0x02, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x46, 0x00, 0x03, 0x18, 0x00, 0x08, 0x60, 0x00, 0x61,
  0x80, 0x01, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x81, 0x80,
  0x04, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x06,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x3F, 0xFF, 0x0F, 0xFF, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0xFF, 0x03, 0xFF, 0xF0, 0x60,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x20, 0x03,
  0x8E, 0x03, 0xC1, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xE0, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x10,
  0x0C, 0x7F, 0xC3, 0x38, 0x38, 0xD8, 0x03, 0x34, 0x00, 0x4E, 0x00, 0x1B,
  0x80, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x14, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x32, 0x00, 0x08,
  0xC0, 0x06, 0x30, 0x01, 0x06, 0x00, 0xC0, 0xC0, 0x60, 0x1F, 0xF0, 0x01,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x01, 0xFC, 0x00, 0x79, 0xE0, 0x0C, 0x03,
  0x01, 0x80, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x20, 0x00, 0x66, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x20,
  0x00, 0x63, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x01, 0x80,
  0xE0, 0x70, 0x07, 0x0E, 0x00, 0x19, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x03, 0x9C, 0x00, 0x60, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x30, 0x00,
  0xC2, 0x00, 0x0C, 0x60, 0x00, 0x64, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x24, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x04, 0x30, 0x00, 0xC1,
  0x80, 0x18, 0x0E, 0x07, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x03, 0xF8,
  0x00, 0xE7, 0x80, 0x30, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x10, 0x60, 0x03,
  0x18, 0x00, 0x23, 0x00, 0x06, 0x60, 0x00, 0xC8, 0x00, 0x19, 0x00, 0x01,
  0x20, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x40, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0E,
  0x40, 0x01, 0xCC, 0x00, 0x79, 0x80, 0x0B, 0x18, 0x06, 0x61, 0xC3, 0x8C,
  0x0F, 0xE1, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x80, 0xE0, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x39, 0xCE, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x31, 0x8C, 0x62, 0x31, 0x8C, 0x46, 0x31, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0x83, 0xE7, 0x8C, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x86, 0x00, 0x7F,
  0x01, 0x88, 0x01, 0x86, 0x03, 0x30, 0x06, 0x0C, 0x06, 0x60, 0x18, 0x18,
  0x04, 0xC0, 0x20, 0x30, 0x09, 0x00, 0xC0, 0x60, 0x12, 0x01, 0x80, 0xC0,
  0x34, 0x02, 0x01, 0x80, 0x78, 0x0C, 0x03, 0x00, 0xF0, 0x18, 0x06, 0x01,
  0xE0, 0x30, 0x0C, 0x03, 0xC0, 0x60, 0x18, 0x07, 0x80, 0xC0, 0x30, 0x0F,
  0x01, 0x80, 0x60, 0x1E, 0x03, 0x00, 0x80, 0x3C, 0x06, 0x01, 0x00, 0x58,
  0x0C, 0x06, 0x00, 0xB0, 0x18, 0x0C, 0x03, 0x20, 0x30, 0x1C, 0x06, 0x40,
  0x20, 0x28, 0x08, 0x80, 0x60, 0xD0, 0x31, 0x80, 0xC3, 0x30, 0xE3, 0x00,
  0xEE, 0x3F, 0x86, 0x00, 0xF0, 0x3E, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x10, 0x04, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x60, 0x03, 0x00, 0x80, 0x02, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x10, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xC2, 0x00, 0x00, 0x84, 0x00, 0x01, 0x18, 0x00,
  0x03, 0x30, 0x00, 0x06, 0x40, 0x00, 0x04, 0x80, 0x00, 0x0B, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x30, 0xFF, 0xC0, 0x1F, 0xFF, 0x02, 0x00, 0x38, 0x40,
  0x01, 0x88, 0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0x24, 0x00, 0x06, 0x80,
  0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D, 0x00,
  0x01, 0xA0, 0x00, 0x24, 0x00, 0x0C, 0x80, 0x01, 0x90, 0x00, 0x62, 0x00,
  0x1C, 0x40, 0x07, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x20, 0x03, 0x84, 0x00,
  0x18, 0x80, 0x01, 0x90, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x28, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x05, 0x00, 0x01, 0xA0, 0x00,
  0x34, 0x00, 0x0C, 0x80, 0x03, 0x10, 0x00, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xCF, 0xC0, 0x70, 0x04, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x40, 0x38, 0x0E, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x20, 0x0F, 0x01, 0x00, 0x0C, 0x08, 0x00,
  0x30, 0x40, 0x00, 0xC2, 0x00, 0x03, 0x10, 0x00, 0x18, 0x80, 0x00, 0x64,
  0x00, 0x03, 0x20, 0x00, 0x19, 0x00, 0x00, 0x48, 0x00, 0x03, 0x40, 0x00,
  0x1A, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0,
  0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00,
  0x50, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00,
  0x00, 0x28, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x06,
  0x80, 0x00, 0x24, 0x00, 0x03, 0x20, 0x00, 0x19, 0x00, 0x00, 0xC8, 0x00,
  0x0C, 0x40, 0x00, 0x62, 0x00, 0x06, 0x10, 0x00, 0x60, 0x80, 0x07, 0x04,
  0x00, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x78, 0x00, 0xE0, 0x70, 0x00, 0x20, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x22, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x08, 0x40, 0x00, 0x04, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x3C, 0x03, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x3C, 0x00, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x1F, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x83, 0x3F, 0xC3, 0xC0, 0x80, 0x00, 0xE0, 0x00, 0x68, 0x00, 0x32, 0x00,
  0x0C, 0x80, 0x06, 0x20, 0x01, 0x88, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x18,
  0x20, 0x0C, 0x08, 0x03, 0x02, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x08,
  0x18, 0x02, 0x06, 0x00, 0x83, 0x00, 0x20, 0x80, 0x08, 0x60, 0x02, 0x30,
  0x00, 0x8E, 0x00, 0x27, 0x80, 0x0B, 0x30, 0x02, 0x8C, 0x00, 0xE1, 0x80,
  0x30, 0x60, 0x0C, 0x0C, 0x02, 0x03, 0x00, 0x80, 0x60, 0x20, 0x18, 0x08,
  0x03, 0x02, 0x00, 0xC0, 0x80, 0x18, 0x20, 0x06, 0x08, 0x00, 0xC2, 0x00,
  0x30, 0x80, 0x04, 0x20, 0x01, 0x88, 0x00, 0x22, 0x00, 0x0C, 0x80, 0x01,
  0x20, 0x00, 0x68, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x00,
  0x3E, 0xC0, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x02, 0xE4, 0x00, 0x00, 0x1B,
  0x98, 0x00, 0x00, 0x6E, 0x60, 0x00, 0x01, 0x38, 0x80, 0x00, 0x04, 0xE2,
  0x00, 0x00, 0x33, 0x8C, 0x00, 0x00, 0xCE, 0x30, 0x00, 0x02, 0x38, 0x40,
  0x00, 0x18, 0xE1, 0x80, 0x00, 0x63, 0x86, 0x00, 0x01, 0x0E, 0x08, 0x00,
  0x0C, 0x38, 0x30, 0x00, 0x30, 0xE0, 0xC0, 0x00, 0x83, 0x81, 0x00, 0x02,
  0x0E, 0x06, 0x00, 0x18, 0x38, 0x18, 0x00, 0x60, 0xE0, 0x60, 0x01, 0x03,
  0x80, 0x80, 0x0C, 0x0E, 0x03, 0x00, 0x30, 0x38, 0x0C, 0x00, 0x80, 0xE0,
  0x10, 0x06, 0x03, 0x80, 0x60, 0x18, 0x0E, 0x01, 0x80, 0x40, 0x38, 0x02,
  0x03, 0x00, 0xE0, 0x0C, 0x0C, 0x03, 0x80, 0x30, 0x30, 0x0E, 0x00, 0xC0,
  0x80, 0x38, 0x01, 0x06, 0x00, 0xE0, 0x06, 0x18, 0x03, 0x80, 0x18, 0x40,
  0x0E, 0x00, 0x23, 0x00, 0x38, 0x00, 0xCC, 0x00, 0xE0, 0x03, 0x20, 0x03,
  0x80, 0x05, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3A, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0x40, 0x00, 0x73, 0x00, 0x03,
  0x88, 0x00, 0x1C, 0x60, 0x00, 0xE3, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x60,
  0x01, 0xC1, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0x20, 0x03, 0x81, 0x80, 0x1C,
  0x04, 0x00, 0xE0, 0x30, 0x07, 0x01, 0x80, 0x38, 0x06, 0x01, 0xC0, 0x30,
  0x0E, 0x00, 0x80, 0x70, 0x06, 0x03, 0x80, 0x10, 0x1C, 0x00, 0xC0, 0xE0,
  0x02, 0x07, 0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x02, 0x0E, 0x00, 0x18,
  0x70, 0x00, 0x43, 0x80, 0x03, 0x1C, 0x00, 0x08, 0xE0, 0x00, 0x67, 0x00,
  0x03, 0x38, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0x30, 0x00, 0x0D,
  0x80, 0x00, 0x2C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x7F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x10, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x10, 0x00, 0x01, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x32, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x03, 0x40, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x02, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x88, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x43, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x18, 0x00, 0xF0,
  0x38, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xF8,
  0x20, 0x0E, 0x10, 0x01, 0xC8, 0x00, 0x64, 0x00, 0x1A, 0x00, 0x0D, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x50, 0x00, 0x68, 0x00, 0x34, 0x00, 0x32, 0x00, 0x71, 0x00, 0xF0, 0xFF,
  0xE0, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xF1, 0xE0,
  0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x10, 0x00,
  0x01, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x04, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x02, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x18, 0x00, 0x10, 0x06,
  0x00, 0x18, 0x03, 0x80, 0x18, 0x00, 0xF0, 0x38, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xFE, 0x00, 0x3F, 0xFC, 0x08,
  0x03, 0xC2, 0x00, 0x38, 0x80, 0x06, 0x20, 0x00, 0xC8, 0x00, 0x12, 0x00,
  0x06, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x02, 0x80, 0x00,
  0xA0, 0x00, 0x68, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x48,
  0x00, 0x32, 0x00, 0x08, 0x80, 0x06, 0x20, 0x07, 0x08, 0x07, 0x83, 0xFF,
  0x80, 0x80, 0xC0, 0x20, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0x80, 0x20,
  0x20, 0x0C, 0x08, 0x03, 0x02, 0x00, 0x60, 0x80, 0x18, 0x20, 0x03, 0x08,
  0x00, 0xC2, 0x00, 0x18, 0x80, 0x06, 0x20, 0x00, 0x88, 0x00, 0x32, 0x00,
  0x04, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x0E, 0x00, 0x03, 0x03, 0xFE,
  0x03, 0xE3, 0xF1, 0xC0, 0x08, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x20, 0x01, 0x8E, 0x01, 0xC1, 0xFF,
  0xE0, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x50,
  0x00, 0x06, 0x80, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x08, 0x80, 0x00,
  0xC6, 0x00, 0x06, 0x18, 0x00, 0x60, 0xE0, 0x06, 0x03, 0x80, 0xE0, 0x07,
  0xFE, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x09, 0x80, 0x00, 0x26, 0x00, 0x01,
  0x88, 0x00, 0x06, 0x20, 0x00, 0x10, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x04,
  0x00, 0x0C, 0x10, 0x00, 0x30, 0x60, 0x00, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x18, 0x08, 0x00, 0x60, 0x20, 0x01, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x30,
  0x04, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x60, 0x08, 0x01, 0x80, 0x60, 0x02,
  0x01, 0x80, 0x08, 0x04, 0x00, 0x30, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x04, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00,
  0x02, 0x18, 0x00, 0x08, 0x40, 0x00, 0x31, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0x30, 0x00, 0x04, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x80,
  0x00, 0x30, 0x00, 0x0D, 0x00, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0xC0,
  0x00, 0x26, 0x00, 0x03, 0x80, 0x00, 0x4C, 0x00, 0x05, 0x00, 0x01, 0x88,
  0x00, 0x0B, 0x00, 0x03, 0x10, 0x00, 0x36, 0x00, 0x06, 0x30, 0x00, 0x6C,
  0x00, 0x08, 0x60, 0x00, 0xC8, 0x00, 0x30, 0xC0, 0x01, 0x90, 0x00, 0x60,
  0x80, 0x02, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x60, 0x01, 0x83, 0x00, 0x18,
  0xC0, 0x02, 0x06, 0x00, 0x30, 0x80, 0x0C, 0x04, 0x00, 0x61, 0x00, 0x18,
  0x08, 0x00, 0x83, 0x00, 0x30, 0x18, 0x03, 0x06, 0x00, 0x40, 0x30, 0x06,
  0x0C, 0x00, 0x80, 0x60, 0x0C, 0x08, 0x03, 0x00, 0x40, 0x18, 0x10, 0x06,
  0x00, 0x80, 0x20, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x80, 0xC0, 0x04, 0x06, 0x01, 0x01,
  0x80, 0x0C, 0x08, 0x03, 0x02, 0x00, 0x18, 0x10, 0x06, 0x04, 0x00, 0x30,
  0x60, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x08, 0x30, 0x00, 0x41, 0x80, 0x10,
  0x60, 0x00, 0xC2, 0x00, 0x30, 0x80, 0x01, 0x84, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x04, 0x60, 0x01,
  0x10, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x00, 0x19, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x0D, 0x80, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x00, 0x58, 0x00,
  0x14, 0x00, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x41, 0x00, 0x18, 0x30, 0x03, 0x06, 0x00, 0x40, 0x40, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0x10, 0x18, 0x03, 0x02, 0x00, 0x60, 0xC0,
  0x06, 0x18, 0x00, 0xC2, 0x00, 0x08, 0xC0, 0x01, 0x90, 0x00, 0x36, 0x00,
  0x02, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x05, 0x00, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x04, 0x40, 0x01, 0x8C, 0x00,
  0x20, 0x80, 0x0C, 0x10, 0x01, 0x83, 0x00, 0x20, 0x20, 0x0C, 0x06, 0x01,
  0x00, 0xC0, 0x60, 0x08, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x60, 0x02, 0x08,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x00, 0x88, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x26,
  0x00, 0x0C, 0x40, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x0C, 0x10, 0x01, 0x83,
  0x00, 0x20, 0x60, 0x0C, 0x04, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x01,
  0x01, 0x80, 0x30, 0x20, 0x06, 0x0C, 0x00, 0x41, 0x80, 0x0C, 0x20, 0x01,
  0x8C, 0x00, 0x11, 0x80, 0x03, 0x20, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x4C, 0x00, 0x03, 0x18, 0x00, 0x08, 0x60, 0x00, 0x60, 0xC0, 0x01,
  0x03, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x18, 0x01, 0x80, 0x20, 0x04, 0x00,
  0xC0, 0x30, 0x01, 0x00, 0x80, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00, 0x30,
  0xC0, 0x00, 0xC2, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x01, 0xE0, 0x0F, 0xF8, 0x38, 0x0C, 0x10, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0xFF, 0x07, 0x81,
  0x0C, 0x01, 0x38, 0x01, 0x30, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x07, 0x40, 0x05,
  0x60, 0x05, 0x30, 0x09, 0x38, 0x19, 0x0F, 0xF1, 0x01, 0x80, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x81, 0xE0, 0x30, 0xFF, 0x06, 0x70, 0x38,
  0xC8, 0x03, 0x1A, 0x00, 0x33, 0xC0, 0x02, 0x70, 0x00, 0x6E, 0x00, 0x0D,
  0xC0, 0x00, 0xB0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xB8, 0x00, 0x17, 0x00, 0x06, 0xE0, 0x00, 0xDA,
  0x00, 0x33, 0x60, 0x06, 0x66, 0x01, 0x8C, 0x60, 0xE1, 0x87, 0xF8, 0x00,
  0x10, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x38, 0x08, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x01, 0x07, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x03, 0xC0, 0xC1, 0xFE, 0x18, 0x60, 0x73, 0x18, 0x02, 0x66, 0x00,
  0x2C, 0xC0, 0x07, 0xB0, 0x00, 0x76, 0x00, 0x0E, 0x80, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xD0, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xE4, 0x00, 0x2C, 0xC0, 0x0D,
  0x8C, 0x03, 0x30, 0xC0, 0xC6, 0x0F, 0xF0, 0xC0, 0x30, 0x00, 0x01, 0xE0,
  0x03, 0xFC, 0x03, 0x03, 0x03, 0x00, 0xC3, 0x00, 0x21, 0x80, 0x19, 0x80,
  0x04, 0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x04, 0x1C, 0x0E, 0x03, 0xFE, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x1F, 0xC1, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x1F,
  0xF8, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0x10, 0xC0, 0x64, 0x60,
  0x0D, 0x30, 0x01, 0x48, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xD0, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x07, 0x20, 0x01, 0x4C, 0x00, 0xD1,
  0x80, 0x64, 0x30, 0x31, 0x07, 0xF8, 0x40, 0x70, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x40, 0x03, 0x18, 0x03, 0x83,
  0xFF, 0x80, 0x0F, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x07, 0x83, 0x0F, 0xF1,
  0x9C, 0x1C, 0xC8, 0x06, 0x6C, 0x01, 0xB4, 0x00, 0xDC, 0x00, 0x2E, 0x00,
  0x17, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0C, 0xFF, 0xF0, 0x00, 0x00, 0x04, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20, 0x0E,
  0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x06,
  0x19, 0xF3, 0x80, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x03, 0x60, 0x06, 0xC0, 0x19, 0x80,
  0x23, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0,
  0xC3, 0x01, 0x84, 0x03, 0x18, 0x06, 0x78, 0x0C, 0xD0, 0x1B, 0x30, 0x34,
  0x60, 0x78, 0x40, 0xE0, 0xC1, 0x80, 0x83, 0x01, 0x86, 0x03, 0x0C, 0x03,
  0x18, 0x06, 0x30, 0x04, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x1B, 0x00, 0x36,
  0x00, 0x2C, 0x00, 0x78, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x06, 0x3F, 0xC1,
  0xFE, 0x33, 0x06, 0x18, 0x19, 0xB0, 0x18, 0x80, 0x6D, 0x00, 0x48, 0x03,
  0x70, 0x03, 0x40, 0x0B, 0x80, 0x1C, 0x00, 0x7C, 0x00, 0x60, 0x03, 0xC0,
  0x03, 0x00, 0x1E, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xC0, 0x07, 0x80, 0x04,
  0x00, 0x3C, 0x00, 0x20, 0x01, 0xE0, 0x01, 0x00, 0x0F, 0x00, 0x08, 0x00,
  0x78, 0x00, 0x40, 0x03, 0xC0, 0x02, 0x00, 0x1E, 0x00, 0x10, 0x00, 0xF0,
  0x00, 0x80, 0x07, 0x80, 0x04, 0x00, 0x3C, 0x00, 0x20, 0x01, 0xE0, 0x01,
  0x00, 0x0F, 0x00, 0x08, 0x00, 0x78, 0x00, 0x40, 0x03, 0xC0, 0x02, 0x00,
  0x1E, 0x00, 0x10, 0x00, 0xF0, 0x00, 0x80, 0x07, 0x80, 0x04, 0x00, 0x3C,
  0x00, 0x20, 0x01, 0xE0, 0x01, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x78, 0x00,
  0x40, 0x03, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xF0, 0x63, 0xFE, 0x33, 0x83,
  0x9B, 0x00, 0xCD, 0x00, 0x37, 0x80, 0x1B, 0x80, 0x05, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x30, 0x38,
  0x0C, 0x01, 0x83, 0x00, 0x18, 0x40, 0x03, 0x18, 0x00, 0x23, 0x00, 0x06,
  0x40, 0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x16,
  0x00, 0x02, 0xC0, 0x00, 0x48, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x42,
  0x00, 0x18, 0x60, 0x02, 0x06, 0x00, 0xC0, 0x70, 0x70, 0x07, 0xFC, 0x00,
  0x18, 0x00, 0x00, 0xF0, 0x10, 0x7F, 0x82, 0x38, 0x18, 0x66, 0x01, 0x8D,
  0x80, 0x19, 0xA0, 0x01, 0x3C, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0x5C,
  0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x5C, 0x00, 0x0B, 0x80, 0x03, 0x78, 0x00, 0x4D, 0x00, 0x19, 0xB0,
  0x03, 0x33, 0x00, 0xC6, 0x30, 0x70, 0xC3, 0xFC, 0x18, 0x08, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x10, 0xE0,
  0xE4, 0x60, 0x0D, 0x30, 0x01, 0x4C, 0x00, 0x76, 0x00, 0x0D, 0x80, 0x03,
  0x40, 0x00, 0xD0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x07, 0x30, 0x01, 0x4C,
  0x00, 0xD1, 0x80, 0x64, 0x38, 0x31, 0x07, 0xF8, 0x40, 0x38, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x01, 0xD8, 0xFF, 0x38, 0xE6, 0x0D, 0x81, 0xA0,
  0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x00, 0x03, 0xE0, 0x1F, 0xF8, 0xE0, 0x39, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xA0, 0x03,
  0x78, 0x1C, 0x3F, 0xF0, 0x0E, 0x00, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0xFF, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x08,
  0x3F, 0x01, 0x80, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xD0, 0x00,
  0xEC, 0x00, 0xB6, 0x00, 0xD9, 0x80, 0x4C, 0xE0, 0xC6, 0x3F, 0xC3, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0xD0, 0x00, 0x26, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0x08, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x02, 0x04, 0x00,
  0x81, 0x00, 0x60, 0x60, 0x18, 0x18, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x30, 0x30, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0x41, 0x80, 0x18, 0x60, 0x06,
  0x18, 0x01, 0x84, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x03, 0x30, 0x00, 0xC8,
  0x00, 0x12, 0x00, 0x05, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x2C, 0x00, 0x70,
  0x00, 0xB0, 0x01, 0xC0, 0x06, 0x40, 0x05, 0x80, 0x19, 0x00, 0x16, 0x00,
  0x46, 0x00, 0xC8, 0x01, 0x18, 0x03, 0x20, 0x0C, 0x20, 0x0C, 0xC0, 0x30,
  0x80, 0x23, 0x00, 0xC3, 0x00, 0x8C, 0x02, 0x0C, 0x06, 0x10, 0x08, 0x30,
  0x18, 0x40, 0x60, 0x40, 0x61, 0x81, 0x81, 0x01, 0x06, 0x04, 0x06, 0x04,
  0x18, 0x10, 0x18, 0x30, 0x20, 0xC0, 0x20, 0xC0, 0x83, 0x00, 0x83, 0x03,
  0x0C, 0x03, 0x08, 0x0C, 0x20, 0x0C, 0x60, 0x10, 0x80, 0x31, 0x80, 0x46,
  0x00, 0x46, 0x01, 0x98, 0x01, 0x10, 0x06, 0x40, 0x06, 0x40, 0x19, 0x00,
  0x1B, 0x00, 0x24, 0x00, 0x2C, 0x00, 0xB0, 0x00, 0xB0, 0x03, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60,
  0x01, 0x80, 0x60, 0x01, 0xB0, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC1, 0x00,
  0x60, 0xC0, 0x20, 0x20, 0x30, 0x18, 0x10, 0x04, 0x18, 0x03, 0x08, 0x01,
  0x8C, 0x00, 0x66, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x64, 0x00, 0x63, 0x00, 0x30,
  0x80, 0x30, 0x60, 0x18, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x04, 0x01, 0x86,
  0x00, 0xC2, 0x00, 0x33, 0x00, 0x19, 0x80, 0x05, 0x80, 0x03, 0xC0, 0x00,
  0xD0, 0x00, 0x26, 0x00, 0x19, 0x80, 0x06, 0x20, 0x01, 0x88, 0x00, 0x43,
  0x00, 0x30, 0xC0, 0x0C, 0x10, 0x03, 0x04, 0x00, 0x81, 0x80, 0x60, 0x60,
  0x18, 0x08, 0x06, 0x02, 0x01, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x04, 0x0C,
  0x01, 0x02, 0x00, 0x61, 0x80, 0x18, 0x60, 0x02, 0x10, 0x00, 0x84, 0x00,
  0x33, 0x00, 0x0C, 0xC0, 0x01, 0x20, 0x00, 0x48, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x7C,
  0x03, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x1C, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01,
  0xF8, 0x00, 0x38, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xF8, 0x01, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x0F,
  0xC0, 0x18, 0x00, 0x00, 0x1F, 0x00, 0x0B, 0xDE, 0x00, 0x70, 0x1C, 0x0D,
  0x00, 0x3F, 0xC8, 0x00, 0x78, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Thin61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 44, 12, 4, -44 },
  { 23, 10, 16, 18, 4, -44 },
  { 43, 24, 44, 26, 1, -44 },
  { 175, 20, 50, 24, 2, -46 },
  { 300, 29, 45, 35, 3, -44 },
  { 464, 22, 45, 23, 2, -44 },
  { 588, 2, 16, 10, 4, -44 },
  { 592, 11, 54, 16, 3, -44 },
  { 667, 11, 54, 16, 2, -44 },
  { 742, 15, 15, 21, 3, -46 },
  { 771, 21, 29, 24, 2, -36 },
  { 848, 5, 14, 11, 2, -6 },
  { 857, 12, 1, 16, 2, -17 },
  { 859, 3, 4, 11, 4, -4 },
  { 861, 17, 44, 20, 2, -44 },
  { 955, 18, 44, 24, 3, -44 },
  { 1054, 10, 44, 24, 5, -44 },
  { 1109, 19, 44, 24, 2, -44 },
  { 1214, 19, 45, 24, 2, -44 },
  { 1321, 22, 44, 24, 1, -44 },
  { 1442, 18, 45, 24, 3, -44 },
  { 1544, 18, 45, 24, 3, -44 },
  { 1646, 18, 44, 24, 3, -44 },
  { 1745, 20, 45, 24, 2, -44 },
  { 1858, 19, 45, 24, 2, -44 },
  { 1965, 3, 32, 11, 4, -32 },
  { 1977, 5, 40, 11, 2, -32 },
  { 2002, 21, 25, 24, 2, -34 },
  { 2068, 21, 15, 24, 2, -29 },
  { 2108, 21, 25, 24, 2, -34 },
  { 2174, 14, 44, 16, 1, -44 },
  { 2251, 31, 50, 37, 3, -44 },
  { 2445, 23, 44, 23, 0, -44 },
  { 2572, 19, 44, 26, 5, -44 },
  { 2677, 21, 45, 25, 3, -44 },
  { 2796, 21, 44, 29, 5, -44 },
  { 2912, 15, 44, 23, 5, -44 },
  { 2995, 15, 44, 21, 5, -44 },
  { 3078, 25, 45, 32, 3, -44 },
  { 3219, 20, 44, 30, 5, -44 },
  { 3329, 9, 44, 13, 2, -44 },
  { 3379, 10, 55, 11, -3, -44 },
  { 3448, 18, 44, 23, 5, -44 },
  { 3547, 15, 44, 21, 5, -44 },
  { 3630, 30, 44, 40, 5, -44 },
  { 3795, 21, 44, 31, 5, -44 },
  { 3911, 25, 45, 31, 3, -44 },
  { 4052, 17, 44, 24, 5, -44 },
  { 4146, 25, 54, 31, 3, -44 },
  { 4315, 18, 44, 25, 5, -44 },
  { 4414, 18, 45, 24, 3, -44 },
  { 4516, 20, 44, 21, 0, -44 },
  { 4626, 21, 45, 30, 4, -44 },
  { 4745, 22, 44, 22, 0, -44 },
  { 4866, 39, 44, 39, 0, -44 },
  { 5081, 19, 44, 20, 1, -44 },
  { 5186, 19, 44, 19, 0, -44 },
  { 5291, 16, 44, 20, 2, -44 },
  { 5379, 11, 54, 19, 5, -44 },
  { 5454, 17, 44, 20, 2, -44 },
  { 5548, 12, 54, 19, 2, -44 },
  { 5629, 22, 21, 24, 1, -44 },
  { 5687, 24, 1, 24, 0, 6 },
  { 5690, 9, 10, 14, 2, -47 },
  { 5702, 16, 34, 22, 2, -33 },
  { 5770, 19, 47, 26, 4, -46 },
  { 5882, 15, 34, 19, 3, -33 },
  { 5946, 19, 47, 26, 3, -46 },
  { 6058, 17, 34, 23, 3, -33 },
  { 6131, 13, 47, 13, 1, -47 },
  { 6208, 18, 48, 26, 3, -33 },
  { 6316, 17, 46, 25, 4, -46 },
  { 6414, 3, 44, 11, 4, -44 },
  { 6431, 7, 59, 11, 0, -44 },
  { 6483, 15, 46, 20, 4, -46 },
  { 6570, 2, 46, 10, 4, -46 },
  { 6582, 29, 33, 37, 4, -33 },
  { 6702, 17, 33, 25, 4, -33 },
  { 6773, 19, 34, 25, 3, -33 },
  { 6854, 19, 47, 26, 4, -33 },
  { 6966, 18, 47, 26, 3, -33 },
  { 7072, 11, 33, 16, 4, -33 },
  { 7118, 15, 34, 19, 2, -33 },
  { 7182, 11, 41, 13, 1, -40 },
  { 7239, 17, 33, 25, 4, -32 },
  { 7310, 18, 32, 18, 0, -32 },
  { 7382, 30, 32, 31, 1, -32 },
  { 7502, 17, 32, 19, 1, -32 },
  { 7570, 18, 47, 19, 1, -32 },
  { 7676, 12, 32, 16, 2, -32 },
  { 7724, 15, 54, 21, 3, -44 },
  { 7826, 1, 61, 23, 11, -46 },
  { 7834, 15, 54, 21, 3, -44 },
  { 7936, 21, 5, 24, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Thin61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN61PT7B_H_
