#ifndef _NOTOSANS_EXTRACONDENSED_THIN40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEA, 0xAA, 0xAA, 0xA0, 0x0B, 0xC0, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0x04, 0x08, 0x08, 0x20, 0x10, 0x40,
  0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0xFF,
  0xFC, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10,
  0x08, 0x20, 0x30, 0x40, 0x40, 0x87, 0xFF, 0xE1, 0x04, 0x02, 0x08, 0x04,
  0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x81, 0x01, 0x02, 0x02, 0x08,
  0x00, 0x02, 0x00, 0x08, 0x01, 0xFE, 0x0C, 0x84, 0x62, 0x01, 0x08, 0x0C,
  0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x0C, 0x20, 0x10, 0x80, 0x62, 0x00,
  0xC8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x09, 0x80, 0x21, 0x00, 0x82,
  0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x21,
  0x38, 0x98, 0x3F, 0xC0, 0x08, 0x00, 0x20, 0x00, 0x80, 0x38, 0x02, 0x08,
  0x80, 0x81, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20,
  0x82, 0x04, 0x08, 0x80, 0x81, 0x10, 0x10, 0x22, 0x02, 0x04, 0x80, 0x41,
  0x10, 0x88, 0x22, 0x69, 0x04, 0x90, 0xA0, 0x92, 0x12, 0x12, 0x41, 0x44,
  0x88, 0x27, 0x12, 0x04, 0x02, 0x40, 0x80, 0x88, 0x10, 0x11, 0x02, 0x02,
  0x20, 0x40, 0x84, 0x08, 0x10, 0x81, 0x02, 0x08, 0x20, 0x81, 0x04, 0x10,
  0x21, 0x02, 0x02, 0x20, 0x80, 0x78, 0x0F, 0x00, 0x66, 0x01, 0x08, 0x04,
  0x20, 0x30, 0x40, 0x81, 0x02, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01,
  0x08, 0x02, 0x40, 0x0A, 0x00, 0x10, 0x00, 0xC0, 0x04, 0x80, 0x22, 0x01,
  0x04, 0x14, 0x08, 0x50, 0x22, 0x80, 0x4A, 0x01, 0x28, 0x02, 0xA0, 0x0C,
  0xC0, 0x11, 0x00, 0xE4, 0x06, 0x88, 0x31, 0x1F, 0x84, 0xFF, 0xE0, 0x02,
  0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x60, 0x81, 0x02, 0x0C, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x40, 0x81, 0x01, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x18, 0x18, 0x83, 0x04, 0x08, 0x20, 0x41, 0x06,
  0x08, 0x20, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x30, 0x82, 0x18, 0x41, 0x08, 0x21, 0x08, 0x00, 0x08, 0x02, 0x00,
  0x83, 0x23, 0x37, 0x03, 0x01, 0x40, 0x88, 0x21, 0x10, 0x20, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0xFF, 0xFC, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x6D, 0x24, 0xA4, 0x80, 0xFF, 0xBC,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x00, 0x0F, 0x01, 0x08, 0x20, 0x42, 0x04, 0x40, 0x24,
  0x02, 0x40, 0x28, 0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x26, 0x06, 0x20, 0x41, 0x08, 0x0F, 0x00,
  0x02, 0x1C, 0x79, 0xB6, 0x78, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0x1F, 0x06, 0x18, 0x80, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0xFF, 0xF0, 0x1F, 0x81,
  0x86, 0x30, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x3E, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x80, 0xC7, 0xFC, 0x00, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x88,
  0x02, 0x20, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x08, 0x20, 0x21, 0x00, 0x84, 0x02, 0x20, 0x08, 0x80, 0x23, 0xFF,
  0xF0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x7F, 0xE4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0xBF, 0x0C, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x48, 0x0C, 0xFF, 0x00, 0x03, 0xC0, 0xC2,
  0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x9F, 0x8A, 0x04, 0xC0, 0x2C, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x40, 0x34, 0x02,
  0x60, 0x22, 0x04, 0x1D, 0x80, 0x20, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x00, 0x07, 0x80, 0xC3, 0x08, 0x0C, 0x40, 0x24, 0x01, 0x20, 0x05,
  0x00, 0x28, 0x01, 0x60, 0x11, 0x00, 0x8C, 0x0C, 0x30, 0xC0, 0xCC, 0x03,
  0x80, 0x1E, 0x01, 0x18, 0x10, 0x21, 0x00, 0x90, 0x04, 0x80, 0x14, 0x00,
  0xE0, 0x07, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0xC8, 0x04, 0x60, 0x41,
  0xFC, 0x00, 0x1F, 0x03, 0x18, 0x40, 0x44, 0x04, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x54, 0x05, 0x20, 0xB1, 0xF2, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x7E, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0B, 0xC0, 0x6D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0D, 0xA4,
  0x94, 0x90, 0x00, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x00, 0x7C, 0x43, 0x00, 0x40, 0x20, 0x10, 0x0C, 0x06,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x06, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x38, 0xE0, 0x06, 0x03, 0x00, 0x80, 0x08, 0x10,
  0x00, 0xC1, 0x00, 0x04, 0x20, 0x00, 0x62, 0x00, 0x02, 0x40, 0x10, 0x24,
  0x0E, 0xC3, 0x41, 0x84, 0x14, 0x10, 0x41, 0xC1, 0x04, 0x18, 0x20, 0x41,
  0x82, 0x0C, 0x18, 0x20, 0xC1, 0x82, 0x08, 0x18, 0x20, 0x81, 0x82, 0x08,
  0x18, 0x20, 0x81, 0x82, 0x08, 0x38, 0x21, 0x42, 0x41, 0x14, 0x24, 0x1E,
  0x3C, 0x40, 0x41, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x79, 0xC0, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x48, 0x01,
  0x10, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x20, 0x80, 0x41, 0x00, 0x82,
  0x01, 0x04, 0x06, 0x04, 0x08, 0x08, 0x10, 0x10, 0x3F, 0xE0, 0xC0, 0x21,
  0x00, 0x42, 0x00, 0x84, 0x01, 0x08, 0x03, 0x20, 0x02, 0x40, 0x04, 0x80,
  0x09, 0x00, 0x14, 0x00, 0x18, 0x00, 0x20, 0xFC, 0x04, 0x1E, 0x20, 0x19,
  0x00, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0,
  0x0D, 0x00, 0x48, 0x04, 0x7F, 0xC2, 0x0E, 0x10, 0x0C, 0x80, 0x34, 0x00,
  0xA0, 0x05, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x02, 0x80, 0x14,
  0x00, 0xA0, 0x09, 0x01, 0x8F, 0xF8, 0x00, 0x01, 0xF0, 0x18, 0x30, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x01, 0x03, 0xF8, 0xF8, 0x02,
  0x1E, 0x08, 0x04, 0x20, 0x08, 0x80, 0x12, 0x00, 0x48, 0x00, 0xA0, 0x02,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x00, 0x88, 0x06, 0x20, 0x70, 0xFF,
  0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x00, 0x01, 0xFC, 0x03, 0x83, 0x83, 0x00, 0x42, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x7F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x02, 0x40, 0x01, 0x20, 0x00, 0x88, 0x00, 0x46, 0x00,
  0x21, 0x80, 0x30, 0x3F, 0xE0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x4F, 0x80,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0xFE, 0x80, 0x18, 0x02, 0x80, 0x68, 0x04, 0x80, 0x88, 0x08,
  0x81, 0x08, 0x30, 0x82, 0x08, 0x40, 0x84, 0x08, 0x80, 0x98, 0x09, 0x80,
  0xA8, 0x0A, 0xC0, 0xC4, 0x08, 0x60, 0x82, 0x08, 0x30, 0x81, 0x08, 0x10,
  0x80, 0x88, 0x08, 0x80, 0x48, 0x04, 0x80, 0x28, 0x02, 0x80, 0x10, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3A, 0x00, 0x07, 0xA0, 0x00,
  0x5A, 0x00, 0x05, 0xA0, 0x00, 0x59, 0x00, 0x09, 0x90, 0x00, 0x99, 0x00,
  0x09, 0x88, 0x01, 0x18, 0x80, 0x11, 0x88, 0x01, 0x18, 0x40, 0x21, 0x84,
  0x02, 0x18, 0x40, 0x21, 0x86, 0x06, 0x18, 0x20, 0x41, 0x82, 0x04, 0x18,
  0x20, 0x41, 0x81, 0x08, 0x18, 0x10, 0x81, 0x81, 0x08, 0x18, 0x09, 0x01,
  0x80, 0x90, 0x18, 0x09, 0x01, 0x80, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x68, 0x01, 0xA0, 0x06, 0x40, 0x19,
  0x00, 0x64, 0x01, 0x88, 0x06, 0x20, 0x18, 0x40, 0x61, 0x01, 0x82, 0x06,
  0x08, 0x18, 0x30, 0x60, 0x41, 0x81, 0x06, 0x02, 0x18, 0x08, 0x60, 0x11,
  0x80, 0x46, 0x00, 0x98, 0x02, 0x60, 0x0D, 0x80, 0x16, 0x00, 0x58, 0x00,
  0xE0, 0x03, 0x80, 0x04, 0x03, 0xE0, 0x0C, 0x38, 0x10, 0x08, 0x30, 0x04,
  0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x02, 0x40, 0x02, 0x20, 0x02, 0x20, 0x04, 0x10, 0x0C, 0x08, 0x18,
  0x07, 0xF0, 0xF0, 0x11, 0xF2, 0x03, 0x40, 0x38, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x34, 0x1C,
  0xFE, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x03, 0xE0, 0x0C, 0x10, 0x18, 0x08,
  0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x02, 0x20, 0x04, 0x10, 0x0C,
  0x08, 0x18, 0x07, 0xF0, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0xF8, 0x08, 0xF8, 0x80, 0xC8, 0x06,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x28, 0x04, 0x81, 0x8F, 0xF0, 0x86, 0x08, 0x20, 0x83, 0x08, 0x10,
  0x81, 0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x48, 0x02, 0x80, 0x28, 0x03,
  0x80, 0x10, 0x0F, 0xC3, 0x02, 0x60, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x68, 0x0C, 0xFF, 0x80, 0xFF, 0xF8,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xA0, 0x02, 0x80, 0x09, 0x00, 0x24, 0x01, 0x0C, 0x0C, 0x1F,
  0xC0, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01,
  0x10, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x30, 0x80, 0x40, 0x80, 0x81,
  0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21,
  0x00, 0x42, 0x00, 0x44, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x0A, 0x00, 0x18, 0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0x70,
  0x03, 0x00, 0x24, 0x00, 0xC0, 0x09, 0x00, 0x30, 0x02, 0x40, 0x0C, 0x00,
  0x90, 0x05, 0x00, 0x66, 0x01, 0x60, 0x10, 0x80, 0x48, 0x04, 0x20, 0x12,
  0x01, 0x08, 0x04, 0x80, 0x42, 0x02, 0x20, 0x20, 0x40, 0x8C, 0x08, 0x10,
  0x21, 0x02, 0x04, 0x08, 0x40, 0x81, 0x02, 0x10, 0x60, 0x61, 0x04, 0x10,
  0x08, 0x41, 0x84, 0x02, 0x10, 0x21, 0x00, 0x84, 0x08, 0x40, 0x21, 0x02,
  0x30, 0x0C, 0x80, 0x88, 0x01, 0x20, 0x32, 0x00, 0x48, 0x04, 0x80, 0x12,
  0x01, 0x20, 0x04, 0x80, 0x50, 0x00, 0xE0, 0x14, 0x00, 0x30, 0x05, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x09, 0x00, 0x88, 0x04,
  0x60, 0x21, 0x02, 0x08, 0x10, 0x21, 0x81, 0x08, 0x08, 0x40, 0x24, 0x01,
  0x20, 0x09, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x24,
  0x01, 0x20, 0x11, 0x00, 0x84, 0x08, 0x20, 0x41, 0x82, 0x04, 0x20, 0x21,
  0x00, 0x98, 0x04, 0x80, 0x2C, 0x00, 0x80, 0x80, 0x1C, 0x00, 0x90, 0x04,
  0x80, 0x24, 0x02, 0x10, 0x10, 0x80, 0x84, 0x08, 0x10, 0x40, 0x82, 0x04,
  0x20, 0x11, 0x00, 0x88, 0x04, 0x80, 0x14, 0x00, 0xA0, 0x06, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x0F, 0xFE, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0x02, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0xFF, 0x01, 0x00, 0x0C, 0x00, 0x28, 0x01, 0x20, 0x04, 0xC0, 0x21, 0x00,
  0x86, 0x04, 0x08, 0x10, 0x20, 0x80, 0x42, 0x01, 0x10, 0x02, 0x40, 0x0A,
  0x00, 0x10, 0xFF, 0xFF, 0x86, 0x10, 0x41, 0x04, 0x20, 0x7F, 0x10, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x43, 0xF3, 0x05, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0F, 0x05, 0x7E, 0x40,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x09, 0xF8, 0xA0, 0x4C, 0x02, 0xC0, 0x2C, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x02, 0xC0, 0x2C, 0x06, 0xA0, 0xC9, 0xF8, 0x0F, 0xCC, 0x02,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0xC0, 0x1F, 0xC0,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x11, 0xF9, 0x20, 0x56, 0x03, 0x40, 0x34, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x03, 0x40, 0x34, 0x05, 0x20, 0x51, 0xF9, 0x1F, 0x84, 0x19,
  0x81, 0x20, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFE, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18,
  0x11, 0xFC, 0x03, 0x07, 0x42, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x3F, 0x82, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x1F, 0x92, 0x05, 0x40, 0x34, 0x03, 0x40, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x34, 0x03, 0x40, 0x52, 0x0D, 0x1F, 0x90, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x80, 0x4F, 0x38, 0x1E, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x13, 0xF2, 0x83, 0x60, 0x2C, 0x05, 0x80, 0xA0, 0x1C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0xB8, 0x00, 0xAA, 0xAA, 0xAA, 0xAA,
  0xAA, 0x80, 0x10, 0xC4, 0x00, 0x00, 0x00, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x53, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x28, 0x12, 0x0C, 0x82, 0x21, 0x08, 0x42, 0x20, 0x98,
  0x26, 0x0A, 0x82, 0xA0, 0xC4, 0x21, 0x08, 0x22, 0x08, 0x82, 0x20, 0x48,
  0x12, 0x02, 0x80, 0xA0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x9F, 0x1F, 0x94,
  0x12, 0x1B, 0x02, 0x81, 0x60, 0x60, 0x28, 0x04, 0x05, 0x00, 0x80, 0xE0,
  0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x9F,
  0x94, 0x1B, 0x01, 0x60, 0x28, 0x05, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x14, 0x02, 0x60, 0x22, 0x04, 0x1F, 0x80,
  0x9F, 0x8B, 0x04, 0xA0, 0x2C, 0x02, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x2C, 0x02, 0xA0, 0x6B, 0x0C, 0x9F, 0x88, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x1F, 0x93, 0x05,
  0x60, 0x34, 0x03, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x34, 0x03,
  0x60, 0x53, 0x0D, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x9F, 0x42, 0x86, 0x0C, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x00, 0x3F, 0xC8, 0x14, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x0E, 0x02, 0x7F, 0x00, 0x20, 0x40, 0x81, 0x02, 0x1F, 0xC8, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x3C, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x3C, 0x0D, 0x05, 0x3E, 0x40, 0x80, 0x34, 0x02, 0x40, 0x24, 0x02,
  0x40, 0x42, 0x04, 0x20, 0x42, 0x04, 0x20, 0x83, 0x08, 0x10, 0x81, 0x08,
  0x11, 0x01, 0x10, 0x09, 0x00, 0x90, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x20, 0x14, 0x06, 0x01, 0x40, 0x50, 0x34, 0x05, 0x02,
  0x40, 0x50, 0x22, 0x05, 0x02, 0x20, 0x90, 0x22, 0x08, 0x84, 0x20, 0x88,
  0x41, 0x08, 0x84, 0x11, 0x88, 0x41, 0x10, 0x84, 0x11, 0x04, 0x81, 0x10,
  0x48, 0x09, 0x04, 0x80, 0xA0, 0x48, 0x0A, 0x05, 0x00, 0xA0, 0x30, 0x06,
  0x03, 0x00, 0x60, 0x30, 0x04, 0x03, 0x00, 0x80, 0x68, 0x09, 0x03, 0x10,
  0x42, 0x18, 0x22, 0x04, 0x40, 0x50, 0x0A, 0x01, 0x80, 0x10, 0x05, 0x00,
  0xA0, 0x24, 0x04, 0x41, 0x08, 0x20, 0x88, 0x11, 0x01, 0x60, 0x28, 0x06,
  0x40, 0x14, 0x01, 0x20, 0x12, 0x02, 0x20, 0x22, 0x02, 0x10, 0x21, 0x04,
  0x10, 0x41, 0x04, 0x08, 0x40, 0x88, 0x08, 0x80, 0x88, 0x04, 0x80, 0x50,
  0x05, 0x00, 0x50, 0x05, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x0B, 0x00, 0x40, 0x00, 0x7F,
  0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0x80, 0xFF, 0x00, 0x40, 0xE0, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x38, 0x07, 0x00, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x00, 0xF0, 0x38, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x06, 0x0F, 0x00, 0x38, 0x01, 0x98, 0x18, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Thin40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 29, 8, 3, -29 },
  { 9, 6, 11, 12, 3, -29 },
  { 18, 15, 29, 17, 1, -29 },
  { 73, 14, 32, 16, 1, -30 },
  { 129, 19, 29, 23, 2, -29 },
  { 198, 14, 29, 15, 1, -29 },
  { 249, 1, 11, 6, 3, -29 },
  { 251, 7, 35, 11, 2, -29 },
  { 282, 6, 35, 11, 2, -29 },
  { 309, 10, 10, 14, 2, -30 },
  { 322, 14, 18, 16, 1, -23 },
  { 354, 3, 9, 7, 2, -4 },
  { 358, 8, 1, 11, 1, -11 },
  { 359, 2, 3, 7, 3, -3 },
  { 360, 11, 29, 13, 1, -29 },
  { 400, 12, 29, 16, 2, -29 },
  { 444, 7, 29, 16, 3, -29 },
  { 470, 12, 29, 16, 2, -29 },
  { 514, 13, 29, 16, 1, -29 },
  { 562, 14, 29, 16, 1, -29 },
  { 613, 12, 29, 16, 2, -29 },
  { 657, 12, 30, 16, 2, -29 },
  { 702, 12, 29, 16, 2, -29 },
  { 746, 13, 29, 16, 1, -29 },
  { 794, 12, 29, 16, 2, -29 },
  { 838, 2, 21, 7, 3, -21 },
  { 844, 3, 26, 7, 2, -21 },
  { 854, 14, 16, 16, 1, -22 },
  { 882, 14, 10, 16, 1, -19 },
  { 900, 14, 16, 16, 1, -22 },
  { 928, 9, 29, 11, 1, -29 },
  { 961, 20, 33, 24, 2, -29 },
  { 1044, 15, 29, 15, 0, -29 },
  { 1099, 13, 29, 17, 3, -29 },
  { 1147, 14, 29, 17, 2, -29 },
  { 1198, 14, 29, 19, 3, -29 },
  { 1249, 10, 29, 15, 3, -29 },
  { 1286, 10, 29, 14, 3, -29 },
  { 1323, 17, 29, 21, 2, -29 },
  { 1385, 13, 29, 19, 3, -29 },
  { 1433, 5, 29, 9, 2, -29 },
  { 1452, 6, 36, 7, -2, -29 },
  { 1479, 12, 29, 15, 3, -29 },
  { 1523, 10, 29, 14, 3, -29 },
  { 1560, 20, 29, 26, 3, -29 },
  { 1633, 14, 29, 20, 3, -29 },
  { 1684, 16, 29, 20, 2, -29 },
  { 1742, 11, 29, 16, 3, -29 },
  { 1782, 16, 36, 20, 2, -29 },
  { 1854, 12, 29, 16, 3, -29 },
  { 1898, 12, 29, 16, 2, -29 },
  { 1942, 13, 29, 13, 0, -29 },
  { 1990, 14, 29, 19, 3, -29 },
  { 2041, 15, 29, 15, 0, -29 },
  { 2096, 26, 29, 26, 0, -29 },
  { 2191, 13, 29, 13, 0, -29 },
  { 2239, 13, 29, 13, 0, -29 },
  { 2287, 11, 29, 13, 1, -29 },
  { 2327, 8, 35, 12, 3, -29 },
  { 2362, 11, 29, 13, 1, -29 },
  { 2402, 8, 35, 12, 1, -29 },
  { 2437, 14, 14, 16, 1, -29 },
  { 2462, 16, 1, 16, 0, 4 },
  { 2464, 5, 7, 9, 2, -31 },
  { 2469, 10, 21, 15, 2, -21 },
  { 2496, 12, 30, 17, 3, -30 },
  { 2541, 10, 21, 13, 2, -21 },
  { 2568, 12, 30, 17, 2, -30 },
  { 2613, 11, 21, 15, 2, -21 },
  { 2642, 9, 31, 8, 0, -31 },
  { 2677, 12, 31, 17, 2, -21 },
  { 2724, 11, 30, 16, 3, -30 },
  { 2766, 2, 29, 7, 3, -29 },
  { 2774, 5, 39, 7, 0, -29 },
  { 2799, 10, 30, 13, 3, -30 },
  { 2837, 1, 30, 7, 3, -30 },
  { 2841, 19, 21, 24, 3, -21 },
  { 2891, 11, 21, 16, 3, -21 },
  { 2920, 12, 21, 16, 2, -21 },
  { 2952, 12, 30, 17, 3, -21 },
  { 2997, 12, 30, 17, 2, -21 },
  { 3042, 7, 21, 10, 3, -21 },
  { 3061, 10, 21, 12, 1, -21 },
  { 3088, 7, 26, 8, 1, -26 },
  { 3111, 10, 21, 16, 3, -21 },
  { 3138, 12, 21, 12, 0, -21 },
  { 3170, 20, 21, 20, 0, -21 },
  { 3223, 11, 21, 13, 1, -21 },
  { 3252, 12, 31, 13, 0, -21 },
  { 3299, 8, 21, 10, 1, -21 },
  { 3320, 10, 35, 14, 2, -29 },
  { 3364, 1, 40, 15, 7, -30 },
  { 3369, 10, 35, 14, 2, -29 },
  { 3413, 14, 3, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Thin40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN40PT7B_H_
