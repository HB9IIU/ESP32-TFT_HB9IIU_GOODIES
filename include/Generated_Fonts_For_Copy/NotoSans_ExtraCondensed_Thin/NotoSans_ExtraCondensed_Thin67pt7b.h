#ifndef _NOTOSANS_EXTRACONDENSED_THIN67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin67pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x69, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1A, 0x03, 0x40, 0x68, 0x0D, 0x01, 0xA0, 0x34,
  0x06, 0x80, 0xD0, 0x1A, 0x03, 0x40, 0x60, 0x00, 0x20, 0x0C, 0x00, 0x08,
  0x03, 0x00, 0x02, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0x60, 0x08, 0x00,
  0x18, 0x02, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x10, 0x06, 0x00, 0x04, 0x01, 0x80, 0x03, 0x00, 0x40, 0x00, 0xC0,
  0x10, 0x00, 0x30, 0x04, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00,
  0xC0, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x02, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x08, 0x00, 0x18, 0x02, 0x00, 0x06, 0x00,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x10, 0x06, 0x00, 0x04,
  0x01, 0x80, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x04, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x40, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x08, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x02, 0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x04, 0x01, 0x80, 0x01, 0x00, 0x60,
  0x00, 0x40, 0x18, 0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0x9F, 0x81,
  0xC2, 0x07, 0x0E, 0x08, 0x04, 0x30, 0x20, 0x01, 0x80, 0x80, 0x06, 0x02,
  0x00, 0x30, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x80, 0x0C, 0x02, 0x00,
  0x30, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x80, 0x04, 0x02, 0x00, 0x18,
  0x08, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x80, 0x01, 0x82, 0x00, 0x03, 0x88,
  0x00, 0x07, 0x20, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x2F, 0x00, 0x00, 0x8E, 0x00, 0x02, 0x0E, 0x00, 0x08, 0x1C, 0x00,
  0x20, 0x38, 0x00, 0x80, 0x60, 0x02, 0x00, 0xC0, 0x08, 0x03, 0x00, 0x20,
  0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0x00, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x20, 0x1A, 0x00,
  0x80, 0xCE, 0x02, 0x0E, 0x3F, 0x89, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x18,
  0xC0, 0x01, 0x00, 0x30, 0x60, 0x03, 0x00, 0x20, 0x20, 0x03, 0x00, 0x60,
  0x30, 0x02, 0x00, 0x60, 0x30, 0x06, 0x00, 0x40, 0x10, 0x06, 0x00, 0x40,
  0x18, 0x04, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0,
  0x18, 0x08, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC0,
  0x18, 0x10, 0x00, 0xC0, 0x18, 0x30, 0x00, 0xC0, 0x18, 0x30, 0x00, 0xC0,
  0x18, 0x20, 0x00, 0xC0, 0x18, 0x60, 0x00, 0xC0, 0x18, 0x60, 0x00, 0xC0,
  0x18, 0x61, 0xF8, 0xC0, 0x18, 0xC3, 0x1C, 0x40, 0x18, 0xC6, 0x0C, 0x40,
  0x10, 0xC6, 0x06, 0x60, 0x31, 0x84, 0x06, 0x60, 0x31, 0x8C, 0x02, 0x20,
  0x21, 0x8C, 0x03, 0x30, 0x61, 0x08, 0x03, 0x18, 0xC3, 0x08, 0x03, 0x0F,
  0x83, 0x08, 0x03, 0x02, 0x02, 0x18, 0x03, 0x00, 0x06, 0x18, 0x01, 0x00,
  0x06, 0x18, 0x01, 0x00, 0x04, 0x18, 0x01, 0x00, 0x0C, 0x18, 0x01, 0x00,
  0x0C, 0x18, 0x01, 0x00, 0x08, 0x18, 0x01, 0x00, 0x18, 0x18, 0x01, 0x00,
  0x18, 0x18, 0x03, 0x00, 0x10, 0x08, 0x03, 0x00, 0x30, 0x08, 0x03, 0x00,
  0x30, 0x08, 0x03, 0x00, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x02, 0x00,
  0x60, 0x04, 0x06, 0x00, 0x40, 0x06, 0x06, 0x00, 0xC0, 0x06, 0x04, 0x00,
  0xC0, 0x03, 0x0C, 0x00, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x04,
  0x06, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x08,
  0x03, 0x00, 0x08, 0x03, 0x00, 0x08, 0x03, 0x00, 0x08, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x04, 0x02, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0x18, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x20, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x10, 0x00, 0x30, 0x18, 0x06, 0x60, 0x0C, 0x04, 0x60, 0x0C, 0x04, 0x40,
  0x06, 0x04, 0xC0, 0x02, 0x04, 0xC0, 0x03, 0x0C, 0xC0, 0x01, 0x0C, 0xC0,
  0x01, 0x88, 0xC0, 0x00, 0x98, 0xC0, 0x00, 0xD8, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x70, 0x40, 0x00, 0x30, 0x40, 0x00, 0x70, 0x60, 0x00, 0xD8, 0x60,
  0x00, 0xC8, 0x30, 0x01, 0x8C, 0x18, 0x03, 0x06, 0x0C, 0x0E, 0x06, 0x07,
  0xF8, 0x03, 0x00, 0xE0, 0x00, 0xFF, 0x6D, 0x92, 0x49, 0x24, 0x92, 0x40,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x03, 0x82, 0x0E, 0x71, 0x3C, 0x07, 0xF0, 0x00, 0xE0,
  0x00, 0x50, 0x00, 0x4C, 0x00, 0x63, 0x00, 0x60, 0x80, 0x60, 0x20, 0x20,
  0x18, 0x30, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0xC6,
  0x73, 0x18, 0xC6, 0x63, 0x18, 0xCC, 0x62, 0x10, 0xFF, 0xFF, 0xFF, 0xF0,
  0x6F, 0xF7, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F,
  0xC0, 0x07, 0x8E, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x18,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x43, 0x00, 0x06, 0x20, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x34, 0x00, 0x03,
  0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x62, 0x00, 0x06,
  0x30, 0x00, 0x63, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01,
  0x80, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x78, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0x60, 0x1C, 0x07, 0x81, 0xB0, 0x66, 0x18, 0xCE, 0x1B, 0x83, 0xE0, 0x68,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x00, 0xFF, 0xC0, 0x3E, 0x1E,
  0x07, 0x00, 0x30, 0x40, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x3F,
  0xF0, 0x07, 0x83, 0xC0, 0x70, 0x03, 0x0E, 0x00, 0x0C, 0x20, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x71, 0x00, 0x07, 0x0F,
  0x00, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x09, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x02, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x7F, 0xFC, 0x07, 0xE0, 0xF0, 0x40, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x70, 0xF8, 0x1E, 0x03,
  0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xBC, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x1F, 0xE0, 0xC7, 0xFF, 0x0C, 0xE0, 0x18,
  0xC8, 0x00, 0xCD, 0x80, 0x06, 0xF0, 0x00, 0x6E, 0x00, 0x02, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x60,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x20, 0x00, 0x33,
  0x00, 0x02, 0x30, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xC0, 0xC0, 0x18,
  0x06, 0x03, 0x80, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x1E,
  0x1E, 0x00, 0xE0, 0x0C, 0x07, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00,
  0xC3, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x20, 0x00, 0x18, 0x80, 0x00, 0x62,
  0x00, 0x01, 0x88, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00,
  0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x0C,
  0x00, 0xC0, 0xE0, 0x01, 0x87, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0x01, 0xC6, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x38, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x98, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x34, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00,
  0x09, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x18, 0x00, 0x70,
  0x30, 0x03, 0x80, 0x70, 0x3C, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x7F, 0xC0, 0x0E, 0x0E, 0x01, 0x80, 0x30, 0x30, 0x01, 0x83,
  0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x40, 0x00, 0x4C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00,
  0x28, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x74, 0x00, 0x07, 0x60,
  0x00, 0xF6, 0x00, 0x0B, 0x30, 0x01, 0xB1, 0x80, 0x33, 0x1E, 0x0E, 0x30,
  0x7F, 0xC3, 0x00, 0xE0, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x02, 0x07, 0x80, 0x3F,
  0xE0, 0x00, 0x78, 0x00, 0x67, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0x11, 0xCE,
  0x73, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x63, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x46,
  0x31, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x7F, 0xC3, 0xE1, 0xC2, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x00, 0xE0, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x19, 0x80, 0x07, 0xF0, 0x0C, 0xC0,
  0x0F, 0x18, 0x06, 0x60, 0x0E, 0x04, 0x03, 0x20, 0x06, 0x02, 0x00, 0xB0,
  0x06, 0x03, 0x00, 0x78, 0x03, 0x01, 0x80, 0x3C, 0x03, 0x00, 0xC0, 0x1E,
  0x01, 0x80, 0x60, 0x0F, 0x00, 0xC0, 0x30, 0x07, 0x80, 0x40, 0x18, 0x03,
  0xC0, 0x60, 0x0C, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x70, 0x0C, 0x01, 0x80, 0x38, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x60,
  0x0E, 0x01, 0x80, 0x30, 0x07, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x60, 0x1C,
  0x01, 0x60, 0x10, 0x0A, 0x01, 0xB0, 0x0C, 0x05, 0x00, 0xD8, 0x06, 0x02,
  0x80, 0x6C, 0x03, 0x03, 0x60, 0x66, 0x00, 0xC3, 0x30, 0x73, 0x00, 0x73,
  0x8E, 0x70, 0xC0, 0x1F, 0x83, 0xF0, 0x60, 0x01, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x3C, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x46, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x18, 0x40, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x02, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x40, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0x81, 0x80, 0x00, 0x61,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x30, 0x01, 0xE1, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x60,
  0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x26, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x03, 0x83, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xC0, 0x03, 0x86, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0x6C,
  0x00, 0x03, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0xB0, 0x00, 0x1D, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x01, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0x83,
  0xC0, 0x70, 0x01, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x40, 0x3C, 0x07, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x03, 0x00, 0x3C, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x05, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x00,
  0x01, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x18, 0x01, 0xE0, 0x3F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x04, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x07, 0xC0, 0x3F, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0x82, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x21, 0xFF, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xA0, 0xEF,
  0xF0, 0xF0, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC1,
  0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xCF, 0x00, 0x0C,
  0xF0, 0x00, 0xD9, 0x80, 0x0D, 0x18, 0x00, 0xF0, 0xC0, 0x0E, 0x0C, 0x00,
  0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x18,
  0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x02, 0xF4, 0x00, 0x00, 0x01, 0xBD, 0x80, 0x00,
  0x00, 0x6F, 0x60, 0x00, 0x00, 0x13, 0xC8, 0x00, 0x00, 0x0C, 0xF3, 0x00,
  0x00, 0x03, 0x3C, 0xC0, 0x00, 0x00, 0x8F, 0x30, 0x00, 0x00, 0x63, 0xC6,
  0x00, 0x00, 0x18, 0xF1, 0x80, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x03, 0x0F,
  0x08, 0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0x08,
  0x3C, 0x10, 0x00, 0x06, 0x0F, 0x06, 0x00, 0x01, 0x83, 0xC1, 0x80, 0x00,
  0x40, 0xF0, 0x60, 0x00, 0x30, 0x3C, 0x0C, 0x00, 0x0C, 0x0F, 0x03, 0x00,
  0x03, 0x03, 0xC0, 0xC0, 0x01, 0x80, 0xF0, 0x10, 0x00, 0x60, 0x3C, 0x06,
  0x00, 0x18, 0x0F, 0x01, 0x80, 0x0C, 0x03, 0xC0, 0x20, 0x03, 0x00, 0xF0,
  0x0C, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0x20, 0x0F, 0x00, 0x40, 0x18, 0x03,
  0xC0, 0x18, 0x06, 0x00, 0xF0, 0x06, 0x01, 0x80, 0x3C, 0x01, 0x80, 0xC0,
  0x0F, 0x00, 0x30, 0x30, 0x03, 0xC0, 0x0C, 0x0C, 0x00, 0xF0, 0x03, 0x06,
  0x00, 0x3C, 0x00, 0x41, 0x80, 0x0F, 0x00, 0x18, 0x60, 0x03, 0xC0, 0x06,
  0x10, 0x00, 0xF0, 0x00, 0x8C, 0x00, 0x3C, 0x00, 0x33, 0x00, 0x0F, 0x00,
  0x0C, 0x80, 0x03, 0xC0, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xD8,
  0x00, 0x03, 0xD8, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xC4,
  0x00, 0x03, 0xC6, 0x00, 0x03, 0xC2, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC3,
  0x00, 0x03, 0xC1, 0x80, 0x03, 0xC1, 0x80, 0x03, 0xC0, 0xC0, 0x03, 0xC0,
  0xC0, 0x03, 0xC0, 0x40, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x60, 0x03, 0xC0,
  0x30, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x08, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x04, 0x03, 0xC0, 0x06, 0x03, 0xC0,
  0x06, 0x03, 0xC0, 0x03, 0x03, 0xC0, 0x03, 0x03, 0xC0, 0x01, 0x83, 0xC0,
  0x01, 0x83, 0xC0, 0x00, 0x83, 0xC0, 0x00, 0xC3, 0xC0, 0x00, 0x43, 0xC0,
  0x00, 0x63, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x33, 0xC0,
  0x00, 0x1B, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x0B, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x01,
  0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0x00, 0x78, 0x60, 0x01, 0xCC, 0x00, 0x19, 0x80, 0x01, 0xB0,
  0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0D, 0x80,
  0x01, 0xB0, 0x00, 0x66, 0x00, 0x1C, 0xC0, 0x07, 0x18, 0x07, 0xC3, 0xFF,
  0xE0, 0x7F, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x18,
  0x00, 0x00, 0x61, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x0C,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x30, 0x07, 0x81, 0x80, 0x07,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0,
  0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x4C, 0x00, 0x02,
  0x60, 0x00, 0x13, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00,
  0x03, 0x30, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xC3,
  0x00, 0x0E, 0x18, 0x00, 0xE0, 0xC0, 0x3C, 0x07, 0xFF, 0x80, 0x30, 0x18,
  0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0,
  0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x00, 0x18, 0x00, 0x3F,
  0xFC, 0x07, 0x81, 0xF1, 0xC0, 0x02, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x80, 0x03, 0x8F, 0x80, 0xF0, 0x7F, 0xFC, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x06, 0x40, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x80, 0x03, 0x03, 0x80,
  0x0C, 0x03, 0xC0, 0x70, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x40, 0x60, 0x00, 0x60, 0x10, 0x00, 0x30,
  0x08, 0x00, 0x18, 0x06, 0x00, 0x08, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06,
  0x00, 0x40, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x02, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x10, 0x00, 0x60,
  0x18, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x40, 0x00,
  0x18, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x18, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x66, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x68, 0x00, 0x01,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x38, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xA0, 0x00, 0x0C, 0xC0, 0x00, 0x14, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xD8, 0x00, 0x04, 0x30,
  0x00, 0x1B, 0x00, 0x01, 0x86, 0x00, 0x03, 0x60, 0x00, 0x30, 0x40, 0x00,
  0x44, 0x00, 0x06, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x63, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x60, 0x00,
  0xC0, 0x40, 0x01, 0x84, 0x00, 0x18, 0x0C, 0x00, 0x60, 0xC0, 0x02, 0x01,
  0x80, 0x0C, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x83, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x60, 0x03, 0x00, 0x60, 0x06, 0x04, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x18, 0x03, 0x00, 0x30, 0x06, 0x03, 0x00,
  0x60, 0x02, 0x00, 0xC0, 0x60, 0x0C, 0x00, 0x60, 0x18, 0x04, 0x01, 0x00,
  0x0C, 0x06, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00, 0x30,
  0x18, 0x03, 0x01, 0x80, 0x02, 0x03, 0x00, 0x60, 0x30, 0x00, 0x60, 0x60,
  0x04, 0x04, 0x00, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x60, 0x80,
  0x00, 0x61, 0x80, 0x04, 0x30, 0x00, 0x0C, 0x20, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x03, 0x30,
  0x00, 0x62, 0x00, 0x00, 0x66, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0x80, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x00, 0x16, 0x00, 0x03, 0x60,
  0x00, 0x03, 0xC0, 0x00, 0x68, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x60, 0x00,
  0x39, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x0C,
  0x00, 0x20, 0x20, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x00, 0x04,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x04, 0x60, 0x00, 0x32, 0x00,
  0x01, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x02, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x90, 0x00,
  0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04, 0x10, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x30, 0x10, 0x01, 0x80, 0xC0, 0x08, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD8, 0x00, 0x04,
  0xC0, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x18, 0x01, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x04, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x10, 0x40, 0x00,
  0xC6, 0x00, 0x06, 0x30, 0x00, 0x11, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x61, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC1, 0x80,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x03, 0xF0, 0x0F, 0xFE, 0x0E, 0x03, 0x84, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x7F, 0x81, 0xF8, 0xC3, 0x80, 0x67, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x40, 0x05, 0xB0,
  0x06, 0xCE, 0x06, 0x63, 0xFE, 0x30, 0x78, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1F, 0x80,
  0xC7, 0xFE, 0x0C, 0xE0, 0x30, 0xD8, 0x01, 0x8D, 0x00, 0x0C, 0xF0, 0x00,
  0xCA, 0x00, 0x06, 0xA0, 0x00, 0x6E, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2E, 0x00, 0x06, 0xE0, 0x00,
  0x6A, 0x00, 0x04, 0xB0, 0x00, 0xC9, 0x80, 0x18, 0x8C, 0x03, 0x88, 0xF0,
  0xF0, 0x83, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0xC1, 0xC0,
  0x41, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x7F, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x3F, 0x03, 0x03, 0xFE, 0x18, 0x70, 0x18,
  0xC3, 0x00, 0x66, 0x30, 0x01, 0xB3, 0x00, 0x05, 0x98, 0x00, 0x3C, 0x80,
  0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x00, 0xD0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x40, 0x00,
  0x1B, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x98,
  0x00, 0x2C, 0xC0, 0x03, 0x63, 0x00, 0x1B, 0x1C, 0x01, 0x98, 0x78, 0x38,
  0xC0, 0xFF, 0x86, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x38,
  0x1C, 0x0E, 0x01, 0xC1, 0x80, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x00,
  0x02, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xA0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x08, 0x1C, 0x0F, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0xFE,
  0x07, 0x98, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0xFF, 0xE0, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0xC3, 0x80, 0xE6, 0x38, 0x03, 0x31, 0x80, 0x0D, 0x98,
  0x00, 0x2C, 0xC0, 0x01, 0xE4, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x01,
  0xD0, 0x00, 0x06, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1A, 0x00, 0x01, 0xD0, 0x00, 0x0E, 0xC0, 0x00, 0x76,
  0x00, 0x03, 0xB0, 0x00, 0x3C, 0xC0, 0x01, 0x66, 0x00, 0x1B, 0x18, 0x01,
  0x98, 0x60, 0x1C, 0xC3, 0x81, 0xC6, 0x07, 0xF8, 0x30, 0x07, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x40, 0x01, 0xC3, 0x00, 0x1C, 0x0F, 0xDF, 0xC0,
  0x1F, 0xF8, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x07, 0xE0, 0xC7, 0xFC, 0x33, 0x81, 0x8D, 0xC0, 0x33, 0x60, 0x06,
  0xF0, 0x01, 0xA8, 0x00, 0x6A, 0x00, 0x0B, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0C, 0x27, 0xFF,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x02,
  0x06, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0xF8, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30,
  0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0x80, 0xC1, 0x80, 0xC3, 0x00,
  0xC3, 0x00, 0xC7, 0x00, 0xCF, 0x00, 0xCD, 0x00, 0x99, 0x80, 0x91, 0x80,
  0xB0, 0xC0, 0xE0, 0xC0, 0xC0, 0x40, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x10, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x07, 0xC1, 0x0F, 0xF0, 0x3F, 0xE2, 0x30, 0x30, 0xE0, 0xE4, 0xC0,
  0x31, 0x00, 0xEB, 0x00, 0x66, 0x00, 0xD4, 0x00, 0x48, 0x00, 0xA8, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x03,
  0x00, 0x0F, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x10,
  0x00, 0x78, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x80,
  0x03, 0xC0, 0x01, 0x00, 0x07, 0x80, 0x02, 0x00, 0x0F, 0x00, 0x04, 0x00,
  0x1E, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x78, 0x00, 0x20, 0x00,
  0xF0, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x80, 0x03, 0xC0, 0x01, 0x00, 0x07,
  0x80, 0x02, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x3C,
  0x00, 0x10, 0x00, 0x78, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x40, 0x01, 0xE0,
  0x00, 0x80, 0x03, 0xC0, 0x01, 0x00, 0x07, 0x80, 0x02, 0x00, 0x0F, 0x00,
  0x04, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x30, 0x01, 0xF8, 0x21, 0xFF, 0x88,
  0xE0, 0x72, 0x60, 0x0C, 0x90, 0x01, 0xAC, 0x00, 0x6A, 0x00, 0x1B, 0x80,
  0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0xE0,
  0x38, 0x03, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00,
  0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0x05, 0x80, 0x00, 0x2C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00, 0x00,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x10, 0x00, 0x18, 0xC0,
  0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0xC1, 0xE0,
  0x07, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x08, 0x7F, 0xE0, 0x8E,
  0x07, 0x09, 0xC0, 0x18, 0x98, 0x00, 0xCB, 0x00, 0x0C, 0xA0, 0x00, 0x6A,
  0x00, 0x06, 0xE0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x02, 0xE0, 0x00, 0x6A, 0x00, 0x06, 0xB0, 0x00, 0xC9,
  0x00, 0x0C, 0x98, 0x01, 0x88, 0xC0, 0x38, 0xC7, 0x07, 0x0C, 0x3F, 0xC0,
  0xC0, 0x70, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0xC1, 0xC0, 0xE6,
  0x18, 0x03, 0x31, 0x80, 0x0D, 0x98, 0x00, 0x2C, 0xC0, 0x01, 0xE4, 0x00,
  0x07, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00, 0x00,
  0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x90, 0x00, 0x3C, 0xC0,
  0x01, 0x67, 0x00, 0x1B, 0x18, 0x01, 0x98, 0x60, 0x1C, 0xC1, 0xC1, 0xC6,
  0x07, 0xFC, 0x30, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x01, 0xE8, 0x7F,
  0x8E, 0x18, 0xC0, 0x98, 0x09, 0x00, 0xB0, 0x0A, 0x00, 0xA0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x87, 0x00, 0xC6, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x60, 0x03, 0x3E, 0x07, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F,
  0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x10, 0x7F, 0x01, 0xC0, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xBC, 0x00, 0x2D, 0x80, 0x13, 0x70, 0x0C, 0xCE, 0x0E, 0x31, 0xFF,
  0x0C, 0x0E, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00,
  0x26, 0x00, 0x0C, 0x40, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x04, 0x30, 0x01,
  0x82, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x10, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x00, 0x80, 0xC0, 0x18, 0x18,
  0x03, 0x03, 0x00, 0x60, 0x40, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x18, 0x60,
  0x03, 0x08, 0x00, 0x63, 0x00, 0x04, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x00,
  0x03, 0x60, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xB0,
  0x00, 0x70, 0x00, 0xC8, 0x00, 0x28, 0x00, 0x64, 0x00, 0x34, 0x00, 0x33,
  0x00, 0x1B, 0x00, 0x11, 0x80, 0x0D, 0x80, 0x18, 0xC0, 0x04, 0xC0, 0x0C,
  0x20, 0x06, 0x20, 0x06, 0x18, 0x03, 0x10, 0x03, 0x0C, 0x01, 0x8C, 0x01,
  0x06, 0x00, 0xC6, 0x01, 0x81, 0x00, 0x43, 0x00, 0xC0, 0x80, 0x60, 0x80,
  0x60, 0x60, 0x30, 0x60, 0x20, 0x30, 0x18, 0x30, 0x30, 0x18, 0x0C, 0x18,
  0x18, 0x04, 0x04, 0x0C, 0x0C, 0x03, 0x06, 0x02, 0x06, 0x01, 0x83, 0x01,
  0x82, 0x00, 0xC1, 0x80, 0xC3, 0x00, 0x20, 0x80, 0x61, 0x80, 0x10, 0xC0,
  0x30, 0xC0, 0x0C, 0x60, 0x08, 0x40, 0x06, 0x30, 0x06, 0x20, 0x03, 0x18,
  0x03, 0x30, 0x00, 0x88, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x4C, 0x00, 0x36,
  0x00, 0x24, 0x00, 0x1B, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x0F, 0x00, 0x02,
  0x80, 0x07, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x06, 0x08,
  0x00, 0xC1, 0x80, 0x10, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x06,
  0x06, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x11, 0x80, 0x03,
  0x60, 0x00, 0x2C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xD8, 0x00, 0x19, 0x00, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x02, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x00, 0xCC, 0x00,
  0x1B, 0x00, 0x01, 0x80, 0x40, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C,
  0x10, 0x00, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x08, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x02, 0x00, 0x60,
  0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x02, 0x04, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x01, 0x08, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00,
  0x19, 0x80, 0x00, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x7E, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xE1, 0xE0,
  0x0F, 0x00, 0xF0, 0x3C, 0x00, 0x7F, 0xC8, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Thin67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 48, 13, 5, -48 },
  { 19, 11, 17, 20, 4, -48 },
  { 43, 26, 48, 28, 1, -48 },
  { 199, 22, 55, 26, 2, -51 },
  { 351, 32, 50, 38, 3, -49 },
  { 551, 24, 50, 26, 2, -49 },
  { 701, 3, 17, 11, 4, -48 },
  { 708, 12, 59, 18, 3, -48 },
  { 797, 11, 59, 18, 3, -48 },
  { 879, 17, 17, 23, 3, -51 },
  { 916, 23, 31, 27, 2, -39 },
  { 1006, 5, 16, 12, 3, -7 },
  { 1016, 14, 2, 18, 2, -19 },
  { 1020, 4, 4, 12, 4, -4 },
  { 1022, 19, 48, 22, 2, -48 },
  { 1136, 20, 49, 26, 3, -49 },
  { 1259, 11, 48, 26, 5, -48 },
  { 1325, 20, 49, 26, 3, -49 },
  { 1448, 21, 50, 26, 2, -49 },
  { 1580, 25, 48, 26, 1, -48 },
  { 1730, 20, 49, 26, 3, -48 },
  { 1853, 20, 49, 26, 3, -48 },
  { 1976, 20, 48, 26, 3, -48 },
  { 2096, 22, 49, 26, 2, -48 },
  { 2231, 20, 50, 26, 3, -49 },
  { 2356, 4, 36, 12, 4, -36 },
  { 2374, 5, 45, 12, 3, -36 },
  { 2403, 23, 27, 27, 2, -37 },
  { 2481, 23, 16, 27, 2, -32 },
  { 2527, 23, 27, 27, 2, -37 },
  { 2605, 15, 49, 18, 1, -49 },
  { 2697, 33, 54, 40, 4, -48 },
  { 2920, 25, 48, 25, 0, -48 },
  { 3070, 21, 48, 29, 5, -48 },
  { 3196, 22, 50, 28, 4, -49 },
  { 3334, 23, 48, 32, 5, -48 },
  { 3472, 17, 48, 26, 5, -48 },
  { 3574, 17, 48, 24, 5, -48 },
  { 3676, 27, 50, 35, 4, -49 },
  { 3845, 22, 48, 33, 5, -48 },
  { 3977, 9, 48, 15, 3, -48 },
  { 4031, 10, 60, 12, -3, -48 },
  { 4106, 20, 48, 25, 5, -48 },
  { 4226, 17, 48, 23, 5, -48 },
  { 4328, 34, 48, 44, 5, -48 },
  { 4532, 24, 48, 34, 5, -48 },
  { 4676, 27, 50, 34, 4, -49 },
  { 4845, 19, 48, 26, 5, -48 },
  { 4959, 27, 60, 34, 4, -49 },
  { 5162, 21, 48, 27, 5, -48 },
  { 5288, 20, 50, 26, 3, -49 },
  { 5413, 22, 48, 23, 0, -48 },
  { 5545, 23, 49, 33, 5, -48 },
  { 5686, 25, 48, 25, 0, -48 },
  { 5836, 43, 48, 43, 0, -48 },
  { 6094, 21, 48, 22, 1, -48 },
  { 6220, 21, 48, 21, 0, -48 },
  { 6346, 18, 48, 22, 2, -48 },
  { 6454, 12, 59, 21, 6, -48 },
  { 6543, 19, 48, 22, 2, -48 },
  { 6657, 13, 59, 21, 2, -48 },
  { 6753, 24, 23, 26, 1, -48 },
  { 6822, 26, 2, 26, 0, 6 },
  { 6829, 9, 10, 15, 3, -51 },
  { 6841, 17, 37, 25, 3, -36 },
  { 6920, 20, 52, 28, 5, -51 },
  { 7050, 17, 37, 21, 3, -36 },
  { 7129, 21, 52, 28, 3, -51 },
  { 7266, 19, 37, 25, 3, -36 },
  { 7354, 15, 51, 14, 1, -51 },
  { 7450, 21, 52, 28, 3, -36 },
  { 7587, 18, 51, 27, 5, -51 },
  { 7702, 4, 49, 12, 4, -49 },
  { 7727, 8, 65, 12, 0, -49 },
  { 7792, 16, 51, 22, 5, -51 },
  { 7894, 2, 51, 11, 5, -51 },
  { 7907, 31, 36, 41, 5, -36 },
  { 8047, 18, 36, 27, 5, -36 },
  { 8128, 21, 37, 27, 3, -36 },
  { 8226, 20, 52, 28, 5, -36 },
  { 8356, 21, 52, 28, 3, -36 },
  { 8493, 12, 36, 18, 5, -36 },
  { 8547, 17, 37, 21, 2, -36 },
  { 8626, 12, 45, 14, 1, -44 },
  { 8694, 18, 36, 27, 5, -35 },
  { 8775, 19, 35, 20, 0, -35 },
  { 8859, 33, 35, 34, 1, -35 },
  { 9004, 19, 35, 21, 1, -35 },
  { 9088, 20, 51, 21, 1, -35 },
  { 9216, 14, 35, 17, 2, -35 },
  { 9278, 17, 59, 23, 3, -48 },
  { 9404, 2, 67, 25, 12, -51 },
  { 9421, 17, 59, 23, 3, -48 },
  { 9547, 23, 5, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Thin67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN67PT7B_H_
