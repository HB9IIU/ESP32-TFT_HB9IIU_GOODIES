#ifndef _NOTOSANS_EXTRACONDENSED_THIN41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0B, 0xC0, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x10, 0x06, 0x08, 0x04, 0x08, 0x04, 0x08, 0x04,
  0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x7F, 0xFF, 0x0C,
  0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08, 0x20, 0x08,
  0x20, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE, 0x10, 0x20, 0x10, 0x20, 0x10,
  0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20,
  0x40, 0x20, 0x40, 0x02, 0x00, 0x08, 0x00, 0xFC, 0x06, 0x8E, 0x22, 0x01,
  0x08, 0x04, 0x20, 0x30, 0x80, 0x82, 0x02, 0x08, 0x0C, 0x20, 0x10, 0x80,
  0x42, 0x00, 0x88, 0x01, 0xA0, 0x03, 0x80, 0x03, 0x80, 0x0B, 0x00, 0x23,
  0x00, 0x86, 0x02, 0x08, 0x08, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x30, 0x20, 0x80, 0x86, 0xE2, 0x30, 0xFF, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x06, 0x40, 0x20, 0x42, 0x04, 0x04, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x10, 0x80, 0x81, 0x08, 0x08, 0x10, 0x80, 0x81, 0x10, 0x08,
  0x11, 0x00, 0x81, 0x10, 0x08, 0x13, 0x00, 0x81, 0x23, 0x88, 0x32, 0x44,
  0x82, 0x64, 0x24, 0x24, 0x82, 0x42, 0x48, 0x26, 0x4C, 0x82, 0x18, 0x88,
  0x20, 0x08, 0x81, 0x00, 0x88, 0x10, 0x10, 0x81, 0x01, 0x08, 0x10, 0x10,
  0x83, 0x02, 0x08, 0x20, 0x20, 0x82, 0x02, 0x08, 0x20, 0x40, 0xC2, 0x04,
  0x04, 0x40, 0xC0, 0x3C, 0x06, 0x00, 0x13, 0x00, 0x42, 0x00, 0x82, 0x01,
  0x04, 0x02, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x21, 0x80, 0x42,
  0x00, 0x44, 0x00, 0x90, 0x00, 0xC0, 0x03, 0x00, 0x0D, 0x00, 0x32, 0x00,
  0x42, 0x09, 0x04, 0x12, 0x04, 0x24, 0x0C, 0x50, 0x08, 0xA0, 0x0A, 0x40,
  0x14, 0x80, 0x18, 0x80, 0x21, 0x00, 0xA2, 0x01, 0x42, 0x0C, 0x43, 0xF0,
  0xC0, 0xFF, 0xC0, 0x06, 0x08, 0x20, 0xC1, 0x06, 0x08, 0x10, 0x60, 0x81,
  0x02, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x20,
  0x40, 0x81, 0x81, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x80, 0x81,
  0x81, 0x01, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x81, 0x83,
  0x02, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x04, 0x18, 0x20, 0x41, 0x82,
  0x04, 0x10, 0x20, 0x83, 0x00, 0x04, 0x01, 0x00, 0x42, 0x11, 0x77, 0x83,
  0x00, 0xC0, 0x48, 0x21, 0x10, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0xFF, 0xF0,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x2D, 0xA4, 0xA4, 0x80, 0xFF, 0x80, 0xBC, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x06, 0x01, 0xD8, 0x30, 0x42,
  0x06, 0x40, 0x24, 0x02, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x24, 0x02, 0x20, 0x22,
  0x04, 0x10, 0xC0, 0xF8, 0x06, 0x14, 0x49, 0x14, 0x30, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x0E, 0x07, 0xB8, 0xC0, 0x40, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x0F, 0xFF, 0x1C, 0x07, 0x38, 0x80, 0x40, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x18,
  0x1E, 0x00, 0x38, 0x00, 0xC0, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x06, 0x80, 0xCF, 0xF8,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x24, 0x00,
  0x48, 0x01, 0x10, 0x02, 0x20, 0x08, 0x40, 0x10, 0x80, 0x41, 0x00, 0x82,
  0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x80, 0x41, 0x00, 0x84,
  0x01, 0x08, 0x02, 0x1F, 0xFF, 0xC0, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x7F, 0xE4, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0xFF, 0x88, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x68,
  0x0C, 0x7F, 0x00, 0x00, 0x80, 0x7E, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x8F, 0x89, 0x8C,
  0xA0, 0x2C, 0x02, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x40, 0x14, 0x01, 0x40, 0x32, 0x02, 0x30, 0x41, 0xDC,
  0x02, 0x00, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x33, 0x81, 0x03, 0x08, 0x04, 0x60, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02,
  0x40, 0x08, 0x80, 0x62, 0x01, 0x04, 0x0C, 0x08, 0x60, 0x12, 0x00, 0x30,
  0x01, 0x20, 0x18, 0x60, 0xC0, 0xC2, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00,
  0x3C, 0x00, 0x70, 0x03, 0x40, 0x0D, 0x00, 0x24, 0x00, 0x88, 0x04, 0x30,
  0x30, 0x3F, 0x00, 0x06, 0x03, 0x98, 0x60, 0x44, 0x04, 0xC0, 0x28, 0x02,
  0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x34, 0x03, 0x40, 0x53, 0x19, 0x0F, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x01, 0x07, 0xE0,
  0xBC, 0x00, 0x00, 0x00, 0x02, 0xF0, 0x6D, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xB6, 0x92, 0x92, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x04, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x77, 0x00,
  0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x20,
  0x30, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x03, 0x01, 0x80, 0x01, 0xFE, 0x00, 0x30, 0x18,
  0x03, 0x00, 0x20, 0x10, 0x00, 0x81, 0x00, 0x06, 0x18, 0x00, 0x10, 0x80,
  0x00, 0x84, 0x00, 0x02, 0x40, 0x7C, 0x12, 0x06, 0x20, 0x90, 0x61, 0x04,
  0x82, 0x08, 0x2C, 0x10, 0x41, 0xC1, 0x02, 0x06, 0x08, 0x10, 0x30, 0x40,
  0x81, 0x82, 0x04, 0x0C, 0x10, 0x20, 0xE0, 0x83, 0x05, 0x04, 0x18, 0x28,
  0x20, 0xC1, 0x60, 0x86, 0x09, 0x04, 0x58, 0x88, 0x1E, 0x78, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x08, 0x00, 0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x24, 0x00, 0x48, 0x01, 0x10, 0x02,
  0x20, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x41, 0x00, 0x83, 0x01, 0x02,
  0x06, 0x04, 0x08, 0x08, 0x1F, 0xF8, 0x20, 0x10, 0xC0, 0x21, 0x00, 0x42,
  0x00, 0x84, 0x00, 0x88, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x05, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0xFF, 0xC4, 0x03, 0x20, 0x0D, 0x00, 0x28,
  0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x0D, 0x00,
  0x48, 0x0C, 0x7F, 0x82, 0x03, 0x10, 0x04, 0x80, 0x14, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xA0,
  0x0D, 0x01, 0xCF, 0xF8, 0x00, 0x00, 0xF0, 0x1E, 0x70, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x04, 0x0F, 0xF0, 0xFF, 0x82,
  0x03, 0x08, 0x02, 0x20, 0x04, 0x80, 0x1A, 0x00, 0x28, 0x00, 0xA0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0xC8, 0x06, 0x20, 0x30, 0xFF,
  0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0xFF, 0xA0, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x0F, 0xFE, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x3F, 0xF7, 0xFE, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x00, 0x30, 0x01,
  0xE7, 0x81, 0x00, 0x61, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x3F, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0xC0, 0x01,
  0x20, 0x00, 0x98, 0x00, 0x44, 0x00, 0x21, 0x00, 0x10, 0x60, 0x08, 0x1F,
  0xF8, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x4F, 0x80, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x82, 0x04, 0x08, 0x37, 0xC0, 0x80, 0x34, 0x01, 0x20, 0x11,
  0x00, 0x88, 0x08, 0x40, 0xC2, 0x04, 0x10, 0x40, 0x82, 0x04, 0x20, 0x23,
  0x01, 0x10, 0x09, 0x80, 0x4C, 0x02, 0xA0, 0x1C, 0x80, 0xC4, 0x04, 0x10,
  0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x42, 0x02, 0x10, 0x08, 0x80, 0x44,
  0x01, 0x20, 0x09, 0x00, 0x28, 0x01, 0x80, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE8, 0x00, 0x0B, 0x40, 0x00, 0x5A, 0x00, 0x06, 0xD8, 0x00, 0x26,
  0x40, 0x01, 0x32, 0x00, 0x09, 0x90, 0x00, 0x8C, 0x40, 0x04, 0x62, 0x00,
  0x23, 0x10, 0x02, 0x18, 0x40, 0x10, 0xC2, 0x00, 0x86, 0x10, 0x0C, 0x30,
  0xC0, 0x41, 0x82, 0x02, 0x0C, 0x10, 0x10, 0x60, 0x81, 0x03, 0x02, 0x08,
  0x18, 0x10, 0x40, 0xC0, 0x84, 0x06, 0x02, 0x20, 0x30, 0x11, 0x01, 0x80,
  0x98, 0x0C, 0x06, 0x80, 0x60, 0x14, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00,
  0x80, 0xC0, 0x07, 0x80, 0x0E, 0x80, 0x1D, 0x00, 0x39, 0x00, 0x72, 0x00,
  0xE4, 0x01, 0xC4, 0x03, 0x88, 0x07, 0x08, 0x0E, 0x10, 0x1C, 0x10, 0x38,
  0x20, 0x70, 0x60, 0xE0, 0x41, 0xC0, 0x83, 0x80, 0x87, 0x01, 0x0E, 0x01,
  0x1C, 0x02, 0x38, 0x02, 0x70, 0x04, 0xE0, 0x0D, 0xC0, 0x0B, 0x80, 0x17,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x98,
  0x06, 0x03, 0x02, 0x00, 0x82, 0x00, 0x21, 0x00, 0x11, 0x00, 0x04, 0x80,
  0x02, 0x40, 0x01, 0x20, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x34, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x60,
  0x03, 0x10, 0x01, 0x0C, 0x01, 0x82, 0x00, 0x80, 0x80, 0x80, 0x3F, 0x80,
  0xFF, 0x08, 0x0C, 0x80, 0x68, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0x80, 0x28, 0x06, 0x80, 0xCF, 0xF8,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x98,
  0x06, 0x03, 0x02, 0x00, 0x82, 0x00, 0x21, 0x00, 0x11, 0x00, 0x04, 0x80,
  0x02, 0x40, 0x01, 0x20, 0x00, 0xB0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x34, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x60,
  0x03, 0x10, 0x01, 0x0C, 0x01, 0x82, 0x00, 0x80, 0x80, 0x80, 0x3F, 0x80,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x40, 0xFF, 0x04, 0x06, 0x20, 0x19, 0x00, 0x48, 0x03, 0x40,
  0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x0D, 0x00, 0x48, 0x02,
  0x40, 0x22, 0x0E, 0x1F, 0xC0, 0x82, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08,
  0x08, 0x40, 0x42, 0x01, 0x10, 0x08, 0x80, 0x64, 0x01, 0x20, 0x0D, 0x00,
  0x28, 0x01, 0x80, 0x07, 0x01, 0xC7, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x80, 0xCF, 0xF8,
  0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x09, 0x00, 0x26, 0x01, 0x8C,
  0x0C, 0x1F, 0xE0, 0x80, 0x03, 0x00, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0xC0, 0x40,
  0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x0C, 0x04, 0x10, 0x08, 0x20, 0x10,
  0x40, 0x20, 0x80, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10, 0x01, 0x40,
  0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x18, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x50, 0x03, 0x00, 0x14, 0x00, 0xC0, 0x05, 0x00, 0x30, 0x03, 0x40,
  0x0A, 0x00, 0x98, 0x02, 0x80, 0x22, 0x01, 0x20, 0x08, 0x80, 0x48, 0x06,
  0x20, 0x12, 0x01, 0x08, 0x04, 0x40, 0x43, 0x01, 0x10, 0x10, 0x40, 0x84,
  0x04, 0x10, 0x21, 0x03, 0x04, 0x08, 0x40, 0x81, 0x02, 0x08, 0x20, 0x20,
  0x82, 0x08, 0x08, 0x40, 0x82, 0x02, 0x10, 0x21, 0x00, 0x84, 0x08, 0x40,
  0x31, 0x01, 0x10, 0x04, 0x40, 0x44, 0x01, 0x30, 0x13, 0x00, 0x48, 0x04,
  0x80, 0x12, 0x01, 0x20, 0x06, 0x80, 0x28, 0x00, 0xA0, 0x0A, 0x00, 0x38,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x60, 0x09, 0x00,
  0x8C, 0x04, 0x20, 0x21, 0x02, 0x04, 0x10, 0x21, 0x81, 0x08, 0x04, 0x40,
  0x24, 0x01, 0x20, 0x05, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x80, 0x24, 0x01, 0x20, 0x10, 0x80, 0x84, 0x0C, 0x30, 0x40, 0x82, 0x04,
  0x20, 0x31, 0x00, 0x98, 0x04, 0x80, 0x3C, 0x00, 0x80, 0x80, 0x0A, 0x00,
  0x90, 0x04, 0x80, 0x22, 0x02, 0x10, 0x10, 0x80, 0x82, 0x08, 0x10, 0x40,
  0x82, 0x02, 0x20, 0x11, 0x00, 0x88, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x04,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0F,
  0xFE, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0xFF, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x01, 0x00, 0x05, 0x00, 0x1A,
  0x00, 0x26, 0x00, 0xC4, 0x01, 0x0C, 0x06, 0x08, 0x08, 0x18, 0x30, 0x10,
  0x40, 0x21, 0x80, 0x22, 0x00, 0x4C, 0x00, 0x50, 0x00, 0xC0, 0xFF, 0xFF,
  0x81, 0x02, 0x0C, 0x18, 0x30, 0x1F, 0x18, 0x60, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFC, 0xC1, 0x40, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x41, 0x5F, 0x90, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x7C, 0x24, 0x31, 0x40, 0x4C, 0x02, 0x60, 0x0B, 0x00, 0x50, 0x02, 0x80,
  0x14, 0x00, 0xA0, 0x05, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x50, 0x02,
  0x80, 0x14, 0x00, 0xB0, 0x05, 0x80, 0x4A, 0x02, 0x58, 0x22, 0x7E, 0x00,
  0x07, 0xC6, 0x13, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00,
  0x80, 0x30, 0x07, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x78, 0xC4, 0x36, 0x40, 0xF4,
  0x03, 0x20, 0x0D, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xD0, 0x06,
  0x80, 0x56, 0x02, 0x90, 0x24, 0x7E, 0x20, 0x0F, 0x03, 0x08, 0x20, 0x44,
  0x02, 0x40, 0x2C, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x21, 0xFC, 0x07, 0xC2, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x3F, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x0F, 0x93, 0x0D, 0x20, 0x34,
  0x03, 0x40, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x36,
  0x03, 0x20, 0x51, 0xF9, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x06, 0x60, 0xC3, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x11, 0xE2, 0x42, 0x50, 0x2C,
  0x05, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0xBC, 0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x10, 0xC6,
  0x00, 0x00, 0x00, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x9C, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x28,
  0x0A, 0x04, 0x83, 0x20, 0x88, 0x42, 0x10, 0x88, 0x26, 0x09, 0x82, 0xA0,
  0xA4, 0x31, 0x08, 0x62, 0x08, 0x82, 0x20, 0x48, 0x12, 0x02, 0x80, 0xA0,
  0x28, 0x04, 0xFF, 0xFF, 0xFF, 0xFE, 0x9F, 0x0F, 0x96, 0x33, 0x1A, 0x82,
  0x41, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x40, 0x8F,
  0x12, 0x1A, 0x81, 0x60, 0x3C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x0F, 0x81, 0x86, 0x08, 0x08, 0x80,
  0x44, 0x01, 0x60, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x50, 0x02, 0x80, 0x12, 0x00, 0x90,
  0x0C, 0xC0, 0x43, 0x06, 0x0F, 0xC0, 0x8F, 0x84, 0x86, 0x28, 0x09, 0x80,
  0x4C, 0x01, 0x60, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x07,
  0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x16, 0x00, 0xB0,
  0x09, 0x40, 0x4B, 0x04, 0x4F, 0xC2, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x0F, 0x91,
  0x0D, 0x20, 0x74, 0x03, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14,
  0x01, 0x40, 0x36, 0x03, 0x30, 0x51, 0xF9, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x8F, 0x26,
  0x85, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x1F, 0x8C, 0x16, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0xC0, 0x9F, 0xC0, 0x20, 0x40,
  0x81, 0x02, 0x1F, 0xC8, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x78, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xE0, 0x54, 0x12, 0x7E, 0x40, 0x80, 0x1C, 0x03, 0x40, 0x24, 0x02, 0x40,
  0x26, 0x06, 0x20, 0x42, 0x04, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x10,
  0x81, 0x08, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x80, 0x20, 0x0A, 0x01, 0x00, 0x90, 0x0C, 0x04, 0x80, 0xA0,
  0x24, 0x05, 0x01, 0x10, 0x28, 0x10, 0x81, 0x60, 0x84, 0x19, 0x04, 0x20,
  0x88, 0x21, 0x04, 0x41, 0x04, 0x22, 0x10, 0x21, 0x08, 0x81, 0x10, 0x44,
  0x08, 0x82, 0x20, 0x24, 0x12, 0x01, 0x20, 0x90, 0x09, 0x02, 0x80, 0x50,
  0x14, 0x02, 0x80, 0xA0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0x80,
  0x80, 0x28, 0x0D, 0x01, 0x10, 0x62, 0x08, 0x61, 0x04, 0x40, 0x88, 0x0A,
  0x01, 0x40, 0x10, 0x02, 0x00, 0xA0, 0x14, 0x04, 0x40, 0x88, 0x20, 0x84,
  0x11, 0x83, 0x20, 0x2C, 0x07, 0x00, 0x40, 0x40, 0x1A, 0x00, 0x98, 0x04,
  0x40, 0x22, 0x03, 0x10, 0x10, 0xC0, 0x82, 0x04, 0x10, 0x60, 0x82, 0x06,
  0x10, 0x10, 0x80, 0x8C, 0x04, 0x40, 0x32, 0x00, 0x90, 0x05, 0x80, 0x28,
  0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x02, 0x40, 0x1C, 0x00, 0x7F,
  0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08, 0x08, 0x07, 0xFC,
  0x03, 0xC1, 0x80, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x38, 0x03, 0x00,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x70, 0x30, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x0F, 0x00, 0x3E, 0x07,
  0x0C, 0x18, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Thin41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 29, 8, 3, -29 },
  { 9, 6, 10, 12, 3, -29 },
  { 17, 16, 29, 17, 1, -29 },
  { 75, 14, 33, 16, 1, -31 },
  { 133, 20, 30, 23, 2, -30 },
  { 208, 15, 30, 16, 1, -30 },
  { 265, 1, 10, 7, 3, -29 },
  { 267, 7, 35, 11, 2, -29 },
  { 298, 7, 35, 11, 2, -29 },
  { 329, 10, 10, 14, 2, -31 },
  { 342, 14, 19, 16, 1, -24 },
  { 376, 3, 9, 7, 2, -4 },
  { 380, 9, 1, 11, 1, -12 },
  { 382, 2, 3, 7, 3, -3 },
  { 383, 12, 29, 13, 1, -29 },
  { 427, 12, 30, 16, 2, -30 },
  { 472, 7, 29, 16, 3, -29 },
  { 498, 12, 30, 16, 2, -30 },
  { 543, 12, 30, 16, 2, -30 },
  { 588, 15, 29, 16, 1, -29 },
  { 643, 12, 29, 16, 2, -29 },
  { 687, 12, 31, 16, 2, -30 },
  { 734, 12, 29, 16, 2, -29 },
  { 778, 14, 30, 16, 1, -30 },
  { 831, 12, 30, 16, 2, -30 },
  { 876, 2, 22, 7, 3, -22 },
  { 882, 3, 27, 7, 2, -22 },
  { 893, 14, 17, 16, 1, -23 },
  { 923, 14, 9, 16, 1, -19 },
  { 939, 14, 17, 16, 1, -23 },
  { 969, 9, 30, 11, 1, -30 },
  { 1003, 21, 33, 25, 2, -29 },
  { 1090, 15, 29, 15, 0, -29 },
  { 1145, 13, 29, 18, 3, -29 },
  { 1193, 14, 30, 17, 2, -30 },
  { 1246, 14, 29, 19, 3, -29 },
  { 1297, 11, 29, 16, 3, -29 },
  { 1337, 11, 29, 14, 3, -29 },
  { 1377, 17, 30, 21, 2, -30 },
  { 1441, 14, 29, 20, 3, -29 },
  { 1492, 5, 29, 9, 2, -29 },
  { 1511, 7, 36, 8, -2, -29 },
  { 1543, 13, 29, 16, 3, -29 },
  { 1591, 10, 29, 14, 3, -29 },
  { 1628, 21, 29, 27, 3, -29 },
  { 1705, 15, 29, 21, 3, -29 },
  { 1760, 17, 30, 21, 2, -30 },
  { 1824, 12, 29, 16, 3, -29 },
  { 1868, 17, 37, 21, 2, -30 },
  { 1947, 13, 29, 17, 3, -29 },
  { 1995, 12, 30, 16, 2, -30 },
  { 2040, 13, 29, 14, 0, -29 },
  { 2088, 14, 29, 20, 3, -29 },
  { 2139, 15, 29, 15, 0, -29 },
  { 2194, 26, 29, 27, 0, -29 },
  { 2289, 13, 29, 14, 0, -29 },
  { 2337, 13, 29, 13, 0, -29 },
  { 2385, 11, 29, 13, 1, -29 },
  { 2425, 8, 35, 13, 3, -29 },
  { 2460, 12, 29, 13, 1, -29 },
  { 2504, 8, 35, 13, 1, -29 },
  { 2539, 15, 14, 16, 1, -29 },
  { 2566, 16, 1, 16, 0, 4 },
  { 2568, 6, 6, 9, 2, -31 },
  { 2573, 10, 22, 15, 2, -22 },
  { 2601, 13, 31, 17, 3, -31 },
  { 2652, 10, 22, 13, 2, -22 },
  { 2680, 13, 31, 17, 2, -31 },
  { 2731, 12, 22, 16, 2, -22 },
  { 2764, 10, 31, 9, 0, -31 },
  { 2803, 12, 32, 17, 2, -22 },
  { 2851, 11, 31, 17, 3, -31 },
  { 2894, 2, 30, 7, 3, -30 },
  { 2902, 5, 40, 7, 0, -30 },
  { 2927, 10, 31, 13, 3, -31 },
  { 2966, 1, 31, 7, 3, -31 },
  { 2970, 19, 22, 25, 3, -22 },
  { 3023, 11, 22, 17, 3, -22 },
  { 3054, 13, 22, 17, 2, -22 },
  { 3090, 13, 32, 17, 3, -22 },
  { 3142, 12, 32, 17, 2, -22 },
  { 3190, 7, 22, 11, 3, -22 },
  { 3210, 10, 22, 13, 1, -22 },
  { 3238, 7, 27, 9, 1, -27 },
  { 3262, 11, 22, 17, 3, -22 },
  { 3293, 12, 22, 12, 0, -22 },
  { 3326, 21, 22, 21, 0, -22 },
  { 3384, 11, 22, 13, 1, -22 },
  { 3415, 13, 32, 13, 0, -22 },
  { 3467, 9, 22, 11, 1, -22 },
  { 3492, 10, 35, 14, 2, -29 },
  { 3536, 1, 41, 16, 7, -31 },
  { 3542, 10, 35, 14, 2, -29 },
  { 3586, 14, 3, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Thin41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN41PT7B_H_
