#ifndef _NOTOSANS_EXTRACONDENSED_THIN8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0x6F, 0x2B, 0x40, 0x7B, 0x27, 0x80, 0x5E, 0xB7, 0x77,
  0x55, 0x2B, 0xC0, 0xC0, 0x6A, 0xA4, 0x95, 0x58, 0x70, 0x4B, 0xA0, 0xC0,
  0xC0, 0x80, 0x55, 0xA0, 0x56, 0xDB, 0xC0, 0xFC, 0xE4, 0x95, 0xC0, 0xE4,
  0xB3, 0xC0, 0x29, 0x5E, 0x40, 0xF3, 0x13, 0xC0, 0x73, 0x5B, 0xC0, 0xE5,
  0x24, 0x80, 0xF7, 0xDB, 0xC0, 0xF6, 0xF2, 0xC0, 0x10, 0x18, 0x78, 0x80,
  0xFC, 0xCE, 0x00, 0xD6, 0xA0, 0x79, 0xFF, 0xF8, 0x60, 0x4A, 0xFB, 0x40,
  0xFF, 0xF0, 0x72, 0x48, 0xC0, 0xBF, 0xF0, 0xEE, 0xB0, 0xEB, 0xA0, 0x78,
  0x8B, 0x97, 0xFF, 0xF0, 0xFC, 0xFE, 0xEA, 0xB0, 0xAA, 0xB0, 0x99, 0x9B,
  0xBD, 0xFF, 0xF0, 0x69, 0x99, 0x97, 0xBE, 0xA0, 0x69, 0x99, 0x95, 0x20,
  0xBE, 0xB0, 0x72, 0x33, 0xC0, 0xE9, 0x24, 0x80, 0xFF, 0xF0, 0xB6, 0xD4,
  0x80, 0xAD, 0x6B, 0xA5, 0x28, 0xB9, 0x2D, 0x40, 0xB7, 0x24, 0x80, 0xD5,
  0xB0, 0xFE, 0xA5, 0x50, 0xD5, 0x5C, 0x4A, 0x80, 0xE0, 0x80, 0x5F, 0xAF,
  0xF0, 0xEB, 0x2E, 0xDB, 0xC0, 0xFE, 0x70, 0xEA, 0xA0, 0xF6, 0xF3, 0xC0,
  0xAF, 0xF0, 0xBC, 0xBF, 0xAA, 0xB0, 0xFC, 0xFF, 0xF0, 0xFF, 0xF6, 0xF0,
  0xFF, 0xA0, 0xF6, 0xF2, 0x40, 0xF0, 0xE7, 0xEA, 0xC0, 0xFF, 0xF5, 0xDB,
  0x66, 0xD7, 0xFD, 0x60, 0xDB, 0x57, 0x54, 0xFF, 0x95, 0x5C, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 2, 1, -6 },
  { 3, 3, 6, 3, 0, -6 },
  { 6, 3, 6, 3, 0, -6 },
  { 9, 4, 6, 5, 0, -6 },
  { 12, 3, 6, 3, 0, -6 },
  { 15, 1, 2, 1, 0, -6 },
  { 16, 2, 7, 2, 0, -6 },
  { 18, 2, 7, 2, 0, -6 },
  { 20, 2, 2, 3, 0, -6 },
  { 21, 3, 4, 3, 0, -5 },
  { 23, 1, 2, 1, 0, -1 },
  { 24, 2, 1, 2, 0, -3 },
  { 25, 1, 1, 1, 0, -1 },
  { 26, 2, 6, 3, 0, -6 },
  { 28, 3, 6, 3, 0, -6 },
  { 31, 1, 6, 3, 1, -6 },
  { 32, 3, 6, 3, 0, -6 },
  { 35, 3, 6, 3, 0, -6 },
  { 38, 3, 6, 3, 0, -6 },
  { 41, 3, 6, 3, 0, -6 },
  { 44, 3, 6, 3, 0, -6 },
  { 47, 3, 6, 3, 0, -6 },
  { 50, 3, 6, 3, 0, -6 },
  { 53, 3, 6, 3, 0, -6 },
  { 56, 1, 4, 1, 0, -4 },
  { 57, 1, 5, 1, 0, -4 },
  { 58, 3, 3, 3, 0, -4 },
  { 60, 3, 2, 3, 0, -4 },
  { 61, 3, 3, 3, 0, -4 },
  { 63, 2, 6, 2, 0, -6 },
  { 65, 4, 7, 5, 0, -6 },
  { 69, 3, 6, 3, 0, -6 },
  { 72, 2, 6, 3, 1, -6 },
  { 74, 3, 6, 3, 0, -6 },
  { 77, 2, 6, 4, 1, -6 },
  { 79, 2, 6, 3, 1, -6 },
  { 81, 2, 6, 3, 1, -6 },
  { 83, 4, 6, 4, 0, -6 },
  { 86, 2, 6, 4, 1, -6 },
  { 88, 1, 6, 2, 0, -6 },
  { 89, 1, 7, 1, 0, -6 },
  { 90, 2, 6, 3, 1, -6 },
  { 92, 2, 6, 3, 1, -6 },
  { 94, 4, 6, 5, 1, -6 },
  { 97, 2, 6, 4, 1, -6 },
  { 99, 4, 6, 4, 0, -6 },
  { 102, 2, 6, 3, 1, -6 },
  { 104, 4, 7, 4, 0, -6 },
  { 108, 2, 6, 3, 1, -6 },
  { 110, 3, 6, 3, 0, -6 },
  { 113, 3, 6, 3, 0, -6 },
  { 116, 2, 6, 4, 1, -6 },
  { 118, 3, 6, 3, 0, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 3, 6, 3, 0, -6 },
  { 128, 3, 6, 3, 0, -6 },
  { 131, 2, 6, 3, 0, -6 },
  { 133, 1, 7, 2, 1, -6 },
  { 134, 2, 6, 3, 0, -6 },
  { 136, 2, 7, 2, 0, -6 },
  { 138, 3, 3, 3, 0, -6 },
  { 140, 3, 1, 3, 0, 0 },
  { 141, 1, 1, 2, 0, -6 },
  { 142, 2, 4, 3, 0, -4 },
  { 143, 2, 6, 3, 1, -6 },
  { 145, 2, 4, 3, 0, -4 },
  { 146, 3, 6, 3, 0, -6 },
  { 149, 3, 4, 3, 0, -4 },
  { 151, 2, 6, 2, 0, -6 },
  { 153, 3, 6, 3, 0, -4 },
  { 156, 2, 6, 3, 1, -6 },
  { 158, 1, 6, 1, 0, -6 },
  { 159, 1, 8, 1, 0, -6 },
  { 160, 2, 6, 3, 1, -6 },
  { 162, 1, 6, 1, 0, -6 },
  { 163, 3, 4, 5, 1, -4 },
  { 165, 2, 4, 3, 1, -4 },
  { 166, 3, 4, 3, 0, -4 },
  { 168, 2, 6, 3, 1, -4 },
  { 170, 3, 6, 3, 0, -4 },
  { 173, 1, 4, 2, 1, -4 },
  { 174, 2, 4, 3, 0, -4 },
  { 175, 2, 5, 2, 0, -5 },
  { 177, 2, 4, 3, 1, -4 },
  { 178, 2, 4, 2, 0, -4 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 2, 4, 3, 0, -4 },
  { 182, 2, 6, 3, 0, -4 },
  { 184, 2, 4, 2, 0, -4 },
  { 185, 2, 7, 3, 0, -6 },
  { 187, 1, 8, 3, 1, -6 },
  { 188, 2, 7, 3, 0, -6 },
  { 190, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Thin8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN8PT7B_H_
