#ifndef _NOTOSANS_EXTRACONDENSED_THIN65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin65pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C,
  0x92, 0x49, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xD0, 0x1A, 0x03, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x00, 0x02, 0x00, 0x80,
  0x01, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x01, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x01, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0xC0,
  0x10, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x04, 0x01, 0x80, 0x02, 0x00, 0x80, 0x01, 0x00, 0x40, 0x01,
  0x80, 0x20, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x07,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x06, 0x01, 0x80, 0x02, 0x00, 0xC0,
  0x01, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x04, 0x01,
  0x80, 0x02, 0x00, 0x80, 0x01, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x39, 0x83, 0xC1, 0x86, 0x02,
  0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0xE6, 0x00, 0x01, 0xD8, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x63,
  0x80, 0x01, 0x83, 0x80, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x60, 0x06, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x18, 0x02, 0x00, 0x60, 0x18, 0x01, 0x80,
  0x60, 0x06, 0x03, 0x00, 0x18, 0x1C, 0xC0, 0x60, 0xE3, 0xF1, 0x9E, 0x01,
  0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x33,
  0x80, 0x06, 0x00, 0xC1, 0x00, 0x08, 0x01, 0x03, 0x00, 0x30, 0x06, 0x02,
  0x00, 0x60, 0x08, 0x06, 0x00, 0x80, 0x10, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x06, 0x00, 0xC0, 0x10, 0x08, 0x01, 0x80, 0x20, 0x30, 0x03, 0x00, 0x40,
  0x60, 0x06, 0x00, 0x80, 0x80, 0x0C, 0x01, 0x03, 0x00, 0x18, 0x03, 0x06,
  0x00, 0x30, 0x06, 0x08, 0x00, 0x60, 0x0C, 0x30, 0x00, 0xC0, 0x10, 0x60,
  0x01, 0x80, 0x20, 0x80, 0x03, 0x00, 0x43, 0x03, 0x06, 0x00, 0x86, 0x1F,
  0x8C, 0x01, 0x08, 0x61, 0x98, 0x06, 0x10, 0x81, 0x10, 0x0C, 0x63, 0x03,
  0x30, 0x18, 0xC4, 0x02, 0x60, 0x21, 0x18, 0x04, 0x40, 0xC6, 0x30, 0x0C,
  0xC3, 0x0C, 0x60, 0x18, 0xFE, 0x10, 0xC0, 0x30, 0xF0, 0x61, 0x00, 0x60,
  0x00, 0xC2, 0x00, 0x40, 0x01, 0x04, 0x00, 0x80, 0x06, 0x08, 0x01, 0x00,
  0x0C, 0x10, 0x02, 0x00, 0x10, 0x20, 0x04, 0x00, 0x60, 0x40, 0x08, 0x00,
  0xC0, 0x80, 0x10, 0x01, 0x01, 0x00, 0x60, 0x06, 0x02, 0x00, 0xC0, 0x0C,
  0x06, 0x01, 0x80, 0x10, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x08, 0x01, 0x00, 0x20, 0x10, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x00,
  0x40, 0x80, 0x10, 0x00, 0xC3, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x60, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x18, 0x30, 0x00, 0x20, 0x20,
  0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x02, 0x00, 0x80, 0x04, 0x01, 0x00,
  0x08, 0x02, 0x00, 0x10, 0x04, 0x00, 0x20, 0x08, 0x00, 0x40, 0x10, 0x00,
  0x80, 0x20, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x02, 0x02, 0x00, 0x06,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x60,
  0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x80, 0x62, 0x01, 0x80,
  0xCC, 0x01, 0x01, 0x90, 0x03, 0x03, 0x20, 0x02, 0x04, 0xC0, 0x06, 0x09,
  0x80, 0x06, 0x13, 0x00, 0x0C, 0x66, 0x00, 0x0C, 0xCC, 0x00, 0x09, 0x18,
  0x00, 0x1E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0x40, 0x00, 0x70, 0xC0,
  0x01, 0xE1, 0x80, 0x06, 0x61, 0x80, 0x18, 0x43, 0x80, 0x70, 0xC3, 0x83,
  0x80, 0x81, 0xFE, 0x01, 0x80, 0x60, 0x00, 0xFF, 0xFF, 0xFD, 0x55, 0x00,
  0x70, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x07, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x06, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0xC0, 0x83, 0x70, 0x8E, 0x0E, 0xF0, 0x03, 0xC0, 0x01, 0xC0,
  0x02, 0x40, 0x06, 0x20, 0x0C, 0x30, 0x18, 0x18, 0x10, 0x0C, 0x20, 0x04,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x30, 0xC6, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x08, 0x61, 0x8C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x6F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x18,
  0x01, 0x81, 0x80, 0x18, 0x30, 0x00, 0x83, 0x00, 0x0C, 0x20, 0x00, 0xC6,
  0x00, 0x04, 0x60, 0x00, 0x46, 0x00, 0x06, 0x60, 0x00, 0x64, 0x00, 0x06,
  0x40, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00,
  0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x64,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x04,
  0x20, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x01,
  0x80, 0xC0, 0x30, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x03, 0xFC, 0x00, 0x00,
  0xE0, 0x3C, 0x0D, 0x83, 0x30, 0xC6, 0x30, 0xDC, 0x1F, 0x03, 0x40, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x70, 0x06, 0x04, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x38, 0x03, 0x8E, 0x00, 0x18, 0x40,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x40, 0x01, 0x87, 0x80, 0x70, 0x3F, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x10, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x3F, 0xFF,
  0x83, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0xC0, 0x07, 0xFF, 0xC0,
  0x78, 0x0F, 0x04, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x88, 0x00, 0x70,
  0xF0, 0x1E, 0x03, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xFC, 0x01, 0xC0, 0x40, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x3F, 0xC0, 0xC7, 0x8F,
  0x0C, 0xC0, 0x18, 0xD8, 0x00, 0x8D, 0x00, 0x0C, 0xE0, 0x00, 0x4E, 0x00,
  0x06, 0xE0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x34,
  0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x26, 0x00, 0x06,
  0x20, 0x00, 0x63, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x1C, 0x01,
  0x80, 0xE0, 0x70, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xF8, 0x03, 0x80, 0x60, 0x18, 0x01, 0x81, 0x80, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x00, 0xC4, 0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x62, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x06, 0x01, 0x80, 0x60,
  0x06, 0x06, 0x00, 0x18, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x3B,
  0x80, 0x03, 0x86, 0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x30, 0x01, 0x83,
  0x00, 0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x40, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0D, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x13, 0x00, 0x01,
  0x8C, 0x00, 0x0C, 0x70, 0x00, 0xC1, 0xC0, 0x0C, 0x07, 0x81, 0xC0, 0x0F,
  0xFC, 0x00, 0x06, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x70, 0x18, 0x18,
  0x01, 0x83, 0x00, 0x10, 0xC0, 0x03, 0x18, 0x00, 0x22, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x3B, 0x00,
  0x07, 0x60, 0x01, 0xE6, 0x00, 0x6C, 0x60, 0x19, 0x87, 0xBE, 0x30, 0x7F,
  0x86, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x40, 0xF0, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0x6E, 0xFE,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0xFF, 0xE0, 0x08, 0x71, 0xC7, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x08, 0x61, 0x8C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFF,
  0xC3, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x60, 0x03,
  0xFC, 0x06, 0x60, 0x07, 0x1C, 0x06, 0x40, 0x0C, 0x0C, 0x06, 0xC0, 0x18,
  0x0C, 0x02, 0xC0, 0x10, 0x0C, 0x03, 0xC0, 0x30, 0x08, 0x03, 0xC0, 0x30,
  0x08, 0x03, 0xC0, 0x60, 0x08, 0x03, 0xC0, 0x60, 0x08, 0x03, 0x80, 0x60,
  0x08, 0x03, 0x80, 0x60, 0x18, 0x03, 0x80, 0x60, 0x18, 0x03, 0x80, 0x60,
  0x18, 0x03, 0x80, 0x60, 0x18, 0x03, 0x80, 0x60, 0x18, 0x03, 0x80, 0x60,
  0x18, 0x03, 0x80, 0x60, 0x18, 0x03, 0x80, 0x60, 0x18, 0x02, 0x80, 0x60,
  0x18, 0x06, 0x80, 0x60, 0x38, 0x06, 0xC0, 0x60, 0x28, 0x06, 0xC0, 0x30,
  0x2C, 0x0C, 0xC0, 0x30, 0x6C, 0x0C, 0xC0, 0x18, 0xC6, 0x18, 0x40, 0x0F,
  0x83, 0xF0, 0x60, 0x07, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x02, 0x00, 0x01, 0xE0,
  0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x02,
  0x60, 0x00, 0x01, 0x30, 0x00, 0x01, 0x88, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x20, 0x00,
  0x0C, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x80, 0x60, 0x00, 0x40, 0x30, 0x00, 0x60, 0x08,
  0x00, 0x30, 0x04, 0x00, 0x18, 0x03, 0x00, 0x08, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xC0, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x06, 0x04, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x41, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x18,
  0x40, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0xFF, 0xFC,
  0x0C, 0x01, 0xF0, 0xC0, 0x03, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x30,
  0xC0, 0x1E, 0x0F, 0xFF, 0x80, 0xC0, 0x3E, 0x0C, 0x00, 0x38, 0xC0, 0x00,
  0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x78,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x70,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x80, 0x70, 0x1C, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0xFF,
  0xF8, 0x03, 0x00, 0xF8, 0x0C, 0x00, 0x70, 0x30, 0x00, 0x60, 0xC0, 0x00,
  0xC3, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x38, 0x30, 0x03, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0xFB, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE, 0xFF,
  0xFF, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x02, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x04, 0x1C, 0x00, 0x01, 0x01, 0xC0, 0x00,
  0xC0, 0x3C, 0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x3F, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x1B,
  0x1C, 0xFE, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00,
  0x18, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x0C,
  0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x08, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xF0, 0x00, 0xDB, 0x00,
  0x0D, 0x18, 0x00, 0xF1, 0x80, 0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x06,
  0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xC0,
  0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x08,
  0xC0, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x05, 0xF0, 0x00,
  0x00, 0x0D, 0xD0, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0x09, 0xD8, 0x00,
  0x00, 0x19, 0xC8, 0x00, 0x00, 0x19, 0xCC, 0x00, 0x00, 0x11, 0xCC, 0x00,
  0x00, 0x31, 0xCC, 0x00, 0x00, 0x31, 0xC4, 0x00, 0x00, 0x31, 0xC6, 0x00,
  0x00, 0x21, 0xC6, 0x00, 0x00, 0x61, 0xC2, 0x00, 0x00, 0x61, 0xC3, 0x00,
  0x00, 0x41, 0xC3, 0x00, 0x00, 0xC1, 0xC1, 0x00, 0x00, 0xC1, 0xC1, 0x80,
  0x00, 0x81, 0xC1, 0x80, 0x01, 0x81, 0xC1, 0x80, 0x01, 0x81, 0xC0, 0xC0,
  0x01, 0x81, 0xC0, 0xC0, 0x03, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0xC0, 0x40,
  0x03, 0x01, 0xC0, 0x60, 0x02, 0x01, 0xC0, 0x60, 0x06, 0x01, 0xC0, 0x20,
  0x06, 0x01, 0xC0, 0x30, 0x04, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0xC0, 0x10,
  0x0C, 0x01, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0x18, 0x18, 0x01, 0xC0, 0x18,
  0x18, 0x01, 0xC0, 0x08, 0x18, 0x01, 0xC0, 0x0C, 0x30, 0x01, 0xC0, 0x0C,
  0x30, 0x01, 0xC0, 0x04, 0x30, 0x01, 0xC0, 0x06, 0x20, 0x01, 0xC0, 0x06,
  0x60, 0x01, 0xC0, 0x02, 0x60, 0x01, 0xC0, 0x03, 0x40, 0x01, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3D, 0x00, 0x00,
  0x7B, 0x00, 0x00, 0xF6, 0x00, 0x01, 0xE6, 0x00, 0x03, 0xCC, 0x00, 0x07,
  0x88, 0x00, 0x0F, 0x18, 0x00, 0x1E, 0x10, 0x00, 0x3C, 0x30, 0x00, 0x78,
  0x20, 0x00, 0xF0, 0x60, 0x01, 0xE0, 0xC0, 0x03, 0xC0, 0xC0, 0x07, 0x81,
  0x80, 0x0F, 0x01, 0x00, 0x1E, 0x03, 0x00, 0x3C, 0x02, 0x00, 0x78, 0x06,
  0x00, 0xF0, 0x0C, 0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x18, 0x07, 0x80, 0x18,
  0x0F, 0x00, 0x30, 0x1E, 0x00, 0x20, 0x3C, 0x00, 0x60, 0x78, 0x00, 0x40,
  0xF0, 0x00, 0xC1, 0xE0, 0x01, 0x83, 0xC0, 0x01, 0x87, 0x80, 0x03, 0x0F,
  0x00, 0x02, 0x1E, 0x00, 0x06, 0x3C, 0x00, 0x04, 0x78, 0x00, 0x0C, 0xF0,
  0x00, 0x09, 0xE0, 0x00, 0x1B, 0xC0, 0x00, 0x37, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x30, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x0C, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x18, 0x20, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x18,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0xF0, 0x18, 0x0F, 0x83, 0x00, 0x3C, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80,
  0x03, 0x30, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x0B, 0x00,
  0x01, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x16, 0x00,
  0x02, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00,
  0x19, 0x80, 0x07, 0x30, 0x01, 0xC6, 0x00, 0x70, 0xFF, 0xFC, 0x1F, 0xFC,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x18, 0x20, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x01, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x08, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xF0,
  0x0C, 0x07, 0xC0, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x4C, 0x00, 0x04, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C,
  0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18,
  0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x0E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x00, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C,
  0x00, 0x18, 0xC0, 0x00, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x03, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x38, 0x01,
  0x8C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC8, 0x00, 0x31, 0xE0, 0x1C, 0x1F, 0xFF, 0x00, 0x3F, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x19, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x06, 0x00,
  0x38, 0x0E, 0x03, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x10, 0x08, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x04, 0x00, 0x60, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00, 0x40, 0x02, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01, 0x01,
  0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x66, 0x00, 0x00, 0x64, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xD0, 0x00, 0x03,
  0x00, 0x00, 0x66, 0x00, 0x01, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x78, 0x00,
  0x06, 0x60, 0x00, 0x1E, 0x00, 0x01, 0x88, 0x00, 0x07, 0x80, 0x00, 0x43,
  0x00, 0x01, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x48, 0x00, 0x0C, 0x30, 0x00,
  0x33, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0xC0, 0x00, 0xC1, 0x00, 0x03, 0x30,
  0x00, 0x20, 0x60, 0x00, 0xCC, 0x00, 0x18, 0x18, 0x00, 0x21, 0x00, 0x06,
  0x06, 0x00, 0x18, 0x60, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x40, 0x20,
  0x01, 0x86, 0x00, 0x30, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x03, 0x00, 0x10,
  0x20, 0x03, 0x00, 0xC0, 0x0C, 0x08, 0x00, 0xC0, 0x10, 0x03, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x30, 0x06, 0x00,
  0x60, 0x08, 0x04, 0x01, 0x80, 0x18, 0x06, 0x01, 0x00, 0x40, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x06,
  0x03, 0x00, 0x0C, 0x04, 0x00, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x20, 0x20,
  0x00, 0x40, 0xC0, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x03, 0x06, 0x00, 0x06,
  0x0C, 0x00, 0xC1, 0x80, 0x01, 0x82, 0x00, 0x10, 0x60, 0x00, 0x21, 0x80,
  0x04, 0x10, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x00, 0x02, 0x20, 0x00,
  0x04, 0xC0, 0x00, 0x98, 0x00, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x06, 0x80, 0x00,
  0xD0, 0x00, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x33, 0x00, 0x06, 0x30,
  0x00, 0x61, 0x00, 0x04, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x01, 0x80,
  0xC0, 0x18, 0x0C, 0x01, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x20, 0x20,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x01, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x88,
  0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x05, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00, 0x0D, 0x80, 0x01,
  0x98, 0x00, 0x18, 0x80, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x04, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0x40, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x10, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00,
  0xC6, 0x00, 0x0C, 0x60, 0x00, 0x64, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00,
  0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x20,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xC1, 0x00, 0x0C, 0x18, 0x00, 0xC1,
  0x80, 0x18, 0x08, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0x00, 0x40, 0x30,
  0x06, 0x03, 0x00, 0x60, 0x20, 0x02, 0x06, 0x00, 0x30, 0x60, 0x03, 0x04,
  0x00, 0x10, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x80, 0x00, 0x98, 0x00, 0x0D,
  0x80, 0x00, 0xD0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0xFF, 0xF0, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x26, 0x00, 0x00, 0x62, 0x00, 0x00, 0x43,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x1C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x01, 0xF0, 0x07,
  0xFE, 0x07, 0x01, 0x82, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0F, 0x00, 0xFF, 0x83, 0xE0, 0x43,
  0x80, 0x23, 0x00, 0x13, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01,
  0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x34, 0x00, 0x1A, 0x00,
  0x1D, 0x80, 0x0A, 0xC0, 0x0D, 0x30, 0x04, 0x8C, 0x0E, 0x43, 0xFC, 0x20,
  0x38, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x81, 0xF8, 0x08, 0x7F, 0xE0, 0x8E, 0x07, 0x09, 0x80, 0x38, 0xB0,
  0x01, 0x8A, 0x00, 0x0C, 0xA0, 0x00, 0xCE, 0x00, 0x04, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xE0,
  0x00, 0xCA, 0x00, 0x0C, 0xB0, 0x01, 0x89, 0x00, 0x18, 0x98, 0x03, 0x08,
  0xE0, 0xE0, 0x87, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0x07,
  0x01, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x03, 0x03, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x01, 0xF8, 0x30, 0x7F, 0xE3, 0x0E,
  0x07, 0x31, 0xC0, 0x1B, 0x18, 0x00, 0xB3, 0x00, 0x0F, 0x30, 0x00, 0x76,
  0x00, 0x07, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x72, 0x00, 0x05, 0x30, 0x00, 0x91,
  0x80, 0x19, 0x18, 0x03, 0x10, 0xE0, 0x61, 0x07, 0xFC, 0x10, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0x80, 0x38, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0x23, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x09,
  0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0xE0, 0x78, 0x0F, 0xFC, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x07, 0xF0, 0x30, 0x41, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xE0, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE1, 0x0E,
  0x03, 0x11, 0x80, 0x1B, 0x18, 0x00, 0xB3, 0x00, 0x0F, 0x20, 0x00, 0x76,
  0x00, 0x07, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40,
  0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x72, 0x00, 0x0F, 0x30, 0x00, 0xB1,
  0x80, 0x1B, 0x18, 0x03, 0x30, 0xE0, 0xE3, 0x07, 0xFC, 0x30, 0x0E, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0xC4, 0x00, 0x38, 0x70, 0x0F, 0x03, 0xFF, 0xC0, 0x07,
  0xE0, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x07, 0xC1, 0x0F, 0xF8,
  0x8E, 0x0E, 0x4C, 0x03, 0x24, 0x00, 0xD6, 0x00, 0x6A, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x6E,
  0xF6, 0x00, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06,
  0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82,
  0x04, 0x08, 0x30, 0x61, 0xDF, 0x38, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x02, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x18, 0x80, 0x30, 0x80,
  0x60, 0x80, 0x60, 0x80, 0xC0, 0x80, 0x80, 0x81, 0x80, 0x83, 0x00, 0x83,
  0x00, 0x86, 0x00, 0x86, 0x00, 0x8F, 0x00, 0x9B, 0x00, 0x91, 0x80, 0xB1,
  0x80, 0xA0, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x60, 0x80, 0x60, 0x80,
  0x20, 0x80, 0x30, 0x80, 0x30, 0x80, 0x18, 0x80, 0x18, 0x80, 0x08, 0x80,
  0x0C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0x82, 0x3F, 0xE0, 0x7F, 0x89,
  0xC1, 0xC3, 0x07, 0x24, 0x03, 0x18, 0x06, 0xB0, 0x06, 0xC0, 0x1A, 0x80,
  0x1A, 0x00, 0x2E, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03,
  0x00, 0x0F, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0xE0, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0xF0, 0x43, 0xFE, 0x23, 0x03, 0x93, 0x00,
  0x6B, 0x00, 0x35, 0x00, 0x0A, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x0E, 0x07, 0x01, 0x80, 0x18, 0x10, 0x00, 0xC3, 0x00, 0x0C, 0x20, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03,
  0x60, 0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0xC1, 0x80, 0x0C, 0x1C, 0x01, 0x80, 0xE0, 0x70, 0x03, 0xFE, 0x00, 0x07,
  0x00, 0x01, 0xF8, 0x08, 0x7F, 0xE0, 0x8E, 0x07, 0x09, 0x80, 0x38, 0x90,
  0x01, 0x8B, 0x00, 0x0C, 0xA0, 0x00, 0xCE, 0x00, 0x04, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x04, 0xE0,
  0x00, 0xCA, 0x00, 0x0C, 0xB0, 0x01, 0x89, 0x80, 0x18, 0x9C, 0x03, 0x08,
  0xE0, 0xE0, 0x87, 0xFC, 0x08, 0x0E, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xE1, 0x0E,
  0x07, 0x11, 0xC0, 0x1B, 0x18, 0x00, 0xB3, 0x00, 0x0F, 0x30, 0x00, 0x76,
  0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60,
  0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x73, 0x00, 0x0F, 0x30, 0x00, 0xB1,
  0x80, 0x1B, 0x1C, 0x03, 0x30, 0xE0, 0xE3, 0x03, 0xFC, 0x30, 0x07, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x01,
  0xD0, 0xFE, 0x30, 0xCC, 0x09, 0x01, 0x60, 0x28, 0x05, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00,
  0x03, 0xF8, 0x0F, 0xFE, 0x1C, 0x07, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0xC0, 0x0E, 0xF0, 0x1C, 0x3F, 0xF0, 0x07, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x18, 0x0F, 0xFF, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0xE1, 0x07, 0xE0, 0x1C, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x1D, 0x80, 0x05, 0x60, 0x01, 0x58,
  0x00, 0x93, 0x00, 0x64, 0xC0, 0x31, 0x1C, 0x18, 0x43, 0xFC, 0x10, 0x18,
  0x00, 0xC0, 0x00, 0x68, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00,
  0x0C, 0x40, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x82, 0x00,
  0x20, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x10, 0x04, 0x02, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x80, 0x80, 0x10, 0x30, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x10, 0x00, 0x82, 0x00, 0x18, 0xC0, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x04, 0x40, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x80, 0x01,
  0x80, 0x03, 0xC0, 0x01, 0x80, 0x02, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x03,
  0xC0, 0x06, 0x40, 0x03, 0xC0, 0x06, 0x60, 0x02, 0xC0, 0x04, 0x60, 0x06,
  0x40, 0x04, 0x60, 0x06, 0x40, 0x0C, 0x20, 0x06, 0x60, 0x0C, 0x20, 0x04,
  0x60, 0x08, 0x30, 0x04, 0x60, 0x08, 0x30, 0x0C, 0x20, 0x18, 0x10, 0x0C,
  0x30, 0x18, 0x10, 0x0C, 0x30, 0x18, 0x18, 0x08, 0x30, 0x10, 0x18, 0x08,
  0x10, 0x10, 0x18, 0x18, 0x10, 0x30, 0x08, 0x18, 0x18, 0x30, 0x08, 0x18,
  0x18, 0x30, 0x0C, 0x10, 0x18, 0x20, 0x0C, 0x30, 0x08, 0x60, 0x04, 0x30,
  0x08, 0x60, 0x04, 0x30, 0x0C, 0x60, 0x06, 0x20, 0x0C, 0x40, 0x06, 0x20,
  0x0C, 0x40, 0x06, 0x60, 0x04, 0xC0, 0x02, 0x60, 0x04, 0xC0, 0x02, 0x60,
  0x06, 0xC0, 0x03, 0x40, 0x06, 0x80, 0x03, 0x40, 0x06, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x00, 0xC8, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x18,
  0x03, 0x06, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x0C, 0x01, 0x83,
  0x00, 0x21, 0x80, 0x0C, 0x60, 0x01, 0x30, 0x00, 0x6C, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1A, 0x00, 0x06, 0xC0, 0x03,
  0x30, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x30, 0x0C, 0x0C, 0x03, 0x01,
  0x00, 0x80, 0x60, 0x60, 0x08, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x00, 0xF0, 0x00, 0x30, 0xC0, 0x00, 0x6C, 0x00, 0x09,
  0x80, 0x03, 0x30, 0x00, 0x62, 0x00, 0x0C, 0x60, 0x01, 0x0C, 0x00, 0x61,
  0x80, 0x0C, 0x10, 0x01, 0x83, 0x00, 0x20, 0x60, 0x0C, 0x0C, 0x01, 0x80,
  0x80, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x04, 0x06, 0x00,
  0xC0, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x20, 0xC0, 0x06, 0x10, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x01, 0x18, 0x00, 0x32, 0x00, 0x06, 0xC0, 0x00,
  0xD8, 0x00, 0x0B, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x04, 0x60,
  0x00, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x1E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x16, 0x07, 0x00, 0xF0,
  0x0F, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Thin65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 46, 13, 5, -46 },
  { 19, 11, 16, 19, 4, -46 },
  { 41, 25, 46, 28, 1, -46 },
  { 185, 22, 53, 26, 2, -49 },
  { 331, 31, 48, 37, 3, -47 },
  { 517, 23, 48, 25, 2, -47 },
  { 655, 2, 16, 10, 4, -46 },
  { 659, 12, 56, 17, 3, -46 },
  { 743, 11, 56, 17, 3, -46 },
  { 820, 16, 16, 22, 3, -49 },
  { 852, 22, 30, 26, 2, -38 },
  { 935, 6, 15, 11, 2, -7 },
  { 947, 13, 2, 17, 2, -19 },
  { 951, 4, 4, 12, 4, -4 },
  { 953, 18, 46, 21, 2, -46 },
  { 1057, 20, 47, 26, 3, -47 },
  { 1175, 11, 46, 26, 5, -46 },
  { 1239, 20, 47, 26, 3, -47 },
  { 1357, 20, 48, 26, 2, -47 },
  { 1477, 24, 47, 26, 1, -47 },
  { 1618, 20, 47, 26, 3, -46 },
  { 1736, 20, 48, 26, 3, -47 },
  { 1856, 19, 46, 26, 3, -46 },
  { 1966, 21, 48, 26, 2, -47 },
  { 2092, 19, 48, 26, 3, -47 },
  { 2206, 4, 35, 12, 4, -35 },
  { 2224, 6, 43, 12, 2, -35 },
  { 2257, 22, 26, 26, 2, -36 },
  { 2329, 22, 16, 26, 2, -31 },
  { 2373, 22, 26, 26, 2, -36 },
  { 2445, 15, 47, 17, 1, -47 },
  { 2534, 32, 53, 39, 4, -47 },
  { 2746, 25, 46, 25, 0, -46 },
  { 2890, 20, 46, 28, 5, -46 },
  { 3005, 21, 48, 27, 4, -47 },
  { 3131, 22, 46, 31, 5, -46 },
  { 3258, 17, 46, 25, 5, -46 },
  { 3356, 17, 46, 23, 5, -46 },
  { 3454, 26, 48, 34, 4, -47 },
  { 3610, 22, 46, 32, 5, -46 },
  { 3737, 10, 46, 14, 2, -46 },
  { 3795, 10, 57, 12, -3, -46 },
  { 3867, 20, 46, 25, 5, -46 },
  { 3982, 16, 46, 22, 5, -46 },
  { 4074, 32, 46, 42, 5, -46 },
  { 4258, 23, 46, 33, 5, -46 },
  { 4391, 26, 48, 33, 4, -47 },
  { 4547, 19, 46, 26, 5, -46 },
  { 4657, 26, 58, 33, 4, -47 },
  { 4846, 20, 46, 26, 5, -46 },
  { 4961, 19, 48, 25, 3, -47 },
  { 5075, 21, 46, 22, 0, -46 },
  { 5196, 22, 47, 32, 5, -46 },
  { 5326, 24, 46, 24, 0, -46 },
  { 5464, 42, 46, 42, 0, -46 },
  { 5706, 20, 46, 22, 1, -46 },
  { 5821, 20, 46, 20, 0, -46 },
  { 5936, 18, 46, 21, 2, -46 },
  { 6040, 13, 56, 20, 5, -46 },
  { 6131, 18, 46, 21, 2, -46 },
  { 6235, 12, 56, 20, 2, -46 },
  { 6319, 24, 22, 26, 1, -46 },
  { 6385, 26, 2, 25, 0, 6 },
  { 6392, 9, 11, 15, 3, -50 },
  { 6405, 17, 36, 24, 2, -35 },
  { 6482, 20, 50, 28, 5, -49 },
  { 6607, 16, 36, 20, 3, -35 },
  { 6679, 20, 50, 28, 3, -49 },
  { 6804, 19, 36, 25, 3, -35 },
  { 6890, 14, 50, 14, 1, -50 },
  { 6978, 20, 51, 27, 3, -35 },
  { 7106, 17, 49, 27, 5, -49 },
  { 7211, 4, 47, 12, 4, -47 },
  { 7235, 7, 63, 12, 0, -47 },
  { 7291, 16, 49, 21, 5, -49 },
  { 7389, 1, 49, 11, 5, -49 },
  { 7396, 30, 35, 40, 5, -35 },
  { 7528, 17, 35, 27, 5, -35 },
  { 7603, 20, 36, 26, 3, -35 },
  { 7693, 20, 50, 28, 5, -35 },
  { 7818, 20, 50, 27, 3, -35 },
  { 7943, 11, 35, 17, 5, -35 },
  { 7992, 16, 36, 20, 2, -35 },
  { 8064, 12, 44, 14, 1, -43 },
  { 8130, 18, 35, 27, 4, -34 },
  { 8209, 19, 34, 19, 0, -34 },
  { 8290, 32, 34, 33, 1, -34 },
  { 8426, 18, 34, 20, 1, -34 },
  { 8503, 19, 50, 21, 1, -34 },
  { 8622, 13, 34, 17, 2, -34 },
  { 8678, 16, 56, 22, 3, -46 },
  { 8790, 2, 65, 25, 11, -49 },
  { 8807, 16, 56, 22, 3, -46 },
  { 8919, 22, 6, 26, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Thin65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN65PT7B_H_
