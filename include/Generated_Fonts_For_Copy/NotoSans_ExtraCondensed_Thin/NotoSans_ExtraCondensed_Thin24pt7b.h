#ifndef _NOTOSANS_EXTRACONDENSED_THIN24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF9, 0x80, 0xB6, 0xDB, 0x40, 0x09, 0x04, 0x41, 0x10, 0x44,
  0x11, 0x1F, 0xF1, 0x10, 0x44, 0x12, 0x04, 0x82, 0x23, 0xFE, 0x22, 0x08,
  0x82, 0x20, 0x88, 0x24, 0x00, 0x10, 0x3C, 0xD2, 0x90, 0x90, 0x90, 0x90,
  0x90, 0x70, 0x18, 0x14, 0x12, 0x11, 0x11, 0x11, 0x12, 0xD4, 0x38, 0x10,
  0x70, 0x88, 0x88, 0x89, 0x08, 0x90, 0x89, 0x08, 0xA0, 0x8A, 0x48, 0xAA,
  0x8D, 0x25, 0x51, 0x25, 0x10, 0x91, 0x09, 0x10, 0x91, 0x11, 0x11, 0x12,
  0x10, 0xE0, 0x38, 0x48, 0x44, 0x44, 0x48, 0x48, 0x28, 0x30, 0x50, 0x50,
  0x89, 0x89, 0x85, 0x82, 0x82, 0x85, 0x79, 0xFC, 0x12, 0x24, 0x44, 0x88,
  0x88, 0x88, 0x88, 0x44, 0x42, 0x21, 0x10, 0x84, 0x42, 0x21, 0x11, 0x11,
  0x11, 0x11, 0x12, 0x22, 0x44, 0x80, 0x10, 0x4D, 0xCC, 0x49, 0x20, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x5A, 0x80,
  0xF8, 0xC0, 0x04, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x82, 0x10, 0x41,
  0x08, 0x20, 0x80, 0x3C, 0x89, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x50, 0xA2, 0x3C, 0x35, 0x91, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x10, 0xFC, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x20, 0x81, 0x04, 0x10, 0x20, 0xFE, 0xFC, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x04, 0x38, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFC, 0x02, 0x01, 0x01,
  0x81, 0x40, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x21, 0x10, 0x88, 0x4F, 0xF8,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x7E, 0x82, 0x04, 0x08, 0x10, 0x20, 0x7E,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0xF8, 0x1E, 0x41, 0x02, 0x08,
  0x10, 0x26, 0x52, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xA1, 0x3C, 0xFE,
  0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x40, 0x7C, 0x42, 0x82, 0x82, 0x82, 0x42, 0x44, 0x38, 0x28, 0x44,
  0x82, 0x81, 0x81, 0x81, 0x82, 0x82, 0x7C, 0x7D, 0x0A, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x82, 0x9C, 0xC8, 0x10, 0x20, 0x41, 0x02, 0xF8, 0xC0, 0x18,
  0x50, 0x00, 0x01, 0x6A, 0x03, 0x0C, 0x30, 0x40, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x30, 0x08, 0x06, 0x03, 0x04,
  0x18, 0x20, 0xC0, 0xF8, 0x10, 0x41, 0x04, 0x10, 0x82, 0x10, 0x82, 0x08,
  0x20, 0x00, 0x08, 0x20, 0x0F, 0x81, 0x04, 0x20, 0x24, 0x01, 0x40, 0x14,
  0x79, 0x88, 0x98, 0x89, 0x88, 0x98, 0x91, 0x89, 0x18, 0x91, 0x89, 0x18,
  0xEE, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x1F, 0x80, 0x08, 0x0A, 0x05,
  0x02, 0x81, 0x40, 0x90, 0x88, 0x44, 0x22, 0x1F, 0x10, 0x48, 0x24, 0x12,
  0x0A, 0x03, 0x01, 0x80, 0x80, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xF6,
  0x9D, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFC, 0x1F, 0x20, 0x40, 0x40,
  0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20,
  0x1F, 0xF8, 0x84, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x84, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x3F,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x1F, 0xC8, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x83, 0xA0, 0x18, 0x06, 0x01, 0x40,
  0x50, 0x14, 0x04, 0x81, 0x1F, 0xC0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE9,
  0x24, 0x92, 0x49, 0x24, 0x92, 0xE0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xE0, 0x83, 0x0A, 0x24, 0x49, 0x12, 0x28, 0x60,
  0xE1, 0x22, 0x44, 0x48, 0x90, 0xA1, 0x41, 0x82, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80, 0x18, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x5A, 0x05, 0xA0, 0x5A, 0x09, 0x90, 0x99, 0x09,
  0x91, 0x18, 0x91, 0x89, 0x18, 0x91, 0x8A, 0x18, 0x61, 0x84, 0x10, 0x81,
  0x81, 0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x89, 0x85, 0x85,
  0x83, 0x83, 0x81, 0x81, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14, 0x08, 0x82,
  0x1F, 0x00, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC2, 0x8D, 0xC2, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x80, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14, 0x08,
  0x82, 0x1F, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0xF9, 0x0A, 0x0C, 0x18,
  0x30, 0x60, 0xC2, 0xF9, 0x22, 0x44, 0x48, 0x90, 0xA1, 0x41, 0x82, 0x7E,
  0x82, 0x04, 0x08, 0x10, 0x10, 0x10, 0x18, 0x08, 0x08, 0x10, 0x20, 0x40,
  0x81, 0xFC, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x7C,
  0x80, 0xC0, 0x60, 0x48, 0x24, 0x12, 0x09, 0x08, 0x44, 0x22, 0x11, 0x09,
  0x04, 0x81, 0x40, 0xA0, 0x50, 0x30, 0x08, 0x00, 0x81, 0x03, 0x02, 0x05,
  0x06, 0x0A, 0x0C, 0x14, 0x28, 0x28, 0x50, 0x90, 0x91, 0x11, 0x22, 0x22,
  0x44, 0x48, 0x90, 0x91, 0x21, 0x21, 0x41, 0x42, 0x82, 0x85, 0x06, 0x0C,
  0x0C, 0x18, 0x08, 0x10, 0x41, 0x42, 0x22, 0x24, 0x24, 0x14, 0x18, 0x08,
  0x08, 0x18, 0x14, 0x24, 0x24, 0x42, 0x42, 0x42, 0x81, 0x81, 0x82, 0x42,
  0x42, 0x44, 0x24, 0x24, 0x28, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xFC, 0x10, 0x42, 0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0x41,
  0x08, 0x20, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0xF0, 0x82, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x41, 0x02, 0x08,
  0x20, 0x41, 0x04, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x08, 0x06, 0x04, 0x82, 0x42, 0x11, 0x09, 0x05, 0x81, 0xFF,
  0x80, 0x88, 0x80, 0x78, 0x10, 0x41, 0x04, 0x13, 0xF1, 0x86, 0x18, 0x61,
  0x7C, 0x81, 0x02, 0x04, 0x08, 0x17, 0x31, 0x41, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x85, 0xF0, 0x3D, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x10, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x01, 0x39, 0x45, 0x43, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x43, 0x3D, 0x38, 0x89, 0x0C,
  0x18, 0x30, 0x7F, 0x40, 0x81, 0x02, 0x02, 0x03, 0xE0, 0x3C, 0x82, 0x08,
  0x23, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3E,
  0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0A, 0x13, 0xE0, 0x40,
  0x81, 0x03, 0x09, 0xE0, 0x82, 0x08, 0x20, 0x82, 0xEC, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0x8F, 0xFF, 0x80, 0x20, 0x02, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0xB0, 0x82, 0x08, 0x20, 0x82, 0x28, 0xA4,
  0x92, 0x8E, 0x28, 0x92, 0x49, 0x22, 0x8A, 0x10, 0xFF, 0xFF, 0xC0, 0xF1,
  0xD1, 0x46, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x30,
  0x86, 0x10, 0xC2, 0x18, 0x42, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x84, 0x3C, 0x42, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x82, 0x42, 0x3C, 0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x2F, 0x90, 0x20, 0x40, 0x81, 0x02, 0x00, 0x3A, 0x8D, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0A, 0x13, 0xE0, 0x40, 0x81, 0x02,
  0x04, 0x08, 0xBC, 0x88, 0x88, 0x88, 0x88, 0x88, 0x80, 0x7E, 0x08, 0x20,
  0x81, 0x02, 0x06, 0x04, 0x10, 0x41, 0xF8, 0x21, 0x09, 0xF2, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x87, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x63, 0x74, 0x83, 0x06, 0x0A, 0x24, 0x48, 0x91, 0x14, 0x28, 0x50,
  0xA0, 0x81, 0x00, 0x82, 0x18, 0x21, 0x46, 0x14, 0x61, 0x45, 0x24, 0x52,
  0x49, 0x22, 0x92, 0x29, 0x42, 0x8C, 0x30, 0xC1, 0x0C, 0x10, 0x80, 0x42,
  0x85, 0x11, 0x22, 0x83, 0x04, 0x0C, 0x28, 0x49, 0x12, 0x18, 0x20, 0x82,
  0x85, 0x0A, 0x14, 0x44, 0x89, 0x12, 0x28, 0x30, 0x60, 0xC1, 0x02, 0x04,
  0x08, 0x20, 0x43, 0x00, 0xF8, 0x44, 0x22, 0x10, 0x88, 0x42, 0x21, 0x0F,
  0x80, 0x0C, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8C, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x81, 0x04, 0x0C, 0xFF, 0xFF, 0xFF, 0xE0, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x40, 0xC4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08, 0xC0,
  0xFF,
};

const GFXglyph NotoSans_ExtraCondensed_Thin24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 17, 5, 2, -17 },
  { 4, 3, 6, 7, 2, -17 },
  { 7, 10, 17, 10, 0, -17 },
  { 29, 8, 19, 9, 1, -18 },
  { 48, 12, 17, 14, 1, -17 },
  { 74, 8, 17, 9, 1, -17 },
  { 91, 1, 6, 4, 1, -17 },
  { 92, 4, 21, 6, 1, -17 },
  { 103, 4, 21, 6, 1, -17 },
  { 114, 6, 6, 8, 1, -18 },
  { 119, 8, 11, 10, 1, -14 },
  { 130, 2, 5, 4, 1, -2 },
  { 132, 5, 1, 6, 1, -7 },
  { 133, 1, 2, 4, 2, -2 },
  { 134, 6, 17, 8, 1, -17 },
  { 147, 7, 17, 9, 1, -17 },
  { 162, 4, 17, 9, 2, -17 },
  { 171, 7, 17, 9, 1, -17 },
  { 186, 7, 17, 9, 1, -17 },
  { 201, 9, 17, 9, 0, -17 },
  { 221, 7, 17, 9, 1, -17 },
  { 236, 7, 17, 9, 1, -17 },
  { 251, 7, 17, 9, 1, -17 },
  { 266, 8, 17, 9, 1, -17 },
  { 283, 7, 17, 9, 1, -17 },
  { 298, 1, 13, 4, 2, -13 },
  { 300, 2, 16, 4, 1, -13 },
  { 304, 8, 9, 10, 1, -13 },
  { 313, 8, 5, 10, 1, -11 },
  { 318, 8, 9, 10, 1, -13 },
  { 327, 6, 17, 6, 0, -17 },
  { 340, 12, 19, 14, 1, -17 },
  { 369, 9, 17, 9, 0, -17 },
  { 389, 7, 17, 10, 2, -17 },
  { 404, 8, 17, 10, 1, -17 },
  { 421, 8, 17, 11, 2, -17 },
  { 438, 6, 17, 9, 2, -17 },
  { 451, 6, 17, 8, 2, -17 },
  { 464, 10, 17, 12, 1, -17 },
  { 486, 8, 17, 12, 2, -17 },
  { 503, 3, 17, 5, 1, -17 },
  { 510, 4, 21, 4, -1, -17 },
  { 521, 7, 17, 9, 2, -17 },
  { 536, 6, 17, 8, 2, -17 },
  { 549, 12, 17, 16, 2, -17 },
  { 575, 8, 17, 12, 2, -17 },
  { 592, 10, 17, 12, 1, -17 },
  { 614, 7, 17, 9, 2, -17 },
  { 629, 10, 21, 12, 1, -17 },
  { 656, 7, 17, 10, 2, -17 },
  { 671, 7, 17, 9, 1, -17 },
  { 686, 8, 17, 8, 0, -17 },
  { 703, 8, 17, 12, 2, -17 },
  { 720, 9, 17, 9, 0, -17 },
  { 740, 15, 17, 16, 0, -17 },
  { 772, 8, 17, 8, 0, -17 },
  { 789, 8, 17, 8, 0, -17 },
  { 806, 6, 17, 8, 1, -17 },
  { 819, 4, 21, 7, 2, -17 },
  { 830, 6, 17, 8, 1, -17 },
  { 843, 4, 21, 7, 1, -17 },
  { 854, 9, 8, 9, 0, -17 },
  { 863, 9, 1, 9, 0, 2 },
  { 865, 3, 3, 5, 1, -18 },
  { 867, 6, 13, 9, 1, -13 },
  { 877, 7, 18, 10, 2, -18 },
  { 893, 6, 13, 8, 1, -13 },
  { 903, 8, 18, 10, 1, -18 },
  { 921, 7, 13, 9, 1, -13 },
  { 933, 6, 18, 5, 0, -18 },
  { 947, 7, 19, 10, 1, -13 },
  { 964, 6, 18, 10, 2, -18 },
  { 978, 1, 17, 4, 2, -17 },
  { 981, 3, 23, 4, 0, -17 },
  { 990, 6, 18, 8, 2, -18 },
  { 1004, 1, 18, 4, 2, -18 },
  { 1007, 11, 13, 15, 2, -13 },
  { 1025, 6, 13, 10, 2, -13 },
  { 1035, 8, 13, 10, 1, -13 },
  { 1048, 7, 19, 10, 2, -13 },
  { 1065, 7, 19, 10, 1, -13 },
  { 1082, 4, 13, 6, 2, -13 },
  { 1089, 6, 13, 7, 1, -13 },
  { 1099, 5, 16, 5, 0, -16 },
  { 1109, 6, 13, 10, 2, -13 },
  { 1119, 7, 13, 7, 0, -13 },
  { 1131, 12, 13, 12, 0, -13 },
  { 1151, 7, 13, 8, 0, -13 },
  { 1163, 7, 19, 8, 0, -13 },
  { 1180, 5, 13, 6, 1, -13 },
  { 1189, 6, 21, 8, 1, -17 },
  { 1205, 1, 24, 9, 4, -18 },
  { 1208, 6, 21, 8, 1, -17 },
  { 1224, 8, 1, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Thin24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN24PT7B_H_
