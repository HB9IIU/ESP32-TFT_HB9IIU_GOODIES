#ifndef _NOTOSANS_EXTRACONDENSED_THIN6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x80, 0xFF, 0x69, 0xC0, 0xBD, 0xB0, 0x6F, 0x80, 0xF8, 0xF8,
  0x70, 0x74, 0xC0, 0x80, 0x80, 0x5A, 0xFF, 0xF0, 0xD7, 0xD7, 0x7D, 0xE7,
  0xFF, 0xD6, 0xDF, 0xF7, 0xA0, 0xB0, 0xD0, 0xF0, 0xF0, 0xF0, 0xFE, 0xE4,
  0xBF, 0xFF, 0xEB, 0xF6, 0xF0, 0xFB, 0xFA, 0xF2, 0xF0, 0xFF, 0xF0, 0xF8,
  0xEF, 0xAB, 0xB7, 0xF0, 0xBE, 0xD0, 0xF6, 0xF0, 0xFA, 0xF6, 0xF2, 0xFF,
  0xE7, 0xEA, 0xFF, 0xF6, 0xDD, 0xAA, 0xEB, 0xEA, 0xDB, 0xEA, 0xC0, 0xA5,
  0xF8, 0x70, 0xC0, 0x80, 0xFC, 0xAF, 0xC0, 0xEC, 0x5F, 0xC0, 0xEC, 0xF8,
  0xFF, 0xAF, 0xC0, 0xF0, 0xF8, 0xAE, 0xC0, 0xF8, 0xFF, 0x80, 0xFC, 0xFC,
  0xFE, 0xFD, 0xE8, 0xDC, 0xF0, 0xFC, 0xE8, 0xFE, 0x80, 0xEC, 0xEA, 0xE0,
  0xEA, 0x40, 0xFC, 0xD5, 0xC0, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 0, -4 },
  { 3, 2, 4, 3, 0, -4 },
  { 4, 2, 5, 2, 0, -5 },
  { 6, 3, 4, 3, 0, -4 },
  { 8, 2, 4, 2, 0, -4 },
  { 9, 1, 1, 1, 0, -4 },
  { 10, 1, 5, 2, 0, -4 },
  { 11, 1, 5, 2, 0, -4 },
  { 12, 2, 2, 2, 0, -5 },
  { 13, 2, 3, 2, 0, -4 },
  { 14, 1, 2, 1, 0, -1 },
  { 15, 1, 1, 2, 0, -2 },
  { 16, 1, 1, 1, 0, -1 },
  { 17, 2, 4, 2, 0, -4 },
  { 18, 2, 4, 2, 0, -4 },
  { 19, 1, 4, 2, 0, -4 },
  { 20, 2, 4, 2, 0, -4 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 2, 4, 2, 0, -4 },
  { 26, 2, 4, 2, 0, -4 },
  { 27, 2, 4, 2, 0, -4 },
  { 28, 1, 3, 1, 0, -3 },
  { 29, 1, 4, 1, 0, -3 },
  { 30, 2, 2, 2, 0, -3 },
  { 31, 2, 2, 2, 0, -3 },
  { 32, 2, 2, 2, 0, -3 },
  { 33, 1, 4, 2, 0, -4 },
  { 34, 3, 5, 4, 0, -4 },
  { 36, 2, 4, 2, 0, -4 },
  { 37, 2, 4, 3, 0, -4 },
  { 38, 2, 4, 2, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 2, 4, 2, 0, -4 },
  { 42, 2, 4, 2, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 2, 4, 3, 0, -4 },
  { 46, 1, 4, 1, 0, -4 },
  { 47, 1, 5, 1, 0, -4 },
  { 48, 2, 4, 2, 0, -4 },
  { 49, 2, 4, 2, 0, -4 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 2, 4, 2, 0, -4 },
  { 57, 3, 5, 3, 0, -4 },
  { 59, 2, 4, 2, 0, -4 },
  { 60, 2, 4, 2, 0, -4 },
  { 61, 2, 4, 2, 0, -4 },
  { 62, 2, 4, 3, 0, -4 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 2, 4, 2, 0, -4 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 2, 4, 2, 0, -4 },
  { 69, 2, 5, 2, 0, -4 },
  { 71, 2, 4, 2, 0, -4 },
  { 72, 1, 5, 2, 0, -4 },
  { 73, 2, 2, 2, 0, -4 },
  { 74, 2, 1, 2, 0, 0 },
  { 75, 1, 1, 1, 0, -5 },
  { 76, 2, 3, 2, 0, -3 },
  { 77, 2, 5, 3, 0, -5 },
  { 79, 2, 3, 2, 0, -3 },
  { 80, 2, 5, 3, 0, -5 },
  { 82, 2, 3, 2, 0, -3 },
  { 83, 1, 5, 1, 0, -5 },
  { 84, 2, 4, 3, 0, -3 },
  { 85, 2, 5, 2, 0, -5 },
  { 87, 1, 4, 1, 0, -4 },
  { 88, 1, 5, 1, 0, -4 },
  { 89, 2, 5, 2, 0, -5 },
  { 91, 1, 5, 1, 0, -5 },
  { 92, 3, 3, 4, 0, -3 },
  { 94, 2, 3, 2, 0, -3 },
  { 95, 2, 3, 2, 0, -3 },
  { 96, 2, 4, 3, 0, -3 },
  { 97, 2, 4, 3, 0, -3 },
  { 98, 2, 3, 2, 0, -3 },
  { 99, 2, 3, 2, 0, -3 },
  { 100, 1, 4, 1, 0, -4 },
  { 101, 2, 3, 2, 0, -3 },
  { 102, 2, 3, 2, 0, -3 },
  { 103, 3, 3, 3, 0, -3 },
  { 105, 2, 3, 2, 0, -3 },
  { 106, 2, 4, 2, 0, -3 },
  { 107, 1, 3, 2, 0, -3 },
  { 108, 2, 5, 2, 0, -4 },
  { 110, 1, 6, 2, 1, -5 },
  { 111, 2, 5, 2, 0, -4 },
  { 113, 2, 1, 2, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Thin6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN6PT7B_H_
