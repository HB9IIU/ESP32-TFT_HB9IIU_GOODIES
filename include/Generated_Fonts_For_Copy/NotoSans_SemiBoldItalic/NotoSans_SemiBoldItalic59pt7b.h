#ifndef _NOTOSANS_SEMIBOLDITALIC59PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x87, 0xF3,
  0xF8, 0x7F, 0x3F, 0x07, 0xF3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0xFE,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F,
  0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x3C, 0x7C, 0x07,
  0xF8, 0xF0, 0x20, 0x1F, 0xC3, 0xC0, 0x00, 0xFF, 0x1E, 0x00, 0x03, 0xF8,
  0x78, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x3F, 0xC7, 0x80, 0x00, 0x7F, 0x9E,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0x3F, 0xE0, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0xF0, 0xFE, 0x00, 0x03,
  0xC3, 0xF8, 0x00, 0x0F, 0x0F, 0xE2, 0x00, 0x78, 0x7F, 0x8C, 0x01, 0xE1,
  0xFC, 0x3C, 0x07, 0x9F, 0xF0, 0xFF, 0xDF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0xE1,
  0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x7E, 0x1F, 0x83, 0xF0, 0x7F, 0x1F, 0x8F, 0xFC, 0x7E, 0x0F, 0xC7, 0xE3,
  0xFF, 0xCF, 0xC3, 0xF9, 0xF8, 0xFF, 0xFD, 0xFF, 0xFE, 0x3F, 0x3F, 0xFF,
  0x9F, 0xFF, 0x8F, 0xCF, 0xF3, 0xFB, 0xFF, 0xF3, 0xF1, 0xFC, 0x3F, 0x3F,
  0xFC, 0xFC, 0x7F, 0x07, 0xE3, 0xFE, 0x1F, 0x8F, 0xC0, 0xFC, 0x1E, 0x07,
  0xE1, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x01,
  0xF8, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x1F,
  0xC7, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xFF, 0x00, 0x3F,
  0xC3, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0xFB, 0xFC, 0x07, 0xF8, 0xFF, 0x8F,
  0xF0, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8,
  0x7F, 0x00, 0xFF, 0x9F, 0xC3, 0xFC, 0x01, 0xFE, 0xFF, 0x0F, 0xF0, 0x03,
  0xFF, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFE, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8,
  0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x30, 0x07, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x07,
  0xFC, 0x7C, 0x00, 0x7F, 0xF7, 0x80, 0x0F, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xC3, 0xF0, 0x1F, 0xFC, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x7F,
  0x3E, 0x00, 0x0F, 0xE3, 0xF0, 0x03, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0xF8, 0x1F, 0x80, 0x07, 0x01, 0xFC, 0x00, 0x30, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFE, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80,
  0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF,
  0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80,
  0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF,
  0x7F, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF3, 0xFF, 0xDF, 0xC7, 0xFC, 0xFF,
  0x0F, 0xE3, 0xF8, 0x3E, 0x0F, 0xE0, 0x70, 0x3F, 0x81, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7C,
  0x00, 0xFF, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x08, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0x00, 0x7C, 0x03,
  0xFE, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x84, 0x00, 0x01,
  0xFF, 0x0F, 0x00, 0x0F, 0xFC, 0x1F, 0xFB, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x40,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC3, 0x00, 0x01, 0xFF,
  0x07, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC7, 0x80, 0x7F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFE, 0x3F, 0xF8, 0x03, 0xFB, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0xE0, 0x7F,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x3F, 0xF0,
  0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF3,
  0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80,
  0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xF3, 0xFE,
  0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xEF,
  0xE0, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x3F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF, 0x9E, 0x00,
  0xFF, 0x30, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFC,
  0x7E, 0x00, 0xFF, 0xFF, 0x83, 0xF1, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xCF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0x7D, 0xF8,
  0x0F, 0xE0, 0x3F, 0x01, 0xF7, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xDF, 0x81,
  0xF8, 0x03, 0xE0, 0x1F, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xF0, 0x3F,
  0x00, 0x7E, 0x03, 0xFF, 0xC0, 0xFC, 0x01, 0xF0, 0x0F, 0xFF, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0xFB, 0xF0, 0x7E, 0x00,
  0xFC, 0x07, 0xEF, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0xBF, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0xFC, 0x1F, 0x80, 0xFE, 0x03, 0xF3, 0xF0, 0x7E, 0x03, 0xF8,
  0x1F, 0x8F, 0xC1, 0xFC, 0x1F, 0xF0, 0xFE, 0x3F, 0x03, 0xFF, 0xF7, 0xFF,
  0xF0, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0x81, 0xF8, 0x1F, 0xFE, 0x7F, 0xFC,
  0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0xC1, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x02, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0x00, 0x3F, 0xF8, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x7F,
  0x80, 0x3F, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0x3F,
  0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFF, 0x8F, 0xF0,
  0x07, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x7F, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFC,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x80,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xE1,
  0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x00, 0x7F, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x01,
  0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x7F, 0x7E, 0x00, 0x0F, 0xDF, 0xC0,
  0x3F, 0xBF, 0x00, 0x0F, 0xCF, 0xE0, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0, 0x03, 0xF3, 0xF8,
  0x07, 0xF3, 0xF0, 0x03, 0xF1, 0xFC, 0x03, 0xF9, 0xF8, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x3E, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F,
  0xE0, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0x7E, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x1F, 0xC1,
  0xFE, 0x01, 0xF8, 0x1F, 0x8F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xCF, 0xE0,
  0x7F, 0x00, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xF7, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x7F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xBF, 0x80,
  0x07, 0xF0, 0x0F, 0xEF, 0xE0, 0x03, 0xF8, 0x03, 0xFB, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xC7, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x0F, 0xE0, 0x03, 0xF9, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0xFE,
  0x00, 0x1F, 0xDF, 0x80, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xE0, 0x00,
  0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x07,
  0xE0, 0x00, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xF8,
  0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x3F,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xF8,
  0x0F, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F,
  0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x01,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x3C, 0x03, 0xFC, 0x00,
  0x10, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x08, 0x00,
  0x07, 0xF8, 0x30, 0x00, 0x3F, 0xE0, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01,
  0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xF8, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xC3,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x7E, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x80, 0xFE, 0x03, 0xF9, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x3F,
  0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xF8,
  0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F,
  0xC3, 0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x00, 0x0F,
  0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x00,
  0x3F, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0,
  0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x3F, 0x7F,
  0x00, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x07,
  0xF8, 0x3F, 0x80, 0x0F, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F,
  0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xFF, 0x83, 0xF0, 0x0F, 0xFF, 0x0F, 0xC0, 0x7F, 0xFE, 0x3F, 0x03, 0xFF,
  0xFD, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x07,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x1F,
  0xF0, 0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0xFC, 0x03,
  0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0x8F, 0xC0, 0x0F, 0xF8, 0x3F, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x20, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x3F,
  0xFC, 0x00, 0xFE, 0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xBF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8,
  0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xFE,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFD, 0xFF, 0xFF, 0x01, 0xF9, 0xFF,
  0xFC, 0x03, 0xF1, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFD, 0xFC,
  0x3F, 0xF0, 0x04, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x04, 0x3F,
  0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x30, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xE0, 0x03,
  0xFF, 0xC7, 0xF0, 0x03, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xFD, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F,
  0xF0, 0x1F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xDF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xDF, 0x80, 0x0F, 0xFF, 0xCF, 0xC0, 0x03, 0xFF,
  0xC7, 0xE0, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFC, 0xFE, 0x01, 0xFF, 0x9F, 0xC3,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x41, 0xFE, 0x00, 0x38, 0x3F, 0xF0, 0x3F, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x10,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x87,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x1F, 0xC0, 0x0F, 0xFF, 0x0F, 0xC0, 0x0F, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF,
  0xF7, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFC,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F,
  0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0xFE, 0x7F,
  0x00, 0x0F, 0xFE, 0x3F, 0x80, 0x03, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x01, 0x80, 0x03,
  0xFE, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x20, 0x00, 0x3F, 0x87,
  0xFC, 0x00, 0x7F, 0x1F, 0xFE, 0x00, 0xFE, 0xFF, 0xFC, 0x03, 0xFB, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xE0, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8,
  0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x02, 0x0F, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFB, 0xFC,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0x80,
  0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x83, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0xF0, 0x7F, 0xC0, 0x07, 0xE3,
  0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xC0, 0x7E, 0xFF,
  0xFF, 0xC0, 0xFD, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0x01,
  0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x3F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0x81, 0xFE, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07,
  0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFC, 0xFF, 0x00,
  0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x03, 0xF1, 0xFF, 0xE0, 0x00, 0xFC,
  0xFF, 0xFC, 0x00, 0x7E, 0x7F, 0xFF, 0x00, 0x1F, 0xBF, 0xFF, 0xE0, 0x07,
  0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFB, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0xFE, 0x00, 0x3F, 0x9F, 0xFF,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x81,
  0xF0, 0x0F, 0xFF, 0x8F, 0xC0, 0x7F, 0xFE, 0x3F, 0x03, 0xFF, 0xFD, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x1F,
  0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFF, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xF0, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFB,
  0xFF, 0xE0, 0x7F, 0xFF, 0xBF, 0x81, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xE7,
  0xF0, 0x07, 0xFF, 0x1F, 0xC0, 0x0F, 0xF8, 0x7F, 0x00, 0x02, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0xFC, 0x1F, 0xC0, 0x7E, 0x3F, 0xE0,
  0x3F, 0x3F, 0xF0, 0x3F, 0xBF, 0xF8, 0x1F, 0xDF, 0xF8, 0x0F, 0xDF, 0xFC,
  0x07, 0xFF, 0xE6, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC0, 0xF8, 0x3F, 0xC0, 0x0C, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x40, 0x01, 0xFE, 0x30, 0x01, 0xFF, 0x1F, 0x03,
  0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xFE, 0x70, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x10, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F,
  0x80, 0x7F, 0xE0, 0xFF, 0x01, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0xFF, 0x7E, 0x03, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xF9, 0xF8, 0x07, 0xFF,
  0xE3, 0xF0, 0x07, 0xFF, 0x8F, 0xC0, 0x07, 0xFC, 0x1F, 0x80, 0x01, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFB, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xFC,
  0x01, 0xFE, 0x3F, 0x80, 0x7F, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0x0F, 0xE0, 0x3E, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xF7, 0xE0, 0x7F,
  0x83, 0xF8, 0x1F, 0xBF, 0x03, 0xF8, 0x1F, 0xC0, 0xF9, 0xF8, 0x1F, 0xC0,
  0xFE, 0x0F, 0xCF, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0x3F,
  0x87, 0xE3, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x1F, 0x87, 0xF0, 0x0F, 0xE3,
  0xF0, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0x03, 0xF8, 0xFC,
  0x3F, 0x1F, 0xC0, 0x1F, 0xCF, 0xC1, 0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x0F,
  0xCF, 0xE0, 0x07, 0xF7, 0xE0, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x03, 0xF7,
  0xF0, 0x01, 0xFD, 0xF0, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x3E, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xE3,
  0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xF0,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x09, 0xFF, 0xF0,
  0x00, 0xDF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xD8, 0x00, 0x3F, 0xF8, 0x80,
  0x00, 0x0F, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 43, 16, 1, -42 },
  { 93, 20, 15, 25, 6, -42 },
  { 131, 37, 42, 38, 1, -42 },
  { 326, 30, 48, 33, 2, -45 },
  { 506, 43, 44, 49, 4, -43 },
  { 743, 38, 44, 41, 2, -43 },
  { 952, 9, 15, 14, 6, -42 },
  { 969, 21, 51, 19, 2, -42 },
  { 1103, 21, 52, 19, -4, -43 },
  { 1240, 28, 28, 32, 5, -45 },
  { 1338, 29, 28, 34, 3, -35 },
  { 1440, 14, 15, 16, -3, -7 },
  { 1467, 16, 6, 19, 1, -19 },
  { 1479, 9, 9, 16, 1, -8 },
  { 1490, 31, 42, 23, -3, -42 },
  { 1653, 30, 44, 33, 2, -43 },
  { 1818, 22, 42, 33, 6, -42 },
  { 1934, 32, 43, 33, -1, -43 },
  { 2106, 31, 44, 33, 1, -43 },
  { 2277, 32, 42, 33, 0, -42 },
  { 2445, 31, 43, 33, 1, -42 },
  { 2612, 30, 44, 33, 3, -43 },
  { 2777, 31, 42, 33, 3, -42 },
  { 2940, 30, 44, 33, 2, -43 },
  { 3105, 28, 44, 33, 3, -43 },
  { 3259, 14, 34, 16, 1, -33 },
  { 3319, 18, 41, 16, -3, -33 },
  { 3412, 29, 31, 34, 3, -37 },
  { 3525, 28, 17, 34, 4, -29 },
  { 3585, 29, 31, 34, 3, -37 },
  { 3698, 23, 44, 26, 5, -43 },
  { 3825, 46, 47, 50, 3, -42 },
  { 4096, 35, 42, 36, -3, -42 },
  { 4280, 34, 42, 36, 2, -42 },
  { 4459, 34, 44, 36, 4, -43 },
  { 4646, 36, 42, 40, 2, -42 },
  { 4835, 32, 42, 31, 2, -42 },
  { 5003, 31, 42, 30, 2, -42 },
  { 5166, 36, 44, 40, 4, -43 },
  { 5364, 39, 42, 41, 2, -42 },
  { 5569, 27, 42, 21, -2, -42 },
  { 5711, 28, 54, 18, -9, -42 },
  { 5900, 38, 42, 35, 2, -42 },
  { 6100, 24, 42, 30, 2, -42 },
  { 6226, 49, 42, 51, 2, -42 },
  { 6484, 42, 42, 44, 2, -42 },
  { 6705, 37, 44, 43, 4, -43 },
  { 6909, 33, 42, 35, 2, -42 },
  { 7083, 37, 53, 43, 4, -43 },
  { 7329, 33, 42, 36, 2, -42 },
  { 7503, 30, 44, 31, 1, -43 },
  { 7668, 30, 42, 31, 5, -42 },
  { 7826, 37, 43, 40, 4, -42 },
  { 8025, 34, 42, 34, 5, -42 },
  { 8204, 51, 42, 52, 6, -42 },
  { 8472, 42, 42, 34, -3, -42 },
  { 8693, 32, 42, 32, 5, -42 },
  { 8861, 35, 42, 32, -1, -42 },
  { 9045, 24, 51, 19, -1, -42 },
  { 9198, 13, 42, 23, 6, -42 },
  { 9267, 24, 51, 19, -4, -42 },
  { 9420, 30, 27, 33, 1, -42 },
  { 9522, 24, 4, 23, -5, 5 },
  { 9534, 11, 9, 18, 9, -45 },
  { 9547, 30, 34, 34, 3, -33 },
  { 9675, 31, 46, 35, 1, -45 },
  { 9854, 25, 34, 28, 3, -33 },
  { 9961, 33, 46, 35, 3, -45 },
  { 10151, 27, 34, 32, 3, -33 },
  { 10266, 34, 59, 21, -6, -45 },
  { 10517, 33, 47, 35, 1, -33 },
  { 10711, 31, 45, 35, 1, -45 },
  { 10886, 17, 44, 17, 1, -44 },
  { 10980, 26, 58, 17, -8, -44 },
  { 11169, 33, 45, 32, 1, -45 },
  { 11355, 17, 45, 17, 1, -45 },
  { 11451, 49, 33, 53, 1, -33 },
  { 11654, 31, 33, 35, 1, -33 },
  { 11782, 28, 34, 34, 3, -33 },
  { 11901, 34, 47, 35, -2, -33 },
  { 12101, 30, 47, 35, 3, -33 },
  { 12278, 25, 33, 24, 1, -33 },
  { 12382, 25, 34, 27, 1, -33 },
  { 12489, 21, 40, 22, 3, -39 },
  { 12594, 31, 33, 35, 3, -32 },
  { 12722, 29, 32, 29, 3, -32 },
  { 12838, 45, 32, 45, 3, -32 },
  { 13018, 36, 32, 30, -3, -32 },
  { 13162, 37, 46, 29, -5, -32 },
  { 13375, 28, 32, 27, -1, -32 },
  { 13487, 24, 51, 21, 0, -42 },
  { 13640, 5, 59, 33, 14, -45 },
  { 13677, 24, 51, 21, -3, -42 },
  { 13830, 29, 9, 34, 3, -25 },
};

const GFXfont NotoSans_SemiBoldItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMIBOLDITALIC59PT7B_H_
