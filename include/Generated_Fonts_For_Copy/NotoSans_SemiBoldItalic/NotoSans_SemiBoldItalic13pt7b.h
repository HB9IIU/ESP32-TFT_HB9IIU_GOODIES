#ifndef _NOTOSANS_SEMIBOLDITALIC13PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x64, 0x0C, 0xC0, 0x5A, 0xB4, 0x0B, 0x12, 0x7F, 0x7F,
  0x34, 0xFF, 0x24, 0x28, 0x48, 0x08, 0x3C, 0xFB, 0x43, 0x03, 0x85, 0x4A,
  0xFC, 0x40, 0x80, 0x71, 0xE9, 0x25, 0x96, 0xBE, 0xA8, 0xB4, 0xD2, 0x4B,
  0xC7, 0x00, 0x1E, 0x19, 0x0D, 0x83, 0x83, 0x9B, 0x6B, 0x1C, 0xDC, 0x7B,
  0x00, 0x5C, 0x19, 0x88, 0xC4, 0x21, 0x18, 0x42, 0x18, 0x30, 0x86, 0x31,
  0x8C, 0x46, 0x23, 0x30, 0x1A, 0x4F, 0x4F, 0x71, 0x60, 0x30, 0xC3, 0x3F,
  0x30, 0xC3, 0x00, 0x2D, 0x60, 0xF0, 0xF0, 0x06, 0x08, 0x30, 0x41, 0x86,
  0x08, 0x30, 0xC0, 0x7D, 0x3C, 0xF3, 0x8E, 0x38, 0xB6, 0xF0, 0x3F, 0xD6,
  0x23, 0x18, 0xC4, 0x20, 0x7E, 0x4C, 0x18, 0x20, 0xC3, 0x08, 0x60, 0xFC,
  0x3E, 0x4C, 0x18, 0x63, 0x80, 0x81, 0x46, 0xF8, 0x06, 0x1C, 0x51, 0xA6,
  0xD9, 0xBF, 0x84, 0x18, 0x3E, 0x60, 0x83, 0xC3, 0xC0, 0x81, 0x46, 0xF8,
  0x3D, 0x8C, 0x3E, 0xCE, 0x38, 0xB6, 0xF0, 0xFE, 0x18, 0x20, 0xC3, 0x06,
  0x18, 0x20, 0xC0, 0x3E, 0x4C, 0x99, 0xE3, 0xCC, 0xB1, 0x26, 0x78, 0x7B,
  0x3C, 0xF3, 0xFD, 0xA1, 0xAC, 0xE0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x02,
  0x64, 0xC0, 0x04, 0x76, 0x30, 0x70, 0x70, 0x40, 0xFC, 0x0F, 0xC0, 0x83,
  0x83, 0x83, 0x3B, 0x08, 0x00, 0xFC, 0x46, 0x66, 0x20, 0x18, 0xC0, 0x1F,
  0x18, 0x24, 0xEE, 0x49, 0xB2, 0x69, 0xBB, 0x7A, 0x6C, 0xC0, 0x1F, 0x80,
  0x06, 0x0E, 0x0A, 0x1B, 0x13, 0x3F, 0x3F, 0x63, 0xC3, 0x3E, 0x33, 0x23,
  0x3E, 0x7C, 0x66, 0x66, 0x4E, 0xFC, 0x3E, 0xC7, 0x06, 0x0C, 0x18, 0x30,
  0x72, 0x7C, 0x3E, 0x33, 0x21, 0x21, 0x61, 0x63, 0x63, 0x4E, 0xF8, 0x3E,
  0x60, 0x81, 0xE7, 0xCC, 0x18, 0x20, 0xFC, 0x3E, 0x60, 0x81, 0x07, 0xCC,
  0x18, 0x20, 0xC0, 0x3F, 0x61, 0xC0, 0xC0, 0xCE, 0xC6, 0xC6, 0xE6, 0x7C,
  0x31, 0x98, 0xC8, 0x47, 0xE7, 0xF3, 0x19, 0x8C, 0x84, 0xC6, 0x00, 0x79,
  0x8C, 0x62, 0x31, 0x8C, 0xF0, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x84, 0x10,
  0xCF, 0x30, 0x33, 0x9B, 0x0B, 0x05, 0x07, 0x83, 0x61, 0xB0, 0x88, 0xC6,
  0x00, 0x30, 0xC2, 0x08, 0x61, 0x86, 0x10, 0xFC, 0x38, 0x67, 0x1C, 0xA3,
  0x94, 0xB6, 0xB4, 0xD4, 0x93, 0xB2, 0x66, 0xCC, 0x80, 0x30, 0xCE, 0x22,
  0x88, 0xB6, 0x6D, 0x99, 0x44, 0x71, 0x1C, 0xC3, 0x00, 0x3E, 0x63, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC6, 0xCE, 0x7C, 0x3E, 0x33, 0x23, 0x23, 0x7E, 0x78,
  0x60, 0x40, 0xC0, 0x3E, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xCE, 0x7C,
  0x0C, 0x0E, 0x3E, 0x33, 0x23, 0x26, 0x7C, 0x6C, 0x6C, 0x44, 0xC6, 0x3E,
  0xC1, 0x81, 0x83, 0x81, 0x83, 0x46, 0xF8, 0xFE, 0x60, 0xC1, 0x82, 0x04,
  0x18, 0x30, 0x60, 0x63, 0x63, 0x42, 0xC2, 0xC6, 0xC6, 0xC6, 0xCC, 0x78,
  0xC3, 0xC6, 0xC4, 0x4C, 0x48, 0x58, 0x50, 0x70, 0x60, 0xC6, 0x3C, 0xE6,
  0xCE, 0x4D, 0xEC, 0xD6, 0x8D, 0x28, 0xF3, 0x86, 0x30, 0x63, 0x00, 0x31,
  0xC6, 0xC1, 0xA0, 0x38, 0x0C, 0x07, 0x83, 0x61, 0x88, 0xE3, 0x00, 0xC6,
  0x99, 0x23, 0xC7, 0x04, 0x18, 0x30, 0x60, 0x3F, 0x46, 0x0C, 0x18, 0x10,
  0x30, 0x60, 0xC0, 0xFC, 0x39, 0x08, 0xC6, 0x21, 0x08, 0xC6, 0x38, 0xC9,
  0x26, 0xD9, 0x20, 0x38, 0x46, 0x31, 0x08, 0xC6, 0x21, 0x38, 0x18, 0x30,
  0xB1, 0x24, 0x58, 0x40, 0xF8, 0xD0, 0x77, 0x3C, 0xE3, 0x8B, 0x6E, 0x80,
  0x30, 0x60, 0x81, 0x77, 0x6C, 0xD9, 0xA3, 0x6D, 0xF0, 0x7E, 0x71, 0x08,
  0x67, 0xC0, 0x06, 0x0C, 0x13, 0xAC, 0xD9, 0xA3, 0x44, 0x99, 0xD0, 0x7B,
  0x3C, 0xBC, 0x83, 0x2F, 0x80, 0x0E, 0x34, 0x61, 0xE1, 0x02, 0x0C, 0x18,
  0x30, 0x41, 0x83, 0x0C, 0x00, 0x3A, 0xCD, 0x9A, 0x34, 0x4D, 0x9F, 0x06,
  0x89, 0xF0, 0x30, 0x60, 0x81, 0x77, 0x6C, 0xD9, 0xA3, 0x45, 0x98, 0x33,
  0x02, 0x66, 0x64, 0x4C, 0x0C, 0x30, 0x02, 0x18, 0x61, 0x84, 0x10, 0xC3,
  0x0C, 0xE0, 0x30, 0x30, 0x21, 0x26, 0x6C, 0x78, 0x78, 0x78, 0x4C, 0xCC,
  0x33, 0x32, 0x66, 0x64, 0x4C, 0x2E, 0xEE, 0xED, 0x99, 0xB3, 0x34, 0x44,
  0x88, 0xB3, 0x30, 0x2E, 0xED, 0x9B, 0x34, 0x68, 0xB3, 0x00, 0x7B, 0x3C,
  0xE3, 0x8F, 0x6F, 0x00, 0x2E, 0xED, 0x9B, 0x34, 0x6D, 0xBE, 0x60, 0xC1,
  0x00, 0x77, 0x3C, 0xE3, 0x8A, 0x6F, 0x86, 0x18, 0x40, 0x2D, 0xC6, 0x18,
  0x41, 0x0C, 0x00, 0x7D, 0x96, 0x0E, 0x1A, 0x6F, 0x00, 0x26, 0xF4, 0xCC,
  0xC8, 0xE0, 0x47, 0x1C, 0xF3, 0x8A, 0x6E, 0x80, 0x8E, 0x29, 0xB4, 0xF3,
  0x8E, 0x00, 0x98, 0xE6, 0x69, 0xD2, 0xBC, 0xAE, 0x3B, 0x8C, 0xC0, 0x33,
  0x16, 0x1C, 0x18, 0x1C, 0x24, 0xE6, 0x23, 0x22, 0x36, 0x34, 0x3C, 0x38,
  0x18, 0x30, 0x30, 0xE0, 0x7C, 0x21, 0x8C, 0x63, 0x0F, 0x80, 0x19, 0x8C,
  0x46, 0x61, 0x8C, 0x42, 0x18, 0xFF, 0xF8, 0x38, 0x61, 0x84, 0x18, 0x33,
  0x0C, 0x21, 0x8E, 0x00, 0x47, 0xF0,
};

const GFXglyph NotoSans_SemiBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 4, 0, -9 },
  { 6, 5, 3, 6, 1, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 7, 11, 7, 0, -10 },
  { 27, 9, 9, 11, 1, -9 },
  { 38, 9, 9, 9, 0, -9 },
  { 49, 2, 3, 3, 1, -9 },
  { 50, 5, 11, 4, 0, -9 },
  { 57, 5, 11, 4, -1, -9 },
  { 64, 6, 6, 7, 1, -10 },
  { 69, 6, 7, 7, 1, -8 },
  { 75, 3, 4, 4, -1, -2 },
  { 77, 4, 1, 4, 0, -4 },
  { 78, 2, 2, 4, 0, -2 },
  { 79, 7, 9, 5, -1, -9 },
  { 87, 6, 9, 7, 1, -9 },
  { 94, 5, 9, 7, 1, -9 },
  { 100, 7, 9, 7, 0, -9 },
  { 108, 7, 9, 7, 0, -9 },
  { 116, 7, 9, 7, 0, -9 },
  { 124, 7, 9, 7, 0, -9 },
  { 132, 6, 9, 7, 1, -9 },
  { 139, 7, 9, 7, 1, -9 },
  { 147, 7, 9, 7, 0, -9 },
  { 155, 6, 9, 7, 1, -9 },
  { 162, 3, 7, 4, 0, -7 },
  { 165, 4, 9, 4, -1, -7 },
  { 170, 6, 7, 7, 1, -8 },
  { 176, 6, 3, 7, 1, -6 },
  { 179, 6, 7, 7, 1, -8 },
  { 185, 5, 9, 6, 1, -9 },
  { 191, 10, 10, 11, 1, -9 },
  { 204, 8, 9, 8, -1, -9 },
  { 213, 8, 9, 8, 0, -9 },
  { 222, 7, 9, 8, 1, -9 },
  { 230, 8, 9, 9, 0, -9 },
  { 239, 7, 9, 7, 0, -9 },
  { 247, 7, 9, 7, 0, -9 },
  { 255, 8, 9, 9, 1, -9 },
  { 264, 9, 9, 9, 0, -9 },
  { 275, 5, 9, 5, 0, -9 },
  { 281, 6, 12, 4, -2, -9 },
  { 290, 9, 9, 8, 0, -9 },
  { 301, 6, 9, 7, 0, -9 },
  { 308, 11, 9, 11, 0, -9 },
  { 321, 10, 9, 10, 0, -9 },
  { 333, 8, 9, 9, 1, -9 },
  { 342, 8, 9, 8, 0, -9 },
  { 351, 8, 11, 9, 1, -9 },
  { 362, 8, 9, 8, 0, -9 },
  { 371, 7, 9, 7, 0, -9 },
  { 379, 7, 9, 7, 1, -9 },
  { 387, 8, 9, 9, 1, -9 },
  { 396, 8, 9, 7, 1, -9 },
  { 405, 12, 9, 11, 1, -9 },
  { 419, 10, 9, 8, -1, -9 },
  { 431, 7, 9, 7, 1, -9 },
  { 439, 8, 9, 7, 0, -9 },
  { 448, 5, 11, 4, 0, -9 },
  { 455, 3, 9, 5, 1, -9 },
  { 459, 5, 11, 4, -1, -9 },
  { 466, 7, 6, 7, 0, -9 },
  { 472, 5, 1, 5, -1, 1 },
  { 473, 2, 2, 4, 2, -10 },
  { 474, 6, 7, 8, 1, -7 },
  { 480, 7, 10, 8, 0, -10 },
  { 489, 5, 7, 6, 1, -7 },
  { 494, 7, 10, 8, 1, -10 },
  { 503, 6, 7, 7, 1, -7 },
  { 509, 7, 13, 5, -1, -10 },
  { 521, 7, 10, 8, 0, -7 },
  { 530, 7, 10, 8, 0, -10 },
  { 539, 4, 10, 4, 0, -10 },
  { 544, 6, 13, 4, -2, -10 },
  { 554, 8, 10, 7, 0, -10 },
  { 564, 4, 10, 4, 0, -10 },
  { 569, 11, 7, 12, 0, -7 },
  { 579, 7, 7, 8, 0, -7 },
  { 586, 6, 7, 8, 1, -7 },
  { 592, 7, 10, 8, 0, -7 },
  { 601, 6, 10, 8, 1, -7 },
  { 609, 6, 7, 5, 0, -7 },
  { 615, 6, 7, 6, 0, -7 },
  { 621, 4, 9, 5, 1, -9 },
  { 626, 6, 7, 8, 1, -7 },
  { 632, 6, 7, 6, 1, -7 },
  { 638, 10, 7, 10, 1, -7 },
  { 647, 8, 7, 7, -1, -7 },
  { 654, 8, 10, 6, -1, -7 },
  { 664, 6, 7, 6, 0, -7 },
  { 670, 5, 11, 5, 0, -9 },
  { 677, 1, 13, 7, 3, -10 },
  { 679, 6, 11, 5, -1, -9 },
  { 688, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMIBOLDITALIC13PT7B_H_
