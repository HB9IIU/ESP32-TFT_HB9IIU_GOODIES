#ifndef _NOTOSANS_SEMIBOLDITALIC66PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F,
  0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3F, 0x9F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x3E, 0x3E, 0x00, 0xFF, 0x0F, 0x01, 0x80, 0x7F, 0xC3, 0xC0, 0x00, 0x1F,
  0xE0, 0xF0, 0x00, 0x07, 0xF8, 0x7C, 0x00, 0x01, 0xFE, 0x1F, 0x00, 0x00,
  0x7F, 0x87, 0x80, 0x00, 0x1F, 0xF1, 0xE0, 0x00, 0x07, 0xFE, 0x78, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0x9F, 0xF0, 0x00,
  0x03, 0xC3, 0xFC, 0x00, 0x00, 0xF0, 0xFF, 0x00, 0x00, 0x3C, 0x3F, 0xC0,
  0x00, 0x1F, 0x0F, 0xF0, 0x00, 0x07, 0x83, 0xFC, 0x20, 0x01, 0xE0, 0xFF,
  0x0E, 0x00, 0x78, 0x7F, 0xC3, 0xF0, 0x3E, 0x3F, 0xE0, 0xFF, 0xEF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x00, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0xFE, 0x3F, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x7F, 0xFC, 0xFE, 0x0F, 0xE3,
  0xF8, 0xFF, 0xFE, 0x7F, 0x1F, 0xE3, 0xF1, 0xFF, 0xFF, 0x7F, 0xFF, 0xC7,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0x8F, 0xE3, 0xFC, 0x7F, 0x3F, 0xFF, 0x9F,
  0xC7, 0xF8, 0x7F, 0x1F, 0xFE, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xFC, 0x3F,
  0x8F, 0xE0, 0x3F, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0xE7, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0x07, 0xF8, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x9F, 0xF0, 0x7F, 0x80, 0x1F, 0xF3, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x7F,
  0xC0, 0x03, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x1F, 0xF8, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1E, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x7F, 0x9F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x08, 0x00, 0xFC, 0x00, 0x1C, 0x01, 0xF8, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0xFF, 0x07, 0xC0, 0x01, 0xFF, 0x8F, 0x80, 0x07, 0xFF, 0xDF,
  0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x78, 0x0F, 0xEF, 0x80, 0x00, 0x3F, 0xDF, 0x80,
  0x00, 0xFF, 0x3F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0x7E, 0x00,
  0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1E, 0x03, 0xFC, 0x00,
  0x1C, 0x03, 0xF8, 0x00, 0x10, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF8,
  0x3F, 0x9F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F,
  0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07,
  0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFB, 0xFC, 0x7F, 0xF3, 0xFC, 0x7F, 0xC7, 0xF8, 0x3F,
  0x87, 0xF8, 0x1E, 0x07, 0xF8, 0x18, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x03, 0xE0,
  0x01, 0xFF, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x00, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFE, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0C, 0x00, 0x1F, 0xF0,
  0x02, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC3, 0x00, 0x00, 0x3F, 0xF0, 0xF0, 0x00, 0x1F, 0xF8, 0x3F,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x30, 0x00,
  0x03, 0xFF, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x04, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xFF, 0x00, 0x3F, 0xCF, 0xFF, 0xE0, 0x0F,
  0xF7, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07,
  0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x17, 0x40, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF,
  0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFF,
  0x3F, 0xC0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xFE,
  0x1F, 0xFE, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFD, 0xFE,
  0x0F, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xE3, 0xFC,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x80, 0x03, 0xFF, 0x80, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0B, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0xFF, 0x03, 0xFF, 0x1E, 0x00, 0x7F, 0xC6, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x7E,
  0x0F, 0xE0, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x7F, 0x1F, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xF1, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0x3F, 0x80, 0x7F, 0xC0, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xF0,
  0x0F, 0xC0, 0x3F, 0x3F, 0x01, 0xFE, 0x00, 0xFC, 0x03, 0xF7, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF7, 0xE0,
  0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF7,
  0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x07,
  0xEF, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0xFE, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xEF, 0xE0, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0xFE, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xCF, 0xE0, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0xFE, 0x07, 0xE0,
  0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x03, 0xFE, 0x07, 0xF8, 0xFE, 0x07,
  0xF8, 0x7F, 0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0xFF, 0xBF, 0xFF, 0xE0, 0x7E,
  0x03, 0xFF, 0xFB, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0x80,
  0x7F, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x3F, 0xFC, 0x00, 0x3C,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x3F,
  0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x01,
  0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7C,
  0x01, 0xFF, 0xE0, 0x00, 0x0C, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFC, 0x7F, 0xC0,
  0x07, 0xFF, 0xFC, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x7F, 0x80, 0x0F, 0xFF,
  0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x07,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xEF,
  0xE0, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0xC0, 0x1F, 0xEF, 0xC0, 0x00,
  0x7F, 0x7F, 0x80, 0x3F, 0x9F, 0x80, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x03,
  0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x1F,
  0xE0, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x1F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0x80, 0x3F, 0x87, 0xF8, 0x03,
  0xFC, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xF8, 0x0F,
  0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0x03,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x8F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x7F,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFD, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFB, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xE0, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x00,
  0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x0F,
  0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF9, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xF8,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0xC0, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x03, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x7F, 0xC0, 0x00,
  0x80, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x08,
  0x00, 0x00, 0xFF, 0x83, 0x80, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0xF3, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF1,
  0xFF, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC7, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xDF, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF7, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFD,
  0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F,
  0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xF8,
  0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xDF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF,
  0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0x87, 0xF0, 0x07, 0xFF,
  0xF1, 0xFC, 0x03, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xF1,
  0xF8, 0x00, 0xFF, 0xF8, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0xFF,
  0xF0, 0x00, 0xFF, 0x3F, 0xFF, 0x00, 0x3F, 0xCF, 0xFF, 0xF0, 0x07, 0xFB,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xCF, 0xFF, 0xFC, 0x03, 0xF8, 0xFF, 0xFE, 0x00, 0x7E, 0x0F, 0xFF,
  0x80, 0x1F, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x1F,
  0x81, 0xFF, 0xC0, 0x0C, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x02, 0x07, 0xFE, 0x00, 0x70, 0x3F, 0xF8, 0x1F, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x07, 0xFF, 0xC7, 0xF8, 0x00, 0x7F, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0xF9,
  0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xF9, 0xFF, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFB, 0xF8, 0x00, 0xFF,
  0xFF, 0x9F, 0xC0, 0x03, 0xFF, 0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0x87, 0xE0,
  0x00, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F,
  0xC7, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x1C, 0x0F, 0xFE, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x83, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x08, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0x00, 0x1F, 0xFF,
  0xC7, 0xF0, 0x07, 0xFF, 0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0xEF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF,
  0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xBF, 0xC0,
  0x0F, 0xFF, 0xF3, 0xFC, 0x00, 0x7F, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0xC7,
  0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x38, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x80, 0x00, 0x3F,
  0xE0, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0xF8, 0x00, 0xFE, 0x3F, 0xFF, 0x80, 0x3F, 0xCF, 0xFF,
  0xF0, 0x07, 0xFB, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xCF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC,
  0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x83, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xCF,
  0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F,
  0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC0, 0x3F, 0xBF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x03, 0xF0, 0x7F, 0xFC, 0x00,
  0xFE, 0x1F, 0xFF, 0xC0, 0x1F, 0xC7, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xFF,
  0x80, 0x7F, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x9F, 0xFE, 0x0F, 0xFC, 0x03, 0xFE,
  0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x17, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFF,
  0x00, 0x00, 0x7E, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0xFF, 0xFE, 0x00, 0x0F,
  0xE7, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFD, 0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xFF, 0xFE, 0x00, 0x3F, 0xCF, 0xFF,
  0xE0, 0x00, 0xFF, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0x1F,
  0xE0, 0x1C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0x83, 0xF0,
  0x07, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFF, 0xBF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xCF, 0xF0, 0x07,
  0xFF, 0xE7, 0xF8, 0x00, 0xFF, 0xF1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x00, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF8,
  0x07, 0xF0, 0xFF, 0x80, 0x3F, 0x8F, 0xFC, 0x03, 0xF8, 0xFF, 0xE0, 0x1F,
  0xCF, 0xFF, 0x00, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x8C, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xC0, 0xFF, 0x80, 0x0C, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x88, 0x00, 0x0F, 0xF0, 0xC0, 0x01, 0xFF,
  0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x68, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF0,
  0x03, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF, 0xBF, 0x80,
  0x7F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xE0, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x01, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF9, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xFC, 0x7F, 0x80,
  0x7E, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x7E, 0x03, 0xFE, 0x1F, 0xE0,
  0x3F, 0x3F, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0x9F, 0x81, 0xFF, 0x07, 0xF8,
  0x1F, 0xCF, 0xC0, 0xFF, 0x01, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x80, 0xFE,
  0x0F, 0xE3, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0xC0, 0x3F,
  0x87, 0xF0, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x3F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x1F, 0x8F, 0xF0, 0x03,
  0xF9, 0xFC, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0xFE, 0x07, 0xE7, 0xF8, 0x00,
  0xFE, 0x7E, 0x03, 0xF3, 0xFC, 0x00, 0x7F, 0x7F, 0x01, 0xF9, 0xFC, 0x00,
  0x3F, 0xBF, 0x00, 0xFD, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x7E, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x3F,
  0xFF, 0x00, 0x07, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0xE0,
  0x03, 0xFF, 0xFC, 0x80, 0x00, 0x7F, 0xF8, 0x80, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_SemiBoldItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 19, 48, 18, 1, -47 },
  { 115, 22, 17, 28, 7, -47 },
  { 162, 41, 47, 43, 2, -47 },
  { 403, 34, 54, 36, 2, -50 },
  { 633, 48, 49, 55, 4, -48 },
  { 927, 43, 49, 46, 2, -48 },
  { 1191, 10, 17, 16, 7, -47 },
  { 1213, 23, 57, 21, 3, -47 },
  { 1377, 24, 58, 21, -5, -48 },
  { 1551, 31, 31, 36, 6, -50 },
  { 1672, 32, 32, 38, 4, -39 },
  { 1800, 15, 17, 18, -3, -8 },
  { 1832, 18, 7, 21, 1, -21 },
  { 1848, 10, 10, 18, 1, -9 },
  { 1861, 34, 47, 26, -3, -47 },
  { 2061, 33, 49, 36, 3, -48 },
  { 2264, 24, 47, 36, 7, -47 },
  { 2405, 36, 48, 36, -1, -48 },
  { 2621, 34, 49, 36, 1, -48 },
  { 2830, 35, 47, 36, 0, -47 },
  { 3036, 35, 48, 36, 1, -47 },
  { 3246, 34, 49, 36, 3, -48 },
  { 3455, 34, 47, 36, 4, -47 },
  { 3655, 34, 49, 36, 2, -48 },
  { 3864, 32, 49, 36, 3, -48 },
  { 4060, 16, 38, 18, 1, -37 },
  { 4136, 20, 46, 18, -3, -37 },
  { 4251, 32, 34, 38, 4, -41 },
  { 4387, 31, 19, 38, 4, -33 },
  { 4461, 32, 34, 38, 4, -41 },
  { 4597, 26, 49, 30, 5, -48 },
  { 4757, 52, 53, 56, 3, -47 },
  { 5102, 40, 47, 40, -4, -47 },
  { 5337, 38, 47, 40, 2, -47 },
  { 5561, 39, 49, 40, 4, -48 },
  { 5800, 40, 47, 44, 2, -47 },
  { 6035, 35, 47, 35, 2, -47 },
  { 6241, 35, 47, 34, 2, -47 },
  { 6447, 40, 49, 45, 4, -48 },
  { 6692, 44, 47, 46, 2, -47 },
  { 6951, 30, 47, 24, -2, -47 },
  { 7128, 31, 60, 21, -10, -47 },
  { 7361, 43, 47, 39, 2, -47 },
  { 7614, 27, 47, 33, 2, -47 },
  { 7773, 55, 47, 57, 2, -47 },
  { 8097, 47, 47, 49, 2, -47 },
  { 8374, 42, 49, 48, 4, -48 },
  { 8632, 37, 47, 39, 2, -47 },
  { 8850, 42, 59, 48, 4, -48 },
  { 9160, 37, 47, 40, 2, -47 },
  { 9378, 34, 49, 34, 1, -48 },
  { 9587, 33, 47, 34, 6, -47 },
  { 9781, 41, 48, 45, 5, -47 },
  { 10027, 38, 47, 38, 6, -47 },
  { 10251, 58, 47, 58, 6, -47 },
  { 10592, 47, 47, 38, -4, -47 },
  { 10869, 36, 47, 36, 6, -47 },
  { 11081, 39, 47, 35, -1, -47 },
  { 11311, 27, 57, 21, -1, -47 },
  { 11504, 15, 47, 26, 7, -47 },
  { 11593, 27, 57, 21, -5, -47 },
  { 11786, 33, 30, 37, 2, -47 },
  { 11910, 27, 4, 26, -6, 6 },
  { 11924, 12, 11, 20, 10, -51 },
  { 11941, 34, 37, 38, 3, -36 },
  { 12099, 35, 51, 39, 1, -50 },
  { 12323, 29, 37, 31, 3, -36 },
  { 12458, 37, 51, 39, 3, -50 },
  { 12694, 31, 37, 35, 3, -36 },
  { 12838, 38, 66, 23, -7, -50 },
  { 13152, 36, 52, 39, 1, -36 },
  { 13386, 35, 50, 39, 1, -50 },
  { 13605, 19, 50, 19, 1, -50 },
  { 13724, 28, 66, 19, -8, -50 },
  { 13955, 37, 50, 36, 1, -50 },
  { 14187, 19, 50, 19, 1, -50 },
  { 14306, 55, 36, 59, 1, -36 },
  { 14554, 35, 37, 39, 1, -37 },
  { 14716, 32, 37, 38, 3, -36 },
  { 14864, 38, 52, 39, -2, -36 },
  { 15111, 34, 52, 39, 3, -36 },
  { 15332, 29, 36, 27, 1, -36 },
  { 15463, 28, 37, 30, 1, -36 },
  { 15593, 24, 45, 25, 3, -44 },
  { 15728, 34, 37, 39, 4, -36 },
  { 15886, 33, 36, 33, 3, -36 },
  { 16035, 49, 36, 50, 4, -36 },
  { 16256, 40, 36, 34, -3, -36 },
  { 16436, 41, 52, 33, -5, -36 },
  { 16703, 32, 36, 30, -1, -36 },
  { 16847, 27, 57, 23, 0, -47 },
  { 17040, 6, 65, 36, 16, -50 },
  { 17089, 26, 57, 23, -3, -47 },
  { 17275, 32, 10, 38, 4, -28 },
};

const GFXfont NotoSans_SemiBoldItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMIBOLDITALIC66PT7B_H_
