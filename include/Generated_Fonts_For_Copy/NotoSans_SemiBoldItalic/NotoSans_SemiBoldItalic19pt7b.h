#ifndef _NOTOSANS_SEMIBOLDITALIC19PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x31, 0x80, 0x18, 0xE3, 0x80,
  0x6F, 0xBC, 0xF3, 0xC8, 0x06, 0x60, 0x66, 0x06, 0x60, 0x44, 0x3F, 0xF3,
  0xFF, 0x0C, 0x81, 0x98, 0x7F, 0xEF, 0xFE, 0x11, 0x03, 0x30, 0x33, 0x03,
  0x20, 0x06, 0x0F, 0x8F, 0xEE, 0x96, 0x43, 0xE0, 0xF0, 0x3E, 0x0F, 0x0D,
  0xA6, 0xDF, 0xEF, 0xC0, 0x80, 0xC0, 0x18, 0x18, 0xF0, 0xC6, 0x63, 0x19,
  0x98, 0xCC, 0xC3, 0x36, 0x0C, 0xDF, 0xDE, 0xDB, 0x36, 0xCC, 0x33, 0x30,
  0xCC, 0xC6, 0x33, 0x30, 0xD9, 0x83, 0xC0, 0x0F, 0x01, 0xF8, 0x39, 0x83,
  0x18, 0x39, 0x81, 0xF0, 0x1E, 0x07, 0xC7, 0xEE, 0x6C, 0x7E, 0xC3, 0xCC,
  0x38, 0xFF, 0xC7, 0xCE, 0x7F, 0x6C, 0x0C, 0x71, 0x8C, 0x71, 0x86, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x60, 0x18, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC6, 0x18, 0xC3, 0x18, 0xC0, 0x08, 0x06, 0x23, 0x1D,
  0x07, 0xF8, 0xFD, 0xF1, 0xD8, 0x46, 0x04, 0x00, 0x0C, 0x06, 0x03, 0x1F,
  0xFF, 0xF8, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x37, 0x6E, 0x7F, 0xE0, 0x7F,
  0x80, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x00, 0x0E, 0x0F, 0x8E, 0xEE, 0x36,
  0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xD8, 0xEF, 0xE3, 0xE0, 0x06,
  0x3C, 0xFF, 0xE4, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x00,
  0x07, 0x07, 0xE3, 0x9C, 0x43, 0x00, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xFF, 0xBF, 0xE0, 0x0F, 0x0F, 0xF1, 0x9C, 0x03, 0x00,
  0xC0, 0x61, 0xF0, 0x7C, 0x03, 0x80, 0x60, 0x1A, 0x0E, 0xFF, 0x3F, 0x80,
  0x00, 0xC0, 0x70, 0x3C, 0x1E, 0x0D, 0x87, 0x61, 0x98, 0xCE, 0x63, 0x3F,
  0xFF, 0xFC, 0x0C, 0x07, 0x01, 0x80, 0x0F, 0xC7, 0xF1, 0xFC, 0x60, 0x38,
  0x0C, 0x03, 0xF0, 0xDE, 0x01, 0x80, 0x60, 0x1A, 0x0E, 0xFF, 0x1F, 0x80,
  0x07, 0xC7, 0xE3, 0xC0, 0xC0, 0x60, 0x1B, 0x8F, 0xF3, 0xCE, 0xE3, 0xB0,
  0xEC, 0x33, 0x9C, 0x7E, 0x1F, 0x00, 0x7F, 0xDF, 0xF7, 0xF8, 0x0E, 0x03,
  0x01, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x00,
  0x0E, 0x1F, 0xCC, 0x6E, 0x37, 0x19, 0x9C, 0x78, 0x7C, 0xE7, 0x61, 0xB0,
  0xD8, 0x6F, 0xF3, 0xF0, 0x0E, 0x1F, 0x9C, 0xEC, 0x3E, 0x1F, 0x0F, 0x8E,
  0xFF, 0x3F, 0x01, 0x81, 0xC1, 0xCF, 0xC7, 0xC0, 0x11, 0xCE, 0x00, 0x00,
  0x00, 0x67, 0x38, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC7, 0x18,
  0xC0, 0x00, 0x80, 0xC1, 0xE3, 0x87, 0x07, 0x01, 0xE0, 0x1E, 0x03, 0x80,
  0x40, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x1C, 0x3C, 0xF8, 0xF0, 0x40, 0x00, 0x1C, 0x7F, 0x67, 0x03, 0x07,
  0x0E, 0x1C, 0x38, 0x30, 0x60, 0x00, 0x60, 0x60, 0xE0, 0x00, 0xC0, 0x1F,
  0xF0, 0x70, 0x71, 0x80, 0x66, 0x3E, 0x6C, 0xFC, 0xF3, 0x19, 0xE6, 0x23,
  0xC8, 0xC7, 0x91, 0x9B, 0x37, 0x76, 0x7B, 0x86, 0x00, 0x0E, 0x04, 0x0F,
  0xF8, 0x07, 0xC0, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0xE0, 0x6C, 0x1D, 0x83,
  0x38, 0xE7, 0x1F, 0xE7, 0xFC, 0xC1, 0xB8, 0x36, 0x07, 0xC0, 0xC0, 0x3E,
  0x0F, 0xF3, 0x1C, 0xC3, 0x30, 0xDC, 0x77, 0xF9, 0xFE, 0x61, 0x98, 0x7E,
  0x1B, 0x8E, 0xFF, 0xBF, 0x80, 0x03, 0xC1, 0xFC, 0xF1, 0x9C, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x47, 0xF8, 0x7F,
  0x00, 0x3E, 0x07, 0xF0, 0xCF, 0x18, 0x73, 0x06, 0xE0, 0xDC, 0x1B, 0x03,
  0x60, 0xEC, 0x1F, 0x87, 0x71, 0xCF, 0xF1, 0xF8, 0x00, 0x3F, 0xCF, 0xF3,
  0x00, 0xC0, 0x30, 0x1C, 0x07, 0xF1, 0xFC, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xFE, 0x3F, 0x80, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0xF1,
  0xFC, 0x7F, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0xFF,
  0x1C, 0x63, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x3E, 0xE3, 0xEE, 0x0C,
  0xE0, 0xC7, 0x0C, 0x7F, 0xC3, 0xFC, 0x38, 0x33, 0x83, 0x30, 0x73, 0x07,
  0x30, 0x67, 0x06, 0x7F, 0xE7, 0xFE, 0x60, 0xE6, 0x0C, 0xE0, 0xCE, 0x1C,
  0xC1, 0xCC, 0x18, 0x1F, 0x8F, 0xC3, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x03, 0x07, 0xC7, 0xE0, 0x01, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x38, 0xF8, 0x78, 0x00, 0x38, 0x73, 0x8E, 0x31, 0xC3, 0x38, 0x33, 0x07,
  0x60, 0x7E, 0x07, 0xE0, 0x76, 0x06, 0x60, 0xE7, 0x0E, 0x30, 0xC3, 0x8C,
  0x38, 0x38, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0F,
  0xFF, 0xC0, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E,
  0x7C, 0x6C, 0x6C, 0x6C, 0x6C, 0xCC, 0x6C, 0xCC, 0x65, 0x9C, 0xE7, 0x98,
  0xC7, 0x18, 0xC7, 0x18, 0xC6, 0x38, 0x38, 0x19, 0xE0, 0xCF, 0x0E, 0x78,
  0x63, 0xE3, 0x3B, 0x19, 0x98, 0xCC, 0xEE, 0x63, 0x63, 0x1B, 0x38, 0xF9,
  0x83, 0xCC, 0x1E, 0x60, 0xE0, 0x07, 0x81, 0xFE, 0x3C, 0xF3, 0x87, 0x70,
  0x36, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xE7, 0x1E, 0x7F,
  0xC3, 0xF0, 0x3E, 0x0F, 0xE3, 0x3C, 0xC3, 0x30, 0xDC, 0x37, 0x1D, 0xFE,
  0x7E, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x07, 0x81, 0xFE, 0x3C,
  0xF3, 0x07, 0x70, 0x36, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0xE7, 0x1C, 0x7F, 0xC3, 0xF0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x3E, 0x0F,
  0xE3, 0x3C, 0xC3, 0x30, 0xDC, 0x77, 0x39, 0xFC, 0x7E, 0x19, 0xCE, 0x73,
  0x8C, 0xC3, 0xB0, 0xE0, 0x07, 0x87, 0xF3, 0xC8, 0xE0, 0x30, 0x0E, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3A, 0x0C, 0xFF, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xE3, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06,
  0x03, 0x00, 0x38, 0x33, 0x83, 0x30, 0x73, 0x07, 0x70, 0x67, 0x06, 0x60,
  0xE6, 0x0E, 0x60, 0xEE, 0x0C, 0xE1, 0xC6, 0x1C, 0x7F, 0x83, 0xF0, 0xC0,
  0xF8, 0x1B, 0x07, 0x60, 0xCC, 0x39, 0x86, 0x39, 0xC7, 0x30, 0xEC, 0x0D,
  0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0xC3,
  0x87, 0xC3, 0x86, 0xC7, 0x8E, 0xC7, 0x8C, 0xCD, 0x9C, 0xCC, 0x98, 0xD8,
  0x98, 0xD8, 0xF0, 0xD8, 0xF0, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x1C,
  0x1C, 0x70, 0xE0, 0xC7, 0x03, 0x98, 0x06, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x76, 0x01, 0x9C, 0x0C, 0x30, 0x70, 0xC3, 0x83, 0x80,
  0xC1, 0xF0, 0x6E, 0x39, 0x9C, 0x66, 0x1B, 0x87, 0xC0, 0xE0, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x1F, 0xE7, 0xFC, 0x03, 0x00, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0F, 0xF9,
  0xFF, 0x00, 0x1E, 0x3C, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83,
  0x06, 0x1C, 0x30, 0x78, 0xF0, 0xCC, 0xC6, 0x66, 0x66, 0x67, 0x33, 0x33,
  0x1E, 0x3C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x87,
  0x0C, 0x78, 0xF0, 0x06, 0x01, 0x80, 0xF0, 0x3C, 0x19, 0x04, 0x63, 0x19,
  0x82, 0xE0, 0xC0, 0xFF, 0xDD, 0x80, 0x3E, 0xDF, 0xE6, 0x3B, 0x86, 0xE3,
  0xB0, 0xEC, 0x33, 0x1C, 0xFF, 0x1E, 0xC0, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x3F, 0xCF, 0x73, 0x8C, 0xC3, 0x30, 0xDC, 0x37, 0x1D, 0xC6, 0x7F, 0xB3,
  0xC0, 0x3F, 0x7B, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0xFE, 0x7E, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xE3, 0xFC, 0xF7, 0x18, 0xE7, 0x0C, 0xE3, 0x98,
  0x73, 0x0C, 0x63, 0x8F, 0xF0, 0xF6, 0x00, 0x3F, 0x39, 0xD8, 0xFC, 0x6F,
  0xF7, 0xC3, 0x01, 0xC0, 0xFE, 0x3F, 0x00, 0x00, 0x80, 0x7C, 0x0C, 0x83,
  0x80, 0x60, 0x3F, 0x07, 0xE0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x17, 0x03, 0xC0, 0x20, 0x00, 0x1F,
  0x67, 0xB8, 0xC7, 0x38, 0x67, 0x1C, 0xC3, 0x98, 0x63, 0x1C, 0x7F, 0x87,
  0xF0, 0x0C, 0x01, 0x8C, 0x71, 0xFC, 0x0E, 0x00, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x3F, 0xCF, 0x73, 0x8C, 0xC3, 0x30, 0xDC, 0x77, 0x1D, 0x86, 0x61,
  0xB8, 0xE0, 0x1C, 0x70, 0x00, 0x38, 0xE3, 0x0C, 0x31, 0xC7, 0x18, 0x63,
  0x80, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x38, 0x38, 0xF0, 0xF0, 0xC0, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x13, 0x8C, 0x73, 0x0C, 0xC1, 0xB0, 0x3E, 0x0F, 0xC1, 0xDC, 0x33,
  0x86, 0x39, 0xC7, 0x00, 0x1C, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x31, 0xC7,
  0x18, 0x63, 0x80, 0x37, 0xDF, 0x3D, 0xF7, 0x38, 0xE3, 0x30, 0xC7, 0x31,
  0xC7, 0x71, 0xC6, 0x71, 0x86, 0x61, 0x86, 0x61, 0x8E, 0xE3, 0x8E, 0x01,
  0x0D, 0xF3, 0xDC, 0xE3, 0x30, 0xCC, 0x37, 0x1D, 0xC7, 0x61, 0x98, 0x6E,
  0x38, 0x3F, 0x3F, 0xD8, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F, 0xCE, 0xFE, 0x3E,
  0x00, 0x1B, 0xE3, 0xDC, 0x71, 0x8C, 0x31, 0x86, 0x70, 0xCE, 0x39, 0xC6,
  0x3F, 0xC6, 0xF1, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x00, 0x3E, 0xDE,
  0xE6, 0x3B, 0x86, 0xE3, 0xB0, 0xEC, 0x33, 0x1C, 0xFF, 0x1F, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x3F, 0x9F, 0x8E, 0x06, 0x03, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x00, 0x3F, 0x73, 0x70, 0x78, 0x3C, 0x1E, 0x06,
  0x06, 0xFE, 0xFC, 0x18, 0x60, 0xC7, 0xFF, 0xCE, 0x18, 0x30, 0xE1, 0xC3,
  0x87, 0xC7, 0x80, 0x71, 0xD8, 0x76, 0x19, 0x86, 0xE3, 0xB8, 0xEC, 0x33,
  0x1C, 0xFF, 0x1E, 0xC0, 0xC3, 0xE1, 0xB9, 0xDC, 0xC6, 0xE3, 0x61, 0xF0,
  0xF0, 0x78, 0x38, 0x00, 0xC3, 0x0F, 0x1C, 0x7C, 0x59, 0xB3, 0x6E, 0xCD,
  0xB3, 0x67, 0xCD, 0x9E, 0x34, 0x78, 0x71, 0xC1, 0x87, 0x00, 0x38, 0xF1,
  0xDC, 0x0D, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xB0, 0x73, 0x8E,
  0x1C, 0x30, 0xE6, 0x18, 0xE7, 0x1C, 0xC1, 0xB8, 0x36, 0x06, 0xC0, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x0C, 0x0F, 0x81, 0xE0, 0x30, 0x00, 0x3F, 0x9F,
  0x81, 0xC1, 0xC1, 0xC1, 0xC0, 0xC0, 0xC0, 0xFE, 0x7F, 0x00, 0x03, 0x0F,
  0x0C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0xE0, 0xF0, 0x30, 0x30, 0x30, 0x60,
  0x60, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x1C, 0x0E, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x07, 0x0E, 0x18, 0x18, 0x38, 0x30, 0x30, 0xF0,
  0xE0, 0x78, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_SemiBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 6, 5, 8, 2, -14 },
  { 16, 12, 14, 12, 0, -14 },
  { 37, 9, 15, 10, 1, -14 },
  { 54, 14, 14, 16, 1, -14 },
  { 79, 12, 14, 13, 1, -14 },
  { 100, 3, 5, 5, 2, -14 },
  { 102, 6, 17, 6, 1, -14 },
  { 115, 6, 17, 6, -1, -14 },
  { 128, 9, 10, 10, 2, -15 },
  { 140, 9, 9, 11, 1, -11 },
  { 151, 4, 4, 5, -1, -2 },
  { 153, 6, 2, 6, 0, -6 },
  { 155, 3, 3, 5, 0, -3 },
  { 157, 10, 14, 8, -1, -14 },
  { 175, 9, 14, 10, 1, -14 },
  { 191, 7, 14, 10, 2, -14 },
  { 204, 10, 14, 10, 0, -14 },
  { 222, 10, 14, 10, 0, -14 },
  { 240, 10, 14, 10, 0, -14 },
  { 258, 10, 14, 10, 0, -14 },
  { 276, 10, 14, 10, 1, -14 },
  { 294, 10, 14, 10, 1, -14 },
  { 312, 9, 14, 10, 1, -14 },
  { 328, 9, 14, 10, 1, -14 },
  { 344, 5, 11, 5, 0, -11 },
  { 351, 6, 13, 5, -1, -11 },
  { 361, 9, 10, 11, 1, -12 },
  { 373, 9, 5, 11, 1, -9 },
  { 379, 9, 10, 11, 1, -12 },
  { 391, 8, 14, 9, 1, -14 },
  { 405, 15, 16, 16, 1, -14 },
  { 435, 11, 14, 11, -1, -14 },
  { 455, 10, 14, 12, 1, -14 },
  { 473, 11, 14, 11, 1, -14 },
  { 493, 11, 14, 13, 1, -14 },
  { 513, 10, 14, 10, 1, -14 },
  { 531, 10, 14, 10, 1, -14 },
  { 549, 12, 14, 13, 1, -14 },
  { 570, 12, 14, 13, 1, -14 },
  { 591, 9, 14, 7, -1, -14 },
  { 607, 9, 18, 6, -3, -14 },
  { 628, 12, 14, 11, 1, -14 },
  { 649, 7, 14, 10, 1, -14 },
  { 662, 16, 14, 16, 1, -14 },
  { 690, 13, 14, 14, 1, -14 },
  { 713, 12, 14, 14, 1, -14 },
  { 734, 10, 14, 11, 1, -14 },
  { 752, 12, 17, 14, 1, -14 },
  { 778, 10, 14, 11, 1, -14 },
  { 796, 10, 14, 10, 0, -14 },
  { 814, 9, 14, 10, 2, -14 },
  { 830, 12, 14, 13, 1, -14 },
  { 851, 11, 14, 11, 2, -14 },
  { 871, 16, 14, 17, 2, -14 },
  { 899, 14, 14, 11, -1, -14 },
  { 924, 10, 14, 10, 2, -14 },
  { 942, 11, 14, 10, 0, -14 },
  { 962, 7, 17, 6, 0, -14 },
  { 977, 4, 14, 8, 2, -14 },
  { 984, 7, 17, 6, -1, -14 },
  { 999, 10, 9, 11, 0, -14 },
  { 1011, 8, 1, 8, -2, 2 },
  { 1012, 3, 3, 6, 3, -15 },
  { 1014, 10, 10, 11, 1, -10 },
  { 1027, 10, 14, 11, 0, -14 },
  { 1045, 8, 10, 9, 1, -10 },
  { 1055, 11, 14, 11, 1, -14 },
  { 1075, 9, 10, 10, 1, -10 },
  { 1087, 11, 20, 7, -2, -15 },
  { 1115, 11, 15, 11, 0, -10 },
  { 1136, 10, 14, 11, 0, -14 },
  { 1154, 6, 14, 5, 0, -14 },
  { 1165, 8, 19, 5, -2, -14 },
  { 1184, 11, 14, 10, 0, -14 },
  { 1204, 6, 14, 5, 0, -14 },
  { 1215, 16, 10, 17, 0, -10 },
  { 1235, 10, 11, 11, 0, -11 },
  { 1249, 9, 10, 11, 1, -10 },
  { 1261, 11, 15, 11, -1, -10 },
  { 1282, 10, 15, 11, 1, -10 },
  { 1301, 9, 10, 8, 0, -10 },
  { 1313, 8, 10, 9, 0, -10 },
  { 1323, 7, 13, 7, 1, -13 },
  { 1335, 10, 10, 11, 1, -10 },
  { 1348, 9, 10, 9, 1, -10 },
  { 1360, 14, 10, 15, 1, -10 },
  { 1378, 12, 10, 10, -1, -10 },
  { 1393, 11, 15, 9, -1, -10 },
  { 1414, 9, 10, 9, 0, -10 },
  { 1426, 8, 17, 7, 0, -14 },
  { 1443, 2, 18, 10, 4, -14 },
  { 1448, 8, 17, 7, -1, -14 },
  { 1465, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_SemiBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMIBOLDITALIC19PT7B_H_
