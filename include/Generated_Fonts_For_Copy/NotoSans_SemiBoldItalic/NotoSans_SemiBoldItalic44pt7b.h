#ifndef _NOTOSANS_SEMIBOLDITALIC44PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x02,
  0x00, 0x3E, 0x3F, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C,
  0x7C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x70, 0x00,
  0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xCE, 0x18, 0x1F, 0x1C, 0x00, 0x3E, 0x38, 0x00, 0x7C, 0x70, 0x00, 0xF8,
  0xC0, 0x01, 0xFB, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xBF,
  0x00, 0x07, 0x3F, 0x00, 0x1C, 0x7E, 0x00, 0x38, 0xFC, 0x80, 0x71, 0xF1,
  0xC0, 0xE7, 0xE3, 0xF3, 0xBF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x04,
  0x0F, 0xF8, 0x00, 0x78, 0x1F, 0xF8, 0x00, 0xF0, 0x3F, 0xFC, 0x01, 0xF0,
  0x3E, 0x7C, 0x03, 0xE0, 0x7C, 0x3C, 0x03, 0xC0, 0x7C, 0x3C, 0x07, 0x80,
  0x78, 0x3C, 0x0F, 0x80, 0xF8, 0x3C, 0x1F, 0x00, 0xF8, 0x3C, 0x1E, 0x00,
  0xF8, 0x7C, 0x3C, 0x00, 0xF0, 0x7C, 0x7C, 0x00, 0xF0, 0x7C, 0xF8, 0x00,
  0xF0, 0x78, 0xF1, 0xF8, 0xF0, 0xF9, 0xE7, 0xFE, 0xF9, 0xF3, 0xEF, 0xFE,
  0xFF, 0xF7, 0xCF, 0xFF, 0x7F, 0xE7, 0x9F, 0x1F, 0x3F, 0xCF, 0x1F, 0x1F,
  0x1F, 0x1F, 0x3E, 0x1F, 0x00, 0x1E, 0x3E, 0x1F, 0x00, 0x3C, 0x3C, 0x1F,
  0x00, 0x7C, 0x3C, 0x1F, 0x00, 0xF8, 0x3C, 0x1E, 0x00, 0xF0, 0x7C, 0x1E,
  0x01, 0xE0, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0x3C, 0x7C,
  0x07, 0x80, 0x3E, 0xFC, 0x0F, 0x00, 0x3F, 0xF8, 0x1F, 0x00, 0x1F, 0xF0,
  0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xF8,
  0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x3E,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x01, 0xF8, 0x7F, 0xF8, 0x0F, 0x87, 0xF7, 0xE0,
  0xFC, 0x7E, 0x1F, 0x87, 0xC7, 0xE0, 0xFC, 0x7E, 0x3F, 0x03, 0xF7, 0xE1,
  0xF0, 0x0F, 0xFE, 0x1F, 0x80, 0x7F, 0xF0, 0xFC, 0x01, 0xFF, 0x07, 0xE0,
  0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x1F, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFE, 0x7F, 0x01, 0xFF, 0xC1, 0xFC,
  0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xE3, 0xC0, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x30, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0xCF, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xBF, 0x83, 0xFC,
  0x00, 0x3E, 0xF0, 0x03, 0xE7, 0x80, 0x7F, 0x3E, 0x01, 0xF0, 0xF0, 0x07,
  0x07, 0xC0, 0x10, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE1, 0xFC, 0x0F, 0x87,
  0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80,
  0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E,
  0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBE, 0x00, 0x7E, 0xF8,
  0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xFC, 0x07,
  0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x1F, 0x8F, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFE,
  0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0x7C, 0xFE, 0x7C,
  0x7C, 0xFC, 0x30, 0xFC, 0x20, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xF0, 0x7F, 0x01, 0xC0, 0x3F, 0x00, 0x80, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x70, 0x1F, 0x80, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE2, 0x00, 0x1F, 0xC7, 0x80, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xE1, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0xC1, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF1, 0x80, 0x0F, 0xC3, 0xE0, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE3, 0xF8, 0x07, 0xDF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xC7, 0xF0, 0xFE, 0x07,
  0xE3, 0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E,
  0x3F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xC1,
  0xF8, 0x1F, 0x83, 0xF8, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3F, 0x9F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3F, 0x07,
  0xE0, 0x3F, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0x81, 0xF8, 0x1F, 0x87,
  0xE0, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0xFC,
  0x01, 0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xF8, 0x3F, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xC1, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x07,
  0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x0F, 0xEF, 0xE0, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0x7C,
  0x1F, 0xF3, 0xE0, 0x3C, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE1, 0x81, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xC3,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xE0, 0x20, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xCE, 0x03, 0xF2, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x7F, 0x03, 0xC3, 0xC0, 0x7F, 0xF8,
  0x78, 0xF8, 0x1F, 0xFF, 0x0F, 0x9E, 0x07, 0xFF, 0xE0, 0xF7, 0xC1, 0xF0,
  0x78, 0x1E, 0xF0, 0x7C, 0x0F, 0x03, 0xDE, 0x0F, 0x01, 0xE0, 0x7B, 0xC3,
  0xE0, 0x7C, 0x1F, 0xF8, 0x78, 0x0F, 0x03, 0xDE, 0x0F, 0x01, 0xE0, 0x7B,
  0xC1, 0xE0, 0x3C, 0x0F, 0x78, 0x7C, 0x0F, 0x83, 0xEF, 0x0F, 0x81, 0xF0,
  0x79, 0xF0, 0xF0, 0x7C, 0x1F, 0x3E, 0x1F, 0x1F, 0xC7, 0xC7, 0xC3, 0xFF,
  0xFF, 0xF0, 0x78, 0x3F, 0xE7, 0xFC, 0x0F, 0x03, 0xF8, 0xFF, 0x01, 0xF0,
  0x08, 0x02, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0x00, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00,
  0x01, 0xFB, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x0F,
  0x80, 0x1F, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x3E,
  0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xF0, 0x7F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x1F,
  0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7C, 0x01, 0xF8,
  0x1F, 0x00, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83,
  0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xFE, 0x0F, 0x80, 0x7F,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0, 0x78,
  0x3F, 0x80, 0x08, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x08, 0x0F, 0xFC, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0x0F, 0xF8, 0x07, 0xC0, 0x3F, 0x80, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0xFF, 0x07, 0xC0, 0x7F,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0x03, 0xFC, 0x00, 0x20,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0xFC, 0xFC, 0x07, 0xFF, 0x9F, 0x80, 0xFF,
  0xF3, 0xF0, 0x1F, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFE, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0xF1, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF8,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3F,
  0x03, 0xF8, 0x01, 0xF0, 0x3F, 0x80, 0x0F, 0x83, 0xF8, 0x00, 0xFC, 0x3F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x7C,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3E,
  0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xEF,
  0x00, 0x1F, 0xF8, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0xFB, 0xC0, 0x0F, 0xBE,
  0x07, 0xDE, 0x00, 0x7B, 0xE0, 0x3E, 0xF0, 0x07, 0xDF, 0x01, 0xF7, 0x80,
  0x3C, 0xF8, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x1E, 0x7E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x1F, 0x01, 0xF3, 0xE0, 0xF8,
  0xF8, 0x1F, 0x8F, 0x0F, 0x8F, 0xC0, 0xF8, 0x78, 0x7C, 0x7E, 0x07, 0xC3,
  0xC7, 0xC3, 0xE0, 0x3E, 0x1E, 0x3E, 0x1F, 0x01, 0xF0, 0xF3, 0xE0, 0xF8,
  0x1F, 0x07, 0x9F, 0x0F, 0xC0, 0xF8, 0x3D, 0xF0, 0x7C, 0x07, 0xC1, 0xEF,
  0x83, 0xE0, 0x3E, 0x0F, 0xF8, 0x1F, 0x01, 0xF0, 0x7F, 0xC0, 0xF8, 0x1F,
  0x03, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0xC0, 0x7C, 0x07, 0xC0, 0xFE, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3E, 0x03,
  0xFE, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x03,
  0xFF, 0x00, 0x7C, 0x07, 0xDF, 0x00, 0x7C, 0x07, 0xDF, 0x00, 0x7C, 0x07,
  0xDF, 0x80, 0xFC, 0x07, 0xCF, 0x80, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0x0F,
  0x8F, 0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x87, 0xC1, 0xF8, 0x0F,
  0x87, 0xE1, 0xF0, 0x1F, 0x83, 0xE1, 0xF0, 0x1F, 0x03, 0xE1, 0xF0, 0x1F,
  0x03, 0xF1, 0xF0, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x01, 0xFB, 0xE0, 0x3F,
  0x00, 0xFB, 0xE0, 0x3E, 0x00, 0xFB, 0xE0, 0x3E, 0x00, 0xFF, 0xE0, 0x3E,
  0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x7F, 0xC0, 0x7C,
  0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x83, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0xFF, 0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0x07, 0xF8, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0x7E, 0x03, 0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x87,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3, 0xF0,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xC0, 0xE0, 0xFC, 0x00, 0x83, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x8C, 0x00, 0xFC, 0x3E, 0x1F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xF0,
  0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x01,
  0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E,
  0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03,
  0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF0, 0x03,
  0xE7, 0xE0, 0x0F, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0xC0, 0x1F, 0x9F, 0x80,
  0x7F, 0x80, 0x7E, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x3E, 0x03, 0xFE, 0x01,
  0xF0, 0x7C, 0x07, 0xBC, 0x07, 0xE0, 0xF8, 0x1F, 0x78, 0x0F, 0x81, 0xF0,
  0x3E, 0xF0, 0x3F, 0x03, 0xE0, 0xF9, 0xE0, 0x7C, 0x07, 0xC1, 0xF3, 0xC0,
  0xF8, 0x0F, 0x87, 0xC7, 0x83, 0xF0, 0x1F, 0x0F, 0x8F, 0x07, 0xC0, 0x3E,
  0x1E, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x7C,
  0xFC, 0x01, 0xF3, 0xE0, 0xF9, 0xF0, 0x03, 0xE7, 0xC1, 0xF3, 0xE0, 0x07,
  0xDF, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x0F,
  0xBE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xC0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xCF, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFE, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3E, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x1F,
  0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x00, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07,
  0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3D, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x01,
  0xF0, 0x78, 0x07, 0x81, 0xE0, 0x3E, 0x07, 0xC0, 0xF0, 0x0F, 0x07, 0x80,
  0x3C, 0x3E, 0x00, 0xF8, 0xF0, 0x01, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x0F,
  0xF8, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x3F,
  0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x1E, 0x00, 0xFC, 0x3E, 0x07, 0xFE, 0x7C,
  0x1F, 0xFC, 0xF0, 0x7F, 0xFF, 0xE1, 0xFE, 0x7F, 0xC3, 0xF0, 0x3F, 0x8F,
  0xC0, 0x7F, 0x1F, 0x80, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F,
  0x87, 0xF1, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0x78, 0x0F, 0xFC, 0xF0,
  0x0F, 0xE3, 0xE0, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x1F, 0x3F, 0xE0, 0x3E,
  0xFF, 0xE0, 0xFB, 0xFF, 0xC1, 0xFF, 0x1F, 0x83, 0xF8, 0x1F, 0x87, 0xE0,
  0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xF8, 0x03,
  0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E,
  0x3E, 0x00, 0xFC, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF8, 0x1F, 0x87,
  0xF8, 0x7F, 0x0F, 0xFF, 0xFC, 0x3E, 0xFF, 0xF0, 0x7C, 0xFF, 0xC0, 0xF0,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFE, 0x1C, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x04, 0x3F,
  0x83, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFF, 0xDF, 0x80, 0xFF, 0xEF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0x1F, 0xE0, 0x7E, 0x07, 0xF0, 0x7E, 0x03,
  0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0x00,
  0x7F, 0xE7, 0x80, 0x1F, 0xC3, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xC3, 0xF1, 0xF8, 0x1F, 0x3F, 0x01,
  0xF3, 0xE0, 0x1F, 0x7E, 0x03, 0xF7, 0xC0, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x87, 0xF0, 0x38, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x1F, 0x01, 0xFF, 0x9F, 0x03, 0xFF, 0xDE, 0x07, 0xFF, 0xFE, 0x0F, 0xF1,
  0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x1F, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFB, 0xE0, 0x1F, 0xF3, 0xE0, 0x0F, 0xE3, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x80, 0x0F,
  0xC0, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x8F, 0xE0,
  0x1F, 0x3F, 0xE0, 0x3E, 0xFF, 0xE0, 0xFB, 0xFF, 0xC1, 0xFF, 0x1F, 0xC3,
  0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F,
  0xC1, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xDF,
  0x80, 0x07, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xFC, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0x87, 0xF0, 0x1F, 0x80,
  0x78, 0xFF, 0x87, 0xFE, 0x07, 0x9F, 0xF8, 0xFF, 0xE0, 0xFB, 0xFF, 0xDF,
  0xFF, 0x0F, 0xF8, 0xFF, 0xE7, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0x0F, 0xE0,
  0x7F, 0x03, 0xF1, 0xFC, 0x07, 0xF0, 0x3F, 0x1F, 0x80, 0x7E, 0x03, 0xF1,
  0xF8, 0x07, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0xC0,
  0x3E, 0x3F, 0x00, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0x80, 0x7E, 0x3E, 0x00,
  0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x07, 0xC7,
  0xE0, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x00,
  0xFC, 0x7C, 0x03, 0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x00, 0xF8, 0xFC, 0x03,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0x87, 0xF0, 0x0F, 0x1F,
  0xF0, 0x3E, 0x7F, 0xF0, 0x7D, 0xFF, 0xE0, 0xFF, 0x8F, 0xE1, 0xFE, 0x0F,
  0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F,
  0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE1, 0xFE, 0x7F, 0x1F, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0,
  0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3E, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x01, 0xF8, 0xFE, 0x3F, 0x87, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xE1, 0xF8, 0x00, 0xF3,
  0xFF, 0x00, 0x7B, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xE3, 0xF0, 0x1F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x3F, 0x03, 0xFC, 0x3F, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFD, 0xFF, 0x80, 0x7C, 0x7F, 0x80, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x1E,
  0x07, 0xFE, 0x7C, 0x1F, 0xFE, 0xF0, 0x7F, 0xFF, 0xE1, 0xFE, 0x3F, 0xC3,
  0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0x7C, 0x7E, 0x00, 0xF8, 0xFC,
  0x01, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80,
  0x3E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x3F, 0x87, 0xF0, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8,
  0x0F, 0xF9, 0xF0, 0x0F, 0xE3, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xC7, 0xE0, 0xF1, 0xF8, 0x1E, 0x7F, 0x07, 0xDF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFC, 0x1C, 0x3F,
  0x00, 0x87, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF2, 0x00, 0x7E, 0x70, 0x1F, 0xCF, 0xFF,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x10, 0x7F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xE0, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F,
  0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8,
  0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00,
  0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F,
  0x87, 0xF1, 0xFF, 0x07, 0xFF, 0xBE, 0x0F, 0xFF, 0x7C, 0x0F, 0xFC, 0xF0,
  0x0F, 0xE1, 0xE0, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0x9F,
  0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x03,
  0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x8F, 0xC0,
  0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0xFC, 0x07, 0xF0, 0x1F, 0xBE, 0x03, 0xF8, 0x0F, 0xDF, 0x03, 0xFC,
  0x0F, 0xCF, 0x81, 0xFE, 0x07, 0xE7, 0xC1, 0xFF, 0x03, 0xE3, 0xE0, 0xF7,
  0x83, 0xF1, 0xF0, 0x7B, 0xC1, 0xF0, 0xF8, 0x7D, 0xE1, 0xF8, 0x7C, 0x3C,
  0xF0, 0xF8, 0x3E, 0x3E, 0x78, 0xFC, 0x1F, 0x1E, 0x3C, 0x7C, 0x0F, 0x9F,
  0x1E, 0x7E, 0x07, 0xCF, 0x0F, 0x3E, 0x03, 0xE7, 0x87, 0x9F, 0x01, 0xF7,
  0xC3, 0xDF, 0x00, 0xFB, 0xC1, 0xEF, 0x80, 0x7F, 0xE0, 0xF7, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xF8, 0x0F, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xC1,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E,
  0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x40, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x0B, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x3F, 0xFA, 0x00, 0x1F, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 32, 12, 1, -31 },
  { 49, 16, 11, 19, 4, -31 },
  { 71, 28, 31, 28, 1, -31 },
  { 180, 23, 36, 24, 1, -33 },
  { 284, 32, 32, 37, 3, -32 },
  { 412, 29, 32, 31, 1, -32 },
  { 528, 7, 11, 11, 4, -31 },
  { 538, 15, 38, 14, 2, -31 },
  { 610, 15, 39, 14, -3, -32 },
  { 684, 21, 21, 24, 4, -34 },
  { 740, 21, 21, 25, 3, -26 },
  { 796, 10, 11, 12, -2, -5 },
  { 810, 12, 5, 14, 1, -14 },
  { 818, 6, 7, 12, 1, -6 },
  { 824, 23, 32, 18, -2, -32 },
  { 916, 22, 32, 24, 2, -32 },
  { 1004, 16, 31, 24, 5, -31 },
  { 1066, 24, 32, 24, -1, -32 },
  { 1162, 23, 32, 24, 1, -32 },
  { 1254, 24, 31, 24, 0, -31 },
  { 1347, 23, 31, 24, 1, -31 },
  { 1437, 23, 32, 24, 2, -32 },
  { 1529, 24, 31, 24, 2, -31 },
  { 1622, 23, 32, 24, 1, -32 },
  { 1714, 21, 32, 24, 2, -32 },
  { 1798, 10, 25, 12, 1, -24 },
  { 1830, 13, 30, 12, -2, -24 },
  { 1879, 21, 22, 25, 3, -27 },
  { 1937, 21, 13, 25, 3, -22 },
  { 1972, 21, 22, 25, 3, -27 },
  { 2030, 18, 33, 20, 3, -32 },
  { 2105, 35, 35, 38, 2, -31 },
  { 2259, 27, 31, 27, -3, -31 },
  { 2364, 26, 31, 27, 1, -31 },
  { 2465, 25, 32, 27, 3, -32 },
  { 2565, 27, 31, 30, 1, -31 },
  { 2670, 24, 31, 23, 1, -31 },
  { 2763, 24, 31, 23, 1, -31 },
  { 2856, 27, 32, 30, 3, -32 },
  { 2964, 30, 31, 30, 1, -31 },
  { 3081, 19, 31, 16, -1, -31 },
  { 3155, 21, 40, 14, -7, -31 },
  { 3260, 29, 31, 26, 1, -31 },
  { 3373, 18, 31, 22, 1, -31 },
  { 3443, 37, 31, 38, 1, -31 },
  { 3587, 32, 31, 33, 1, -31 },
  { 3711, 28, 32, 32, 3, -32 },
  { 3823, 25, 31, 26, 1, -31 },
  { 3920, 28, 39, 32, 3, -32 },
  { 4057, 25, 31, 26, 1, -31 },
  { 4154, 22, 32, 23, 1, -32 },
  { 4242, 22, 31, 23, 4, -31 },
  { 4328, 28, 31, 30, 3, -31 },
  { 4437, 25, 31, 25, 4, -31 },
  { 4534, 39, 31, 39, 4, -31 },
  { 4686, 31, 31, 25, -2, -31 },
  { 4807, 24, 31, 24, 4, -31 },
  { 4900, 27, 31, 24, -1, -31 },
  { 5005, 18, 38, 14, -1, -31 },
  { 5091, 9, 32, 18, 5, -32 },
  { 5127, 18, 38, 14, -3, -31 },
  { 5213, 22, 21, 25, 1, -32 },
  { 5271, 18, 3, 18, -4, 4 },
  { 5278, 9, 7, 14, 6, -34 },
  { 5286, 23, 24, 26, 2, -24 },
  { 5355, 23, 33, 26, 1, -33 },
  { 5450, 19, 24, 21, 2, -24 },
  { 5507, 25, 33, 26, 2, -33 },
  { 5611, 20, 24, 24, 2, -24 },
  { 5671, 26, 45, 16, -5, -34 },
  { 5818, 24, 35, 26, 1, -24 },
  { 5923, 23, 33, 26, 1, -33 },
  { 6018, 12, 33, 12, 1, -33 },
  { 6068, 19, 44, 12, -6, -33 },
  { 6173, 25, 33, 24, 1, -33 },
  { 6277, 13, 33, 12, 1, -33 },
  { 6331, 36, 24, 39, 1, -24 },
  { 6439, 23, 24, 26, 1, -24 },
  { 6508, 21, 24, 25, 2, -24 },
  { 6571, 25, 35, 26, -1, -24 },
  { 6681, 23, 35, 26, 2, -24 },
  { 6782, 19, 24, 18, 1, -24 },
  { 6839, 19, 24, 20, 0, -24 },
  { 6896, 16, 29, 17, 2, -29 },
  { 6954, 23, 24, 26, 2, -24 },
  { 7023, 22, 24, 22, 2, -24 },
  { 7089, 33, 24, 34, 3, -24 },
  { 7188, 26, 24, 23, -2, -24 },
  { 7266, 27, 35, 22, -3, -24 },
  { 7385, 21, 24, 20, -1, -24 },
  { 7448, 18, 38, 16, 0, -31 },
  { 7534, 5, 43, 24, 10, -33 },
  { 7561, 18, 38, 16, -2, -31 },
  { 7647, 21, 7, 25, 3, -19 },
};

const GFXfont NotoSans_SemiBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMIBOLDITALIC44PT7B_H_
