#ifndef _NOTOSANS_SEMIBOLDITALIC18PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x73, 0x18, 0xC6, 0x60, 0x11, 0xCE, 0x00, 0xEF, 0x3C,
  0xB6, 0x98, 0x06, 0x60, 0x44, 0x04, 0xC0, 0xCC, 0x3F, 0xF4, 0x98, 0x19,
  0x81, 0x90, 0x7F, 0xE9, 0x30, 0x33, 0x03, 0x20, 0x26, 0x00, 0x02, 0x00,
  0x81, 0xFC, 0xFE, 0x36, 0x0D, 0x03, 0xC0, 0x7C, 0x07, 0x82, 0x68, 0xBB,
  0xFC, 0x7E, 0x06, 0x01, 0x00, 0x38, 0x33, 0xE1, 0x1B, 0x19, 0x99, 0x8C,
  0xD8, 0x66, 0xBB, 0xEF, 0xEE, 0xDB, 0x0C, 0x98, 0x4C, 0xC6, 0x66, 0x63,
  0xE6, 0x0F, 0x00, 0x0F, 0x03, 0xF0, 0xC6, 0x18, 0xC3, 0x30, 0x3C, 0x0F,
  0x1F, 0x67, 0xC6, 0xD8, 0xF3, 0x0E, 0x7F, 0xC7, 0xDC, 0xFB, 0x68, 0x0C,
  0x63, 0x0C, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0x18,
  0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x71, 0x86, 0x30, 0xC6, 0x30, 0x0C,
  0x08, 0x98, 0xF8, 0x3F, 0x39, 0xEC, 0x4C, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x37, 0x6C, 0x7F, 0xC0, 0x5F,
  0x80, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xE0, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x7E, 0x3E,
  0x1F, 0x0F, 0x86, 0xC3, 0x63, 0xB1, 0x9F, 0xC7, 0xC0, 0x0C, 0xF7, 0xFB,
  0x5C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x70, 0x0F, 0x0F, 0xE1, 0x1C, 0x07,
  0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFC, 0xFF, 0x00,
  0x1F, 0x0F, 0xE1, 0x1C, 0x07, 0x01, 0x81, 0xC1, 0xE0, 0x1C, 0x03, 0x80,
  0xE8, 0x3B, 0xFC, 0xFE, 0x00, 0x01, 0xC0, 0xE0, 0x78, 0x3E, 0x0D, 0x86,
  0xC3, 0x31, 0x8C, 0xFF, 0xFF, 0xE0, 0x60, 0x18, 0x06, 0x00, 0x1F, 0xC7,
  0xF1, 0x80, 0xE0, 0x30, 0x0F, 0x83, 0xF0, 0x0E, 0x01, 0x80, 0xE8, 0x33,
  0xFC, 0xFE, 0x00, 0x0F, 0x8F, 0xCE, 0x0E, 0x06, 0x07, 0xF3, 0xFD, 0xC6,
  0xC3, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x7F, 0xBF, 0xC0, 0xE0, 0x60, 0x70,
  0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0C, 0x0E, 0x00, 0x1F, 0x1F, 0xDC,
  0x6E, 0x37, 0x31, 0xF0, 0xF0, 0xCC, 0xC3, 0x61, 0xB0, 0xDF, 0xC7, 0xC0,
  0x1E, 0x3F, 0x98, 0xDC, 0x6E, 0x3F, 0x1B, 0x9C, 0xFE, 0x03, 0x03, 0x03,
  0x9F, 0x8F, 0x80, 0x31, 0xCC, 0x00, 0x00, 0x08, 0xE7, 0x00, 0x18, 0x71,
  0x80, 0x00, 0x00, 0x00, 0x31, 0x86, 0x30, 0x01, 0x83, 0xC7, 0x8F, 0x0E,
  0x03, 0x80, 0x78, 0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x78, 0xF1, 0xE0, 0x80, 0x00, 0x3C,
  0x7E, 0x47, 0x07, 0x06, 0x1C, 0x38, 0x30, 0x60, 0x00, 0x40, 0xE0, 0xE0,
  0x03, 0xE0, 0x3F, 0xC3, 0x81, 0x98, 0x03, 0x67, 0xEF, 0x33, 0x3C, 0xCC,
  0xF6, 0x33, 0xD8, 0x8B, 0x67, 0x6C, 0xEF, 0x30, 0x00, 0x70, 0x40, 0xFF,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0x78, 0x0F, 0x03, 0x60, 0xEC, 0x19, 0x87,
  0x30, 0xC6, 0x3F, 0xC7, 0xF9, 0xC3, 0xB0, 0x7E, 0x06, 0x3F, 0x0F, 0xE3,
  0x1C, 0xC7, 0x71, 0xDF, 0xE7, 0xE1, 0x8E, 0x61, 0xB8, 0x6C, 0x3B, 0xFC,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0xE1, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0xC7,
  0x18, 0x67, 0x0E, 0xC1, 0xD8, 0x33, 0x06, 0x61, 0xDC, 0x3B, 0x0E, 0x7F,
  0x8F, 0xC0, 0x3F, 0x9F, 0xCC, 0x06, 0x07, 0x03, 0xF9, 0xFC, 0xC0, 0x60,
  0x70, 0x30, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xCC, 0x06, 0x07, 0x03, 0x01,
  0xFC, 0xFC, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x00, 0x07, 0xC3, 0xFC, 0xE0,
  0xB8, 0x06, 0x00, 0xC0, 0x38, 0xF7, 0x3E, 0xE0, 0xDC, 0x39, 0x86, 0x3F,
  0xC3, 0xF8, 0x38, 0x73, 0x06, 0x30, 0x63, 0x06, 0x70, 0xE7, 0xFC, 0x7F,
  0xC6, 0x0C, 0x61, 0xCE, 0x1C, 0xC1, 0x8C, 0x18, 0xC1, 0x80, 0x3F, 0x3E,
  0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0xF8, 0xF8, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0x80, 0xC0, 0xE0, 0x61, 0xF0, 0xE0, 0x00, 0x38, 0xE6, 0x38, 0xC6, 0x19,
  0x87, 0x60, 0xDC, 0x1F, 0x03, 0xF0, 0x66, 0x1C, 0xC3, 0x1C, 0x61, 0x8C,
  0x38, 0x38, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x07, 0xFF,
  0xE0, 0x38, 0x1E, 0x70, 0x38, 0xF0, 0xF1, 0xE1, 0xE6, 0xC6, 0xCD, 0x8F,
  0x9B, 0x36, 0x36, 0x4C, 0x6D, 0x99, 0x9A, 0x33, 0x3C, 0xC6, 0x71, 0x8C,
  0x63, 0x00, 0x38, 0x33, 0x83, 0x3C, 0x33, 0xC3, 0x6C, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x63, 0x6C, 0x3C, 0xC3, 0xCC, 0x1C, 0xC1, 0xC0, 0x0F, 0x81,
  0xFC, 0x38, 0xE7, 0x06, 0x60, 0x7E, 0x07, 0xE0, 0x6E, 0x06, 0xE0, 0xEE,
  0x0E, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xE3, 0x1C, 0xC7, 0x71,
  0xD8, 0x67, 0xF9, 0xFC, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F,
  0x81, 0xFC, 0x38, 0xE7, 0x06, 0x60, 0x7E, 0x07, 0xE0, 0x6E, 0x06, 0xE0,
  0xEE, 0x0E, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x3F,
  0x0F, 0xE3, 0x18, 0xC7, 0x71, 0x98, 0xE7, 0xF1, 0xF8, 0x66, 0x39, 0x8C,
  0x73, 0x0C, 0xC3, 0x80, 0x0F, 0xC7, 0xE3, 0x88, 0xC0, 0x30, 0x0F, 0x01,
  0xE0, 0x3C, 0x03, 0x00, 0xC8, 0x33, 0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0x86,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x00,
  0x30, 0x73, 0x06, 0x30, 0x67, 0x06, 0x70, 0xE6, 0x0C, 0x60, 0xC6, 0x0C,
  0xE1, 0xCE, 0x18, 0xE3, 0x87, 0xF0, 0x3E, 0x00, 0xC1, 0xF0, 0x6C, 0x3B,
  0x0C, 0xC7, 0x31, 0x8C, 0xE3, 0x30, 0xDC, 0x1E, 0x05, 0x81, 0xC0, 0x70,
  0x00, 0xC3, 0x87, 0x87, 0x0F, 0x1E, 0x36, 0x3C, 0x6C, 0x59, 0xD9, 0xB3,
  0x33, 0x6E, 0x6C, 0xD8, 0xD9, 0xB1, 0xE3, 0xC3, 0xC7, 0x87, 0x0E, 0x0E,
  0x1C, 0x00, 0x18, 0x38, 0xE3, 0x83, 0x18, 0x19, 0x80, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1F, 0x80, 0xCC, 0x0C, 0x70, 0xE3, 0x8E, 0x0C, 0x00,
  0xC1, 0xE1, 0xF1, 0xCC, 0xC6, 0xC3, 0xE1, 0xE0, 0x60, 0x30, 0x38, 0x18,
  0x0C, 0x06, 0x00, 0x3F, 0xCF, 0xF0, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0,
  0x70, 0x38, 0x1C, 0x06, 0x03, 0xFC, 0xFF, 0x00, 0x1E, 0x3C, 0x61, 0x83,
  0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x3C, 0x78, 0xCC, 0xCC,
  0x66, 0x66, 0x66, 0x23, 0x30, 0x1E, 0x3C, 0x10, 0x60, 0xC1, 0x83, 0x0C,
  0x18, 0x30, 0x60, 0xC3, 0x06, 0x3C, 0x78, 0x06, 0x03, 0x80, 0xE0, 0x6C,
  0x13, 0x0C, 0x42, 0x1B, 0x87, 0xFF, 0xD9, 0x80, 0x1D, 0x9F, 0xDC, 0xFC,
  0x7C, 0x36, 0x1B, 0x1D, 0x8E, 0xFA, 0x3B, 0x00, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x3B, 0x8F, 0xE3, 0x9C, 0xC7, 0x31, 0xD8, 0x76, 0x19, 0xCE, 0x7F,
  0x37, 0x80, 0x1F, 0x3E, 0x70, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C,
  0x00, 0xC0, 0x30, 0x1C, 0x06, 0x1D, 0x8F, 0xE7, 0x3B, 0x8E, 0xC3, 0x30,
  0xCC, 0x33, 0x1C, 0xFE, 0x1F, 0x80, 0x1E, 0x3F, 0x63, 0xE3, 0xFE, 0xFC,
  0xC0, 0xC0, 0xFE, 0x7E, 0x01, 0xC0, 0xF0, 0x70, 0x18, 0x0F, 0x87, 0xE0,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0xF0, 0x3C, 0x00, 0x0E, 0xC7, 0xF3, 0x9D, 0xC7, 0x61, 0x98, 0x66, 0x39,
  0x8E, 0x7F, 0x0E, 0xC0, 0x30, 0x1C, 0xEE, 0x3F, 0x00, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x3B, 0x8F, 0xF3, 0x9C, 0xC7, 0x31, 0xDC, 0x66, 0x19, 0x86,
  0x63, 0xB8, 0xC0, 0x08, 0xC6, 0x03, 0x98, 0xC6, 0x33, 0x98, 0xC6, 0x70,
  0x02, 0x0C, 0x18, 0x00, 0xE1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83,
  0x0E, 0x18, 0xF1, 0xC0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0xCC, 0x63,
  0x30, 0xD8, 0x3C, 0x1F, 0x87, 0x61, 0x9C, 0x63, 0x38, 0xE0, 0x1C, 0x61,
  0x86, 0x38, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x63, 0x80, 0x33, 0x9C, 0x6F,
  0x7C, 0xE7, 0x99, 0x8E, 0x33, 0x18, 0x6E, 0x31, 0xD8, 0x63, 0x31, 0xC6,
  0x63, 0x8D, 0xC6, 0x38, 0x33, 0x8D, 0xF3, 0x9C, 0xC7, 0x31, 0xDC, 0x66,
  0x19, 0x86, 0x63, 0xB8, 0xC0, 0x1E, 0x1F, 0x98, 0xDC, 0x7C, 0x3E, 0x1B,
  0x0D, 0x8E, 0xFE, 0x3E, 0x00, 0x19, 0xC3, 0xF8, 0x73, 0x8C, 0x71, 0x8E,
  0x61, 0xCC, 0x31, 0xCE, 0x3F, 0x87, 0xE1, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x00, 0x1D, 0x9F, 0xDC, 0xFC, 0x7C, 0x36, 0x1B, 0x0D, 0x8E, 0xFE, 0x3B,
  0x01, 0x80, 0xC0, 0xE0, 0x60, 0x33, 0x37, 0x38, 0x30, 0x30, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0x1E, 0x3F, 0x70, 0x70, 0x38, 0x1E, 0x0E, 0x06, 0xFE,
  0xFC, 0x10, 0xC7, 0xFF, 0x61, 0x86, 0x38, 0xE3, 0x0F, 0x9E, 0x71, 0xB0,
  0xD8, 0x6C, 0x7E, 0x36, 0x1B, 0x1D, 0x8E, 0xFB, 0x3B, 0x00, 0xC3, 0xE1,
  0xB1, 0xD8, 0xCC, 0xE3, 0x61, 0xE0, 0xF0, 0x70, 0x38, 0x00, 0xC7, 0x1F,
  0x1C, 0x6C, 0xF3, 0xB3, 0xCC, 0xCB, 0x73, 0x6D, 0x8D, 0xB6, 0x3C, 0xF0,
  0xF3, 0xC3, 0x8E, 0x00, 0x38, 0xE3, 0x38, 0x76, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0xC1, 0xD8, 0x73, 0x1C, 0x70, 0x30, 0xE6, 0x18, 0xC7, 0x18, 0xC1,
  0xB8, 0x36, 0x07, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x0F, 0x01,
  0xC0, 0x00, 0x3F, 0x3F, 0x06, 0x0E, 0x1C, 0x38, 0x30, 0x60, 0xFE, 0xFE,
  0x06, 0x1C, 0x70, 0xC1, 0x83, 0x0C, 0x78, 0xE0, 0x60, 0xC1, 0x86, 0x0C,
  0x1C, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x38, 0x30, 0x60, 0xC1,
  0x83, 0x07, 0x0E, 0x30, 0x61, 0x83, 0x06, 0x3C, 0x60, 0x70, 0xFF, 0xE3,
  0xC0,
};

const GFXglyph NotoSans_SemiBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 6, 5, 8, 2, -13 },
  { 14, 12, 13, 12, 0, -13 },
  { 34, 10, 15, 10, 0, -14 },
  { 53, 13, 13, 15, 1, -13 },
  { 75, 11, 13, 13, 1, -13 },
  { 93, 3, 5, 4, 2, -13 },
  { 95, 6, 16, 6, 1, -13 },
  { 107, 6, 16, 6, -1, -13 },
  { 119, 8, 9, 10, 2, -14 },
  { 128, 9, 9, 10, 1, -11 },
  { 139, 4, 4, 5, -1, -2 },
  { 141, 5, 2, 6, 0, -6 },
  { 143, 3, 3, 5, 0, -3 },
  { 145, 10, 13, 7, -1, -13 },
  { 162, 9, 13, 10, 1, -13 },
  { 177, 6, 13, 10, 2, -13 },
  { 187, 10, 13, 10, 0, -13 },
  { 204, 10, 13, 10, 0, -13 },
  { 221, 10, 13, 10, 0, -13 },
  { 238, 10, 13, 10, 0, -13 },
  { 255, 9, 13, 10, 1, -13 },
  { 270, 9, 13, 10, 1, -13 },
  { 285, 9, 13, 10, 1, -13 },
  { 300, 9, 13, 10, 1, -13 },
  { 315, 5, 10, 5, 0, -10 },
  { 322, 6, 12, 5, -1, -10 },
  { 331, 9, 9, 10, 1, -11 },
  { 342, 9, 5, 10, 1, -9 },
  { 348, 9, 9, 10, 1, -11 },
  { 359, 8, 13, 8, 1, -13 },
  { 372, 14, 15, 15, 1, -13 },
  { 399, 11, 13, 11, -1, -13 },
  { 417, 10, 13, 11, 1, -13 },
  { 434, 11, 13, 11, 1, -13 },
  { 452, 11, 13, 12, 1, -13 },
  { 470, 9, 13, 10, 1, -13 },
  { 485, 9, 13, 9, 1, -13 },
  { 500, 11, 13, 12, 1, -13 },
  { 518, 12, 13, 12, 1, -13 },
  { 538, 8, 13, 7, 0, -13 },
  { 551, 9, 17, 6, -3, -13 },
  { 571, 11, 13, 11, 1, -13 },
  { 589, 7, 13, 9, 1, -13 },
  { 601, 15, 13, 16, 1, -13 },
  { 626, 12, 13, 13, 1, -13 },
  { 646, 12, 13, 13, 1, -13 },
  { 666, 10, 13, 11, 1, -13 },
  { 683, 12, 16, 13, 1, -13 },
  { 707, 10, 13, 11, 1, -13 },
  { 724, 10, 13, 9, 0, -13 },
  { 741, 9, 13, 9, 2, -13 },
  { 756, 12, 13, 12, 1, -13 },
  { 776, 10, 13, 10, 2, -13 },
  { 793, 15, 13, 16, 2, -13 },
  { 818, 13, 13, 10, -1, -13 },
  { 840, 9, 13, 10, 2, -13 },
  { 855, 10, 13, 10, 0, -13 },
  { 872, 7, 16, 6, 0, -13 },
  { 886, 4, 13, 7, 2, -13 },
  { 893, 7, 16, 6, -1, -13 },
  { 907, 10, 8, 10, 0, -13 },
  { 917, 8, 1, 7, -2, 2 },
  { 918, 3, 3, 6, 3, -14 },
  { 920, 9, 10, 11, 1, -10 },
  { 932, 10, 14, 11, 0, -14 },
  { 950, 8, 10, 9, 1, -10 },
  { 960, 10, 14, 11, 1, -14 },
  { 978, 8, 10, 10, 1, -10 },
  { 988, 10, 18, 6, -2, -14 },
  { 1011, 10, 14, 11, 0, -10 },
  { 1029, 10, 14, 11, 0, -14 },
  { 1047, 5, 14, 5, 0, -14 },
  { 1056, 7, 18, 5, -2, -14 },
  { 1072, 10, 14, 10, 0, -14 },
  { 1090, 6, 14, 5, 0, -14 },
  { 1101, 15, 10, 16, 0, -10 },
  { 1120, 10, 10, 11, 0, -10 },
  { 1133, 9, 10, 10, 1, -10 },
  { 1145, 11, 14, 11, -1, -10 },
  { 1165, 9, 14, 11, 1, -10 },
  { 1181, 8, 10, 7, 0, -10 },
  { 1191, 8, 10, 8, 0, -10 },
  { 1201, 6, 12, 7, 1, -12 },
  { 1210, 9, 10, 11, 1, -10 },
  { 1222, 9, 10, 9, 1, -10 },
  { 1234, 14, 10, 14, 1, -10 },
  { 1252, 11, 10, 9, -1, -10 },
  { 1266, 11, 14, 9, -1, -10 },
  { 1286, 8, 10, 8, 0, -10 },
  { 1296, 7, 16, 6, 0, -13 },
  { 1310, 2, 18, 10, 4, -14 },
  { 1315, 7, 16, 6, -1, -13 },
  { 1329, 9, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMIBOLDITALIC18PT7B_H_
