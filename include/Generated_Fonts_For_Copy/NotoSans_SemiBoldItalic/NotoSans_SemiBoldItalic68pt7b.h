#ifndef _NOTOSANS_SEMIBOLDITALIC68PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC,
  0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x9F,
  0xE0, 0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC,
  0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFE, 0x3C, 0x1E, 0x00, 0xFF, 0x87, 0x80, 0xC0, 0x1F, 0xE1,
  0xF0, 0x00, 0x07, 0xFC, 0x3E, 0x00, 0x00, 0xFF, 0x87, 0x80, 0x00, 0x1F,
  0xF0, 0xF0, 0x00, 0x03, 0xFE, 0x1E, 0x00, 0x00, 0x7F, 0xC7, 0xC0, 0x00,
  0x07, 0xFC, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xE7, 0xFE, 0x00, 0x00, 0x3C, 0x7F, 0xC0, 0x00, 0x0F, 0x87,
  0xF8, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x3C, 0x1F, 0xE0, 0x00, 0x07,
  0x83, 0xFC, 0x00, 0x01, 0xF0, 0x7F, 0x84, 0x00, 0x3E, 0x1F, 0xF0, 0xF0,
  0x07, 0xC7, 0xFC, 0x1F, 0xC0, 0xF1, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x7F, 0x0F, 0xFC, 0x3F, 0x81, 0xFE, 0x3F,
  0x8F, 0xFF, 0xC7, 0xF0, 0x7F, 0x1F, 0xC7, 0xFF, 0xF1, 0xFC, 0x3F, 0xC7,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1,
  0xFC, 0x7F, 0x8F, 0xF3, 0xFF, 0xF8, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0xFC,
  0x3F, 0x8F, 0xE0, 0x7F, 0x0F, 0xFE, 0x1F, 0xC7, 0xF8, 0x1F, 0xC1, 0xFE,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFE,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xEF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x1F, 0xFC, 0x7F, 0xC0,
  0x3F, 0xC1, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF9, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xF0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0x8F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x30, 0x01, 0xF8, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x7F, 0xC1, 0xF0, 0x00, 0x7F, 0xF3, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x07, 0xFC, 0xFC, 0x00, 0x0F, 0xF8, 0xFC, 0x00, 0x1F, 0xF0, 0xFE, 0x00,
  0x3F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xC0, 0x7F, 0x00,
  0x03, 0x80, 0x7F, 0x80, 0x01, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x07, 0x0F,
  0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE3, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC,
  0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xBF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0x7F, 0xC7, 0xFF, 0x3F,
  0xC1, 0xFF, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3C, 0x0F, 0xF8, 0x0C, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xF8,
  0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x10, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xF8, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x06, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x84, 0x00, 0x00, 0x1F, 0xF0,
  0xC0, 0x00, 0x0F, 0xFE, 0x1F, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xD0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x01, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xFF, 0xE0, 0x00, 0x80,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x08, 0x00, 0x00, 0x7F,
  0xE0, 0xE0, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xE7,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x02, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF1, 0xFF,
  0xF0, 0x03, 0xFE, 0x7F, 0xFF, 0x00, 0x7F, 0x9F, 0xFF, 0xF0, 0x0F, 0xF7,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x7F,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8,
  0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F,
  0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFE,
  0x1F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0x8F,
  0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x18, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x40, 0x01,
  0xFF, 0xC0, 0x3F, 0x9F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3F, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0x80, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0x1E,
  0x00, 0x3F, 0xE1, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xFF,
  0xC0, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x7E, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xF1, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xC7, 0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F,
  0x3F, 0x80, 0x7F, 0x80, 0x7E, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0x01, 0xF8,
  0x07, 0xF3, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFD, 0xF8, 0x0F,
  0xE0, 0x03, 0xF0, 0x07, 0xF7, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0x9F,
  0x80, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x03,
  0xFB, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xEF, 0xE0, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF3, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0xFE, 0x07, 0xFE, 0x0F, 0xF0,
  0x7E, 0x03, 0xFC, 0x7F, 0xFC, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0xF7, 0xFF,
  0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xF9, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xF0,
  0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x78, 0x01, 0xFF, 0xE0, 0x00, 0x18, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x1F, 0xFE, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xE1, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x1F, 0xF0, 0x01,
  0xFF, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xFF, 0xE3, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x3F, 0xE0, 0x02, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00,
  0x03, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF7, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x00,
  0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xE0, 0x07, 0xF7,
  0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xF0,
  0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7E, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F,
  0x80, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0xFF, 0x00,
  0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x83,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x3F,
  0xC0, 0xFC, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC7,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xF0, 0x03, 0xFC,
  0x07, 0xF3, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xFC,
  0x00, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xC0, 0x07,
  0xF7, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x87, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xCF,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xF1, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x03, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0x3F, 0xF0, 0x00,
  0x20, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x04, 0x00, 0x00, 0x7F, 0xC0,
  0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x00, 0x7F, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xF3, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF1,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x00,
  0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x01, 0xFC,
  0x3F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x03,
  0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xDF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0x80,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xE0,
  0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F,
  0xC0, 0x7E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0x00,
  0x3F, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0x8F,
  0xE0, 0x1F, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xBF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xFF, 0x7F, 0x80, 0x3F,
  0xFF, 0xE7, 0xF0, 0x01, 0xFF, 0xFC, 0x7F, 0x00, 0x0F, 0xFF, 0x87, 0xF0,
  0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x40, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF,
  0x0F, 0xFF, 0x00, 0x0F, 0xF3, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0xFF, 0xC0,
  0x1F, 0xEF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xDF,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xF1, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0xFF, 0x80, 0x7F, 0x3F,
  0xFF, 0xF0, 0x07, 0xF1, 0xFF, 0xFE, 0x00, 0x7F, 0x0F, 0xFF, 0xC0, 0x07,
  0xE0, 0x7F, 0xF0, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0x00, 0x60, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x02, 0x07, 0xFE, 0x00, 0x70, 0x1F, 0xFF, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0xFE, 0x3F, 0xC0, 0x03, 0xFF, 0xFE, 0x7F, 0x80, 0x0F, 0xFF, 0xFE,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFB, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0xFE,
  0x00, 0x1F, 0xFF, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0xF7, 0xF0, 0x00, 0x3F,
  0xFF, 0xCF, 0xE0, 0x00, 0x3F, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x3F,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x0F,
  0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F,
  0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xFC, 0x7F,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x7F, 0xE0, 0x00, 0xC0, 0x7F,
  0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x04, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07,
  0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x07, 0xFF, 0xF8, 0xFE, 0x00, 0x3F,
  0xFF, 0xE3, 0xF8, 0x01, 0xFF, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0xBF,
  0xE0, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0xFC, 0x00, 0x07,
  0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFB,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x20, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xFF,
  0x80, 0x0F, 0xF3, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xEF, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xDF, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x01, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x01, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x01,
  0xFD, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xE0, 0x7F, 0xE0, 0x00, 0xFE, 0x0F,
  0xFF, 0x80, 0x0F, 0xE3, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0xFF, 0xE0, 0x1F,
  0xEF, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03,
  0xFD, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x81,
  0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x3F, 0xFF, 0x80,
  0x01, 0xFC, 0xFF, 0xFF, 0x80, 0x07, 0xF3, 0xFF, 0xFF, 0x00, 0x0F, 0xEF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xFF,
  0xFE, 0x00, 0x3F, 0xCF, 0xFF, 0xF8, 0x00, 0x7F, 0x9F, 0xFF, 0xE0, 0x00,
  0xFF, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x07,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0x00, 0x1F, 0xFF, 0x07, 0xE0, 0x07, 0xFF, 0xF8, 0xFE, 0x00, 0xFF,
  0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFD, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x7F,
  0x80, 0x3F, 0xFF, 0xEF, 0xF0, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0x0F, 0xFF,
  0x8F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x00, 0x70, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07,
  0xF0, 0x3F, 0xC0, 0x3F, 0x83, 0xFE, 0x01, 0xFC, 0x7F, 0xF0, 0x0F, 0xE7,
  0xFF, 0x80, 0xFF, 0x7F, 0xF8, 0x07, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0x80, 0xFC, 0x0F, 0xF8, 0x00, 0xE0, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x40, 0x00,
  0x7F, 0xC3, 0x00, 0x07, 0xFE, 0x1F, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x83, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x1F, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xBF,
  0x80, 0x7F, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xF8, 0xFE, 0x00, 0xFF, 0xFE,
  0x1F, 0xC0, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xF7, 0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x07, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0xFF,
  0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF,
  0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x7E,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0xC3, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x7E, 0x03, 0xFE, 0x07, 0xF0,
  0x1F, 0xCF, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF1, 0xF8, 0x1F, 0xF0, 0x1F,
  0xC0, 0xFE, 0x3F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xC7, 0xE0, 0xFF, 0x80,
  0x7F, 0x07, 0xF0, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x1F, 0x83, 0xFC,
  0x01, 0xFC, 0x3F, 0x83, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x7E, 0x1F,
  0xE0, 0x07, 0xF0, 0xFC, 0x0F, 0xC7, 0xFC, 0x00, 0xFE, 0x3F, 0x81, 0xF8,
  0xFF, 0x00, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0xE0, 0x03, 0xF9, 0xFC, 0x07,
  0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xE0,
  0x1F, 0x9F, 0xC0, 0x01, 0xFD, 0xFC, 0x03, 0xF7, 0xF8, 0x00, 0x3F, 0xBF,
  0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x9F, 0xFF, 0x80, 0x00, 0xDF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0xC0, 0x00, 0xFF, 0xFC, 0x40, 0x00, 0x0F,
  0xF8, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 20, 50, 19, 1, -49 },
  { 126, 23, 18, 29, 7, -49 },
  { 178, 42, 49, 44, 2, -49 },
  { 436, 35, 56, 37, 2, -52 },
  { 681, 50, 50, 57, 4, -49 },
  { 994, 44, 50, 47, 2, -49 },
  { 1269, 10, 18, 16, 7, -49 },
  { 1292, 24, 60, 22, 3, -49 },
  { 1472, 24, 60, 22, -5, -49 },
  { 1652, 32, 32, 37, 6, -52 },
  { 1780, 33, 33, 39, 4, -41 },
  { 1917, 15, 17, 19, -3, -8 },
  { 1949, 19, 7, 22, 1, -22 },
  { 1966, 10, 11, 19, 1, -10 },
  { 1980, 35, 49, 27, -3, -49 },
  { 2195, 34, 50, 37, 3, -49 },
  { 2408, 25, 49, 37, 7, -49 },
  { 2562, 37, 49, 37, -1, -49 },
  { 2789, 35, 50, 37, 1, -49 },
  { 3008, 36, 49, 37, 0, -49 },
  { 3229, 36, 50, 37, 1, -49 },
  { 3454, 35, 50, 37, 3, -49 },
  { 3673, 36, 49, 37, 4, -49 },
  { 3894, 35, 50, 37, 2, -49 },
  { 4113, 33, 50, 37, 3, -49 },
  { 4320, 16, 39, 19, 1, -38 },
  { 4398, 21, 47, 19, -4, -38 },
  { 4522, 33, 35, 39, 4, -42 },
  { 4667, 32, 20, 39, 4, -34 },
  { 4747, 33, 35, 39, 4, -42 },
  { 4892, 27, 50, 30, 5, -49 },
  { 5061, 54, 55, 58, 3, -49 },
  { 5433, 41, 49, 41, -4, -49 },
  { 5685, 39, 49, 42, 2, -49 },
  { 5924, 40, 50, 41, 4, -49 },
  { 6174, 42, 49, 46, 2, -49 },
  { 6432, 37, 49, 36, 2, -49 },
  { 6659, 37, 49, 35, 2, -49 },
  { 6886, 42, 50, 47, 4, -49 },
  { 7149, 45, 49, 47, 2, -49 },
  { 7425, 30, 49, 25, -2, -49 },
  { 7609, 33, 63, 21, -11, -49 },
  { 7869, 45, 49, 40, 2, -49 },
  { 8145, 28, 49, 34, 2, -49 },
  { 8317, 57, 49, 59, 2, -49 },
  { 8667, 49, 49, 50, 2, -49 },
  { 8968, 43, 50, 49, 4, -49 },
  { 9237, 39, 49, 40, 2, -49 },
  { 9476, 43, 61, 49, 4, -49 },
  { 9804, 38, 49, 41, 2, -49 },
  { 10037, 35, 50, 35, 1, -49 },
  { 10256, 35, 49, 35, 6, -49 },
  { 10471, 42, 50, 47, 5, -49 },
  { 10734, 39, 49, 39, 6, -49 },
  { 10973, 59, 49, 60, 7, -49 },
  { 11335, 49, 49, 39, -4, -49 },
  { 11636, 37, 49, 37, 6, -49 },
  { 11863, 42, 49, 36, -2, -49 },
  { 12121, 27, 60, 21, -1, -49 },
  { 12324, 15, 49, 27, 7, -49 },
  { 12416, 28, 60, 21, -5, -49 },
  { 12626, 34, 31, 38, 2, -49 },
  { 12758, 28, 5, 27, -6, 6 },
  { 12776, 13, 11, 21, 10, -52 },
  { 12794, 36, 39, 40, 3, -38 },
  { 12970, 36, 53, 40, 1, -52 },
  { 13209, 30, 39, 32, 3, -38 },
  { 13356, 39, 53, 40, 3, -52 },
  { 13615, 32, 39, 36, 3, -38 },
  { 13771, 39, 68, 24, -7, -52 },
  { 14103, 38, 54, 40, 1, -38 },
  { 14360, 36, 52, 40, 1, -52 },
  { 14594, 20, 51, 19, 1, -51 },
  { 14722, 30, 67, 19, -9, -51 },
  { 14974, 39, 52, 37, 1, -52 },
  { 15228, 20, 52, 19, 1, -52 },
  { 15358, 56, 38, 61, 1, -38 },
  { 15624, 36, 38, 40, 1, -38 },
  { 15795, 33, 38, 39, 3, -37 },
  { 15952, 39, 54, 40, -2, -38 },
  { 16216, 36, 54, 40, 3, -38 },
  { 16459, 29, 38, 28, 1, -38 },
  { 16597, 29, 39, 31, 1, -38 },
  { 16739, 24, 46, 26, 3, -45 },
  { 16877, 35, 38, 40, 4, -37 },
  { 17044, 34, 37, 34, 3, -37 },
  { 17202, 51, 37, 52, 4, -37 },
  { 17438, 41, 37, 35, -3, -37 },
  { 17628, 42, 53, 34, -5, -37 },
  { 17907, 33, 37, 31, -1, -37 },
  { 18060, 28, 60, 24, 0, -49 },
  { 18270, 6, 68, 37, 16, -52 },
  { 18321, 27, 60, 24, -3, -49 },
  { 18524, 33, 10, 39, 4, -29 },
};

const GFXfont NotoSans_SemiBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMIBOLDITALIC68PT7B_H_
