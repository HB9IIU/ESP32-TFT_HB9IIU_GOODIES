#ifndef _NOTOSANS_SEMIBOLDITALIC34PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x00, 0x00, 0x0E, 0x0F,
  0x87, 0xC3, 0xE1, 0xE0, 0x3C, 0xF7, 0x8F, 0x78, 0xE7, 0x8E, 0x71, 0xE7,
  0x1C, 0x71, 0xC7, 0x1C, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x07, 0x8F, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0xE1, 0xC0, 0x0F,
  0x1E, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x70, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xDC,
  0x3C, 0xE2, 0x1E, 0x60, 0x0F, 0x30, 0x07, 0x98, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xDF, 0x00, 0xCF, 0x80,
  0x67, 0xD0, 0x33, 0xCE, 0x3B, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xE0,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xE0, 0x0F, 0x07, 0xF8, 0x07, 0x07, 0xBC, 0x07, 0x07, 0x8E, 0x07,
  0x83, 0xC7, 0x07, 0x81, 0xC3, 0x83, 0x81, 0xE1, 0xC3, 0x80, 0xF0, 0xE3,
  0xC0, 0x78, 0xF3, 0xC0, 0x3C, 0x79, 0xCF, 0x9E, 0x79, 0xCF, 0xEF, 0x7D,
  0xEF, 0xFB, 0xFD, 0xEF, 0x3C, 0xFC, 0xE7, 0x8E, 0x18, 0xE7, 0x87, 0x00,
  0xF3, 0xC7, 0x80, 0xF1, 0xE3, 0xC0, 0x70, 0xE1, 0xE0, 0x70, 0x70, 0xE0,
  0x78, 0x38, 0xF0, 0x78, 0x1E, 0x78, 0x38, 0x0F, 0xF8, 0x38, 0x03, 0xF8,
  0x3C, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC1, 0xF3, 0xEF, 0x87, 0x9F, 0x1F, 0x3E,
  0x78, 0x3C, 0xF3, 0xE0, 0xFF, 0x8F, 0x01, 0xFE, 0x3E, 0x03, 0xF0, 0xF8,
  0x0F, 0x83, 0xF9, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8, 0x1F, 0xE1,
  0xF0, 0x3D, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0xE0, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x03, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0x00, 0xD0, 0x00, 0xE0, 0x00, 0xE0, 0x41, 0xE0, 0x71, 0xC0, 0x7D,
  0xC0, 0xFF, 0xC3, 0x1F, 0xFF, 0x03, 0xFF, 0x07, 0xCF, 0x0E, 0xE0, 0x3E,
  0xE0, 0x7C, 0xF0, 0x38, 0xF0, 0x10, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x1F, 0x1E, 0x3E, 0x3C, 0x38, 0x78,
  0xF0, 0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0x39, 0xFF, 0xFF, 0x78, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xE0, 0xF8, 0xF8, 0xF8, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0xBE,
  0x03, 0xDF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x0F, 0xBE, 0x07, 0xCF, 0x07, 0xC7, 0x83,
  0xE3, 0xE7, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xF0,
  0x3F, 0x0F, 0xE3, 0xFE, 0x7F, 0xEF, 0xDE, 0x73, 0xE6, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x87, 0xC1, 0x81, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0x07, 0xC1, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x43, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x80, 0x1F, 0x3C, 0x1F, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0x78, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x87,
  0x81, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x18, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE2, 0x00, 0xF8, 0xF1, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFC, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x20, 0x1E, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x03,
  0xC7, 0xC7, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x0F, 0x07, 0x87, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1E, 0x0F, 0x07,
  0x83, 0xE3, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x03,
  0xF3, 0xE1, 0xF0, 0x78, 0x78, 0x1F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF8, 0x1F, 0x1F, 0x0F, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0,
  0x00, 0x00, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xF0, 0xF1,
  0xF0, 0x7C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x03,
  0xE7, 0x83, 0xF3, 0xE3, 0xF9, 0xFF, 0xF8, 0x7F, 0xBC, 0x1F, 0x9E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC6, 0x0F, 0xC3,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0x07, 0xC7, 0xE3, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0xF8, 0xFC, 0x7E, 0x1E, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0x07, 0x81, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF3, 0xC0, 0x78, 0x1C, 0xE0, 0xFF, 0xC7,
  0x78, 0x7F, 0xF1, 0xDC, 0x3C, 0x38, 0x7F, 0x1E, 0x0E, 0x1F, 0x87, 0x07,
  0x87, 0xE1, 0xC1, 0xE1, 0xF8, 0xF0, 0x70, 0x7E, 0x38, 0x1C, 0x3F, 0x8E,
  0x0F, 0x0E, 0xE3, 0xC3, 0xC7, 0xB8, 0xF3, 0xF3, 0xCE, 0x1F, 0xDF, 0xE3,
  0xC7, 0xE3, 0xF0, 0xF0, 0x20, 0x20, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x01, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xDC, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1E,
  0x01, 0xE0, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79,
  0xE0, 0x03, 0xDF, 0x00, 0x1F, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0xF8, 0x7E, 0x0F, 0x81, 0xE0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0,
  0x1E, 0x1F, 0x03, 0xE1, 0xE1, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xFF, 0x03, 0xE0, 0xF8, 0x3C, 0x07, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xE1, 0xF8, 0x02, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0x07, 0xF9, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x1F, 0xC0, 0xF8, 0x1F, 0x07, 0x80, 0xF8,
  0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80,
  0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF0, 0x07, 0xC7,
  0x80, 0x3E, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF0, 0x3F,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x41, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x07,
  0x0F, 0xC0, 0x08, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x81, 0xFF, 0x7C, 0x0F, 0xF3,
  0xE0, 0xFF, 0x9F, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x3E, 0x00,
  0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3F, 0xC7, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C,
  0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x83,
  0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C,
  0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0xFC, 0x1E, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF8,
  0x0F, 0x07, 0xC0, 0x3C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x1F,
  0x7C, 0x00, 0x79, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x3C, 0x01,
  0xF0, 0xF8, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0xC0, 0x78, 0x1F, 0x01, 0xE0,
  0x3C, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x81, 0xDE, 0x07, 0xBC, 0x1E, 0xF0, 0x39, 0xE0, 0xF7, 0x83,
  0xDF, 0x07, 0xBC, 0x1C, 0xF0, 0x3C, 0xE1, 0xE7, 0x83, 0xC7, 0x0E, 0x3C,
  0x1E, 0x38, 0xF1, 0xE0, 0xF1, 0xC7, 0x1F, 0x07, 0x8E, 0x78, 0xF0, 0x3C,
  0x73, 0x87, 0x83, 0xC3, 0xBC, 0x3C, 0x1E, 0x1F, 0xC1, 0xE0, 0xF0, 0xFE,
  0x1E, 0x07, 0x87, 0xE0, 0xF0, 0x3C, 0x3F, 0x07, 0x83, 0xC1, 0xF0, 0x3C,
  0x1E, 0x07, 0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x07, 0xE0, 0x0F, 0x07, 0xE0,
  0x0F, 0x0F, 0xE0, 0x1F, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0E, 0xF0,
  0x1E, 0x0E, 0x78, 0x1E, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x3C,
  0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78, 0x3C, 0x1E,
  0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x0F, 0x78, 0x78, 0x0F, 0x78, 0x78, 0x0F,
  0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0xF0, 0x03,
  0xE0, 0xF0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F,
  0x80, 0x1E, 0x3C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00,
  0x1F, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0xF8, 0x7C,
  0x07, 0xE1, 0xFC, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xF0, 0xF8,
  0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xC0,
  0x7C, 0x78, 0x1F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFE,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7E, 0x03, 0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00, 0x7D, 0xF0,
  0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x1E, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xFE, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xC3, 0xE0, 0xF8, 0x3E,
  0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0xF8,
  0x78, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0x1F, 0x01,
  0xE1, 0xE0, 0x3C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x87,
  0x80, 0xF0, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x00, 0x70, 0x01,
  0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1, 0xF8, 0x70, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x88, 0x07, 0xC7, 0x8F, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0,
  0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE1,
  0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0,
  0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1E,
  0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x1E,
  0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x1F, 0x03,
  0xE0, 0x7F, 0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x80, 0x7C, 0x78, 0x07,
  0x87, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78,
  0xF0, 0x03, 0x9E, 0x00, 0x39, 0xE0, 0x03, 0xBC, 0x00, 0x3F, 0xC0, 0x03,
  0xB8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x07, 0x80, 0x7F, 0xC0, 0x3E, 0x01, 0xEF, 0x00, 0xF8, 0x0F, 0xBC,
  0x07, 0xE0, 0x3C, 0xF0, 0x1F, 0x80, 0xF3, 0xC0, 0xFE, 0x07, 0x87, 0x03,
  0xF8, 0x1E, 0x1E, 0x0E, 0xE0, 0xF8, 0x78, 0x7B, 0x83, 0xC1, 0xE1, 0xCE,
  0x1F, 0x07, 0x8F, 0x38, 0x78, 0x1E, 0x3C, 0xE1, 0xE0, 0x79, 0xE3, 0xCF,
  0x01, 0xE7, 0x8F, 0x3C, 0x07, 0xBC, 0x3D, 0xE0, 0x1E, 0xF0, 0xF7, 0x80,
  0x7B, 0x83, 0xDE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0x70, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0xF8, 0x00, 0xF1, 0xF0,
  0x00, 0xF3, 0xE0, 0x00, 0xFB, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xC7, 0x80, 0x07, 0xC7, 0x80,
  0x0F, 0x87, 0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xEF, 0x00, 0xF1, 0xE0,
  0x3E, 0x3C, 0x0F, 0x87, 0xC1, 0xE0, 0x78, 0x7C, 0x0F, 0x1F, 0x01, 0xE3,
  0xC0, 0x3C, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0xE1, 0xE3, 0xC7,
  0x8F, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x87, 0x0F, 0x1E, 0x3C,
  0x78, 0x70, 0xE1, 0xE3, 0xC7, 0x8F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xF0, 0x1E, 0x38, 0x0E,
  0x1C, 0x0F, 0x07, 0x07, 0x03, 0x87, 0x01, 0xE7, 0x80, 0x73, 0x80, 0x3B,
  0xC0, 0x1E, 0xFF, 0xFF, 0xFF, 0xF0, 0xF9, 0xE7, 0x8F, 0x1C, 0x03, 0xC0,
  0x07, 0xF9, 0xC7, 0xFD, 0xE7, 0xFF, 0xF3, 0xE1, 0xF3, 0xE0, 0xF9, 0xE0,
  0x3D, 0xF0, 0x1E, 0xF8, 0x1F, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x03, 0xE7, 0x81, 0xF3, 0xC1, 0xF1, 0xF1, 0xF8, 0xFF, 0xFC, 0x3F, 0xDE,
  0x0F, 0xCE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x38, 0x1F, 0x7F, 0x0F, 0x7F,
  0x87, 0xFF, 0xE3, 0xF0, 0xF1, 0xF0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xF7, 0xC1, 0xF3,
  0xE0, 0xFB, 0xF8, 0xF9, 0xFF, 0xF8, 0xF7, 0xF8, 0x71, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3E, 0x09, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3F, 0x1C, 0x7F, 0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x1E, 0x3C, 0x0F, 0xE7, 0x83, 0xFE, 0xF0, 0xFF, 0xFE, 0x1F,
  0x0F, 0x87, 0xC1, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0xF8, 0xF0,
  0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xE1, 0xE0,
  0xF8, 0x3E, 0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xBC, 0x07, 0xE7, 0x00, 0x01,
  0xF0, 0x0F, 0xF8, 0x7F, 0xF9, 0xFD, 0xF3, 0xE1, 0xEF, 0x83, 0xDE, 0x07,
  0xFC, 0x1F, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0x87, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x0C, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF2, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x9F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0x01, 0xFE, 0x70, 0xFF, 0xBC, 0x7F, 0xFF, 0x1F, 0x0F, 0x8F,
  0x83, 0xE3, 0xC0, 0x79, 0xF0, 0x1E, 0x7C, 0x0F, 0x9E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x83, 0xE1, 0xF1, 0xF8,
  0x7F, 0xFE, 0x0F, 0xF7, 0x81, 0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x08, 0x07, 0x83, 0x87, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x38, 0x1F, 0x7F, 0x0F, 0x7F, 0xC7, 0xFF,
  0xE3, 0xF0, 0xF1, 0xF0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0xDF, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xFB,
  0xE0, 0x7D, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0x03, 0x03, 0xC3,
  0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1,
  0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0,
  0xF0, 0x78, 0x00, 0x00, 0x08, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x0B, 0xF0, 0x3F, 0x80, 0xFE,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x01, 0x1F, 0x07,
  0xC3, 0xC1, 0xF0, 0x78, 0x7C, 0x0F, 0x1F, 0x01, 0xE7, 0xC0, 0x7D, 0xF0,
  0x0F, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3E, 0x78, 0x07, 0x8F, 0x80, 0xF0, 0xF0, 0x3E, 0x1F, 0x07, 0xC1, 0xE0,
  0xF0, 0x3E, 0x1E, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0,
  0x3C, 0x00, 0x00, 0x1C, 0x07, 0x81, 0xE7, 0xF1, 0xFC, 0x1E, 0xFF, 0x3F,
  0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0x87, 0xE1, 0xF1, 0xF0, 0x7C, 0x1F, 0x3E,
  0x07, 0xC1, 0xF3, 0xE0, 0x78, 0x1E, 0x3C, 0x0F, 0x81, 0xE3, 0xC0, 0xF8,
  0x1E, 0x3C, 0x0F, 0x03, 0xE7, 0xC0, 0xF0, 0x3E, 0x78, 0x0F, 0x03, 0xC7,
  0x81, 0xF0, 0x3C, 0x78, 0x1E, 0x03, 0xCF, 0x81, 0xE0, 0x7C, 0xF8, 0x1E,
  0x07, 0x8F, 0x01, 0xE0, 0x78, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x3F, 0x87, 0xBF, 0xE3, 0xFF, 0xF1, 0xF8, 0x78, 0xF8, 0x3C, 0xF8, 0x1E,
  0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xE7, 0x80,
  0xF3, 0xC0, 0x79, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1E, 0x78, 0x0F, 0x3C,
  0x0F, 0x80, 0x01, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3E, 0x1F,
  0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF8, 0xFC, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0xF3, 0xF8, 0x1E, 0xFF, 0x03,
  0xFF, 0xF0, 0x7E, 0x1E, 0x0F, 0x83, 0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x3E,
  0x0F, 0x87, 0xC1, 0xF1, 0xFC, 0x7C, 0x3F, 0xFF, 0x07, 0xBF, 0xC0, 0xF3,
  0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0xF9, 0xC7, 0xFD, 0xE7, 0xFF, 0xF3, 0xE1, 0xF3, 0xE0, 0xF9, 0xE0, 0x3D,
  0xF0, 0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03,
  0xE7, 0x81, 0xF3, 0xC1, 0xF1, 0xF1, 0xF8, 0xFF, 0xFC, 0x3F, 0xDE, 0x0F,
  0x9E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x79, 0xF1, 0xEF,
  0xC7, 0xFF, 0x1F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xFC, 0x7F, 0xF8, 0xF9,
  0xE3, 0xE0, 0x47, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x60, 0x7C, 0xFF,
  0xF1, 0xFF, 0xE1, 0xFF, 0x00, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x7F,
  0xFF, 0xFE, 0xFF, 0xE3, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x8F, 0xF0, 0xFF,
  0x07, 0xF0, 0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF7, 0xC0,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x7C, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0xCF, 0x03, 0xE7, 0x83, 0xF3, 0xE3, 0xF1, 0xFF, 0xB8,
  0x7F, 0xBC, 0x1F, 0x9E, 0x00, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x07, 0x9E,
  0x07, 0xCF, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x3E, 0x07, 0xFC,
  0x1F, 0x83, 0xEF, 0x07, 0xE0, 0xF3, 0xC1, 0xF8, 0x7C, 0xF0, 0xEE, 0x1E,
  0x3C, 0x3B, 0x8F, 0x8F, 0x1E, 0xE3, 0xC3, 0xC7, 0x38, 0xF0, 0xF3, 0xCE,
  0x78, 0x3C, 0xE3, 0x9E, 0x0F, 0x78, 0xEF, 0x01, 0xDC, 0x3B, 0xC0, 0x77,
  0x0E, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00,
  0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xF8, 0x3E, 0x1F,
  0x00, 0xF0, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x7D, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x7C, 0x03, 0xC1,
  0xE0, 0x3E, 0x0F, 0x87, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x7C, 0x1E, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xE0, 0x0F, 0x0F, 0x80,
  0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0xF7, 0x80, 0x01, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x08, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x0F,
  0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x0C, 0x01, 0x7F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0x80, 0x18,
};

const GFXglyph NotoSans_SemiBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 24, 9, 1, -24 },
  { 28, 12, 9, 15, 3, -24 },
  { 42, 21, 24, 22, 1, -24 },
  { 105, 17, 28, 19, 1, -26 },
  { 165, 25, 25, 28, 2, -25 },
  { 244, 22, 25, 24, 1, -25 },
  { 313, 6, 9, 8, 3, -24 },
  { 320, 12, 29, 11, 1, -24 },
  { 364, 12, 30, 11, -2, -25 },
  { 409, 16, 16, 19, 3, -26 },
  { 441, 16, 16, 19, 2, -20 },
  { 473, 8, 8, 9, -2, -4 },
  { 481, 9, 4, 11, 1, -11 },
  { 486, 6, 5, 9, 0, -5 },
  { 490, 18, 24, 14, -2, -24 },
  { 544, 17, 25, 19, 1, -25 },
  { 598, 12, 24, 19, 4, -24 },
  { 634, 18, 25, 19, 0, -25 },
  { 691, 18, 25, 19, 0, -25 },
  { 748, 18, 24, 19, 0, -24 },
  { 802, 18, 24, 19, 1, -24 },
  { 856, 17, 25, 19, 2, -25 },
  { 910, 18, 24, 19, 2, -24 },
  { 964, 18, 25, 19, 1, -25 },
  { 1021, 17, 25, 19, 1, -25 },
  { 1075, 9, 19, 9, 0, -19 },
  { 1097, 11, 23, 9, -2, -19 },
  { 1129, 16, 17, 19, 2, -21 },
  { 1163, 16, 10, 19, 2, -17 },
  { 1183, 16, 17, 19, 2, -21 },
  { 1217, 13, 25, 15, 3, -25 },
  { 1258, 26, 27, 29, 2, -24 },
  { 1346, 21, 24, 21, -2, -24 },
  { 1409, 20, 24, 21, 1, -24 },
  { 1469, 20, 25, 21, 2, -25 },
  { 1532, 21, 24, 23, 1, -24 },
  { 1595, 18, 24, 18, 1, -24 },
  { 1649, 18, 24, 17, 1, -24 },
  { 1703, 21, 25, 23, 2, -25 },
  { 1769, 23, 24, 24, 1, -24 },
  { 1838, 15, 24, 12, -1, -24 },
  { 1883, 16, 31, 11, -5, -24 },
  { 1945, 22, 24, 20, 1, -24 },
  { 2011, 14, 24, 17, 1, -24 },
  { 2053, 29, 24, 29, 1, -24 },
  { 2140, 24, 24, 25, 1, -24 },
  { 2212, 22, 25, 25, 2, -25 },
  { 2281, 19, 24, 20, 1, -24 },
  { 2338, 22, 31, 25, 2, -25 },
  { 2424, 19, 24, 20, 1, -24 },
  { 2481, 17, 25, 18, 1, -25 },
  { 2535, 17, 24, 18, 3, -24 },
  { 2586, 22, 24, 23, 2, -24 },
  { 2652, 20, 24, 20, 3, -24 },
  { 2712, 30, 24, 30, 3, -24 },
  { 2802, 24, 24, 20, -2, -24 },
  { 2874, 19, 24, 18, 3, -24 },
  { 2931, 21, 24, 18, -1, -24 },
  { 2994, 14, 29, 11, -1, -24 },
  { 3045, 7, 24, 14, 4, -24 },
  { 3066, 13, 29, 11, -2, -24 },
  { 3114, 17, 15, 19, 1, -24 },
  { 3146, 14, 2, 14, -3, 3 },
  { 3150, 6, 5, 10, 5, -26 },
  { 3154, 17, 19, 20, 2, -19 },
  { 3195, 17, 26, 20, 1, -26 },
  { 3251, 14, 19, 16, 2, -19 },
  { 3285, 19, 26, 20, 2, -26 },
  { 3347, 15, 19, 18, 2, -19 },
  { 3383, 20, 34, 12, -4, -26 },
  { 3468, 18, 27, 20, 1, -19 },
  { 3529, 17, 26, 20, 1, -26 },
  { 3585, 9, 26, 10, 1, -26 },
  { 3615, 14, 34, 10, -4, -26 },
  { 3675, 19, 26, 18, 1, -26 },
  { 3737, 10, 26, 10, 1, -26 },
  { 3770, 28, 19, 30, 1, -19 },
  { 3837, 17, 19, 20, 1, -19 },
  { 3878, 16, 19, 20, 2, -19 },
  { 3916, 19, 27, 20, -1, -19 },
  { 3981, 17, 27, 20, 2, -19 },
  { 4039, 14, 19, 14, 1, -19 },
  { 4073, 15, 19, 16, 0, -19 },
  { 4109, 12, 22, 13, 2, -22 },
  { 4142, 17, 18, 20, 2, -18 },
  { 4181, 17, 18, 17, 2, -18 },
  { 4220, 26, 18, 26, 2, -18 },
  { 4279, 21, 18, 18, -2, -18 },
  { 4327, 22, 26, 17, -3, -18 },
  { 4399, 17, 18, 16, -1, -18 },
  { 4438, 14, 29, 12, 0, -24 },
  { 4489, 3, 34, 19, 8, -26 },
  { 4502, 14, 29, 12, -2, -24 },
  { 4553, 16, 6, 19, 2, -15 },
};

const GFXfont NotoSans_SemiBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMIBOLDITALIC34PT7B_H_
