#ifndef _NOTOSANS_SEMIBOLDITALIC28PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x00, 0x00, 0x70, 0x78, 0xF8, 0x70, 0x73, 0xB9, 0xFC,
  0xFC, 0x6E, 0x77, 0x3B, 0x1C, 0x01, 0xC6, 0x00, 0xC7, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x30, 0xC0, 0x18, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x06, 0x38,
  0x07, 0x1C, 0x03, 0x8C, 0x01, 0x86, 0x0F, 0xFF, 0xF7, 0xFF, 0xF8, 0x71,
  0x80, 0x31, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0C, 0x30, 0x0E, 0x38, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xF8, 0xF6, 0x23, 0x98,
  0x0E, 0x60, 0x3D, 0x80, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0D,
  0xE0, 0x27, 0x81, 0x9E, 0xC6, 0xF3, 0xFF, 0xCF, 0xFE, 0x0F, 0xC0, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0xE3, 0xF8, 0x1C, 0x7B, 0x83,
  0x87, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x38, 0xE0, 0xE3, 0x9C, 0x0E, 0x3B,
  0x80, 0xE7, 0x3B, 0xEE, 0xF7, 0x7F, 0xFE, 0xEF, 0x77, 0xDC, 0xE7, 0x01,
  0xDC, 0x70, 0x39, 0xC7, 0x07, 0x1C, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0xE1,
  0xC1, 0xCE, 0x38, 0x1F, 0xC7, 0x00, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x3F,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xFC, 0x3D, 0xF7, 0x0E, 0x71, 0xE7,
  0xBC, 0x3F, 0xCF, 0x07, 0xE3, 0xC1, 0xF8, 0xF0, 0x7C, 0x3F, 0xFF, 0x87,
  0xFE, 0xF0, 0xFE, 0x3E, 0x77, 0xFE, 0xEE, 0xC0, 0x03, 0xC0, 0xE0, 0x70,
  0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x83, 0xC0, 0x03, 0x80, 0x1C, 0x20,
  0xC1, 0xCE, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xE3, 0xE7, 0x3B, 0x03, 0xDC,
  0x3C, 0xE0, 0x43, 0x80, 0x10, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0xE7, 0x9C, 0x73, 0x8C, 0x00, 0xFF,
  0xFF, 0xF8, 0x73, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0x8F, 0x3C,
  0x3C, 0xE0, 0x77, 0x81, 0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0xF0, 0xF1, 0xFF, 0x87,
  0xFC, 0x07, 0xE0, 0x03, 0xC1, 0xF1, 0xFC, 0xFE, 0xFB, 0x9C, 0xE4, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x01, 0xC0, 0xF0, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x60, 0xF0,
  0x81, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x60, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x07, 0xF8, 0x0F,
  0xC0, 0x1F, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x80, 0x79, 0xFF, 0xE3, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xEF, 0x03, 0x9C, 0x0E,
  0x38, 0x3C, 0x70, 0xF1, 0xE1, 0xC3, 0xC7, 0x07, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC7, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x3F, 0xE0, 0xFF, 0xC3, 0x1F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x80, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x1F, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0xF0,
  0x7F, 0xF0, 0xFF, 0xF1, 0xF1, 0xE3, 0xC1, 0xCF, 0x03, 0x9E, 0x07, 0x3C,
  0x1E, 0x38, 0x3C, 0x70, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xF0,
  0x3F, 0xE1, 0xF7, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x9E,
  0x0F, 0xF0, 0x3F, 0x01, 0xFE, 0x1F, 0x3C, 0x70, 0x7B, 0xC1, 0xEE, 0x07,
  0xB8, 0x1E, 0xF0, 0x7B, 0xF7, 0xC7, 0xFE, 0x0F, 0xF0, 0x07, 0xE0, 0x7F,
  0xE1, 0xFF, 0x8F, 0x0E, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0x78,
  0x3D, 0xE3, 0xF3, 0xFF, 0x8F, 0xEE, 0x0F, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x04, 0x3C, 0x78, 0xF1,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0F, 0x3E, 0x78, 0x02, 0x0F,
  0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x38, 0x78, 0x70, 0xF0, 0xE0, 0xC0, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x1E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xF0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x03, 0xF0, 0x7E, 0x1F, 0xC1,
  0xF0, 0x0E, 0x00, 0x40, 0x00, 0x3F, 0x8F, 0xFD, 0xFF, 0xB0, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x7E, 0x1F, 0x03, 0xC0, 0x0E, 0x1E, 0x00, 0x1C, 0x70,
  0x30, 0x73, 0x87, 0xF8, 0xDC, 0x3F, 0xE3, 0x71, 0xC3, 0x0D, 0xCE, 0x1C,
  0x36, 0x38, 0x70, 0xF8, 0xE1, 0xC7, 0xE3, 0x06, 0x1F, 0x8C, 0x38, 0xEE,
  0x39, 0xE7, 0x98, 0xFD, 0xFC, 0x71, 0xE3, 0xC1, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x80, 0x40, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0E, 0xE0, 0x07, 0x70,
  0x07, 0x38, 0x07, 0x9C, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x81, 0xE1,
  0xC0, 0xE0, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x7F, 0xFE, 0x38, 0x0F, 0x3C,
  0x03, 0x9C, 0x01, 0xDE, 0x00, 0xFE, 0x00, 0x70, 0x0F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x1E,
  0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x38, 0x3C, 0x78, 0x1C, 0x78, 0x1E,
  0x78, 0x1C, 0x70, 0x3C, 0x70, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x02, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x10, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xC3,
  0xE1, 0xE0, 0xF0, 0xF0, 0x3C, 0x70, 0x1E, 0x38, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0xCE, 0x01, 0xE7, 0x00, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x78,
  0xE0, 0x7C, 0x70, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF0, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xFF, 0xC3, 0xFF, 0x87, 0xFF,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x08, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xE0, 0x63,
  0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x3F,
  0xBC, 0x3F, 0xDE, 0x1F, 0xCE, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x38, 0x78, 0x1C, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0x01,
  0xE1, 0xC0, 0x38, 0x38, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x07, 0x00, 0xE0, 0xE0, 0x3C, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0x83, 0x80, 0x70,
  0x70, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x00, 0x0F, 0xF8,
  0x7F, 0x81, 0xF8, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x01, 0xF8, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x82, 0xFC, 0x1F, 0xC0, 0xFC, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xC3, 0x81, 0xE0, 0xE0, 0xF0, 0x78, 0x78, 0x1E,
  0x3C, 0x07, 0x1E, 0x01, 0xCF, 0x00, 0x77, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x79, 0xE0, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xC3, 0xC0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x0F,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8,
  0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xB0, 0x3B, 0x87, 0x60, 0x77, 0x0E,
  0xE1, 0xDE, 0x3D, 0xC3, 0xBC, 0x73, 0x8E, 0x70, 0xE7, 0x1C, 0xE1, 0xCE,
  0x71, 0xC7, 0x9C, 0xE7, 0x8E, 0x3B, 0x8F, 0x1C, 0x77, 0x1C, 0x38, 0xFC,
  0x38, 0x71, 0xF8, 0x71, 0xE3, 0xE1, 0xE3, 0x83, 0xC3, 0x87, 0x07, 0x07,
  0x00, 0x0F, 0x00, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xE1, 0xF8, 0x0E, 0x1F,
  0xC0, 0xE1, 0xDC, 0x1E, 0x1D, 0xC1, 0xC1, 0xDE, 0x1C, 0x3C, 0xE1, 0xC3,
  0x8E, 0x1C, 0x38, 0xF3, 0xC3, 0x87, 0x38, 0x78, 0x73, 0x87, 0x87, 0xB8,
  0x70, 0x3B, 0x87, 0x03, 0xF8, 0x70, 0x3F, 0x0F, 0x01, 0xF0, 0xE0, 0x1F,
  0x0E, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xF3,
  0xC0, 0x7B, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x3E, 0x78, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F,
  0x1C, 0x0F, 0x3C, 0x1E, 0x3C, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x7F, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0xC3, 0xC1, 0xF3, 0xC0,
  0x7B, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3B, 0xC0, 0x3D, 0xE0, 0x3C,
  0x78, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF8, 0xF0, 0xF1, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x3C,
  0x3E, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x07, 0x8E, 0x0F, 0x1E, 0x1E, 0x3C,
  0x38, 0x38, 0x70, 0x79, 0xE0, 0xF3, 0xC0, 0xF7, 0x81, 0xE0, 0x07, 0xF8,
  0x3F, 0xF1, 0xFF, 0x8F, 0x02, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x81, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x7F, 0xFE, 0xFF,
  0xFB, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0x8E, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x38,
  0xE0, 0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x1C, 0x03, 0x9E, 0x03,
  0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x78, 0x3F,
  0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x1C,
  0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xF0, 0xF0, 0xF0, 0xE0,
  0xF1, 0xE0, 0x71, 0xC0, 0x73, 0xC0, 0x73, 0x80, 0x77, 0x80, 0x77, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xE0, 0x3C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x7C, 0x1E, 0xE0, 0x7C, 0x1E, 0xE0, 0xFC,
  0x1C, 0xE0, 0xFC, 0x3C, 0xE1, 0xDC, 0x38, 0xE1, 0xDC, 0x78, 0xE3, 0x9C,
  0x70, 0xE3, 0x9C, 0x70, 0xE7, 0x9C, 0xF0, 0xE7, 0x1C, 0xE0, 0xE7, 0x1D,
  0xE0, 0xEE, 0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x38, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x01, 0xC7, 0x80, 0x1E,
  0xF0, 0x01, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x79, 0xC0, 0x07, 0x1E, 0x00,
  0xF1, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0x80, 0x78,
  0xE0, 0x3F, 0xC0, 0x7B, 0xC1, 0xE7, 0x83, 0x87, 0x0F, 0x0E, 0x3C, 0x1E,
  0x70, 0x1D, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x80, 0x07, 0xE1, 0xFC,
  0x3F, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xC0, 0x3F, 0x07, 0xE0, 0xE3, 0x8E, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x1C, 0x71, 0xC7, 0x07, 0xE0, 0xFC,
  0x1F, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x3F, 0x87, 0xE0, 0x01, 0x80, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x0E, 0xE0, 0x3B, 0x81, 0xC6, 0x07, 0x1C, 0x38, 0x30, 0xC0, 0xE7,
  0x03, 0xB8, 0x06, 0xE0, 0x1C, 0xFF, 0xF0, 0xF3, 0x8E, 0x30, 0x0F, 0xCE,
  0x3F, 0xFC, 0xFF, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0E, 0x78,
  0x1C, 0xF0, 0x39, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0x87, 0xFF, 0x0F, 0xEE,
  0x0F, 0x9C, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xDF, 0x8F, 0xFE, 0x3F, 0x7C, 0xF8, 0xF3, 0xC1, 0xCE, 0x07,
  0x78, 0x1D, 0xE0, 0xF7, 0x03, 0xDC, 0x0E, 0x70, 0x7B, 0xE3, 0xEF, 0xFF,
  0x3B, 0xF8, 0xCF, 0xC0, 0x07, 0xF8, 0xFF, 0x8F, 0xDC, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x47,
  0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x0F, 0xDE, 0x1F, 0xFE, 0x3F, 0xFC, 0x3C,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0xF0, 0x7F, 0xF0, 0x7F, 0x70, 0x3E, 0x70, 0x07,
  0xF0, 0xFF, 0xCF, 0x9E, 0x78, 0x77, 0x83, 0xBC, 0x3D, 0xFF, 0xDF, 0xFC,
  0xFE, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x27, 0xDE, 0x1F, 0xF0, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFA, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xFC, 0x07, 0xFC, 0x09, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xCE, 0x3F, 0xFC,
  0xFF, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0E, 0x78, 0x1C, 0xF0,
  0x39, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0x87, 0xFF, 0x0F, 0xEE, 0x0F, 0xBC,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC3, 0x0F, 0x87, 0xFE, 0x0F, 0xF8, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xDF, 0x8F, 0xFF, 0x3F, 0xFC, 0xF8, 0x73, 0xC1, 0xCE, 0x0F, 0x78,
  0x3D, 0xE0, 0xF7, 0x03, 0x9C, 0x0E, 0x70, 0x7B, 0xC1, 0xEF, 0x07, 0xB8,
  0x1C, 0xE0, 0xF0, 0x0E, 0x1C, 0x78, 0x20, 0x00, 0x07, 0x1E, 0x3C, 0x78,
  0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x1E, 0x0F,
  0xE0, 0xFC, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x07, 0x9E, 0x1E, 0x3C, 0x78, 0x79, 0xE0, 0xE7,
  0x81, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3D, 0xE0, 0x71, 0xC1,
  0xE3, 0xC3, 0xC3, 0x87, 0x07, 0x8E, 0x0F, 0x80, 0x0F, 0x0E, 0x0E, 0x1E,
  0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70,
  0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0x1D, 0xF8, 0xF8, 0x77, 0xF3, 0xF8, 0xFF,
  0xFE, 0xF1, 0xF1, 0xF0, 0xF3, 0xC3, 0xE1, 0xE7, 0x07, 0x83, 0x9E, 0x0F,
  0x07, 0x3C, 0x1C, 0x1E, 0x70, 0x38, 0x3C, 0xE0, 0xF0, 0x79, 0xC1, 0xE0,
  0xE7, 0x83, 0x81, 0xCF, 0x07, 0x07, 0x9C, 0x0E, 0x0F, 0x38, 0x3C, 0x1C,
  0x00, 0x1D, 0xF8, 0xEF, 0xF3, 0xFF, 0xCF, 0x87, 0x3C, 0x1C, 0xF0, 0xF7,
  0x83, 0xDE, 0x0F, 0x78, 0x39, 0xC0, 0xE7, 0x07, 0xBC, 0x1E, 0xF0, 0x7B,
  0x81, 0xCE, 0x0F, 0x00, 0x07, 0xF0, 0x7F, 0xE3, 0xFF, 0x8F, 0x0F, 0x78,
  0x3D, 0xE0, 0xF7, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0x9C,
  0x3C, 0x7F, 0xF0, 0xFF, 0x81, 0xF8, 0x00, 0x07, 0x7E, 0x0E, 0xFE, 0x0F,
  0xDF, 0x0F, 0x0F, 0x0F, 0x07, 0x0E, 0x07, 0x1E, 0x07, 0x1E, 0x0F, 0x1C,
  0x0F, 0x1C, 0x0E, 0x1C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFC, 0x3B, 0xF8, 0x39,
  0xF0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x0F, 0xCE, 0x3F, 0xDC, 0xFF, 0xF1, 0xE1, 0xE7, 0x83,
  0xCF, 0x07, 0x9C, 0x0E, 0x78, 0x1C, 0xF0, 0x39, 0xE0, 0xF3, 0xC1, 0xE7,
  0x87, 0x87, 0xFF, 0x0F, 0xEE, 0x0F, 0xBC, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1D, 0xF3, 0xFE,
  0x3B, 0xE3, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xF1, 0xFF, 0x3C,
  0x73, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x01,
  0xE8, 0x1E, 0xF7, 0xCF, 0xFC, 0x7F, 0x00, 0x0E, 0x03, 0x81, 0xE1, 0xFF,
  0xFF, 0xCF, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xFC, 0x7F, 0x0F, 0xC0, 0x38, 0x3D, 0xE0, 0xF7, 0x83, 0x9C,
  0x0E, 0x70, 0x3B, 0xC1, 0xEF, 0x07, 0xBC, 0x1C, 0xE0, 0x73, 0x83, 0xCE,
  0x0F, 0x38, 0x7C, 0xFF, 0xE3, 0xFB, 0x87, 0xCE, 0x00, 0xF0, 0x3D, 0xC0,
  0xE7, 0x07, 0x9C, 0x1C, 0x70, 0xF1, 0xC3, 0x87, 0x1E, 0x1C, 0x70, 0x7B,
  0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0xE0, 0xF0, 0x7F, 0x0F, 0x87, 0xB8, 0x7C, 0x39, 0xC7, 0xE3, 0xCE, 0x3F,
  0x1E, 0x71, 0xB8, 0xE3, 0x9D, 0xCF, 0x1C, 0xEE, 0x70, 0xEE, 0x77, 0x87,
  0x73, 0xB8, 0x3F, 0x1D, 0xC1, 0xF8, 0xFC, 0x0F, 0x83, 0xE0, 0x7C, 0x1E,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F, 0x87, 0x0F, 0x03, 0xCF, 0x00, 0xE7,
  0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xBC, 0x03, 0x8E, 0x03, 0xC7, 0x03, 0xC3, 0xC3, 0xC0, 0xF0,
  0x1E, 0x07, 0x87, 0x03, 0xC3, 0x83, 0xC1, 0xC1, 0xC0, 0xE1, 0xE0, 0x70,
  0xE0, 0x3C, 0xF0, 0x0E, 0x70, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x00, 0x00, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFC, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0x7F, 0xE3, 0xFF, 0x00,
  0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x3E, 0x0F, 0xC0, 0xF0, 0x07, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xF0, 0x3E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xF0,
  0x1E, 0x0F, 0x83, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0xF0, 0x3E, 0x07, 0x80, 0x7C, 0x0F, 0xFD, 0xFF, 0xFF, 0x07, 0xE0,
};

const GFXglyph NotoSans_SemiBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 20, 8, 0, -20 },
  { 21, 9, 7, 12, 3, -20 },
  { 29, 17, 20, 18, 1, -20 },
  { 72, 14, 23, 15, 1, -21 },
  { 113, 20, 20, 23, 2, -20 },
  { 163, 18, 20, 19, 1, -20 },
  { 208, 4, 7, 7, 3, -20 },
  { 212, 10, 24, 9, 1, -20 },
  { 242, 10, 24, 9, -2, -20 },
  { 272, 13, 13, 15, 3, -21 },
  { 294, 13, 14, 16, 2, -17 },
  { 317, 6, 7, 8, -1, -3 },
  { 323, 7, 3, 9, 1, -9 },
  { 326, 5, 4, 8, 0, -4 },
  { 329, 14, 20, 11, -1, -20 },
  { 364, 14, 20, 15, 1, -20 },
  { 399, 10, 20, 15, 3, -20 },
  { 424, 15, 20, 15, 0, -20 },
  { 462, 15, 20, 15, 0, -20 },
  { 500, 15, 20, 15, 0, -20 },
  { 538, 14, 20, 15, 1, -20 },
  { 573, 15, 20, 15, 1, -20 },
  { 611, 14, 20, 15, 2, -20 },
  { 646, 14, 20, 15, 1, -20 },
  { 681, 14, 20, 15, 1, -20 },
  { 716, 7, 16, 8, 0, -16 },
  { 730, 8, 20, 8, -1, -16 },
  { 750, 13, 14, 16, 2, -17 },
  { 773, 13, 8, 16, 2, -14 },
  { 786, 13, 14, 16, 2, -17 },
  { 809, 11, 20, 13, 2, -20 },
  { 837, 22, 23, 24, 1, -20 },
  { 901, 17, 20, 17, -2, -20 },
  { 944, 16, 20, 17, 1, -20 },
  { 984, 16, 20, 17, 2, -20 },
  { 1024, 17, 20, 19, 1, -20 },
  { 1067, 15, 20, 15, 1, -20 },
  { 1105, 15, 20, 14, 1, -20 },
  { 1143, 17, 20, 19, 2, -20 },
  { 1186, 19, 20, 19, 1, -20 },
  { 1234, 13, 20, 10, -1, -20 },
  { 1267, 13, 26, 9, -4, -20 },
  { 1310, 18, 20, 17, 1, -20 },
  { 1355, 11, 20, 14, 1, -20 },
  { 1383, 23, 20, 24, 1, -20 },
  { 1441, 20, 20, 21, 1, -20 },
  { 1491, 17, 20, 20, 2, -20 },
  { 1534, 16, 20, 17, 1, -20 },
  { 1574, 17, 25, 20, 2, -20 },
  { 1628, 15, 20, 17, 1, -20 },
  { 1666, 14, 20, 15, 1, -20 },
  { 1701, 15, 20, 15, 2, -20 },
  { 1739, 17, 20, 19, 2, -20 },
  { 1782, 16, 20, 16, 3, -20 },
  { 1822, 24, 20, 25, 3, -20 },
  { 1882, 20, 20, 16, -2, -20 },
  { 1932, 15, 20, 15, 3, -20 },
  { 1970, 17, 20, 15, -1, -20 },
  { 2013, 11, 24, 9, 0, -20 },
  { 2046, 6, 20, 11, 3, -20 },
  { 2061, 11, 24, 9, -2, -20 },
  { 2094, 14, 13, 16, 1, -20 },
  { 2117, 12, 1, 11, -3, 3 },
  { 2119, 5, 4, 9, 4, -21 },
  { 2122, 15, 15, 16, 1, -15 },
  { 2151, 14, 21, 16, 1, -21 },
  { 2188, 13, 15, 13, 1, -15 },
  { 2213, 16, 21, 16, 1, -21 },
  { 2255, 13, 15, 15, 1, -15 },
  { 2280, 16, 28, 10, -3, -21 },
  { 2336, 15, 22, 17, 1, -15 },
  { 2378, 14, 21, 17, 1, -21 },
  { 2415, 7, 21, 8, 1, -21 },
  { 2434, 12, 28, 8, -4, -21 },
  { 2476, 15, 21, 15, 1, -21 },
  { 2516, 8, 21, 8, 1, -21 },
  { 2537, 23, 15, 25, 1, -15 },
  { 2581, 14, 15, 17, 1, -15 },
  { 2608, 14, 15, 16, 1, -15 },
  { 2635, 16, 22, 16, -1, -15 },
  { 2679, 15, 22, 16, 1, -15 },
  { 2721, 12, 15, 12, 1, -15 },
  { 2744, 12, 15, 13, 0, -15 },
  { 2767, 10, 18, 11, 1, -18 },
  { 2790, 14, 15, 17, 2, -15 },
  { 2817, 14, 15, 14, 1, -15 },
  { 2844, 21, 15, 21, 2, -15 },
  { 2884, 17, 15, 14, -1, -15 },
  { 2916, 17, 22, 14, -2, -15 },
  { 2963, 13, 15, 13, 0, -15 },
  { 2988, 12, 24, 10, 0, -20 },
  { 3024, 2, 28, 15, 7, -21 },
  { 3031, 11, 24, 10, -1, -20 },
  { 3064, 13, 4, 16, 2, -12 },
};

const GFXfont NotoSans_SemiBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMIBOLDITALIC28PT7B_H_
