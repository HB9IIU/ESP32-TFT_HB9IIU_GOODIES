#ifndef _NOTOSANS_SEMIBOLDITALIC23PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x60, 0xC0, 0x00,
  0x0E, 0x3C, 0x78, 0x77, 0x67, 0x66, 0x66, 0xC6, 0xC6, 0x07, 0x38, 0x18,
  0xC0, 0x63, 0x01, 0x98, 0x7F, 0xFD, 0xFF, 0xF0, 0xCE, 0x07, 0x30, 0x18,
  0xC3, 0xFF, 0xEF, 0xFF, 0x8C, 0x60, 0x31, 0x80, 0xCE, 0x07, 0x30, 0x18,
  0xC0, 0x01, 0x80, 0xF0, 0x7F, 0x9F, 0xF3, 0xA2, 0xE4, 0x0E, 0x81, 0xF0,
  0x1F, 0x80, 0xF8, 0x17, 0x06, 0xE0, 0xDD, 0x9F, 0xBF, 0xE3, 0xF0, 0x18,
  0x03, 0x00, 0x0C, 0x00, 0x1F, 0x83, 0x8D, 0xC3, 0x8E, 0x61, 0x86, 0x31,
  0x83, 0x19, 0x81, 0x9D, 0xC1, 0xCC, 0xDE, 0x6E, 0xDF, 0xBE, 0xEC, 0xCE,
  0xEE, 0x60, 0x66, 0x30, 0x63, 0x18, 0x71, 0x9C, 0x70, 0xCC, 0x30, 0x7E,
  0x30, 0x1E, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0xE3, 0x81, 0xC6,
  0x03, 0x9C, 0x07, 0x70, 0x07, 0xC0, 0x1E, 0x02, 0xFE, 0x3B, 0xCE, 0x77,
  0x1D, 0xCE, 0x1F, 0x1C, 0x1E, 0x3C, 0xFC, 0x7F, 0xF8, 0x7F, 0x3C, 0x76,
  0x66, 0xCC, 0x07, 0x0C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0xE0, 0xE0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x06, 0x03,
  0x01, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x00, 0x04, 0x00,
  0xE0, 0x18, 0x33, 0x0F, 0xE0, 0x7F, 0xC3, 0xF9, 0xF0, 0x77, 0x0E, 0x60,
  0x8E, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF, 0xF8,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x39, 0xDC, 0xE6, 0x60, 0x7F, 0xF8,
  0x7F, 0xF0, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x9C, 0x77, 0x8E, 0xE1,
  0xDC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1D, 0xC3, 0xBC,
  0xE3, 0xF8, 0x3E, 0x00, 0x07, 0x8F, 0x8F, 0xDF, 0xE6, 0x70, 0x38, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x03, 0x80,
  0xFE, 0x3F, 0xF1, 0x87, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xEF, 0xFE, 0xFF, 0xC0,
  0x03, 0x81, 0xFE, 0x1F, 0xF0, 0x87, 0x00, 0x70, 0x07, 0x00, 0xF0, 0xFE,
  0x0F, 0x00, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xC1, 0xEF, 0xFC,
  0x7F, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0x60, 0xEE, 0x1C,
  0xE1, 0x8E, 0x30, 0xC7, 0x1C, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x0F, 0xF8, 0x7F, 0x83, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xFF, 0x07, 0xFC, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x61,
  0xE3, 0xFF, 0x0F, 0xE0, 0x00, 0xE0, 0x7F, 0x0F, 0xE1, 0xC0, 0x38, 0x03,
  0x00, 0x71, 0x07, 0xFC, 0x7F, 0xCF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE,
  0x1C, 0x73, 0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0x03, 0x81, 0xFE, 0x1F, 0xE3, 0x87,
  0x38, 0x73, 0x86, 0x38, 0xE1, 0xFC, 0x1F, 0x03, 0xF8, 0x71, 0xCE, 0x1C,
  0xE0, 0xCE, 0x1C, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x07, 0x03, 0xF8, 0xFF,
  0xBC, 0x77, 0x0E, 0xE1, 0xD8, 0x3B, 0x87, 0x71, 0xEF, 0xFC, 0xFB, 0x00,
  0xE0, 0x1C, 0x07, 0x21, 0xE7, 0xF8, 0xFC, 0x00, 0x18, 0xF3, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x3C, 0xF0, 0x0C, 0x3C, 0x78, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE1, 0xC7, 0x0C, 0x38, 0x60, 0x00, 0x20, 0x1C, 0x0F,
  0x87, 0x83, 0xC1, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3C, 0x01, 0x80,
  0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x78, 0x3E, 0x3E, 0x1F, 0x03,
  0x80, 0x40, 0x00, 0x1C, 0x7F, 0xBF, 0xE8, 0x70, 0x38, 0x1C, 0x1C, 0x1C,
  0x3C, 0x1C, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x03,
  0xFE, 0x01, 0xF7, 0xC1, 0xC0, 0x38, 0xE0, 0x07, 0x30, 0xF8, 0xD8, 0xFF,
  0x36, 0x31, 0x8F, 0x98, 0x63, 0xC6, 0x18, 0xF1, 0x8E, 0x3C, 0xE3, 0x1B,
  0x19, 0xCE, 0xE7, 0xDF, 0x18, 0xC3, 0x07, 0x00, 0x00, 0xE0, 0x20, 0x1F,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1B, 0x00, 0xEC, 0x03,
  0x30, 0x1C, 0xC0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x7F, 0xE1, 0xFF, 0x8F,
  0xFE, 0x70, 0x39, 0xC0, 0x6E, 0x01, 0xB8, 0x07, 0x1F, 0xF0, 0xFF, 0x86,
  0x1E, 0x70, 0x73, 0x83, 0x9C, 0x38, 0xFF, 0x87, 0xF0, 0x7F, 0xE3, 0x87,
  0x9C, 0x1C, 0xE0, 0xEE, 0x0F, 0x71, 0xF3, 0xFF, 0x1F, 0xE0, 0x00, 0xE0,
  0x1F, 0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xC6,
  0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC1, 0xC7, 0x8E, 0x0E, 0x38,
  0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x07, 0x70, 0x3D, 0xC0, 0xE7, 0x03, 0x9C,
  0x1E, 0xE0, 0xF3, 0x9F, 0x8F, 0xFC, 0x3F, 0xC0, 0x1F, 0xF1, 0xFF, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xC3, 0xFC, 0x7F, 0xC7, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFC, 0x7F, 0xC7, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC7, 0x81, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xFD,
  0xC7, 0xEF, 0x03, 0xBC, 0x0E, 0x70, 0x39, 0xC0, 0xC7, 0xC7, 0x0F, 0xFC,
  0x1F, 0xE0, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x31, 0xC0, 0xE3, 0x81, 0xC7,
  0x03, 0x8F, 0xFF, 0x1F, 0xFC, 0x7F, 0xF8, 0xE0, 0x71, 0xC0, 0xE3, 0x81,
  0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0x0F, 0xE1, 0xF8, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x1F, 0x87, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC3, 0xF8, 0x7E, 0x07, 0x00, 0x1C,
  0x3E, 0x38, 0x70, 0x61, 0xC1, 0xC7, 0x03, 0x9C, 0x07, 0x70, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xF7, 0x01, 0xCE, 0x03, 0x8E, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0x1E,
  0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x1F, 0x1F, 0x03, 0x63, 0xF0, 0xFC, 0x7E,
  0x1B, 0x8D, 0xC7, 0x71, 0xB8, 0xCC, 0x73, 0x3B, 0x8E, 0x66, 0x71, 0xCD,
  0xCE, 0x31, 0xB1, 0xCE, 0x3E, 0x31, 0xC7, 0x8E, 0x38, 0xF1, 0xC6, 0x1C,
  0x38, 0x1E, 0x07, 0x1E, 0x07, 0x1E, 0x06, 0x3F, 0x06, 0x3F, 0x0E, 0x3B,
  0x8E, 0x33, 0x8E, 0x33, 0x8C, 0x71, 0xCC, 0x71, 0xDC, 0x71, 0xDC, 0x60,
  0xFC, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0x78, 0xE0, 0x78, 0x01, 0xE0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xF0, 0xE3, 0x80, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1F,
  0x3E, 0x1F, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x86, 0x1E, 0x70, 0x73,
  0x83, 0x9C, 0x1C, 0xE1, 0xC6, 0x7E, 0x7F, 0xE3, 0xFC, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xF0, 0xE3, 0x80, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1F, 0x3C, 0x1F,
  0xF0, 0x1F, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1F,
  0xE1, 0xFF, 0x1C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0xF3, 0xFE, 0x7F,
  0xC7, 0xF8, 0x73, 0x87, 0x1C, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F, 0x03,
  0xC0, 0xFF, 0x1F, 0xF1, 0xC1, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0xC3, 0xCF, 0xF8, 0x7F,
  0x00, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x38, 0x1C, 0xE0, 0x77, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE0, 0xE3,
  0xCF, 0x87, 0xFC, 0x0F, 0xC0, 0xE0, 0x3F, 0x03, 0xB8, 0x1D, 0xC1, 0xC6,
  0x0E, 0x30, 0xE1, 0x87, 0x0C, 0x70, 0x73, 0x83, 0xB8, 0x1D, 0xC0, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x06,
  0xE0, 0xF0, 0xEE, 0x1F, 0x0E, 0xE1, 0xF1, 0xCE, 0x3F, 0x1C, 0xE3, 0x73,
  0x8E, 0x77, 0x38, 0x66, 0x33, 0x06, 0xE3, 0x70, 0x6C, 0x36, 0x06, 0xC3,
  0xE0, 0x7C, 0x3E, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x03, 0x80, 0x1E,
  0x0F, 0x0E, 0x1E, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x70, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x3C,
  0x70, 0x38, 0x70, 0x70, 0x70, 0xE0, 0x38, 0xE0, 0x7B, 0x07, 0x1C, 0x78,
  0xE3, 0x87, 0x38, 0x19, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xFF, 0x3F,
  0xF8, 0x0F, 0x87, 0xC7, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x3E, 0x1F, 0x00,
  0xE1, 0x86, 0x18, 0x71, 0xC7, 0x0C, 0x30, 0xC3, 0x0E, 0x38, 0xE1, 0x86,
  0x1C, 0x0F, 0xC3, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x07,
  0xC3, 0xE0, 0x02, 0x00, 0xE0, 0x1C, 0x07, 0x81, 0xD8, 0x33, 0x0C, 0x61,
  0x86, 0x60, 0xDC, 0x1F, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xE3, 0x8C, 0x70,
  0x06, 0x01, 0xF7, 0x3F, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE1, 0xCE, 0x1C, 0xF3, 0xC7, 0xFC, 0x7D, 0x80, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0xC1, 0xFF, 0x1F, 0xF1, 0xC7, 0x38, 0x33, 0x83, 0x38,
  0x73, 0x07, 0x70, 0x77, 0x0E, 0x79, 0xE6, 0xFC, 0xEF, 0x80, 0x07, 0x87,
  0xF3, 0xFD, 0xE0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x11,
  0xFC, 0x3F, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x67, 0x0F,
  0xB8, 0xFF, 0xCF, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x1C,
  0x70, 0xE3, 0xCF, 0x0F, 0xF8, 0x7D, 0x80, 0x07, 0x03, 0xF8, 0xF7, 0xBC,
  0x77, 0x0F, 0xC7, 0xBF, 0xE7, 0xF0, 0xE0, 0x1C, 0x03, 0xC2, 0x3F, 0xC3,
  0xF0, 0x00, 0x60, 0x0F, 0xC0, 0x7C, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F,
  0x83, 0xFC, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x7C,
  0x03, 0xC0, 0x08, 0x00, 0x03, 0x00, 0x7D, 0xC7, 0xFE, 0x78, 0xE3, 0x87,
  0x1C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x1E, 0x78, 0x7F, 0xC3,
  0xEE, 0x00, 0xE0, 0x07, 0x10, 0x78, 0xFF, 0x87, 0xF8, 0x02, 0x00, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0xE1, 0xFF, 0x1F, 0xF1, 0xC7, 0x3C,
  0x33, 0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x06, 0x70, 0xE7, 0x0E, 0xE0,
  0xE0, 0x0E, 0x1C, 0x30, 0x00, 0x03, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC7,
  0x0E, 0x1C, 0x38, 0xF0, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0x70, 0xF8, 0x3E, 0x04, 0x00, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x8E, 0x38, 0x73, 0x87, 0x38, 0x3B, 0x81,
  0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xB8, 0x39, 0xE1, 0xC7, 0x0E, 0x38, 0xE0,
  0xE0, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC7,
  0x0E, 0x1C, 0x38, 0xE0, 0x00, 0xC1, 0xC3, 0x7E, 0xFC, 0x7F, 0xFF, 0x8E,
  0x3C, 0x73, 0xC7, 0x8E, 0x70, 0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x87, 0x70,
  0x60, 0xEE, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xEE, 0x0E, 0x1C, 0x00,
  0xE1, 0xBF, 0x1F, 0xF3, 0xC7, 0x3C, 0x33, 0x87, 0x38, 0x73, 0x87, 0x70,
  0x77, 0x06, 0x70, 0xE7, 0x0E, 0xE0, 0xE0, 0x07, 0x03, 0xF8, 0xFF, 0xBC,
  0x77, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3B, 0xCF, 0x3F, 0xC3,
  0xF0, 0x00, 0x60, 0x6F, 0xC3, 0xFE, 0x1C, 0x71, 0xC1, 0x8E, 0x0C, 0x70,
  0xE3, 0x07, 0x38, 0x39, 0xC3, 0x8F, 0x3C, 0x7F, 0xC3, 0x3C, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0x06, 0x01, 0xFF, 0x3F,
  0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xF3,
  0xC7, 0xFC, 0x7D, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x04, 0xC6, 0xF1, 0xBC, 0x78, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0xF3, 0xDC, 0xE0, 0x38,
  0x0F, 0x01, 0xF0, 0x3E, 0x03, 0x80, 0xE8, 0x3B, 0xFC, 0xFE, 0x00, 0x0C,
  0x18, 0x38, 0xFF, 0xFF, 0x38, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0xFC, 0x7C, 0x38, 0x73, 0x07, 0x70, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x60,
  0xEE, 0x1C, 0xE1, 0xCE, 0x3C, 0x7F, 0xC7, 0xDC, 0xE0, 0xFE, 0x0E, 0xE1,
  0xC6, 0x18, 0x63, 0x86, 0x70, 0x77, 0x07, 0x60, 0x7E, 0x07, 0xC0, 0x7C,
  0x03, 0x80, 0xE1, 0xC3, 0xF8, 0xF0, 0xEE, 0x3C, 0x71, 0x8F, 0x9C, 0x66,
  0xEE, 0x19, 0xBB, 0x86, 0xEE, 0xC1, 0xB3, 0xF0, 0x7C, 0xF8, 0x1E, 0x3E,
  0x07, 0x8F, 0x01, 0xC1, 0xC0, 0x1C, 0x3C, 0x39, 0xC0, 0xEE, 0x03, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1D, 0xC0, 0xE7, 0x07, 0x0E,
  0x3C, 0x38, 0x1C, 0x1E, 0x38, 0x38, 0x30, 0xE0, 0x61, 0xC0, 0xE7, 0x01,
  0xCC, 0x03, 0xB8, 0x07, 0x60, 0x0F, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0x80, 0x00,
  0x3F, 0xE7, 0xF8, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0x83, 0xC3, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x78, 0x70, 0x3C, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70,
  0x1E, 0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x0F, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x07, 0x01,
  0xC3, 0xE3, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x78, 0x3C, 0x18, 0x00,
  0x38, 0x3F, 0xFF, 0x3F, 0xC0, 0xE0,
};

const GFXglyph NotoSans_SemiBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 8, 6, 10, 2, -16 },
  { 21, 14, 16, 15, 1, -16 },
  { 49, 11, 18, 13, 1, -17 },
  { 74, 17, 17, 19, 1, -17 },
  { 111, 15, 17, 16, 1, -17 },
  { 143, 4, 6, 6, 2, -16 },
  { 146, 8, 20, 7, 1, -16 },
  { 166, 9, 21, 7, -2, -17 },
  { 190, 11, 11, 13, 2, -18 },
  { 206, 11, 11, 13, 1, -14 },
  { 222, 5, 6, 6, -1, -3 },
  { 226, 7, 2, 7, 0, -7 },
  { 228, 4, 3, 6, 0, -3 },
  { 230, 12, 17, 9, -1, -17 },
  { 256, 11, 17, 13, 1, -17 },
  { 280, 9, 16, 13, 2, -16 },
  { 298, 12, 17, 13, 0, -17 },
  { 324, 12, 17, 13, 0, -17 },
  { 350, 12, 16, 13, 0, -16 },
  { 374, 13, 16, 13, 0, -16 },
  { 400, 12, 17, 13, 1, -17 },
  { 426, 12, 16, 13, 1, -16 },
  { 450, 12, 17, 13, 1, -17 },
  { 476, 11, 17, 13, 1, -17 },
  { 500, 6, 13, 6, 0, -13 },
  { 510, 7, 16, 6, -1, -13 },
  { 524, 11, 12, 13, 1, -14 },
  { 541, 11, 6, 13, 1, -11 },
  { 550, 11, 12, 13, 1, -14 },
  { 567, 9, 17, 10, 2, -17 },
  { 587, 18, 18, 20, 1, -16 },
  { 628, 14, 16, 14, -1, -16 },
  { 656, 13, 16, 14, 1, -16 },
  { 682, 14, 17, 14, 1, -17 },
  { 712, 14, 16, 15, 1, -16 },
  { 740, 12, 16, 12, 1, -16 },
  { 764, 12, 16, 12, 1, -16 },
  { 788, 14, 17, 16, 1, -17 },
  { 818, 15, 16, 16, 1, -16 },
  { 848, 11, 16, 8, -1, -16 },
  { 870, 11, 21, 7, -4, -16 },
  { 899, 15, 16, 14, 1, -16 },
  { 929, 9, 16, 12, 1, -16 },
  { 947, 19, 16, 20, 1, -16 },
  { 985, 16, 16, 17, 1, -16 },
  { 1017, 15, 17, 17, 1, -17 },
  { 1049, 13, 16, 14, 1, -16 },
  { 1075, 15, 21, 17, 1, -17 },
  { 1115, 12, 16, 14, 1, -16 },
  { 1139, 12, 17, 12, 0, -17 },
  { 1165, 12, 16, 12, 2, -16 },
  { 1189, 14, 16, 16, 2, -16 },
  { 1217, 13, 16, 13, 2, -16 },
  { 1243, 20, 16, 20, 2, -16 },
  { 1283, 16, 16, 13, -1, -16 },
  { 1315, 13, 16, 12, 2, -16 },
  { 1341, 14, 16, 12, -1, -16 },
  { 1369, 9, 20, 7, 0, -16 },
  { 1392, 6, 17, 9, 2, -17 },
  { 1405, 10, 20, 7, -2, -16 },
  { 1430, 11, 11, 13, 1, -17 },
  { 1446, 9, 2, 9, -2, 2 },
  { 1449, 5, 4, 7, 3, -18 },
  { 1452, 12, 13, 13, 1, -13 },
  { 1472, 12, 17, 14, 0, -17 },
  { 1498, 10, 13, 11, 1, -13 },
  { 1515, 13, 17, 14, 1, -17 },
  { 1543, 11, 13, 12, 1, -13 },
  { 1561, 13, 24, 8, -2, -18 },
  { 1600, 13, 19, 14, 0, -13 },
  { 1631, 12, 17, 14, 0, -17 },
  { 1657, 7, 17, 7, 0, -17 },
  { 1672, 10, 23, 7, -3, -17 },
  { 1701, 13, 17, 12, 0, -17 },
  { 1729, 7, 17, 7, 0, -17 },
  { 1744, 19, 13, 21, 0, -13 },
  { 1775, 12, 13, 14, 0, -13 },
  { 1795, 11, 13, 13, 1, -13 },
  { 1813, 13, 19, 14, -1, -13 },
  { 1844, 12, 19, 14, 1, -13 },
  { 1873, 10, 13, 10, 0, -13 },
  { 1890, 10, 13, 11, 0, -13 },
  { 1907, 8, 15, 9, 1, -15 },
  { 1922, 12, 12, 14, 1, -12 },
  { 1940, 12, 12, 11, 1, -12 },
  { 1958, 18, 12, 18, 1, -12 },
  { 1985, 14, 12, 12, -1, -12 },
  { 2006, 15, 18, 11, -2, -12 },
  { 2040, 11, 12, 11, 0, -12 },
  { 2057, 9, 20, 8, 0, -16 },
  { 2080, 3, 22, 13, 5, -17 },
  { 2089, 9, 20, 8, -1, -16 },
  { 2112, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_SemiBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMIBOLDITALIC23PT7B_H_
