#ifndef _NOTOSANS_SEMIBOLDITALIC7PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x80, 0xF0, 0x33, 0xD5, 0xE6, 0x00, 0x76, 0x66, 0xE0, 0x6A,
  0xC5, 0xCD, 0x58, 0x72, 0x9B, 0x6F, 0x00, 0xC0, 0x6A, 0x49, 0x00, 0x24,
  0x93, 0x80, 0xCF, 0x00, 0x2F, 0x20, 0xC0, 0xC0, 0x80, 0x25, 0x48, 0x75,
  0x9A, 0x60, 0x75, 0x80, 0x71, 0x24, 0xE0, 0x71, 0x62, 0xE0, 0x35, 0x6F,
  0x20, 0x74, 0x62, 0xE0, 0x34, 0xE9, 0x60, 0x72, 0x24, 0xC0, 0x75, 0x69,
  0xE0, 0x69, 0x72, 0xE0, 0x42, 0x42, 0x80, 0x3C, 0x30, 0xFF, 0xC3, 0xE0,
  0xD8, 0x80, 0x39, 0x7B, 0x6F, 0x40, 0xC0, 0x25, 0x5F, 0x90, 0x75, 0x69,
  0xE0, 0x3A, 0x21, 0x07, 0x00, 0x72, 0xD5, 0x2E, 0x00, 0x74, 0x68, 0xE0,
  0x74, 0x68, 0x80, 0x3A, 0x25, 0x27, 0x00, 0x4A, 0x5D, 0x29, 0x00, 0x69,
  0x2C, 0x24, 0x95, 0x80, 0x5B, 0x19, 0x49, 0x00, 0x49, 0x4E, 0x65, 0xB7,
  0x6E, 0xA8, 0x4B, 0x5B, 0x29, 0x00, 0x72, 0x63, 0x17, 0x00, 0x75, 0x78,
  0x80, 0x72, 0x63, 0x17, 0x08, 0x75, 0x7A, 0x90, 0x74, 0x62, 0xE0, 0xEA,
  0x48, 0x4A, 0x55, 0x27, 0x00, 0xBA, 0xCC, 0x80, 0xA6, 0xAE, 0xA4, 0x90,
  0x5B, 0x08, 0xCB, 0x00, 0xBB, 0x48, 0x72, 0x44, 0xE0, 0x69, 0x49, 0x80,
  0xF8, 0x55, 0xA0, 0x26, 0x90, 0xE0, 0x80, 0x79, 0x9E, 0x47, 0x59, 0xE0,
  0x72, 0x30, 0x17, 0x99, 0xE0, 0x6B, 0xC6, 0x37, 0x22, 0x44, 0x80, 0x79,
  0x9E, 0x2C, 0x47, 0x59, 0xA0, 0x56, 0x80, 0x24, 0xA4, 0xA0, 0x45, 0x6E,
  0xA0, 0x56, 0x80, 0x7D, 0x59, 0x6B, 0x75, 0x9A, 0x69, 0x96, 0x75, 0x9E,
  0x88, 0x79, 0x9E, 0x22, 0x6A, 0x40, 0x78, 0xF0, 0x5D, 0x4C, 0x55, 0x9E,
  0x9A, 0xA4, 0xA6, 0xED, 0x94, 0x56, 0x4A, 0x4A, 0x8C, 0x42, 0x60, 0x65,
  0x70, 0x29, 0x49, 0x80, 0xFE, 0x55, 0xA0, 0xF0,
};

const GFXglyph NotoSans_SemiBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 5, 5, 5, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 6, 5, 6, 0, -5 },
  { 15, 5, 5, 5, 0, -5 },
  { 19, 1, 2, 2, 1, -5 },
  { 20, 3, 6, 2, 0, -5 },
  { 23, 3, 6, 2, -1, -5 },
  { 26, 3, 3, 4, 1, -5 },
  { 28, 4, 3, 4, 0, -4 },
  { 30, 1, 2, 2, 0, -1 },
  { 31, 2, 1, 2, 0, -2 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 2, 5, 4, 1, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 2, 4, 2, 0, -4 },
  { 65, 2, 5, 2, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 4, 2, 4, 0, -3 },
  { 70, 4, 3, 4, 0, -4 },
  { 72, 2, 5, 3, 1, -5 },
  { 74, 6, 6, 6, 0, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 5, 5, 4, 0, -5 },
  { 89, 5, 5, 5, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 5, 5, 5, 0, -5 },
  { 103, 5, 5, 5, 0, -5 },
  { 107, 3, 5, 3, 0, -5 },
  { 109, 3, 6, 2, -1, -5 },
  { 112, 5, 5, 4, 0, -5 },
  { 116, 3, 5, 4, 0, -5 },
  { 118, 6, 5, 6, 0, -5 },
  { 122, 5, 5, 5, 0, -5 },
  { 126, 5, 5, 5, 0, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 5, 6, 5, 0, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 4, 5, 4, 0, -5 },
  { 143, 3, 5, 4, 1, -5 },
  { 145, 5, 5, 5, 0, -5 },
  { 149, 4, 5, 4, 1, -5 },
  { 152, 6, 5, 6, 1, -5 },
  { 156, 5, 5, 4, 0, -5 },
  { 160, 3, 5, 4, 1, -5 },
  { 162, 4, 5, 4, 0, -5 },
  { 165, 3, 6, 2, 0, -5 },
  { 168, 1, 5, 3, 1, -5 },
  { 169, 2, 6, 2, 0, -5 },
  { 171, 4, 3, 4, 0, -5 },
  { 173, 3, 1, 3, -1, 0 },
  { 174, 1, 1, 2, 1, -5 },
  { 175, 4, 4, 4, 0, -4 },
  { 177, 4, 5, 4, 0, -5 },
  { 180, 3, 4, 3, 0, -4 },
  { 182, 4, 5, 4, 0, -5 },
  { 185, 4, 4, 4, 0, -4 },
  { 187, 4, 7, 2, -1, -5 },
  { 191, 4, 6, 4, 0, -4 },
  { 194, 4, 5, 4, 0, -5 },
  { 197, 2, 5, 2, 0, -5 },
  { 199, 3, 7, 2, -1, -5 },
  { 202, 4, 5, 4, 0, -5 },
  { 205, 2, 5, 2, 0, -5 },
  { 207, 6, 4, 6, 0, -4 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 4, 4, 4, 0, -4 },
  { 214, 4, 6, 4, 0, -4 },
  { 217, 4, 6, 4, 0, -4 },
  { 220, 3, 4, 3, 0, -4 },
  { 222, 3, 4, 3, 0, -4 },
  { 224, 3, 5, 3, 0, -5 },
  { 226, 4, 4, 4, 0, -4 },
  { 228, 4, 4, 3, 0, -4 },
  { 230, 6, 4, 5, 0, -4 },
  { 233, 4, 4, 4, 0, -4 },
  { 235, 5, 6, 4, -1, -4 },
  { 239, 3, 4, 3, 0, -4 },
  { 241, 3, 6, 2, 0, -5 },
  { 244, 1, 7, 4, 1, -5 },
  { 245, 2, 6, 2, 0, -5 },
  { 247, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMIBOLDITALIC7PT7B_H_
