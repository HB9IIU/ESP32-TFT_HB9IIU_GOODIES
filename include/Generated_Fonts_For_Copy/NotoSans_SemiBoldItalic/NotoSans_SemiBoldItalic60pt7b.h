#ifndef _NOTOSANS_SEMIBOLDITALIC60PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0x80, 0x00, 0x3F,
  0x87, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F,
  0x3F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xBC, 0xFE, 0x07, 0xF8, 0xF0, 0x70, 0x1F, 0xC3, 0xC0, 0x00, 0x7F,
  0x0F, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x1F, 0xC7,
  0x80, 0x00, 0x7F, 0x9E, 0x00, 0x01, 0xFF, 0x78, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1E, 0x7F, 0x80, 0x00,
  0xF0, 0xFE, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x3C,
  0x3F, 0x88, 0x00, 0xF1, 0xFE, 0x30, 0x07, 0x87, 0xF8, 0xF8, 0x1E, 0x7F,
  0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x0F,
  0xF0, 0xFC, 0x1F, 0xC7, 0xE3, 0xFF, 0x8F, 0xC1, 0xF8, 0xFC, 0x7F, 0xFC,
  0xFE, 0x3F, 0x8F, 0xCF, 0xFF, 0xEF, 0xFF, 0xF1, 0xF9, 0xFF, 0xFE, 0x7F,
  0xFF, 0x3F, 0x1F, 0xC7, 0xE7, 0xFF, 0xE7, 0xE3, 0xF8, 0x7F, 0x3F, 0xF8,
  0x7E, 0x3F, 0x03, 0xF0, 0xFF, 0x0F, 0xC7, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x7E,
  0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0x83, 0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0xFC,
  0x03, 0xFC, 0x3F, 0xF7, 0xF8, 0x07, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x3F, 0x87, 0xF8, 0x0F, 0xF8, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF3, 0xFC, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xFF, 0xC0,
  0xFF, 0x00, 0x1F, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x20,
  0x0F, 0xC0, 0x07, 0x80, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xF8, 0xF8,
  0x00, 0xFF, 0xEF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xBF, 0xF0, 0x1F, 0xF8, 0x03, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0x7C, 0x00,
  0x1F, 0xE7, 0xE0, 0x03, 0xFC, 0x3E, 0x00, 0x7F, 0x83, 0xF0, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x60, 0x1F, 0x80, 0x02, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF0, 0x04, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x7F,
  0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0,
  0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x1F,
  0xF0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0x7F, 0x3F, 0xF3, 0xF8, 0xFF, 0x1F, 0xC7, 0xE1, 0xFE, 0x1E, 0x0F, 0xE0,
  0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFC, 0x01,
  0xFF, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x08, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0x01, 0xFF, 0x80, 0x78, 0x01, 0xFF, 0x00, 0x40, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE2, 0x00, 0x00, 0x7F, 0x86, 0x00, 0x01, 0xFF, 0x0F, 0x80, 0x0F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x80, 0x00, 0x1F, 0xE0, 0xE0, 0x00, 0x7F, 0xE0, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xF8,
  0x03, 0xF9, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0xFF, 0x3F, 0xC0,
  0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81,
  0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xE3,
  0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03,
  0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F,
  0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F,
  0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0,
  0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x3F,
  0xF8, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0x7F, 0x01, 0xFF, 0xF3, 0xF8, 0x07, 0xFE, 0x3F, 0xC0, 0x03,
  0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x40, 0x0F, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0xFC, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0x01, 0xFE, 0x38, 0x00, 0xFF,
  0x20, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xC7, 0xE0,
  0x0F, 0xFF, 0xF8, 0x1F, 0x8F, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x3F, 0x00,
  0xFF, 0xFF, 0xE0, 0x7E, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0xFD, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFB, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF7, 0xE0, 0x7E,
  0x00, 0xFC, 0x07, 0xEF, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0,
  0x1F, 0x80, 0x7D, 0xF8, 0x3F, 0x00, 0x3E, 0x01, 0xFB, 0xF0, 0x7E, 0x00,
  0xFC, 0x03, 0xF7, 0xE0, 0xFC, 0x01, 0xF8, 0x07, 0xEF, 0xC1, 0xF8, 0x07,
  0xF0, 0x1F, 0x9F, 0x83, 0xF0, 0x0F, 0xE0, 0x7F, 0x3F, 0x07, 0xF0, 0x3F,
  0xC1, 0xFC, 0x7E, 0x07, 0xE0, 0xFF, 0x87, 0xF0, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xF8, 0x1F, 0xFF, 0xBF, 0xFF, 0x81, 0xF8, 0x1F, 0xFE, 0x3F,
  0xFC, 0x03, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x01,
  0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xFC, 0x03,
  0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8,
  0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0xFF, 0x83, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0x80,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xE0, 0x1F,
  0xFC, 0x00, 0x38, 0x07, 0xFE, 0x00, 0x01, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x30, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xF8, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0x00, 0x1C, 0x03, 0xFF, 0x00, 0x00,
  0x40, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0xFC, 0xFF,
  0x00, 0x3F, 0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFF,
  0x8F, 0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFE,
  0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0xC3, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x01, 0xFD, 0xFC, 0x03, 0xFB,
  0xF0, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x3F,
  0xBF, 0x00, 0x0F, 0xCF, 0xE0, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF8, 0x07,
  0xF1, 0xF8, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x7F, 0x80,
  0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC7, 0xF0,
  0x07, 0xF1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xE0, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xF8, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xE1, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x3F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF7,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFD, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xFE,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x00,
  0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x3F, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xEF, 0xE0, 0x01, 0xFC, 0x00,
  0xFD, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x07, 0xF0, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0x87, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x00,
  0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x8F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xE7, 0xE0, 0x0F, 0xF0, 0x01, 0xFD, 0xFC, 0x01, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x01, 0xFF,
  0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F,
  0xC0, 0x0F, 0xFC, 0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0xFF, 0xBF, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xF8, 0x3F, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x7E, 0x01,
  0xFF, 0x00, 0x1C, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x82, 0x00, 0x00, 0xFF, 0x07,
  0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x8F, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x0F,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0xFC, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0xFF, 0x00, 0xFE, 0x07,
  0xF0, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xFE, 0x00, 0x7E,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x00,
  0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x80, 0x07, 0xE3, 0xF8, 0x0F, 0xC7,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x0F,
  0xCF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xE0,
  0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83,
  0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0xFF, 0xE0,
  0xFC, 0x03, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0xEF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0x0F, 0xFC, 0x07, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x1F,
  0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xE0,
  0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xF3,
  0xF0, 0x0F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x1F, 0x80, 0x0F, 0xF8, 0x3F,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x7F, 0xF0, 0x01, 0xFC, 0xFF, 0xF8, 0x01, 0xFD, 0xFF,
  0xFC, 0x03, 0xFB, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x83,
  0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03,
  0xFC, 0x1F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0x80, 0x7E, 0x7F, 0xFF,
  0x00, 0x7E, 0x3F, 0xFE, 0x00, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x70,
  0x7F, 0xE0, 0x04, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x02, 0x07, 0xFC, 0x03, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0xE7, 0xF8,
  0x01, 0xFF, 0xFD, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF7, 0xE0, 0x07, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0x1F,
  0xFE, 0x3F, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xC3, 0xFE, 0x03, 0xF8,
  0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFF, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x9F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x41, 0xFE, 0x00, 0x38, 0x3F, 0xF8, 0x3F, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFC,
  0x10, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x1F, 0x80, 0x0F, 0xFE, 0x0F, 0xC0, 0x0F, 0xFF, 0x8F, 0xE0, 0x1F,
  0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xFB, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0,
  0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFF,
  0x7F, 0x00, 0x3F, 0xFF, 0x7F, 0x80, 0x0F, 0xFE, 0x3F, 0x80, 0x03, 0xFE,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0x80, 0x01, 0xFE, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xF8,
  0x01, 0xFC, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x81, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xFC,
  0x01, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F,
  0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFC,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7E, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0xFF, 0x0F, 0xF7, 0xC1, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x83,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x7F, 0xF8, 0x01,
  0xF8, 0xFF, 0xFC, 0x03, 0xF9, 0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFE, 0x07,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F,
  0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x03,
  0xFE, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x07, 0xE1, 0xFF, 0xC0, 0x00, 0xFC, 0x7F, 0xFC, 0x00, 0x1F, 0x9F, 0xFF,
  0xC0, 0x07, 0xF7, 0xFF, 0xF8, 0x00, 0xFD, 0xFF, 0xFF, 0x80, 0x1F, 0xFC,
  0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0,
  0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xDF, 0xFF, 0xE0, 0x03, 0xF9, 0xFF, 0xF8, 0x00, 0x7F,
  0x1F, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x06, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x7E, 0x00, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0xE7,
  0xE0, 0x3F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFF,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80,
  0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x01,
  0xFF, 0x83, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0x3F,
  0x80, 0x0F, 0xF8, 0x7F, 0x00, 0x01, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x1F, 0xF0, 0x1F, 0x8F, 0xF8, 0x07, 0xE7,
  0xFE, 0x03, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC0, 0x3C, 0x3F, 0xC0,
  0x04, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x40, 0x01, 0xFE, 0x30, 0x01, 0xFF,
  0x1F, 0x83, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xF0, 0xFF, 0x00, 0x7F, 0xC1,
  0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xF3, 0xF0, 0x0F, 0xFF, 0xC7, 0xE0, 0x0F,
  0xFF, 0x0F, 0xC0, 0x0F, 0xF8, 0x1F, 0x80, 0x01, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0,
  0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x01, 0xFE,
  0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x7F, 0x80, 0x01, 0xF9, 0xFC,
  0x00, 0x07, 0xEF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xF0, 0x03, 0xFD, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xCF, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0xE0, 0x0F,
  0xE3, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0x3E, 0xF8, 0x07, 0xF0,
  0xFE, 0x03, 0xF7, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0x7E, 0x03, 0xF8, 0x3F,
  0x81, 0xFB, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xDF, 0x81, 0xFC, 0x0F, 0xE0,
  0xFC, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x03, 0xF8, 0x7E,
  0x3F, 0x07, 0xF0, 0x1F, 0xC3, 0xF1, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0x8F,
  0xC3, 0xF8, 0x07, 0xF1, 0xF8, 0x7E, 0x3F, 0xC0, 0x3F, 0x8F, 0xC3, 0xF1,
  0xFC, 0x01, 0xFC, 0xFC, 0x1F, 0x8F, 0xE0, 0x0F, 0xE7, 0xE0, 0x7C, 0xFE,
  0x00, 0x7F, 0x7E, 0x03, 0xE7, 0xF0, 0x01, 0xFB, 0xF0, 0x1F, 0x3F, 0x00,
  0x0F, 0xDF, 0x80, 0xFB, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xDF, 0x80, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xE3, 0xFC,
  0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x13, 0xFF, 0x80, 0x01, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x80, 0x01, 0xFF, 0x80,
};

const GFXglyph NotoSans_SemiBoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 17, 44, 17, 1, -43 },
  { 95, 21, 16, 26, 6, -43 },
  { 137, 38, 43, 39, 1, -43 },
  { 342, 30, 49, 33, 2, -46 },
  { 526, 44, 44, 50, 4, -43 },
  { 768, 39, 45, 42, 2, -44 },
  { 988, 9, 16, 15, 6, -43 },
  { 1006, 22, 52, 19, 2, -43 },
  { 1149, 21, 52, 19, -4, -43 },
  { 1286, 28, 29, 33, 6, -46 },
  { 1388, 28, 29, 34, 4, -36 },
  { 1490, 14, 15, 17, -3, -7 },
  { 1517, 17, 6, 19, 1, -19 },
  { 1530, 9, 10, 17, 1, -9 },
  { 1542, 32, 43, 24, -3, -43 },
  { 1714, 30, 45, 33, 2, -44 },
  { 1883, 21, 43, 33, 7, -43 },
  { 1996, 33, 43, 33, -1, -43 },
  { 2174, 31, 44, 33, 1, -43 },
  { 2345, 32, 43, 33, 0, -43 },
  { 2517, 32, 44, 33, 1, -43 },
  { 2693, 30, 45, 33, 3, -44 },
  { 2862, 32, 43, 33, 3, -43 },
  { 3034, 31, 45, 33, 2, -44 },
  { 3209, 29, 45, 33, 3, -44 },
  { 3373, 14, 34, 17, 1, -33 },
  { 3433, 18, 41, 17, -3, -33 },
  { 3526, 28, 31, 34, 4, -37 },
  { 3635, 28, 17, 34, 4, -30 },
  { 3695, 28, 31, 34, 4, -37 },
  { 3804, 24, 44, 27, 5, -43 },
  { 3936, 47, 48, 51, 3, -43 },
  { 4218, 37, 43, 36, -4, -43 },
  { 4417, 34, 43, 37, 2, -43 },
  { 4600, 35, 44, 36, 4, -43 },
  { 4793, 37, 43, 40, 2, -43 },
  { 4992, 32, 43, 32, 2, -43 },
  { 5164, 32, 43, 31, 2, -43 },
  { 5336, 36, 44, 41, 4, -43 },
  { 5534, 40, 43, 42, 2, -43 },
  { 5749, 27, 43, 22, -2, -43 },
  { 5895, 28, 55, 19, -9, -43 },
  { 6088, 39, 43, 36, 2, -43 },
  { 6298, 24, 43, 30, 2, -43 },
  { 6427, 50, 43, 52, 2, -43 },
  { 6696, 43, 43, 44, 2, -43 },
  { 6928, 38, 45, 44, 4, -44 },
  { 7142, 34, 43, 36, 2, -43 },
  { 7325, 38, 54, 44, 4, -44 },
  { 7582, 33, 43, 36, 2, -43 },
  { 7760, 31, 44, 31, 1, -43 },
  { 7931, 31, 43, 31, 5, -43 },
  { 8098, 38, 44, 41, 4, -43 },
  { 8307, 35, 43, 35, 5, -43 },
  { 8496, 52, 43, 53, 6, -43 },
  { 8776, 42, 43, 35, -3, -43 },
  { 9002, 33, 43, 33, 5, -43 },
  { 9180, 36, 43, 32, -1, -43 },
  { 9374, 24, 52, 19, -1, -43 },
  { 9530, 14, 43, 24, 6, -43 },
  { 9606, 24, 52, 19, -4, -43 },
  { 9762, 31, 27, 34, 1, -43 },
  { 9867, 24, 4, 24, -5, 5 },
  { 9879, 11, 10, 18, 9, -46 },
  { 9893, 31, 34, 35, 3, -33 },
  { 10025, 32, 47, 35, 1, -46 },
  { 10213, 26, 34, 28, 3, -33 },
  { 10324, 34, 47, 35, 3, -46 },
  { 10524, 27, 34, 32, 3, -33 },
  { 10639, 34, 60, 21, -6, -46 },
  { 10894, 33, 47, 35, 1, -33 },
  { 11088, 32, 46, 36, 1, -46 },
  { 11272, 17, 45, 17, 1, -45 },
  { 11368, 26, 59, 17, -8, -45 },
  { 11560, 34, 46, 32, 1, -46 },
  { 11756, 18, 46, 17, 1, -46 },
  { 11860, 49, 33, 54, 1, -33 },
  { 12063, 32, 33, 36, 1, -33 },
  { 12195, 29, 34, 35, 3, -33 },
  { 12319, 35, 47, 35, -2, -33 },
  { 12525, 31, 47, 35, 3, -33 },
  { 12708, 26, 33, 25, 1, -33 },
  { 12816, 25, 34, 28, 1, -33 },
  { 12923, 21, 41, 23, 3, -40 },
  { 13031, 31, 34, 36, 3, -33 },
  { 13163, 30, 33, 30, 3, -33 },
  { 13287, 45, 33, 46, 4, -33 },
  { 13473, 36, 33, 31, -3, -33 },
  { 13622, 38, 47, 30, -5, -33 },
  { 13846, 29, 33, 28, -1, -33 },
  { 13966, 25, 52, 21, 0, -43 },
  { 14129, 6, 59, 33, 14, -45 },
  { 14174, 24, 52, 21, -3, -43 },
  { 14330, 28, 9, 34, 4, -26 },
};

const GFXfont NotoSans_SemiBoldItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMIBOLDITALIC60PT7B_H_
