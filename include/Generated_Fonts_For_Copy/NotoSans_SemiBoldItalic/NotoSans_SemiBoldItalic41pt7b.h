#ifndef _NOTOSANS_SEMIBOLDITALIC41PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x40, 0x00, 0x7E, 0x7D, 0xF1, 0xF7, 0xC7,
  0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3,
  0x80, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xC1, 0xE0, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1C,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x01, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83,
  0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFD, 0x9E, 0x0F, 0x9C, 0x10,
  0xF8, 0xE0, 0x07, 0xC7, 0x00, 0x3E, 0x38, 0x00, 0xF9, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xEF, 0xC0, 0x07, 0x3E, 0x00, 0x31, 0xF0, 0x03, 0x8F,
  0x90, 0x1C, 0xFC, 0xF0, 0xEF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x10, 0x3F, 0x80, 0x07, 0x81, 0xFF,
  0x00, 0x3C, 0x0F, 0xFE, 0x01, 0xE0, 0x7C, 0x78, 0x07, 0x81, 0xE1, 0xE0,
  0x3C, 0x07, 0x87, 0x81, 0xE0, 0x3E, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x3C,
  0x03, 0xC1, 0xE1, 0xE0, 0x0F, 0x0F, 0x8F, 0x00, 0x3C, 0x3C, 0x7C, 0x00,
  0xF0, 0xF1, 0xE3, 0xE3, 0xC7, 0xCF, 0x3F, 0xCF, 0x1E, 0x79, 0xFF, 0xBF,
  0xFB, 0xEF, 0xFE, 0x7F, 0xCF, 0x3C, 0x79, 0xFE, 0x79, 0xF1, 0xF0, 0xC3,
  0xC7, 0x87, 0xC0, 0x1F, 0x1E, 0x1F, 0x00, 0x78, 0xF8, 0x78, 0x03, 0xC3,
  0xC1, 0xE0, 0x1E, 0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x3E, 0x03, 0xC0, 0xF0,
  0xF0, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x0F, 0x9E, 0x07, 0xC0, 0x1F, 0xF8,
  0x1E, 0x00, 0x7F, 0xC0, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x3F, 0x1F, 0xFE, 0x07, 0xC7, 0xF7, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E,
  0x3F, 0x0F, 0xCF, 0xC7, 0xC0, 0xFD, 0xF1, 0xF8, 0x0F, 0xFC, 0x3F, 0x00,
  0xFF, 0x07, 0xE0, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x0F, 0xC1, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xF3, 0xF0, 0x1F, 0xF8,
  0x3F, 0x00, 0x7E, 0xF9, 0xF3, 0xC7, 0x8F, 0x1E, 0x38, 0xF1, 0xE0, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x06, 0x07, 0x00, 0xF1, 0xE0, 0x3F,
  0xBC, 0x07, 0xFF, 0x07, 0x3F, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83,
  0xF8, 0x30, 0xF7, 0x80, 0x3E, 0xF0, 0x1F, 0x9E, 0x03, 0xE1, 0xE0, 0x18,
  0x3C, 0x01, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE3,
  0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xE0, 0x1C, 0xFD, 0xFB, 0xFF, 0xEF, 0x8C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8,
  0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xC3, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF1, 0xFF, 0xC7, 0xFF, 0xBF, 0xDF, 0x3F, 0x3E, 0x38, 0xF8,
  0x61, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7C, 0x1F, 0xC0, 0x60, 0x1F, 0x80, 0x80,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0x80, 0xFC, 0x08, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x80, 0x0F, 0xC7, 0x00,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x7D,
  0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0,
  0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x90, 0x01, 0xF8, 0xE0,
  0x3F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x38, 0x07, 0xCF, 0xF0, 0x3E,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xF1, 0xF8, 0xFE, 0x07, 0xE7, 0xE0, 0x1F,
  0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0x1F, 0x83, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0xFC, 0x7E, 0x0F, 0x81, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xF0, 0x3F,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3,
  0xF0, 0x7E, 0x3E, 0x03, 0xE3, 0xE0, 0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x7E, 0x7E, 0x0F,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xBE, 0x0F, 0xF7, 0xC0, 0x10,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x08, 0x0F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x07, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xC0, 0xC0, 0x00, 0xE0, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF1, 0x80, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x1F, 0x1E, 0x03, 0xFF, 0x0F, 0x3C, 0x0F, 0xFF,
  0x0F, 0x3C, 0x1F, 0xFF, 0x0F, 0x78, 0x3E, 0x0F, 0x0F, 0x78, 0x7C, 0x1E,
  0x0F, 0x78, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E,
  0x0F, 0xF0, 0xF0, 0x3C, 0x0F, 0xF0, 0xF0, 0x3C, 0x1E, 0xF0, 0xF0, 0x3C,
  0x1E, 0xF0, 0xF0, 0x7C, 0x3E, 0xF0, 0xF0, 0xFC, 0x3C, 0xF0, 0xFF, 0xFE,
  0xF8, 0xF0, 0x7F, 0xDF, 0xF0, 0x78, 0x7F, 0x9F, 0xE0, 0x78, 0x1E, 0x07,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x0E, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x3C,
  0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xE0, 0x7F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F,
  0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x83, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF8,
  0x7C, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x03, 0x87, 0xF0, 0x01, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x40, 0xFF, 0x03, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7E, 0x0F, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0x87, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xE1,
  0xF0, 0x07, 0xF0, 0xF8, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x3F, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x80, 0x70,
  0x7F, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0xF9, 0xF0, 0x1F, 0xFC, 0xF8, 0x0F, 0xFE, 0x7C, 0x07,
  0xFE, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3F,
  0xC0, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C,
  0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xFC,
  0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x8F, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0xFE, 0x01, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xDF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x3D, 0xE0, 0x0F, 0xFC, 0x07, 0xBC,
  0x01, 0xEF, 0x81, 0xF7, 0x80, 0x7D, 0xF0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07,
  0xDE, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x79, 0xF0, 0x1E, 0x7C, 0x1E, 0x3E,
  0x07, 0xC7, 0x83, 0xC7, 0xC0, 0xF8, 0xF0, 0xF1, 0xF0, 0x1F, 0x1E, 0x1E,
  0x3E, 0x03, 0xC3, 0xC7, 0x87, 0xC0, 0xF8, 0x79, 0xF0, 0xF8, 0x1F, 0x0F,
  0x3C, 0x1F, 0x03, 0xE1, 0xEF, 0x87, 0xC0, 0x7C, 0x3D, 0xE0, 0xF8, 0x0F,
  0x07, 0xFC, 0x1F, 0x03, 0xE0, 0xFF, 0x03, 0xE0, 0x7C, 0x1F, 0xE0, 0x78,
  0x0F, 0x83, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0,
  0x03, 0xE0, 0x3F, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0x3E, 0x07, 0xFC, 0x00,
  0xF0, 0x1F, 0xF0, 0x07, 0xC0, 0x7B, 0xE0, 0x1F, 0x01, 0xEF, 0x80, 0x7C,
  0x07, 0xBE, 0x01, 0xF0, 0x3E, 0x7C, 0x07, 0x80, 0xF9, 0xF0, 0x3E, 0x03,
  0xE7, 0xC0, 0xF8, 0x0F, 0x8F, 0x83, 0xE0, 0x3C, 0x3E, 0x0F, 0x81, 0xF0,
  0xF8, 0x7C, 0x07, 0xC1, 0xF1, 0xF0, 0x1F, 0x07, 0xC7, 0xC0, 0x78, 0x1F,
  0x1F, 0x03, 0xE0, 0x3E, 0x7C, 0x0F, 0x80, 0xF9, 0xE0, 0x3E, 0x01, 0xFF,
  0x80, 0xF8, 0x07, 0xFE, 0x03, 0xC0, 0x1F, 0xF8, 0x1F, 0x00, 0x3F, 0xC0,
  0x7C, 0x00, 0xFF, 0x01, 0xF0, 0x03, 0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x1E,
  0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xF8, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03,
  0xF8, 0x7E, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xE0,
  0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F,
  0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xE1, 0xF0,
  0x7F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE3,
  0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xE1, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3E,
  0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x07,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x00, 0x1E,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xE0, 0x30, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x80, 0x1F, 0x87, 0x01, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xC0,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E,
  0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF,
  0x80, 0x1F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0x78,
  0x07, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC1,
  0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x80,
  0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0xF8, 0x03, 0xF0,
  0x07, 0xEF, 0x80, 0x3F, 0x00, 0x7C, 0xF8, 0x07, 0xF0, 0x0F, 0xCF, 0x80,
  0x7F, 0x00, 0xF8, 0xF8, 0x0F, 0xF0, 0x0F, 0x8F, 0x80, 0xFF, 0x01, 0xF0,
  0xF8, 0x1F, 0xF8, 0x1F, 0x0F, 0x81, 0xEF, 0x83, 0xE0, 0xF8, 0x1E, 0xF8,
  0x3E, 0x0F, 0x83, 0xEF, 0x87, 0xE0, 0xF8, 0x3C, 0xF8, 0x7C, 0x0F, 0x87,
  0xCF, 0x87, 0xC0, 0xF8, 0x78, 0xF8, 0xF8, 0x0F, 0x8F, 0x87, 0x8F, 0x80,
  0x78, 0xF0, 0x79, 0xF0, 0x07, 0x9F, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x79,
  0xE0, 0x07, 0x9E, 0x07, 0xBE, 0x00, 0x7B, 0xE0, 0x7B, 0xE0, 0x07, 0xBC,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x01, 0xF0,
  0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x3F, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8,
  0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xEF, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0,
  0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8,
  0x01, 0xE7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x00, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87,
  0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x80, 0x07, 0xBC, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xF0,
  0x1C, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x78, 0x00, 0xF7,
  0xC0, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x7C, 0x3C, 0x3E,
  0x1E, 0x0F, 0x00, 0x60, 0x00, 0x1F, 0xE3, 0xC1, 0xFF, 0x9E, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0,
  0xFE, 0x3F, 0x0F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0x78, 0x1F, 0xF3, 0xC0,
  0x7E, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC3, 0x00, 0x7C, 0x7F, 0x03, 0xEF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x87, 0xF0, 0xFC, 0x7F, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0xFC, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F,
  0xC3, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x79, 0xFF, 0x83, 0xC7, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xE0, 0x23, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x41, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x60, 0xF8, 0x07, 0xF9, 0xF0, 0x1F, 0xFB,
  0xE0, 0x7F, 0xF7, 0xC1, 0xFF, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87,
  0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x83, 0xF0, 0xFF, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0x78, 0x07, 0xFC, 0xF0, 0x07, 0xF1, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0x7E, 0x3E,
  0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x07, 0xCF, 0x83, 0xFB, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x0C, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x0B, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF8, 0xF0, 0x3F, 0xF3,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x07, 0xE1, 0xF0, 0x3F, 0x87, 0xE1, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xDF, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x20, 0x0F, 0xC0, 0xF0, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC3, 0x80, 0x7C,
  0x7F, 0x03, 0xEF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xF0, 0x7C,
  0x7F, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF,
  0xC0, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xCF, 0xC0, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0x01, 0xC0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x00, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x09, 0xFC, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x02, 0x1F, 0x81,
  0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x7E, 0x01, 0xF1, 0xF8,
  0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xDF, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x7E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0xF8, 0x3E, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0x03, 0x00, 0x18, 0x07, 0xC7, 0xF0, 0x7F, 0x83, 0xCF, 0xFC,
  0x7F, 0xC1, 0xEF, 0xFE, 0x7F, 0xF0, 0xF7, 0xFF, 0x7F, 0xF8, 0x7F, 0x0F,
  0xF8, 0x7C, 0x7F, 0x03, 0xF8, 0x3E, 0x3F, 0x01, 0xF8, 0x1F, 0x1F, 0x80,
  0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0x07, 0xC7, 0xC0, 0x7C, 0x03, 0xE7, 0xE0,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x01, 0xF9, 0xF0, 0x0F, 0x80, 0xF8, 0xF8,
  0x0F, 0x80, 0x7C, 0xFC, 0x07, 0xC0, 0x3E, 0x7C, 0x03, 0xE0, 0x1F, 0x3E,
  0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x07, 0xCF,
  0xC0, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x03, 0xF3, 0xE0, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0x80, 0x7C, 0x7F, 0x03, 0xCF, 0xFC, 0x1E, 0xFF, 0xF0, 0xF7,
  0xFF, 0x87, 0xF0, 0x7C, 0x7F, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8,
  0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x00, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE3, 0xF0, 0x7E, 0x3E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0xC0, 0xFC, 0x7C, 0x1F,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xC0, 0x07, 0xCF, 0xF0, 0x0F, 0x3F, 0xF0, 0x1E, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0x0F, 0xC1, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC,
  0x3F, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0x83, 0xEF, 0xFE, 0x07,
  0xCF, 0xF8, 0x0F, 0x8F, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0xE3, 0xC1, 0xFF, 0x9E, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xC3, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F,
  0x3F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0xFE, 0x3F, 0x0F, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xF7, 0xC0, 0x7E, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0x87, 0xC7, 0xC3, 0xEF, 0xE1, 0xFF, 0xF0, 0xF7, 0xF8,
  0x7F, 0x84, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0x87, 0x87, 0xC0, 0x21, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xCC, 0x03, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x27, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0x80, 0xFC,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0xC3, 0xF0, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFD, 0xE0, 0x7F, 0xE7, 0x80, 0x7E, 0x1E, 0x00, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x0F, 0xC7, 0x80, 0x7C, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE1, 0xF0,
  0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x03, 0xCF, 0xC0, 0x1E, 0x7C, 0x00, 0xF3,
  0xE0, 0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x3E,
  0xF0, 0x1F, 0x80, 0xF9, 0xE0, 0x3F, 0x01, 0xF3, 0xC0, 0xFE, 0x07, 0xC7,
  0x81, 0xFC, 0x0F, 0x8F, 0x07, 0xBC, 0x3F, 0x1E, 0x0F, 0x78, 0x7C, 0x3C,
  0x3C, 0xF1, 0xF8, 0x78, 0x79, 0xE3, 0xE0, 0xF1, 0xF3, 0xC7, 0xC1, 0xE3,
  0xC7, 0x9F, 0x03, 0xC7, 0x8F, 0x3E, 0x07, 0x9E, 0x1E, 0xF8, 0x0F, 0x3C,
  0x3D, 0xF0, 0x1E, 0xF0, 0x7B, 0xC0, 0x3D, 0xE0, 0xFF, 0x80, 0x7B, 0xC1,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x81, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F,
  0x1F, 0x80, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x80,
  0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7C,
  0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xC1, 0xF0,
  0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x00, 0xFC, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3,
  0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x02, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3C, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFF, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x04, 0x00, 0x13, 0xFC,
  0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFE, 0x80,
  0x07, 0x80,
};

const GFXglyph NotoSans_SemiBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 30, 11, 1, -29 },
  { 43, 14, 10, 18, 4, -29 },
  { 61, 26, 29, 26, 1, -29 },
  { 156, 21, 33, 23, 1, -31 },
  { 243, 30, 30, 34, 3, -30 },
  { 356, 27, 30, 29, 1, -30 },
  { 458, 7, 10, 10, 4, -29 },
  { 467, 14, 35, 13, 2, -29 },
  { 529, 15, 36, 13, -3, -30 },
  { 597, 19, 19, 22, 4, -31 },
  { 643, 20, 19, 23, 2, -24 },
  { 691, 9, 10, 11, -2, -5 },
  { 703, 11, 4, 13, 1, -13 },
  { 709, 7, 7, 11, 0, -6 },
  { 716, 22, 29, 16, -2, -29 },
  { 796, 20, 30, 23, 2, -30 },
  { 871, 15, 29, 23, 4, -29 },
  { 926, 23, 30, 23, -1, -30 },
  { 1013, 21, 30, 23, 1, -30 },
  { 1092, 22, 29, 23, 0, -29 },
  { 1172, 21, 29, 23, 1, -29 },
  { 1249, 21, 30, 23, 2, -30 },
  { 1328, 22, 29, 23, 2, -29 },
  { 1408, 21, 30, 23, 1, -30 },
  { 1487, 20, 30, 23, 2, -30 },
  { 1562, 10, 24, 11, 0, -23 },
  { 1592, 12, 28, 11, -2, -23 },
  { 1634, 20, 21, 23, 2, -25 },
  { 1687, 19, 11, 23, 3, -20 },
  { 1714, 20, 21, 23, 2, -25 },
  { 1767, 17, 31, 18, 3, -30 },
  { 1833, 32, 33, 35, 2, -29 },
  { 1965, 24, 29, 25, -2, -29 },
  { 2052, 24, 29, 25, 1, -29 },
  { 2139, 23, 30, 25, 3, -30 },
  { 2226, 25, 29, 28, 1, -29 },
  { 2317, 22, 29, 22, 1, -29 },
  { 2397, 22, 29, 21, 1, -29 },
  { 2477, 25, 30, 28, 3, -30 },
  { 2571, 28, 29, 28, 1, -29 },
  { 2673, 18, 29, 15, -1, -29 },
  { 2739, 19, 37, 13, -6, -29 },
  { 2827, 27, 29, 24, 1, -29 },
  { 2925, 17, 29, 21, 1, -29 },
  { 2987, 35, 29, 35, 1, -29 },
  { 3114, 30, 29, 30, 1, -29 },
  { 3223, 26, 30, 30, 3, -30 },
  { 3321, 23, 29, 24, 1, -29 },
  { 3405, 26, 37, 30, 3, -30 },
  { 3526, 23, 29, 25, 1, -29 },
  { 3610, 21, 30, 21, 1, -30 },
  { 3689, 22, 29, 21, 3, -29 },
  { 3769, 26, 29, 28, 3, -29 },
  { 3864, 23, 29, 24, 4, -29 },
  { 3948, 36, 29, 36, 4, -29 },
  { 4079, 29, 29, 24, -2, -29 },
  { 4185, 22, 29, 22, 4, -29 },
  { 4265, 25, 29, 22, -1, -29 },
  { 4356, 17, 35, 13, -1, -29 },
  { 4431, 9, 29, 16, 4, -29 },
  { 4464, 17, 35, 13, -3, -29 },
  { 4539, 21, 18, 23, 1, -29 },
  { 4587, 17, 2, 16, -4, 4 },
  { 4592, 8, 6, 13, 6, -31 },
  { 4598, 21, 23, 24, 2, -23 },
  { 4659, 21, 31, 24, 1, -31 },
  { 4741, 18, 23, 19, 2, -23 },
  { 4793, 23, 31, 24, 2, -31 },
  { 4883, 19, 23, 22, 2, -23 },
  { 4938, 23, 41, 14, -4, -31 },
  { 5056, 22, 33, 24, 1, -23 },
  { 5147, 21, 31, 24, 1, -31 },
  { 5229, 11, 31, 12, 1, -31 },
  { 5272, 17, 41, 12, -5, -31 },
  { 5360, 23, 31, 22, 1, -31 },
  { 5450, 12, 31, 12, 1, -31 },
  { 5497, 33, 23, 37, 1, -23 },
  { 5592, 21, 23, 24, 1, -23 },
  { 5653, 20, 23, 24, 2, -23 },
  { 5711, 23, 33, 24, -1, -23 },
  { 5806, 21, 33, 24, 2, -23 },
  { 5893, 17, 23, 17, 1, -23 },
  { 5942, 18, 23, 19, 0, -23 },
  { 5994, 15, 27, 16, 2, -27 },
  { 6045, 22, 22, 24, 2, -22 },
  { 6106, 21, 22, 20, 2, -22 },
  { 6164, 31, 22, 31, 2, -22 },
  { 6250, 25, 22, 21, -2, -22 },
  { 6319, 26, 32, 20, -3, -22 },
  { 6423, 20, 22, 19, -1, -22 },
  { 6478, 17, 35, 14, 0, -29 },
  { 6553, 4, 41, 23, 10, -31 },
  { 6574, 16, 35, 14, -2, -29 },
  { 6644, 20, 7, 23, 2, -18 },
};

const GFXfont NotoSans_SemiBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMIBOLDITALIC41PT7B_H_
