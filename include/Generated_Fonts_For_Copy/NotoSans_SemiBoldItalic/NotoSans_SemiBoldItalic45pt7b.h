#ifndef _NOTOSANS_SEMIBOLDITALIC45PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0x20, 0x00, 0x7E, 0x3E, 0xF8, 0xFD, 0xF1,
  0xF3, 0xE3, 0xE7, 0x87, 0xDF, 0x0F, 0x3E, 0x1E, 0x78, 0x3C, 0xF0, 0xF9,
  0xE1, 0xE3, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x01,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC0, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x83, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xE7, 0x3C, 0x1F, 0x8E,
  0x08, 0x3E, 0x38, 0x00, 0x7C, 0x70, 0x00, 0xF8, 0xE0, 0x01, 0xF9, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0x3F, 0x00,
  0x0E, 0x7E, 0x00, 0x1C, 0xFC, 0x00, 0x71, 0xF9, 0x00, 0xE3, 0xF3, 0x81,
  0xCF, 0xC7, 0xFB, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x02, 0x03,
  0xFC, 0x00, 0x1E, 0x03, 0xFF, 0x00, 0x1E, 0x03, 0xFF, 0x80, 0x1F, 0x03,
  0xF7, 0xE0, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x00,
  0xF8, 0x7C, 0x0F, 0x80, 0x78, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x07, 0x80,
  0x3E, 0x0F, 0x07, 0x80, 0x1F, 0x07, 0x87, 0xC0, 0x0F, 0x87, 0xC7, 0xC0,
  0x07, 0xC3, 0xE3, 0xC3, 0x83, 0xE1, 0xE3, 0xC7, 0xF9, 0xF1, 0xF3, 0xE7,
  0xFE, 0xFD, 0xF3, 0xE7, 0xFF, 0x3F, 0xF9, 0xE7, 0xEF, 0xDF, 0xF9, 0xE3,
  0xE3, 0xE7, 0xF9, 0xF3, 0xE1, 0xF0, 0x41, 0xF1, 0xF0, 0xF8, 0x00, 0xF0,
  0xF0, 0x7C, 0x00, 0xF0, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x1E, 0x00, 0xF8,
  0x3E, 0x0F, 0x00, 0x78, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0x87, 0xC0, 0x7C,
  0x07, 0xC3, 0xC0, 0x7C, 0x03, 0xE3, 0xE0, 0x3C, 0x01, 0xFF, 0xE0, 0x3E,
  0x00, 0x7F, 0xF0, 0x3E, 0x00, 0x3F, 0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x04, 0x1F, 0xFC, 0x07, 0xE1, 0xFF, 0xF8, 0x1F, 0x8F,
  0xE7, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F, 0x9F, 0x87, 0xE0,
  0x7F, 0x7C, 0x1F, 0x00, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0x83, 0xF0, 0x03,
  0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x80, 0x7F, 0x8F, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE3, 0xF0,
  0x07, 0xFE, 0x0F, 0xE0, 0x7E, 0xF9, 0xF3, 0xE7, 0x9F, 0x3E, 0x78, 0xF1,
  0xE3, 0xC0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x02, 0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xF8, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xC1,
  0x83, 0xFE, 0x00, 0x3E, 0xF8, 0x07, 0xE3, 0xC0, 0x7F, 0x1E, 0x00, 0xF0,
  0xF8, 0x03, 0x07, 0xC0, 0x08, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xC3, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x00, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7D, 0xFB, 0xFF, 0xFF, 0xDF, 0x98, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xC7, 0xE0,
  0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x01, 0xF3, 0xF0,
  0x07, 0xCF, 0xC0, 0x1F, 0x7E, 0x00, 0x7D, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xDF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0,
  0x7F, 0x3F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xFE,
  0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0x7E, 0x7E, 0x7C, 0x78, 0x7C, 0x20, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0x80, 0xFE, 0x01, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF8, 0x3F, 0xC0, 0xC0, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC4, 0x00, 0x3F, 0x8F, 0x83,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x01, 0xF0, 0x3E, 0x03,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xBF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0xC0, 0x07, 0xF0, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xC0, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x60, 0x07, 0xCF, 0xF8, 0x1F, 0xBF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0x07, 0xF1, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF1, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xF1, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F,
  0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x1F, 0x80, 0xFE, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x3F, 0x07, 0xE0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xE0, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00,
  0x0C, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x07, 0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0xFE, 0x3F, 0x07, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0x7E, 0x07, 0xF9, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0xC0, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x83, 0xF0, 0xFC, 0x7F, 0x1F,
  0xC3, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x3F, 0x8F, 0xE3, 0xF0,
  0xFC, 0x18, 0x00, 0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x80,
  0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x78, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x03, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0x87, 0xF1, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x03, 0xE1, 0xF0, 0x0F, 0xFC, 0x1E, 0x1E, 0x03, 0xFF,
  0xE1, 0xE3, 0xE0, 0x7F, 0xFE, 0x1F, 0x3C, 0x0F, 0xC3, 0xC1, 0xF7, 0xC1,
  0xF0, 0x3C, 0x1F, 0x78, 0x3E, 0x07, 0xC1, 0xF7, 0x83, 0xC0, 0x7C, 0x1F,
  0x78, 0x7C, 0x07, 0x81, 0xEF, 0x87, 0xC0, 0x78, 0x1E, 0xF8, 0x78, 0x0F,
  0x81, 0xEF, 0x87, 0x80, 0xF0, 0x3E, 0xF0, 0x78, 0x1F, 0x03, 0xCF, 0x87,
  0x81, 0xF0, 0x7C, 0xF8, 0x78, 0x3F, 0x0F, 0x8F, 0x87, 0xC7, 0xF9, 0xF8,
  0xF8, 0x7F, 0xF7, 0xFF, 0x07, 0x83, 0xFE, 0x7F, 0xE0, 0x7C, 0x1F, 0xC3,
  0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x3C, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x3F, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00,
  0x7E, 0x07, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x1F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0x87, 0xE0, 0x7F, 0x80, 0x30, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x40, 0x3F, 0xF7, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE1, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x83, 0xF0, 0x0F,
  0xF0, 0x3E, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFE, 0x1F, 0x81, 0xFE, 0x00, 0x60, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xFE,
  0xFC, 0x03, 0xFF, 0x9F, 0x80, 0x7F, 0xF3, 0xF0, 0x1F, 0xFE, 0x7E, 0x03,
  0xFF, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00,
  0xF8, 0x3F, 0xC0, 0x3F, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0,
  0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x1F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0xF8, 0x3F, 0x80,
  0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFE, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xEF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE,
  0x07, 0xDF, 0x00, 0x3D, 0xF0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x7D, 0xF0,
  0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xFC, 0x07, 0xDF, 0x01, 0xF3, 0xF0,
  0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0,
  0xF8, 0xF8, 0x0F, 0x8F, 0x07, 0xC7, 0xE0, 0x7E, 0x3C, 0x1F, 0x1F, 0x01,
  0xF0, 0xF0, 0xF8, 0x7C, 0x07, 0xC3, 0xC3, 0xE1, 0xF0, 0x1F, 0x0F, 0x9F,
  0x0F, 0xC0, 0x7C, 0x3E, 0x7C, 0x3F, 0x03, 0xF0, 0xFB, 0xE0, 0xF8, 0x0F,
  0x83, 0xEF, 0x83, 0xE0, 0x3E, 0x0F, 0xFC, 0x0F, 0x80, 0xF8, 0x3F, 0xE0,
  0x7E, 0x03, 0xE0, 0x7F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xC0, 0x7C,
  0x07, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x01, 0xFC,
  0x00, 0x1F, 0x01, 0xFE, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x3F, 0x03, 0xFE,
  0x00, 0x3F, 0x03, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x3E, 0x03, 0xDF,
  0x00, 0x3E, 0x07, 0xDF, 0x80, 0x7E, 0x07, 0xCF, 0x80, 0x7C, 0x07, 0xCF,
  0x80, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x0F, 0xC7,
  0xC0, 0xFC, 0x0F, 0x87, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0xF8, 0x0F, 0x83,
  0xE0, 0xF8, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x01,
  0xF1, 0xF0, 0x1F, 0x01, 0xF9, 0xF0, 0x1F, 0x00, 0xF9, 0xF0, 0x3F, 0x00,
  0xF9, 0xF0, 0x3E, 0x00, 0xFF, 0xF0, 0x3E, 0x00, 0x7F, 0xE0, 0x3E, 0x00,
  0x7F, 0xE0, 0x3E, 0x00, 0x7F, 0xE0, 0x7E, 0x00, 0x3F, 0xE0, 0x7C, 0x00,
  0x3F, 0xC0, 0x7C, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00,
  0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xE3, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0,
  0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x03,
  0xF8, 0x7E, 0x00, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0x81,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x03, 0xF8, 0x7E,
  0x03, 0xF8, 0x3F, 0x0F, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0x1F, 0x83, 0xF8, 0x02, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC2, 0x00, 0x1F, 0x86, 0x00, 0x7F, 0x0F, 0xC7, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7E, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0x7C, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x3F,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE7, 0xC0, 0x00,
  0xFB, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x7C, 0x01, 0xFE, 0x01, 0xF8, 0x7C,
  0x03, 0xFE, 0x01, 0xF8, 0x7C, 0x03, 0xFE, 0x01, 0xF0, 0x7C, 0x07, 0xFE,
  0x03, 0xF0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0xBE, 0x07, 0xE0,
  0x7C, 0x0F, 0xBE, 0x07, 0xE0, 0x7C, 0x0F, 0xBE, 0x07, 0xC0, 0x7C, 0x1F,
  0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x3E, 0x1F,
  0x80, 0x7C, 0x3E, 0x1E, 0x1F, 0x00, 0x7C, 0x7C, 0x1E, 0x3F, 0x00, 0x7C,
  0x7C, 0x1E, 0x3E, 0x00, 0x7C, 0xF8, 0x1E, 0x3E, 0x00, 0x7C, 0xF8, 0x1E,
  0x7C, 0x00, 0x7C, 0xF0, 0x1E, 0x7C, 0x00, 0x7D, 0xF0, 0x1E, 0xFC, 0x00,
  0x7D, 0xF0, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x1E, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x1F,
  0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0x87, 0xE0,
  0x07, 0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0x81,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x07,
  0xC7, 0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x78, 0x00,
  0xF9, 0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x00, 0xFC, 0xFC, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x00, 0x7C,
  0x01, 0x01, 0xFF, 0x1E, 0x03, 0xFF, 0xBE, 0x07, 0xFF, 0xBE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0xFC, 0x00,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0x3F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0, 0x1F, 0xE3,
  0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0xE0, 0x3E, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0x0F,
  0xC0, 0x3E, 0x3F, 0x80, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F,
  0x8F, 0xF0, 0xFE, 0x1F, 0xFF, 0xF8, 0x3D, 0xFF, 0xF0, 0xF9, 0xFF, 0x81,
  0xE1, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x04, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x10, 0x7F, 0x0F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0x0F, 0xC0, 0x1F, 0xE3, 0xE0, 0x0F, 0xFC, 0xF8, 0x07, 0xFF, 0xBE,
  0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F,
  0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xEF, 0x80, 0x3F, 0xF3, 0xE0, 0x07, 0xF8, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x3F, 0x8F, 0xE0,
  0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x01, 0xFB, 0xF0, 0x1F, 0x9F,
  0x83, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xC0,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x87, 0xF0, 0x38, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x80, 0x7F, 0xC7,
  0x80, 0x7F, 0xF7, 0xC0, 0x7F, 0xFB, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x07,
  0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0xFF, 0x07, 0xF9, 0xFF, 0x01,
  0xFF, 0xEF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xE0, 0x0F, 0xE3, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x04, 0x00, 0x7E, 0x03, 0x80, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC3, 0xC0, 0x1F, 0x1F, 0xE0, 0x3E, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F, 0x87, 0xF8, 0x1F, 0x0F, 0xE0, 0x3E,
  0x3F, 0x80, 0x7C, 0x7F, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7C,
  0x01, 0xF8, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x07,
  0xE0, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x41, 0xF8, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xEF,
  0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x41, 0xE0,
  0x0F, 0x80, 0x3C, 0x3F, 0xC1, 0xFF, 0x01, 0xE7, 0xFF, 0x1F, 0xFC, 0x0F,
  0x7F, 0xF9, 0xFF, 0xE0, 0xFB, 0xFF, 0xDF, 0xFF, 0x87, 0xFC, 0x3F, 0xE0,
  0xFC, 0x3F, 0x81, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x7C,
  0x3F, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x41, 0xF0, 0x0F, 0x0F, 0xF0, 0x1E,
  0x7F, 0xF0, 0x7D, 0xFF, 0xF0, 0xFB, 0xFF, 0xE1, 0xFF, 0x0F, 0xC3, 0xFC,
  0x0F, 0x87, 0xF0, 0x1F, 0x1F, 0xC0, 0x3E, 0x3F, 0x80, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7E,
  0x00, 0xF8, 0xFC, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE3, 0xF8, 0x0F,
  0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0x00,
  0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x81, 0xF8,
  0x7F, 0x1F, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x10, 0xF8, 0x00, 0xF1, 0xFF, 0x00, 0x79, 0xFF, 0xC0,
  0x3D, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x1F, 0x07, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x87, 0xF0,
  0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFD,
  0xFF, 0xE0, 0x7E, 0xFF, 0xC0, 0x3F, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0x01, 0xFF,
  0x1E, 0x03, 0xFF, 0xBE, 0x07, 0xFF, 0xBE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF7, 0xE0, 0x1F, 0xC7, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0xFC,
  0x1F, 0x7F, 0x83, 0xCF, 0xE0, 0xFB, 0xFC, 0x1F, 0xFD, 0x83, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xE7, 0xE1, 0xF8, 0x04, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x88, 0x01, 0xF8, 0xF0, 0x3F, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x10, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0,
  0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0x7E, 0x3F, 0xF0, 0x7F, 0xFD,
  0xE0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0, 0x1F, 0xC3, 0xE0, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xF9, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F,
  0x0F, 0x80, 0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07,
  0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xFC,
  0x07, 0xF0, 0x0F, 0xFE, 0x03, 0xF8, 0x0F, 0xDF, 0x03, 0xFC, 0x07, 0xEF,
  0x81, 0xFE, 0x07, 0xE7, 0xC0, 0xFF, 0x03, 0xF3, 0xE0, 0xFF, 0xC1, 0xF1,
  0xF0, 0x7B, 0xE1, 0xF8, 0xF8, 0x7D, 0xF0, 0xF8, 0x7C, 0x3C, 0xF8, 0xFC,
  0x3E, 0x3E, 0x7C, 0x7C, 0x1F, 0x1F, 0x3E, 0x7E, 0x0F, 0x8F, 0x1F, 0x3E,
  0x07, 0xCF, 0x8F, 0x9F, 0x03, 0xE7, 0x87, 0xDF, 0x01, 0xF7, 0xC3, 0xEF,
  0x80, 0xFB, 0xC1, 0xFF, 0xC0, 0x7D, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x07,
  0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0x87, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x02, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3E,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x0F, 0xFA, 0x00,
  0x06, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 33, 12, 1, -32 },
  { 55, 15, 11, 19, 5, -32 },
  { 76, 28, 32, 29, 1, -32 },
  { 188, 23, 37, 25, 1, -34 },
  { 295, 33, 33, 38, 3, -33 },
  { 432, 30, 33, 31, 1, -33 },
  { 556, 7, 11, 11, 5, -32 },
  { 566, 16, 39, 14, 2, -32 },
  { 644, 16, 39, 14, -3, -32 },
  { 722, 21, 21, 25, 4, -34 },
  { 778, 21, 22, 26, 3, -27 },
  { 836, 10, 11, 12, -2, -5 },
  { 850, 12, 4, 14, 1, -14 },
  { 856, 7, 7, 12, 1, -6 },
  { 863, 23, 32, 18, -2, -32 },
  { 955, 22, 33, 25, 2, -33 },
  { 1046, 16, 32, 25, 5, -32 },
  { 1110, 25, 33, 25, -1, -33 },
  { 1214, 23, 33, 25, 1, -33 },
  { 1309, 24, 32, 25, 0, -32 },
  { 1405, 24, 32, 25, 1, -32 },
  { 1501, 23, 33, 25, 2, -33 },
  { 1596, 24, 32, 25, 2, -32 },
  { 1692, 23, 33, 25, 2, -33 },
  { 1787, 22, 33, 25, 2, -33 },
  { 1878, 10, 26, 12, 1, -25 },
  { 1911, 13, 31, 12, -2, -25 },
  { 1962, 21, 23, 26, 3, -28 },
  { 2023, 21, 13, 26, 3, -22 },
  { 2058, 21, 23, 26, 3, -28 },
  { 2119, 18, 34, 20, 3, -33 },
  { 2196, 36, 36, 38, 2, -32 },
  { 2358, 28, 32, 27, -3, -32 },
  { 2470, 26, 32, 28, 1, -32 },
  { 2574, 26, 33, 27, 3, -33 },
  { 2682, 28, 32, 30, 1, -32 },
  { 2794, 25, 32, 24, 1, -32 },
  { 2894, 25, 32, 23, 1, -32 },
  { 2994, 27, 33, 31, 3, -33 },
  { 3106, 30, 32, 31, 1, -32 },
  { 3226, 20, 32, 16, -1, -32 },
  { 3306, 21, 41, 14, -7, -32 },
  { 3414, 30, 32, 27, 1, -32 },
  { 3534, 19, 32, 23, 1, -32 },
  { 3610, 38, 32, 39, 1, -32 },
  { 3762, 32, 32, 33, 1, -32 },
  { 3890, 28, 33, 33, 3, -33 },
  { 4006, 26, 32, 27, 1, -32 },
  { 4110, 28, 41, 33, 3, -33 },
  { 4254, 25, 32, 27, 1, -32 },
  { 4354, 23, 33, 23, 1, -33 },
  { 4449, 23, 32, 23, 4, -32 },
  { 4541, 28, 32, 31, 3, -32 },
  { 4653, 26, 32, 26, 4, -32 },
  { 4757, 40, 32, 40, 4, -32 },
  { 4917, 32, 32, 26, -2, -32 },
  { 5045, 25, 32, 24, 4, -32 },
  { 5145, 27, 32, 24, -1, -32 },
  { 5253, 18, 39, 14, -1, -32 },
  { 5341, 10, 32, 18, 5, -32 },
  { 5381, 18, 39, 14, -3, -32 },
  { 5469, 23, 20, 25, 1, -32 },
  { 5527, 19, 3, 18, -4, 4 },
  { 5535, 8, 7, 14, 7, -34 },
  { 5542, 24, 25, 26, 2, -25 },
  { 5617, 23, 34, 27, 1, -34 },
  { 5715, 20, 25, 21, 2, -25 },
  { 5778, 26, 34, 26, 2, -34 },
  { 5889, 21, 25, 24, 2, -25 },
  { 5955, 26, 45, 16, -5, -34 },
  { 6102, 25, 36, 27, 1, -25 },
  { 6215, 23, 34, 27, 1, -34 },
  { 6313, 13, 34, 13, 1, -34 },
  { 6369, 20, 45, 13, -6, -34 },
  { 6482, 25, 34, 24, 1, -34 },
  { 6589, 13, 34, 13, 1, -34 },
  { 6645, 37, 25, 40, 1, -25 },
  { 6761, 23, 25, 27, 1, -25 },
  { 6833, 22, 25, 26, 2, -25 },
  { 6902, 25, 36, 27, -1, -25 },
  { 7015, 24, 36, 26, 2, -25 },
  { 7123, 19, 25, 19, 1, -25 },
  { 7183, 20, 25, 21, 0, -25 },
  { 7246, 16, 30, 17, 2, -30 },
  { 7306, 24, 24, 27, 2, -24 },
  { 7378, 23, 24, 22, 2, -24 },
  { 7447, 33, 24, 34, 3, -24 },
  { 7546, 27, 24, 23, -2, -24 },
  { 7627, 29, 35, 22, -4, -24 },
  { 7754, 22, 24, 21, -1, -24 },
  { 7820, 19, 39, 16, 0, -32 },
  { 7913, 4, 44, 25, 11, -34 },
  { 7935, 18, 39, 16, -2, -32 },
  { 8023, 21, 7, 26, 3, -19 },
};

const GFXfont NotoSans_SemiBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMIBOLDITALIC45PT7B_H_
