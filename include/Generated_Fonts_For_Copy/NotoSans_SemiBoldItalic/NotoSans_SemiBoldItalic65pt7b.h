#ifndef _NOTOSANS_SEMIBOLDITALIC65PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE7, 0xF8,
  0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x07, 0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F,
  0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F,
  0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xBF, 0xC0, 0x3F, 0xE3, 0xC1, 0xE0, 0x3F, 0xE1, 0xE0,
  0x20, 0x1F, 0xE1, 0xF0, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x07, 0xF8, 0x78,
  0x00, 0x03, 0xFC, 0x3C, 0x00, 0x01, 0xFE, 0x1E, 0x00, 0x00, 0xFF, 0x9F,
  0x00, 0x00, 0x7F, 0xEF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0x3F, 0xF0, 0x00,
  0x07, 0x8F, 0xF8, 0x00, 0x03, 0xC3, 0xFC, 0x00, 0x03, 0xE1, 0xFE, 0x00,
  0x01, 0xE0, 0xFF, 0x00, 0x00, 0xF0, 0x7F, 0x88, 0x00, 0x78, 0x7F, 0x86,
  0x00, 0x7C, 0x3F, 0xC3, 0xE0, 0x3E, 0x7F, 0xE1, 0xFF, 0x9E, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0x00,
  0xFE, 0x07, 0xF0, 0xFC, 0x3F, 0xF0, 0xFE, 0x07, 0xF1, 0xFC, 0x7F, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0xFF, 0xFC, 0x7F, 0x1F, 0xE3, 0xF1, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC7, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xE7, 0xF8, 0xFE,
  0x3F, 0xFF, 0x1F, 0xC7, 0xF0, 0x7E, 0x3F, 0xFE, 0x1F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xFC, 0x3F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x7F,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x7E,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0xFC,
  0x00, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xFE, 0x00, 0x00,
  0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0xFF,
  0xFF, 0xF0, 0x07, 0xF8, 0x7F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x03, 0xFE, 0x3F,
  0xC1, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x3F,
  0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF,
  0x8F, 0xF8, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE7, 0xF9, 0xFE, 0x7F,
  0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F,
  0x83, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x18, 0x01, 0xF8, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xC0,
  0x01, 0xFF, 0x0F, 0x80, 0x03, 0xFF, 0x9F, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x2F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0x87, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x03,
  0xFC, 0x7E, 0x00, 0x0F, 0xF8, 0xFC, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x30,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xF8, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80,
  0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0,
  0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFB, 0xFC, 0xFF, 0xF7, 0xF8, 0x7F, 0xE7, 0xF8, 0x3F, 0x87,
  0xF8, 0x3E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x10, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x01, 0xC0, 0x01,
  0xFF, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0x78,
  0x00, 0xFF, 0xC0, 0x08, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x04, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x08, 0x00, 0x00, 0xFF, 0x83, 0xC0, 0x00,
  0x7F, 0xE0, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF4, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x30,
  0x00, 0x07, 0xFE, 0x0F, 0x00, 0x03, 0xFF, 0x83, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x07, 0xF0, 0xFF, 0xE0,
  0x07, 0xF9, 0xFF, 0xFC, 0x03, 0xFD, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00,
  0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0x9F, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xEF,
  0xF0, 0x3F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFE, 0x3F, 0x80, 0x1F, 0xF0, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x05, 0xD0, 0x00, 0x00, 0x00, 0x7C,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0x7C, 0x03, 0xFF, 0x1C, 0x00, 0x7F, 0xC4, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xFF, 0xF8, 0x1F, 0xC3, 0xF8, 0x03,
  0xFF, 0xFF, 0x81, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x1F, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xFC, 0x3F, 0x80, 0xFC, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x9F, 0x80, 0xFF, 0x00, 0xFC, 0x03, 0xF7,
  0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F,
  0xDF, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFB, 0xF0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0xFC, 0x00, 0x7E,
  0x01, 0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xEF, 0xC0, 0xFE, 0x00, 0xFE, 0x01, 0xFD, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x3F, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F,
  0x00, 0xFF, 0x01, 0xF8, 0xFE, 0x07, 0xE0, 0x3F, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x0F, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xFF, 0xEF, 0xFF, 0xF0, 0x3F,
  0x01, 0xFF, 0xF9, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0xFE, 0x3F, 0xFF, 0x00,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xCF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F,
  0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F,
  0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x03,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x38, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0xF8, 0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x04, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF9, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF9,
  0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0x7E, 0x00,
  0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF1,
  0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x7F, 0x80,
  0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC1, 0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x7F, 0x03,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xC3,
  0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x3F, 0x9F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0x00,
  0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFD, 0xFC, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x3F,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x7F,
  0x80, 0x03, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF3, 0xFC,
  0x00, 0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x00, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x03, 0xFC, 0x00,
  0x1F, 0xEF, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xDF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x1F, 0xFF, 0xC0, 0x1F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x0F, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x0F,
  0xF9, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x00,
  0x06, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x0C, 0x00, 0x03, 0xFF, 0x03, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFF,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFC,
  0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE0, 0x07,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x1F, 0x83, 0xFC, 0x00, 0x3F,
  0xC3, 0xF8, 0x0F, 0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x07, 0xE1, 0xFE,
  0x00, 0x0F, 0xF1, 0xFC, 0x03, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0xFE, 0x01,
  0xF8, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0xFC, 0x7F, 0x80, 0x01, 0xFE,
  0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x3F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xEF, 0xF0, 0x00, 0x0F, 0xEF,
  0xE0, 0x03, 0xF7, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x03,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF,
  0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xFC, 0xFE, 0x01,
  0xFF, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0x80, 0x3F, 0xFF,
  0xEF, 0xE0, 0x07, 0xFF, 0xE3, 0xF8, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0x1F,
  0xF8, 0x3F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0xC0,
  0x03, 0xF8, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0xF0, 0x1F, 0xCF, 0xFF, 0xF8, 0x07,
  0xF3, 0xFF, 0xFC, 0x01, 0xF8, 0x7F, 0xFE, 0x00, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x1C, 0x0F, 0xFC, 0x00,
  0x41, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x06, 0x07, 0xFF,
  0x03, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x2F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF,
  0x00, 0x0F, 0xFF, 0xC7, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0x80, 0x0F, 0xFF,
  0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x7E, 0x00, 0x1F, 0xFF, 0xF7, 0xF0, 0x00,
  0x7F, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0xF1, 0xFC, 0x00, 0x07, 0xFE, 0x0F,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xE7,
  0xFC, 0x03, 0xFF, 0x9F, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x81, 0xFF, 0x80, 0x1E, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x02, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x02, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x20, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x7F, 0x00, 0x1F, 0xFF, 0x87, 0xF0, 0x03, 0xFF,
  0xFC, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xE0, 0x0F, 0xFF, 0xFE, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xBF, 0x80, 0x0F, 0xFF, 0xF7, 0xF8,
  0x00, 0x7F, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0xC7, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0x30, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x80, 0x00, 0x3F, 0xC0, 0x0E, 0x00, 0x07,
  0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x40,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x03, 0xF8, 0xFF, 0xFC, 0x01, 0xFE,
  0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xF0, 0x0F, 0xF0,
  0x3F, 0xF8, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xC1, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x08,
  0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x04, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC,
  0x00, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF9,
  0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x0F, 0xC3, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xFF, 0x80,
  0x1F, 0xC3, 0xFF, 0xF0, 0x07, 0xF1, 0xFF, 0xFE, 0x01, 0xFC, 0xFF, 0xFF,
  0x80, 0x7F, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0,
  0x03, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE,
  0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE,
  0x3F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x1F,
  0xFC, 0x00, 0x07, 0xE1, 0xFF, 0xF0, 0x00, 0x7F, 0x1F, 0xFF, 0xC0, 0x03,
  0xF9, 0xFF, 0xFE, 0x00, 0x1F, 0xDF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF7, 0xFF, 0xFC,
  0x00, 0x7F, 0x9F, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0xFC, 0x00, 0x1F, 0xE1,
  0xFF, 0x80, 0x01, 0xFE, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x07, 0xF0, 0x07, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xFC, 0x7E, 0x01, 0xFF,
  0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xDF,
  0xE0, 0x07, 0xFF, 0xE7, 0xF8, 0x00, 0xFF, 0xF1, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x02,
  0x03, 0xF0, 0x0F, 0xC1, 0xFF, 0x00, 0xFC, 0x3F, 0xF0, 0x1F, 0xC7, 0xFE,
  0x01, 0xFC, 0xFF, 0xE0, 0x1F, 0xDF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFE, 0x1F, 0xC0, 0xFF, 0x80, 0x38, 0x0F, 0xF0, 0x00, 0x81,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x08, 0x00, 0x0F, 0xF0, 0xC0, 0x01, 0xFF, 0x0F, 0x00, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x08,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x3F, 0xF8, 0x3F, 0xC0, 0x1F, 0xFC,
  0x1F, 0xE0, 0x3F, 0xFC, 0x0F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0x7F,
  0x03, 0xFF, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0xFF, 0x0F,
  0xC0, 0x1F, 0xFF, 0x07, 0xE0, 0x03, 0xFF, 0x07, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xC0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xF8, 0x7F, 0x80,
  0x01, 0xFC, 0x7F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xE3, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF1, 0xFE, 0x01,
  0xFB, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFD, 0xF0, 0x0F, 0xF8, 0x7F, 0x80,
  0xFC, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7E, 0x7E, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x3F, 0x81, 0xFE, 0x07, 0xF8,
  0x3F, 0x9F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0x8F, 0xE0, 0xFF, 0x00, 0xFE,
  0x1F, 0xC7, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x80, 0x3F,
  0x87, 0xE1, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0xC0, 0x0F,
  0xE3, 0xF0, 0x3F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x1F, 0x9F, 0xE0, 0x03,
  0xF9, 0xF8, 0x0F, 0xCF, 0xE0, 0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x00,
  0xFE, 0xFE, 0x03, 0xF7, 0xF8, 0x00, 0x7F, 0x7E, 0x01, 0xFB, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xF0,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x7F, 0xFC,
  0x00, 0x0D, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0xC0, 0x00, 0xFF, 0xF9, 0x00, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiBoldItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 19, 47, 18, 1, -46 },
  { 113, 22, 16, 28, 7, -46 },
  { 157, 40, 46, 42, 2, -46 },
  { 387, 33, 53, 36, 2, -49 },
  { 606, 48, 48, 54, 4, -47 },
  { 894, 42, 48, 45, 2, -47 },
  { 1146, 10, 16, 16, 7, -46 },
  { 1166, 24, 56, 21, 2, -46 },
  { 1334, 23, 57, 21, -5, -47 },
  { 1498, 31, 31, 36, 6, -50 },
  { 1619, 31, 32, 37, 4, -39 },
  { 1743, 15, 16, 18, -3, -8 },
  { 1773, 18, 7, 21, 1, -21 },
  { 1789, 10, 10, 18, 1, -9 },
  { 1802, 34, 47, 26, -3, -47 },
  { 2002, 32, 48, 36, 3, -47 },
  { 2194, 24, 46, 36, 7, -46 },
  { 2332, 36, 47, 36, -1, -47 },
  { 2544, 34, 48, 36, 1, -47 },
  { 2748, 35, 46, 36, 0, -46 },
  { 2950, 34, 47, 36, 1, -46 },
  { 3150, 33, 48, 36, 3, -47 },
  { 3348, 34, 46, 36, 4, -46 },
  { 3544, 34, 48, 36, 2, -47 },
  { 3748, 31, 48, 36, 3, -47 },
  { 3934, 16, 37, 18, 1, -36 },
  { 4008, 20, 44, 18, -3, -36 },
  { 4118, 31, 33, 37, 4, -40 },
  { 4246, 31, 18, 37, 4, -32 },
  { 4316, 31, 33, 37, 4, -40 },
  { 4444, 26, 48, 29, 5, -47 },
  { 4600, 51, 52, 55, 3, -46 },
  { 4932, 40, 46, 39, -4, -46 },
  { 5162, 37, 46, 40, 2, -46 },
  { 5375, 38, 48, 39, 4, -47 },
  { 5603, 40, 46, 44, 2, -46 },
  { 5833, 35, 46, 35, 2, -46 },
  { 6035, 35, 46, 33, 2, -46 },
  { 6237, 40, 48, 45, 4, -47 },
  { 6477, 43, 46, 45, 2, -46 },
  { 6725, 29, 46, 23, -2, -46 },
  { 6892, 31, 59, 20, -10, -46 },
  { 7121, 43, 46, 39, 2, -46 },
  { 7369, 27, 46, 33, 2, -46 },
  { 7525, 55, 46, 56, 2, -46 },
  { 7842, 46, 46, 48, 2, -46 },
  { 8107, 41, 48, 47, 4, -47 },
  { 8353, 37, 46, 39, 2, -46 },
  { 8566, 41, 58, 47, 4, -47 },
  { 8864, 36, 46, 39, 2, -46 },
  { 9071, 34, 48, 34, 1, -47 },
  { 9275, 33, 46, 34, 6, -46 },
  { 9465, 40, 47, 45, 5, -46 },
  { 9700, 37, 46, 37, 6, -46 },
  { 9913, 57, 46, 57, 6, -46 },
  { 10241, 47, 46, 38, -4, -46 },
  { 10512, 35, 46, 35, 6, -46 },
  { 10714, 39, 46, 35, -1, -46 },
  { 10939, 26, 56, 21, -1, -46 },
  { 11121, 14, 47, 26, 7, -47 },
  { 11204, 26, 56, 21, -4, -46 },
  { 11386, 32, 30, 36, 2, -47 },
  { 11506, 27, 4, 26, -6, 6 },
  { 11520, 13, 11, 20, 9, -50 },
  { 11538, 34, 37, 38, 3, -36 },
  { 11696, 34, 50, 38, 1, -49 },
  { 11909, 28, 37, 31, 3, -36 },
  { 12039, 37, 50, 38, 3, -49 },
  { 12271, 30, 37, 35, 3, -36 },
  { 12410, 37, 66, 23, -7, -50 },
  { 12716, 36, 52, 38, 1, -36 },
  { 12950, 34, 49, 39, 1, -49 },
  { 13159, 19, 49, 18, 1, -49 },
  { 13276, 28, 65, 18, -8, -49 },
  { 13504, 37, 49, 35, 1, -49 },
  { 13731, 19, 49, 18, 1, -49 },
  { 13848, 54, 36, 58, 1, -36 },
  { 14091, 34, 36, 39, 1, -36 },
  { 14244, 32, 37, 38, 3, -36 },
  { 14392, 37, 52, 38, -2, -36 },
  { 14633, 34, 52, 38, 3, -36 },
  { 14854, 28, 36, 27, 1, -36 },
  { 14980, 28, 37, 30, 1, -36 },
  { 15110, 23, 44, 25, 3, -43 },
  { 15237, 33, 36, 39, 4, -35 },
  { 15386, 33, 35, 32, 3, -35 },
  { 15531, 49, 35, 50, 4, -35 },
  { 15746, 39, 35, 33, -3, -35 },
  { 15917, 41, 51, 32, -5, -35 },
  { 16179, 31, 35, 30, -1, -35 },
  { 16315, 27, 56, 23, 0, -46 },
  { 16504, 6, 64, 36, 15, -49 },
  { 16552, 26, 56, 23, -3, -46 },
  { 16734, 31, 10, 37, 4, -28 },
};

const GFXfont NotoSans_SemiBoldItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMIBOLDITALIC65PT7B_H_
