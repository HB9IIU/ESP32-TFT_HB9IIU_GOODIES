#ifndef _NOTOSANS_SEMIBOLDITALIC67PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x0F, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F,
  0xCF, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF0,
  0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0x9E, 0x7F, 0x00, 0xFF, 0x8F, 0x83, 0xC0, 0x3F,
  0xC3, 0xE0, 0x20, 0x1F, 0xF0, 0xF0, 0x00, 0x07, 0xF8, 0x3C, 0x00, 0x01,
  0xFE, 0x0F, 0x00, 0x00, 0x7F, 0x87, 0xC0, 0x00, 0x1F, 0xF1, 0xF0, 0x00,
  0x07, 0xFC, 0x78, 0x00, 0x00, 0xFF, 0xDE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xBF, 0xF0, 0x00, 0x03, 0xE7, 0xFE, 0x00, 0x00, 0xF8, 0xFF, 0x80,
  0x00, 0x3C, 0x3F, 0xE0, 0x00, 0x0F, 0x07, 0xF8, 0x00, 0x07, 0xC1, 0xFE,
  0x00, 0x01, 0xF0, 0xFF, 0x88, 0x00, 0x7C, 0x3F, 0xC3, 0x80, 0x1E, 0x1F,
  0xF0, 0xFC, 0x07, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0xFF, 0x87, 0xF0, 0x3F, 0x87, 0xF1, 0xFF, 0xE3, 0xF8, 0x1F, 0xC7, 0xF1,
  0xFF, 0xF8, 0xFE, 0x1F, 0xC3, 0xF1, 0xFF, 0xFE, 0x7F, 0xBF, 0xE3, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xE3, 0xF8,
  0xFF, 0x0F, 0xE7, 0xFF, 0xF1, 0xF8, 0x7F, 0x07, 0xF1, 0xFF, 0xE1, 0xFC,
  0x7F, 0x03, 0xF8, 0x3F, 0xE1, 0xFC, 0x3F, 0x81, 0xFC, 0x03, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xCF, 0xF8, 0x07, 0xFC,
  0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE3, 0xFF,
  0x01, 0xFF, 0x8F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0x01,
  0xFF, 0x7F, 0xC3, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xC0, 0x03, 0xFF,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xE1, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F, 0x9F,
  0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x20, 0x01, 0xF8, 0x00, 0x38, 0x03, 0xF8, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x7F, 0xE3, 0xF0, 0x00, 0x7F, 0xFB,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x0F, 0xF0,
  0xFC, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x07, 0x80, 0x7F, 0x00, 0x03, 0x80, 0x7F, 0x80, 0x01, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x02, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF,
  0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x3F,
  0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F,
  0xFB, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x03,
  0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x0F, 0xFE,
  0x7F, 0x87, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7C, 0x1F, 0xF0, 0x38,
  0x0F, 0xF0, 0x08, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x07, 0xFE, 0x00, 0x10, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xBF, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x07, 0x00, 0x0F,
  0xFC, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x84, 0x00, 0x00, 0x3F, 0xF0,
  0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0x00, 0x03, 0xFF, 0x83, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x07, 0xF8, 0x17, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x0C, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x80,
  0x00, 0x07, 0xFE, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x3F, 0xFC,
  0x0F, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x3E, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0x87,
  0xFF, 0x00, 0x3F, 0xE7, 0xFF, 0xE0, 0x0F, 0xF3, 0xFF, 0xFC, 0x03, 0xFD,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xF1, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x02, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xDF, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x0F,
  0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F,
  0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0x3F,
  0xE0, 0x07, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFD, 0xFE, 0x07,
  0xFF, 0xF9, 0xFE, 0x03, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xE3, 0xFC, 0x00,
  0x3F, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x80, 0x03, 0xFF, 0x80, 0xFC, 0x3F, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0B,
  0xC0, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3F,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF1, 0xFF, 0x9F, 0xFE, 0x1F, 0x00, 0x7F, 0xE3, 0x80, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x7F, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xC7, 0xE0, 0x0F, 0xFE, 0x7F, 0x80, 0x7E, 0x7F, 0x00, 0xFF,
  0x01, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0x9F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xEF,
  0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x03,
  0xFB, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xDF, 0x80, 0xFC, 0x00, 0x7E,
  0x00, 0xFD, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xEF, 0xE0, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xFB, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0xFE,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x80, 0xFF, 0x80, 0xFE,
  0x3F, 0x81, 0xFC, 0x07, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFF, 0xF1,
  0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0xDF, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xFC,
  0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F,
  0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x87, 0xFC, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x07, 0xFF, 0x00, 0x00,
  0x40, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x04, 0x00, 0x7F, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x7F,
  0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFF, 0x80,
  0x3F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x7F, 0xC0, 0x07, 0xFF,
  0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xC7, 0xFC, 0x00,
  0x7F, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE3,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFC,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB,
  0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x01, 0xFE, 0xFE, 0x00,
  0x07, 0xF7, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF8,
  0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0x7E, 0x00, 0x3F,
  0x8F, 0xF0, 0x03, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x03,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x3F, 0x80, 0x7F, 0x80, 0x1F,
  0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xFE, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF8,
  0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF8,
  0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x3F, 0xF0, 0x00, 0x60,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x04, 0x00, 0x00, 0x7F, 0xC0, 0xE0,
  0x00, 0x1F, 0xF8, 0x1F, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8,
  0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFF,
  0x80, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x81, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x07,
  0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x07, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xC7, 0xF8, 0x00,
  0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF3,
  0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xE0,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFE,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0xBF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x04, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0,
  0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7E, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xFC,
  0x3F, 0x80, 0x7F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xF9, 0xFC, 0x07, 0xFF,
  0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07,
  0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFC, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF7, 0xF0,
  0x07, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFF, 0x1F, 0xC0, 0x07, 0xFF, 0xC3,
  0xF8, 0x00, 0x7F, 0xE0, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0x1F,
  0xFF, 0x00, 0x1F, 0xEF, 0xFF, 0xF0, 0x07, 0xF9, 0xFF, 0xFE, 0x00, 0xFF,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xF9, 0xFF, 0xFF, 0x80, 0x7F, 0x1F, 0xFF, 0xE0, 0x0F, 0xC1, 0xFF,
  0xF0, 0x03, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1C, 0x0F, 0xFE, 0x00, 0x20, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x10, 0x3F, 0xF0, 0x03, 0x81,
  0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0x3F, 0xE0, 0x03, 0xFF, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xFB, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF1,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x7F, 0x00,
  0x0F, 0xFF, 0xF9, 0xFC, 0x00, 0x1F, 0xFF, 0xC7, 0xF0, 0x00, 0x3F, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFE, 0x1F,
  0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x3F, 0xE0,
  0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x04, 0x0F, 0xFC, 0x00, 0x18, 0x1F, 0xFC, 0x01, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE7, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xC0, 0x07, 0xFF, 0xF0,
  0xFE, 0x00, 0x7F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0xFE, 0x7F, 0x00, 0x7F,
  0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x9F, 0xE0,
  0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x07, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0C, 0x00,
  0x07, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x07,
  0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0x1F, 0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0xF8,
  0x07, 0xF9, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xFE,
  0x00, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x40,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFE, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xF8, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x3F, 0x9F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x80,
  0xFF, 0xF8, 0x3F, 0xEF, 0xC1, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC1, 0xFF, 0xE0, 0x03,
  0xF8, 0x7F, 0xFE, 0x00, 0xFE, 0x3F, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0xFC,
  0x03, 0xF9, 0xFF, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0x81, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xF0, 0x01, 0xFE, 0x0F,
  0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xBF, 0xE0,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x1F,
  0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x7F, 0xFE, 0x00,
  0x07, 0xE3, 0xFF, 0xFC, 0x00, 0x3F, 0x9F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF7, 0xFF, 0xFF, 0x00, 0x3F, 0xCF,
  0xFF, 0xF8, 0x00, 0xFF, 0x3F, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x7F,
  0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xFF, 0xBF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0x81, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x7F, 0xFE,
  0x03, 0xFF, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFD,
  0xFE, 0x00, 0x7F, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0x8F, 0xF8, 0x00, 0x7F,
  0xE1, 0xFE, 0x00, 0x00, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x87, 0xFE,
  0x01, 0xFC, 0x7F, 0xE0, 0x1F, 0xE7, 0xFF, 0x00, 0xFE, 0x7F, 0xF8, 0x07,
  0xF7, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0x1F, 0xE0, 0xFF, 0x80, 0x1C, 0x0F, 0xF8, 0x00, 0x40,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0xFF, 0x8C, 0x00, 0x1F,
  0xF8, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0xC3, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x07, 0xFE, 0x0F, 0xF0,
  0x03, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xF0, 0x3F,
  0xF0, 0xFD, 0xFC, 0x0F, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0x9F, 0xC0,
  0x7F, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xF0, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8,
  0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F,
  0xC3, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFB, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x7F, 0x01, 0xFF, 0x0F, 0xF0, 0x1F,
  0xDF, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xE0, 0x7F, 0x03,
  0xF9, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x7F, 0x07, 0xFC, 0x07, 0xF0,
  0x3F, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x80, 0x7F,
  0x07, 0xF1, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF0, 0x07,
  0xF0, 0xFE, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x07, 0xF1, 0xFE, 0x00,
  0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xE0, 0x7F, 0x3F, 0xC0,
  0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFC, 0x07, 0xF7, 0xF8,
  0x00, 0x7F, 0x7F, 0x01, 0xFD, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x7F, 0x7F,
  0x00, 0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x1F, 0xFE, 0x00, 0x01, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0xC0,
  0x01, 0xFF, 0xFC, 0x80, 0x00, 0x3F, 0xF8, 0x80, 0x00, 0x01, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 19, 49, 19, 1, -48 },
  { 118, 23, 17, 29, 7, -48 },
  { 167, 42, 48, 43, 2, -48 },
  { 419, 34, 55, 37, 2, -51 },
  { 653, 49, 50, 56, 4, -49 },
  { 960, 43, 50, 47, 2, -49 },
  { 1229, 10, 17, 16, 7, -48 },
  { 1251, 23, 59, 22, 3, -48 },
  { 1421, 24, 59, 22, -5, -48 },
  { 1598, 32, 32, 37, 6, -51 },
  { 1726, 32, 33, 38, 4, -40 },
  { 1858, 15, 17, 18, -3, -8 },
  { 1890, 19, 8, 21, 1, -22 },
  { 1909, 10, 11, 18, 1, -10 },
  { 1923, 35, 48, 27, -3, -48 },
  { 2133, 33, 50, 37, 3, -49 },
  { 2340, 25, 48, 37, 7, -48 },
  { 2490, 37, 49, 37, -1, -49 },
  { 2717, 35, 50, 37, 1, -49 },
  { 2936, 36, 48, 37, 0, -48 },
  { 3152, 36, 49, 37, 1, -48 },
  { 3373, 34, 50, 37, 3, -49 },
  { 3586, 35, 48, 37, 4, -48 },
  { 3796, 35, 50, 37, 2, -49 },
  { 4015, 32, 50, 37, 3, -49 },
  { 4215, 16, 38, 18, 1, -37 },
  { 4291, 20, 46, 18, -3, -37 },
  { 4406, 32, 34, 38, 4, -41 },
  { 4542, 32, 19, 38, 4, -33 },
  { 4618, 32, 34, 38, 4, -41 },
  { 4754, 27, 50, 30, 5, -49 },
  { 4923, 53, 54, 57, 3, -48 },
  { 5281, 41, 48, 40, -4, -48 },
  { 5527, 38, 48, 41, 2, -48 },
  { 5755, 39, 50, 40, 4, -49 },
  { 5999, 41, 48, 45, 2, -48 },
  { 6245, 36, 48, 36, 2, -48 },
  { 6461, 36, 48, 34, 2, -48 },
  { 6677, 41, 50, 46, 4, -49 },
  { 6934, 45, 48, 46, 2, -48 },
  { 7204, 30, 48, 24, -2, -48 },
  { 7384, 32, 62, 21, -11, -48 },
  { 7632, 44, 48, 40, 2, -48 },
  { 7896, 27, 48, 34, 2, -48 },
  { 8058, 56, 48, 58, 2, -48 },
  { 8394, 48, 48, 50, 2, -48 },
  { 8682, 43, 50, 49, 4, -49 },
  { 8951, 38, 48, 40, 2, -48 },
  { 9179, 43, 60, 49, 4, -49 },
  { 9502, 37, 48, 40, 2, -48 },
  { 9724, 35, 50, 35, 1, -49 },
  { 9943, 34, 48, 35, 6, -48 },
  { 10147, 42, 49, 46, 5, -48 },
  { 10405, 39, 48, 39, 6, -48 },
  { 10639, 59, 48, 59, 6, -48 },
  { 10993, 48, 48, 39, -4, -48 },
  { 11281, 37, 48, 36, 6, -48 },
  { 11503, 40, 48, 36, -1, -48 },
  { 11743, 27, 59, 21, -1, -48 },
  { 11943, 15, 48, 27, 7, -48 },
  { 12033, 27, 59, 21, -5, -48 },
  { 12233, 33, 31, 37, 2, -48 },
  { 12361, 28, 5, 27, -6, 6 },
  { 12379, 13, 10, 21, 10, -51 },
  { 12396, 35, 38, 39, 3, -37 },
  { 12563, 35, 52, 39, 1, -51 },
  { 12791, 29, 38, 32, 3, -37 },
  { 12929, 38, 52, 39, 3, -51 },
  { 13176, 31, 38, 36, 3, -37 },
  { 13324, 38, 67, 24, -7, -51 },
  { 13643, 37, 53, 40, 1, -37 },
  { 13889, 35, 51, 40, 1, -51 },
  { 14113, 19, 50, 19, 1, -50 },
  { 14232, 29, 66, 19, -9, -50 },
  { 14472, 38, 51, 36, 1, -51 },
  { 14715, 20, 51, 19, 1, -51 },
  { 14843, 55, 37, 60, 1, -37 },
  { 15098, 35, 37, 40, 1, -37 },
  { 15260, 33, 38, 39, 3, -37 },
  { 15417, 38, 53, 39, -2, -37 },
  { 15669, 35, 53, 39, 3, -37 },
  { 15901, 29, 37, 28, 1, -37 },
  { 16036, 28, 38, 31, 1, -37 },
  { 16169, 24, 45, 26, 3, -44 },
  { 16304, 34, 37, 40, 4, -36 },
  { 16462, 34, 36, 33, 3, -36 },
  { 16615, 50, 36, 51, 4, -36 },
  { 16840, 40, 36, 35, -3, -36 },
  { 17020, 42, 52, 33, -5, -36 },
  { 17293, 32, 36, 31, -1, -36 },
  { 17437, 28, 59, 24, 0, -48 },
  { 17644, 6, 67, 37, 16, -51 },
  { 17695, 27, 59, 24, -3, -48 },
  { 17895, 32, 11, 38, 4, -29 },
};

const GFXfont NotoSans_SemiBoldItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_SEMIBOLDITALIC67PT7B_H_
