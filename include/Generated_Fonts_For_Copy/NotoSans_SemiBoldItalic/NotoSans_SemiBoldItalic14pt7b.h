#ifndef _NOTOSANS_SEMIBOLDITALIC14PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x60, 0xCC, 0x7A, 0xD7, 0xA0, 0x09, 0x04, 0x86,
  0xCF, 0xF1, 0x21, 0xB3, 0xFC, 0x48, 0x24, 0x36, 0x00, 0x04, 0x0C, 0x3F,
  0x28, 0x28, 0x38, 0x0E, 0x16, 0x96, 0xFC, 0x10, 0x20, 0x70, 0xB6, 0x4D,
  0xB2, 0x58, 0xB5, 0xFA, 0xD1, 0xA4, 0xCB, 0x26, 0xD0, 0xE0, 0x1E, 0x09,
  0x8C, 0xC2, 0xC1, 0xC3, 0xED, 0xB7, 0x8E, 0x6F, 0x3F, 0xC0, 0x69, 0x60,
  0x19, 0x19, 0x8C, 0x42, 0x10, 0x84, 0x21, 0x80, 0x10, 0xC6, 0x31, 0x8C,
  0x62, 0x31, 0x99, 0x80, 0x10, 0x33, 0x41, 0xF3, 0x8D, 0x13, 0x00, 0x10,
  0x23, 0xFF, 0xF1, 0x02, 0x00, 0x2D, 0x60, 0x7F, 0xF0, 0x03, 0x06, 0x04,
  0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x3C, 0xDB, 0x1E, 0x3C, 0x50,
  0xA3, 0x46, 0xD9, 0xE0, 0x3B, 0xBD, 0x63, 0x11, 0x8C, 0x63, 0x00, 0x3E,
  0xEC, 0x08, 0x30, 0x61, 0x86, 0x30, 0xFF, 0xF8, 0x3E, 0x4C, 0x08, 0x33,
  0xC7, 0x81, 0x83, 0x8D, 0xF0, 0x06, 0x1C, 0x38, 0xB3, 0x6C, 0xBF, 0xFF,
  0x0C, 0x10, 0x1F, 0x3E, 0x30, 0x20, 0x7C, 0x06, 0x06, 0x06, 0x8C, 0xF8,
  0x1E, 0x61, 0x86, 0x0F, 0xD9, 0xA3, 0x46, 0xD8, 0xF0, 0x7F, 0xFC, 0x30,
  0x61, 0x86, 0x0C, 0x30, 0x61, 0x80, 0x1E, 0x33, 0x33, 0x36, 0x1C, 0x7C,
  0x46, 0xC6, 0x66, 0x7C, 0x7D, 0xBC, 0x71, 0xCF, 0xF0, 0xC2, 0xBB, 0xC0,
  0x27, 0x00, 0x00, 0xCC, 0x11, 0xC0, 0x00, 0x00, 0x8C, 0x46, 0x00, 0x02,
  0x1C, 0xE7, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x81, 0x81,
  0xC0, 0xE0, 0xEE, 0x30, 0x40, 0xF9, 0x30, 0xC6, 0x31, 0x84, 0x00, 0xC3,
  0x00, 0x0F, 0x86, 0x19, 0x81, 0x67, 0xB9, 0x37, 0x64, 0xEC, 0x95, 0xFE,
  0x89, 0x08, 0x00, 0xFC, 0x00, 0x07, 0x03, 0x83, 0xC1, 0x61, 0xB0, 0x88,
  0xFC, 0xC2, 0x61, 0x60, 0xC0, 0x3F, 0x37, 0x31, 0x33, 0x3E, 0x7E, 0x63,
  0x63, 0x7E, 0xFC, 0x1F, 0x33, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE4,
  0x7C, 0x3E, 0x1F, 0x8C, 0x66, 0x32, 0x1B, 0x0D, 0x86, 0xC6, 0x7E, 0x7E,
  0x00, 0x3F, 0x3F, 0x30, 0x30, 0x3E, 0x7E, 0x60, 0x60, 0x7C, 0xFC, 0x3F,
  0x3F, 0x30, 0x30, 0x3E, 0x7E, 0x60, 0x60, 0x60, 0xC0, 0x1F, 0x3B, 0x60,
  0xC0, 0xC0, 0xCF, 0xC3, 0xC2, 0xE6, 0x7E, 0x30, 0xCC, 0x23, 0x18, 0xC6,
  0x3F, 0x9F, 0xE6, 0x11, 0x8C, 0x63, 0x30, 0xC0, 0x3C, 0x43, 0x0C, 0x30,
  0xC2, 0x18, 0x63, 0xC0, 0x04, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x43,
  0x3C, 0xE0, 0x31, 0xCC, 0xC3, 0x60, 0xF0, 0x2C, 0x1F, 0x06, 0xC1, 0x98,
  0x66, 0x31, 0xC0, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0x7F, 0xF0, 0x38,
  0x73, 0x87, 0x38, 0xF2, 0x8A, 0x29, 0xA6, 0x96, 0x6B, 0x66, 0xE6, 0x4E,
  0x4C, 0xCC, 0x38, 0x4E, 0x33, 0x8C, 0xB3, 0x2C, 0x99, 0x26, 0x79, 0x9E,
  0x43, 0xB0, 0xC0, 0x1E, 0x39, 0x98, 0x78, 0x3C, 0x1E, 0x0F, 0x0D, 0x86,
  0xEE, 0x3E, 0x00, 0x3E, 0x37, 0x31, 0x33, 0x23, 0x7E, 0x60, 0x60, 0x60,
  0xC0, 0x1E, 0x39, 0x98, 0x78, 0x3C, 0x1E, 0x0F, 0x0D, 0x86, 0xEE, 0x3E,
  0x03, 0x00, 0xC0, 0x3E, 0x37, 0x33, 0x33, 0x27, 0x7C, 0x6C, 0x66, 0x66,
  0xC7, 0x1E, 0x65, 0x81, 0x83, 0x83, 0x83, 0x02, 0xCD, 0xF0, 0xFF, 0xFC,
  0x41, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC0, 0x61, 0xB0, 0x98, 0xCC, 0x6C,
  0x36, 0x1B, 0x09, 0x8C, 0xEE, 0x3E, 0x00, 0xC3, 0xC3, 0x46, 0x46, 0x4C,
  0x48, 0x58, 0x70, 0x70, 0x60, 0xC6, 0x1E, 0x31, 0xB3, 0x89, 0x9C, 0xCC,
  0xA6, 0x2D, 0x61, 0x4B, 0x0E, 0x50, 0x63, 0x83, 0x18, 0x00, 0x18, 0xC6,
  0x61, 0xB0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0xC8, 0x63, 0x38, 0xC0, 0xC3,
  0x46, 0x6C, 0x68, 0x78, 0x30, 0x30, 0x20, 0x60, 0x60, 0x3F, 0x3F, 0x06,
  0x0C, 0x18, 0x38, 0x30, 0x60, 0xFE, 0xFC, 0x39, 0x88, 0x46, 0x31, 0x88,
  0x46, 0x31, 0xC0, 0x92, 0x6D, 0x92, 0x4C, 0x3C, 0x20, 0x86, 0x18, 0x41,
  0x04, 0x30, 0xC2, 0x38, 0x08, 0x38, 0x51, 0x26, 0x78, 0x40, 0xFC, 0xC8,
  0x80, 0x32, 0xFF, 0x16, 0x2C, 0xD1, 0xB7, 0x74, 0x10, 0x30, 0x30, 0x34,
  0x3E, 0x73, 0x63, 0x62, 0x66, 0x6E, 0xFC, 0x3D, 0xEC, 0x30, 0x82, 0x0C,
  0x9E, 0x03, 0x02, 0x06, 0x36, 0x7E, 0xC4, 0xC4, 0x8C, 0x8C, 0xDC, 0xE8,
  0x39, 0xFC, 0xF7, 0xF2, 0x0C, 0x9E, 0x03, 0x83, 0x83, 0x01, 0xE1, 0xE0,
  0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x07, 0x00, 0x19, 0x3F,
  0x63, 0x62, 0x66, 0x46, 0x6E, 0x74, 0x0C, 0x8C, 0xF8, 0x10, 0x30, 0x30,
  0x36, 0x3E, 0x73, 0x62, 0x66, 0x66, 0x46, 0xC6, 0x13, 0x03, 0x26, 0x66,
  0x64, 0xC0, 0x04, 0x30, 0x03, 0x08, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x33,
  0x80, 0x10, 0x30, 0x30, 0x33, 0x26, 0x6C, 0x78, 0x78, 0x6C, 0x4C, 0xC6,
  0x13, 0x33, 0x26, 0x66, 0x64, 0xC0, 0x26, 0x63, 0xEF, 0x73, 0x36, 0x23,
  0x66, 0x26, 0x66, 0x46, 0x6C, 0x46, 0x26, 0x3E, 0x73, 0x62, 0x66, 0x66,
  0x46, 0xC6, 0x39, 0xFC, 0x71, 0x86, 0x3D, 0xDE, 0x2C, 0x3E, 0x73, 0x63,
  0x62, 0x66, 0x6E, 0xDC, 0xC0, 0xC0, 0xC0, 0x32, 0xFF, 0x16, 0x28, 0xD1,
  0xB7, 0x74, 0x18, 0x30, 0x60, 0x24, 0xF7, 0x18, 0x61, 0x84, 0x30, 0x39,
  0xF6, 0x1C, 0x38, 0x29, 0xBE, 0x23, 0xFC, 0x8C, 0x63, 0x1A, 0xE0, 0x66,
  0x8F, 0x1E, 0x2C, 0xD9, 0xB7, 0x76, 0x87, 0x9B, 0x36, 0xCD, 0x1E, 0x38,
  0x30, 0x8C, 0xF3, 0x3D, 0x4B, 0x56, 0xF5, 0x39, 0xCE, 0x63, 0x18, 0x31,
  0x89, 0x87, 0x83, 0x81, 0xC1, 0xE0, 0xD9, 0xCC, 0x21, 0x99, 0x8C, 0xC6,
  0xC3, 0x61, 0xE0, 0x60, 0x30, 0x10, 0x18, 0x38, 0x00, 0x3E, 0xF8, 0x30,
  0xC3, 0x0C, 0x30, 0x7C, 0x1C, 0x61, 0x0C, 0x33, 0x8E, 0x18, 0x61, 0x86,
  0x18, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0xE1, 0x86, 0x18, 0x71, 0xCC, 0x30,
  0x82, 0x38, 0xF3, 0x78,
};

const GFXglyph NotoSans_SemiBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 5, 4, 6, 1, -10 },
  { 9, 9, 10, 9, 0, -10 },
  { 21, 8, 12, 8, 0, -11 },
  { 33, 10, 10, 12, 1, -10 },
  { 46, 9, 10, 10, 0, -10 },
  { 58, 3, 4, 3, 1, -10 },
  { 60, 5, 12, 5, 1, -10 },
  { 68, 5, 12, 5, -1, -10 },
  { 76, 7, 7, 8, 1, -11 },
  { 83, 7, 6, 8, 1, -8 },
  { 89, 3, 4, 4, -1, -2 },
  { 91, 4, 2, 4, 0, -5 },
  { 92, 2, 2, 4, 0, -2 },
  { 93, 8, 10, 6, -1, -10 },
  { 103, 7, 10, 8, 1, -10 },
  { 112, 5, 10, 8, 2, -10 },
  { 119, 7, 10, 8, 0, -10 },
  { 128, 7, 10, 8, 0, -10 },
  { 137, 7, 10, 8, 0, -10 },
  { 146, 8, 10, 8, 0, -10 },
  { 156, 7, 10, 8, 1, -10 },
  { 165, 7, 10, 8, 1, -10 },
  { 174, 8, 10, 8, 0, -10 },
  { 184, 6, 10, 8, 1, -10 },
  { 192, 4, 8, 4, 0, -8 },
  { 196, 5, 10, 4, -1, -8 },
  { 203, 7, 8, 8, 1, -9 },
  { 210, 7, 4, 8, 1, -7 },
  { 214, 7, 8, 8, 1, -9 },
  { 221, 6, 10, 6, 1, -10 },
  { 229, 11, 11, 12, 1, -10 },
  { 245, 9, 10, 8, -1, -10 },
  { 257, 8, 10, 9, 0, -10 },
  { 267, 8, 10, 8, 1, -10 },
  { 277, 9, 10, 9, 0, -10 },
  { 289, 8, 10, 7, 0, -10 },
  { 299, 8, 10, 7, 0, -10 },
  { 309, 8, 10, 10, 1, -10 },
  { 319, 10, 10, 10, 0, -10 },
  { 332, 6, 10, 5, 0, -10 },
  { 340, 6, 13, 4, -2, -10 },
  { 350, 10, 10, 8, 0, -10 },
  { 363, 6, 10, 7, 0, -10 },
  { 371, 12, 10, 12, 0, -10 },
  { 386, 10, 10, 10, 0, -10 },
  { 399, 9, 10, 10, 1, -10 },
  { 411, 8, 10, 8, 0, -10 },
  { 421, 9, 12, 10, 1, -10 },
  { 435, 8, 10, 8, 0, -10 },
  { 445, 7, 10, 7, 0, -10 },
  { 454, 7, 10, 7, 1, -10 },
  { 463, 9, 10, 10, 1, -10 },
  { 475, 8, 10, 8, 1, -10 },
  { 485, 13, 10, 12, 1, -10 },
  { 502, 10, 10, 8, -1, -10 },
  { 515, 8, 10, 8, 1, -10 },
  { 525, 8, 10, 7, 0, -10 },
  { 535, 5, 12, 4, 0, -10 },
  { 543, 3, 10, 6, 2, -10 },
  { 547, 6, 12, 4, -1, -10 },
  { 556, 7, 6, 8, 0, -10 },
  { 562, 6, 1, 6, -1, 1 },
  { 563, 3, 3, 4, 2, -11 },
  { 565, 7, 8, 8, 1, -8 },
  { 572, 8, 11, 8, 0, -11 },
  { 583, 6, 8, 7, 1, -8 },
  { 589, 8, 11, 8, 1, -11 },
  { 600, 6, 8, 7, 1, -8 },
  { 606, 9, 14, 5, -2, -11 },
  { 622, 8, 11, 8, 0, -8 },
  { 633, 8, 11, 8, 0, -11 },
  { 644, 4, 11, 4, 0, -11 },
  { 650, 6, 14, 4, -2, -11 },
  { 661, 8, 11, 8, 0, -11 },
  { 672, 4, 11, 4, 0, -11 },
  { 678, 12, 8, 13, 0, -8 },
  { 690, 8, 8, 8, 0, -8 },
  { 698, 6, 8, 8, 1, -8 },
  { 704, 8, 11, 8, 0, -8 },
  { 715, 7, 11, 8, 1, -8 },
  { 725, 6, 8, 6, 0, -8 },
  { 731, 6, 8, 6, 0, -8 },
  { 737, 5, 9, 5, 1, -9 },
  { 743, 7, 8, 8, 1, -8 },
  { 750, 7, 8, 7, 1, -8 },
  { 757, 10, 8, 11, 1, -8 },
  { 767, 9, 8, 7, -1, -8 },
  { 776, 9, 11, 7, -1, -8 },
  { 789, 7, 8, 6, 0, -8 },
  { 796, 6, 12, 5, 0, -10 },
  { 805, 2, 14, 8, 3, -11 },
  { 809, 6, 12, 5, -1, -10 },
  { 818, 7, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMIBOLDITALIC14PT7B_H_
