#ifndef _NOTOSANS_SEMIBOLDITALIC32PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x01,
  0x01, 0xE0, 0x78, 0x3E, 0x07, 0x80, 0x79, 0xEF, 0x3D, 0xE7, 0xB8, 0xE7,
  0x1C, 0xE3, 0x98, 0x67, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x18, 0x00, 0xE3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x70, 0x03, 0x87, 0x03, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x1C, 0x00, 0xE1, 0xC0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC1,
  0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0xF8, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFE, 0x1E, 0x62, 0x3C, 0xE0, 0x3C, 0xC0, 0x1E, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xBE, 0x01,
  0x9E, 0x03, 0x1E, 0x83, 0x3C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x3C, 0x3F, 0x80,
  0x70, 0xFF, 0x01, 0xC3, 0xCF, 0x07, 0x07, 0x1E, 0x1E, 0x0E, 0x3C, 0x38,
  0x3C, 0x78, 0xE0, 0x78, 0xE3, 0x80, 0xE1, 0xCF, 0x01, 0xC7, 0x9C, 0xFB,
  0x8E, 0x73, 0xFF, 0xFD, 0xCF, 0xF7, 0xF7, 0xBC, 0xE7, 0xCE, 0x71, 0xC0,
  0x39, 0xE3, 0x80, 0xE3, 0xC7, 0x03, 0xC7, 0x0E, 0x07, 0x0E, 0x1C, 0x1C,
  0x1C, 0x78, 0x70, 0x38, 0xE1, 0xE0, 0x7F, 0xC3, 0x80, 0xFF, 0x0E, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x1E,
  0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x3C, 0x3C, 0x00, 0xE3, 0xE0, 0x07,
  0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xF3, 0xFF, 0x0F,
  0x3E, 0x78, 0x79, 0xE1, 0xE7, 0x9E, 0x0F, 0xFC, 0xF0, 0x3F, 0xC7, 0x80,
  0xFC, 0x3C, 0x07, 0xC1, 0xF0, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0x8F, 0x80, 0x7B, 0xDE, 0xE7, 0x39, 0x9C, 0x00, 0xF0, 0x1C, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1C,
  0x07, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x03, 0x0E,
  0x0F, 0x98, 0x1F, 0xF0, 0x4F, 0xFF, 0x83, 0xFF, 0x0F, 0x9E, 0x3F, 0x80,
  0xF7, 0x03, 0xC7, 0x03, 0x8E, 0x02, 0x1E, 0x00, 0x20, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x3E, 0x78, 0xF3, 0xC7, 0x8E, 0x3C, 0x70, 0xFF, 0xFF,
  0xFF, 0x13, 0xFF, 0xF7, 0x80, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x9F, 0x1E,
  0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0,
  0x3E, 0xF0, 0x3C, 0x78, 0x7C, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x00, 0xF0, 0x1F, 0x07, 0xF1, 0xFE, 0x3F, 0xEF, 0xDE, 0x79, 0xE2,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xC1, 0xF3, 0xF0, 0x60, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0xE1, 0xF0, 0x40, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x20, 0x07, 0x9C, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC1,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCE, 0x03, 0xCF, 0x03,
  0xC7, 0x83, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xE1, 0xE0, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x80, 0x7C, 0xC0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xC1, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0xC0, 0x73, 0xF8, 0xFF, 0xF8, 0xFF,
  0xFC, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xFF, 0x9F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xE1, 0xE0, 0xF8, 0xF0,
  0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x1E, 0x07, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x81, 0xE3, 0xE1, 0xE0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x9F, 0x07, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0x80, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0x1E, 0x3C, 0x0F, 0x3C,
  0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3E,
  0xFE, 0x3F, 0xFE, 0x1F, 0xDE, 0x07, 0x9E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x81, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x06,
  0x0F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x78, 0xF8, 0xF8, 0x78, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x00, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0x80, 0x03, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0,
  0x3E, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0F, 0xE3, 0xFF, 0x9F, 0xFE, 0x71,
  0xF2, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x04,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0x00, 0xE0,
  0xF0, 0x00, 0x38, 0xF0, 0x18, 0x1C, 0xF0, 0x7F, 0xCF, 0x70, 0xFF, 0xC3,
  0xF8, 0xF0, 0xE1, 0xF8, 0x70, 0x70, 0xFC, 0x78, 0x70, 0x7E, 0x38, 0x38,
  0x7F, 0x1C, 0x1C, 0x3B, 0x8E, 0x1E, 0x1D, 0xC7, 0x0F, 0x1E, 0xE3, 0x8F,
  0x9E, 0x71, 0xFF, 0xFE, 0x38, 0x7E, 0x7E, 0x1E, 0x1C, 0x1C, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0x7B, 0xC0,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x1C,
  0x03, 0xC1, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80,
  0x1E, 0xF8, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x07,
  0x87, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0x03, 0xC3,
  0xC0, 0xF8, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0x81, 0xF1, 0xE3,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xFC, 0x1F, 0xFF, 0x07, 0xF1, 0xE1, 0xF0, 0x08, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x06, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0x07, 0xE0, 0xF0, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x1E,
  0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0xF8,
  0x78, 0x1F, 0x87, 0x9F, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE,
  0x3E, 0x1F, 0x80, 0x43, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x3F, 0xCF, 0x83, 0xFC, 0xF0, 0x3F, 0xCF,
  0x07, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0x78,
  0x7C, 0x07, 0x87, 0xE0, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1E,
  0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1E,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x3E, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x04, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x3C, 0x0F, 0x83, 0xC0, 0xF8,
  0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0x8F, 0x80, 0x3C, 0xF8, 0x03, 0xC7,
  0x80, 0x1E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x7C,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x78,
  0x0F, 0x83, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1D, 0xC0, 0x7F, 0x87, 0xB8, 0x0E, 0xF0, 0xF7, 0x03, 0xDC, 0x1E, 0xE0,
  0x77, 0x83, 0xDC, 0x1E, 0xF0, 0x73, 0x83, 0x9E, 0x1E, 0x70, 0xF3, 0x83,
  0xCE, 0x1C, 0xF0, 0x79, 0xC7, 0x9E, 0x0E, 0x38, 0xE3, 0xC1, 0xC7, 0xB8,
  0x78, 0x78, 0xF7, 0x0E, 0x0F, 0x0F, 0xC3, 0xC1, 0xE1, 0xF8, 0x78, 0x38,
  0x3E, 0x0F, 0x07, 0x07, 0xC1, 0xE1, 0xE0, 0xF0, 0x38, 0x3C, 0x1E, 0x0F,
  0x00, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x3F, 0x00, 0x70, 0x7F, 0x01,
  0xE0, 0xFE, 0x03, 0xC1, 0xFC, 0x07, 0x87, 0xBC, 0x0E, 0x0F, 0x78, 0x3C,
  0x1E, 0xF0, 0x78, 0x3C, 0xF0, 0xF0, 0x71, 0xE1, 0xE1, 0xE3, 0xC3, 0x83,
  0xC3, 0xCF, 0x07, 0x87, 0x9E, 0x0F, 0x0F, 0x3C, 0x1C, 0x0F, 0x78, 0x78,
  0x1E, 0xE0, 0xF0, 0x3D, 0xC1, 0xE0, 0x3F, 0x83, 0x80, 0x7F, 0x07, 0x00,
  0x7E, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFE, 0x7E, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3C,
  0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF8, 0x03, 0xEF, 0x80, 0x7C, 0x7C, 0x0F, 0xC7, 0xE1, 0xF8, 0x3F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x78, 0x0F,
  0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFF, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFE, 0x7E, 0x1F, 0x01, 0xF3, 0xE0,
  0x1F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x80, 0x7C, 0x7C, 0x0F, 0xC7, 0xE3, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3C, 0xFE, 0x0F, 0x07, 0xC3, 0xC1, 0xF1, 0xF0, 0x3C,
  0x78, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE3, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFE, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3C, 0x07, 0xCF, 0x00, 0xF0,
  0x03, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x8E, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x80, 0x78, 0xE1, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0xF1, 0xE0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF8, 0x1F, 0x07, 0xC3, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xC7, 0x01, 0xE1, 0xC0, 0xF8,
  0x70, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x78, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0x00, 0xF0, 0x1E, 0xF0, 0x1F, 0x01, 0xEF, 0x01, 0xF0, 0x3E,
  0xF0, 0x3F, 0x03, 0xCF, 0x03, 0xF0, 0x3C, 0xF0, 0x7F, 0x07, 0x8F, 0x07,
  0x70, 0x78, 0xF0, 0xF7, 0x0F, 0x0F, 0x0E, 0x70, 0xF0, 0xF1, 0xE7, 0x0E,
  0x0F, 0x1E, 0x71, 0xE0, 0x71, 0xC7, 0x1E, 0x07, 0x3C, 0x73, 0xC0, 0x73,
  0x87, 0x3C, 0x07, 0x78, 0x77, 0x80, 0x77, 0x07, 0x78, 0x07, 0xF0, 0x77,
  0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x07,
  0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x07, 0x80,
  0xF8, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x7C,
  0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x1F, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x78, 0x3E, 0x00,
  0xF8, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x83,
  0xC3, 0xC3, 0xE0, 0xE1, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0xE1, 0xC3, 0x87, 0x8F,
  0x1E, 0x1C, 0x38, 0x70, 0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78,
  0xF0, 0xE1, 0xC3, 0x80, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0x70, 0x07, 0x38, 0x0E, 0x38, 0x1E, 0x1C, 0x1C, 0x1C, 0x38, 0x1C,
  0x38, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF3, 0xC7, 0x9E, 0x38, 0x70, 0x01, 0x80, 0x03, 0xF9, 0xC3, 0xFF, 0xE3,
  0xFF, 0xF3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x3C, 0x0F, 0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x83, 0xE3, 0xC3, 0xE1, 0xE3,
  0xF0, 0xFF, 0xB8, 0x3F, 0xBC, 0x0F, 0x9E, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x18, 0x1E, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x3E,
  0xFC, 0x7C, 0xFF, 0xFC, 0xEF, 0xF8, 0xE7, 0xE0, 0x00, 0xE0, 0x1F, 0xF0,
  0xFF, 0xC7, 0xFF, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC3, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x61, 0xE0, 0x3F, 0xBC, 0x0F,
  0xF7, 0x83, 0xFF, 0xF0, 0xF8, 0x7C, 0x1E, 0x07, 0x87, 0xC0, 0xF0, 0xF0,
  0x1E, 0x1E, 0x03, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xC3, 0xE0,
  0xF8, 0x3C, 0x1E, 0x07, 0x8F, 0xC0, 0xFF, 0xB8, 0x0F, 0xFF, 0x00, 0xF9,
  0xE0, 0x00, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFD, 0xF3, 0xE1, 0xE7, 0x83,
  0xDF, 0x07, 0xBC, 0x3E, 0x7F, 0xFC, 0xFF, 0xE3, 0xFE, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x06, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x10, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x01,
  0x80, 0x03, 0xF9, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xE1, 0xF1, 0xE0, 0x79,
  0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x9F, 0x03,
  0xCF, 0x83, 0xE7, 0xC3, 0xE1, 0xE3, 0xF0, 0xFF, 0xF8, 0x3F, 0xBC, 0x0F,
  0x9E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x84, 0x07, 0x83, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x18, 0x1E, 0xFE, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0x0F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x7C, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x07, 0x07, 0xC3, 0xE1, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0,
  0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0x00, 0x38,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xFF,
  0x03, 0xF8, 0x0F, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x04, 0x78, 0x3E,
  0x1E, 0x1F, 0x07, 0x8F, 0x81, 0xE7, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xC0, 0xF8,
  0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0x00, 0x38, 0x06, 0x07, 0x3F, 0x8F, 0xE1, 0xDF, 0xE7,
  0xF8, 0x77, 0xFF, 0xFF, 0x1F, 0x0F, 0xC3, 0xCF, 0x83, 0xE0, 0xF3, 0xE0,
  0xF8, 0x3C, 0xF0, 0x3C, 0x0F, 0x3C, 0x0F, 0x07, 0x9F, 0x07, 0x81, 0xE7,
  0x81, 0xE0, 0x79, 0xE0, 0x78, 0x1E, 0x78, 0x1E, 0x07, 0x9E, 0x07, 0x83,
  0xCF, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x3C, 0x0F,
  0x07, 0xC0, 0x02, 0x18, 0x1C, 0xFE, 0x1D, 0xFF, 0x1D, 0xFF, 0x1F, 0x0F,
  0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0x00, 0xE0, 0x07, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F,
  0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xE0, 0x00, 0x06, 0x01, 0xCF, 0xE0, 0x77, 0xF8, 0x1F, 0xFF, 0x07,
  0xC3, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE3, 0xF1, 0xF0,
  0xFF, 0xFC, 0x3D, 0xFE, 0x0F, 0x3E, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0xF9, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xE1, 0xF1,
  0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0E, 0x3C, 0x0F, 0x1E, 0x07,
  0x9F, 0x03, 0xCF, 0x83, 0xE3, 0xC1, 0xE1, 0xE3, 0xF0, 0xFF, 0xF8, 0x3F,
  0xBC, 0x0F, 0x9E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x18, 0xF7,
  0xC7, 0x7E, 0x3B, 0xF1, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x3F, 0xF1, 0xFF, 0xC7, 0xDE, 0x3C, 0x08,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xCC, 0x0F, 0x3F, 0xFC, 0xFF, 0xE1, 0xFE, 0x00, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x7F, 0xF7, 0xFF, 0xFF, 0xE1, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0xFC, 0xF1, 0xF8, 0xFF,
  0xB8, 0xFF, 0x38, 0x7E, 0x38, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0,
  0x7C, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0x71, 0xE0, 0x73,
  0xC0, 0x73, 0xC0, 0x77, 0x80, 0x77, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1E, 0xF0, 0xFC, 0x1E,
  0xF0, 0xFC, 0x3C, 0xF1, 0xDC, 0x3C, 0xF1, 0xDC, 0x78, 0xF3, 0xDC, 0x78,
  0xF3, 0x9C, 0xF0, 0xF3, 0x9C, 0xF0, 0xF7, 0x1D, 0xE0, 0xF7, 0x1D, 0xE0,
  0xFF, 0x1D, 0xC0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x07, 0xE1, 0xE0, 0xF0, 0x1E,
  0x3C, 0x03, 0xCF, 0x80, 0x7B, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xBC, 0x01, 0xF7,
  0x80, 0x7C, 0x78, 0x0F, 0x0F, 0x03, 0xC0, 0xF0, 0xF8, 0x1E, 0x00, 0x07,
  0x80, 0xF8, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x3C,
  0x03, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0x71, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0xFF, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x07, 0xE0,
  0x3E, 0x03, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF8, 0x07, 0xC0, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x06, 0x00, 0x78, 0x0F, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x7F, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0x1C, 0x03, 0xFF, 0x07, 0xFF,
  0xFE, 0x3F, 0xF8, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 23, 9, 0, -23 },
  { 30, 11, 8, 14, 3, -23 },
  { 41, 20, 23, 21, 1, -23 },
  { 99, 16, 26, 18, 1, -24 },
  { 151, 23, 23, 27, 2, -23 },
  { 218, 21, 23, 22, 1, -23 },
  { 279, 5, 8, 8, 3, -23 },
  { 284, 12, 28, 10, 1, -23 },
  { 326, 11, 28, 10, -2, -23 },
  { 365, 15, 15, 18, 3, -24 },
  { 394, 15, 15, 18, 2, -19 },
  { 423, 7, 8, 9, -1, -4 },
  { 430, 8, 3, 10, 1, -10 },
  { 433, 5, 5, 9, 0, -5 },
  { 437, 16, 23, 13, -1, -23 },
  { 483, 16, 23, 18, 1, -23 },
  { 529, 12, 23, 18, 3, -23 },
  { 564, 17, 23, 18, 0, -23 },
  { 613, 17, 23, 18, 0, -23 },
  { 662, 17, 23, 18, 0, -23 },
  { 711, 16, 23, 18, 1, -23 },
  { 757, 16, 23, 18, 2, -23 },
  { 803, 17, 23, 18, 2, -23 },
  { 852, 17, 23, 18, 1, -23 },
  { 901, 16, 23, 18, 1, -23 },
  { 947, 8, 18, 9, 0, -18 },
  { 965, 10, 22, 9, -2, -18 },
  { 993, 15, 17, 18, 2, -20 },
  { 1025, 15, 9, 18, 2, -16 },
  { 1042, 15, 17, 18, 2, -20 },
  { 1074, 13, 23, 14, 2, -23 },
  { 1112, 25, 26, 27, 2, -23 },
  { 1194, 20, 23, 19, -2, -23 },
  { 1252, 18, 23, 20, 1, -23 },
  { 1304, 19, 23, 19, 2, -23 },
  { 1359, 20, 23, 22, 1, -23 },
  { 1417, 17, 23, 17, 1, -23 },
  { 1466, 17, 23, 16, 1, -23 },
  { 1515, 20, 23, 22, 2, -23 },
  { 1573, 21, 23, 22, 1, -23 },
  { 1634, 14, 23, 12, -1, -23 },
  { 1675, 15, 30, 10, -5, -23 },
  { 1732, 21, 23, 19, 1, -23 },
  { 1793, 13, 23, 16, 1, -23 },
  { 1831, 27, 23, 28, 1, -23 },
  { 1909, 23, 23, 24, 1, -23 },
  { 1976, 20, 23, 23, 2, -23 },
  { 2034, 18, 23, 19, 1, -23 },
  { 2086, 20, 28, 23, 2, -23 },
  { 2156, 18, 23, 19, 1, -23 },
  { 2208, 16, 23, 17, 1, -23 },
  { 2254, 16, 23, 17, 3, -23 },
  { 2300, 20, 23, 22, 2, -23 },
  { 2358, 18, 23, 18, 3, -23 },
  { 2410, 28, 23, 28, 3, -23 },
  { 2491, 23, 23, 19, -2, -23 },
  { 2558, 17, 23, 17, 3, -23 },
  { 2607, 20, 23, 17, -1, -23 },
  { 2665, 12, 28, 10, 0, -23 },
  { 2707, 7, 23, 13, 3, -23 },
  { 2728, 13, 28, 10, -2, -23 },
  { 2774, 16, 15, 18, 1, -23 },
  { 2804, 13, 2, 13, -3, 3 },
  { 2808, 6, 6, 10, 5, -25 },
  { 2813, 17, 18, 19, 1, -18 },
  { 2852, 16, 24, 19, 1, -24 },
  { 2900, 14, 18, 15, 1, -18 },
  { 2932, 19, 24, 19, 1, -24 },
  { 2989, 15, 18, 17, 1, -18 },
  { 3023, 18, 32, 11, -3, -24 },
  { 3095, 17, 26, 19, 1, -18 },
  { 3151, 16, 24, 19, 1, -24 },
  { 3199, 9, 24, 9, 1, -24 },
  { 3226, 14, 32, 9, -4, -24 },
  { 3282, 18, 24, 17, 1, -24 },
  { 3336, 9, 24, 9, 1, -24 },
  { 3363, 26, 18, 29, 1, -18 },
  { 3422, 16, 18, 19, 1, -18 },
  { 3458, 16, 18, 18, 1, -18 },
  { 3494, 18, 26, 19, -1, -18 },
  { 3553, 17, 26, 19, 1, -18 },
  { 3609, 13, 18, 13, 1, -18 },
  { 3639, 14, 18, 15, 0, -18 },
  { 3671, 12, 21, 12, 1, -21 },
  { 3703, 16, 17, 19, 2, -17 },
  { 3737, 16, 17, 16, 2, -17 },
  { 3771, 24, 17, 24, 2, -17 },
  { 3822, 19, 17, 16, -1, -17 },
  { 3863, 21, 25, 16, -3, -17 },
  { 3929, 16, 17, 15, -1, -17 },
  { 3963, 13, 28, 11, 0, -23 },
  { 4009, 3, 31, 18, 8, -24 },
  { 4021, 12, 28, 11, -1, -23 },
  { 4063, 15, 5, 18, 2, -14 },
};

const GFXfont NotoSans_SemiBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMIBOLDITALIC32PT7B_H_
