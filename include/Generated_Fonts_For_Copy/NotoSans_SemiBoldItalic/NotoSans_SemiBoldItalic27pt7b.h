#ifndef _NOTOSANS_SEMIBOLDITALIC27PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x70, 0x78, 0xF8, 0x70, 0x73, 0xF1, 0xF9, 0xDC,
  0xEE, 0x76, 0x33, 0x18, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x63,
  0x80, 0x71, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x0E, 0x30, 0x07,
  0x18, 0x03, 0x1C, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x63, 0x80,
  0x71, 0x80, 0x38, 0xC0, 0x18, 0xE0, 0x1C, 0x70, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x03, 0xFF, 0x1F, 0xF8, 0xFE, 0xE3, 0x98, 0x0E, 0x60, 0x39,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x0B, 0xC0, 0x67, 0x01,
  0x9C, 0xC6, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x07, 0xE0, 0x39, 0xFC, 0x0E, 0x39, 0xC3, 0x8E,
  0x38, 0x61, 0xC7, 0x1C, 0x38, 0xE7, 0x07, 0x39, 0xC0, 0xE7, 0x33, 0xDC,
  0xEE, 0xFF, 0xFB, 0xBF, 0xBE, 0xEE, 0x33, 0x19, 0xC6, 0x07, 0x38, 0xC1,
  0xC6, 0x38, 0x70, 0xC7, 0x0C, 0x18, 0xE3, 0x83, 0xB8, 0xE0, 0x7F, 0x38,
  0x07, 0xC0, 0x00, 0xC0, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xE7, 0x80, 0xE1,
  0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x1D, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0xEF, 0xF8, 0xF7, 0x1E, 0x77, 0x87, 0x7B, 0x83, 0xF9, 0xC0, 0xF8,
  0xF0, 0x7C, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF1, 0xE0, 0x7E, 0xEE, 0xEC,
  0xC0, 0x03, 0xC1, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x83, 0xC0,
  0x02, 0x00, 0x1E, 0x00, 0xE0, 0x87, 0x07, 0x30, 0x7F, 0x8C, 0x7F, 0xE1,
  0xFF, 0x1F, 0x81, 0xEC, 0x1E, 0x70, 0x63, 0x80, 0x1E, 0x00, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x3C, 0xE7, 0x9C, 0x73,
  0x80, 0xFF, 0xFF, 0xF0, 0x73, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xC0, 0xFF, 0x87, 0x9E,
  0x3C, 0x38, 0xE0, 0xE7, 0x83, 0xDE, 0x0F, 0x70, 0x39, 0xC0, 0xEF, 0x03,
  0xBC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0xF1, 0xE1, 0xFF,
  0x87, 0xFC, 0x0F, 0xC0, 0x03, 0xC3, 0xE3, 0xF9, 0xFE, 0xFF, 0x99, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0x00, 0x40, 0x1F, 0xE1, 0xFF, 0xC7, 0xCF, 0x08,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xEF,
  0xFF, 0x3F, 0xFC, 0x00, 0x40, 0x1F, 0xE1, 0xFF, 0xC3, 0x8F, 0x08, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x02, 0x7C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x80, 0x7B, 0xFF, 0xCF, 0xFE,
  0x1F, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0E,
  0xE0, 0x73, 0x83, 0xCE, 0x1E, 0x78, 0x71, 0xC3, 0x87, 0x1C, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x20, 0x7C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x18,
  0x0F, 0xF0, 0x7F, 0xC3, 0xE1, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x73, 0xE1, 0xFF, 0xC7, 0xEF, 0x1E, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07,
  0xBC, 0x1C, 0x70, 0xF1, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x3F, 0xFE, 0x7F,
  0xF8, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0x80, 0x1F,
  0xC0, 0xFF, 0x87, 0x8F, 0x1C, 0x3C, 0xF0, 0xF1, 0xC3, 0x87, 0x1E, 0x1F,
  0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0x78, 0x78, 0xF3, 0xC1, 0xCE, 0x07, 0x38,
  0x1C, 0xF0, 0x73, 0xE7, 0xC7, 0xFE, 0x0F, 0xF0, 0x01, 0x80, 0x7F, 0x07,
  0xFC, 0x7C, 0xF3, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x7B, 0xC3,
  0xDF, 0xFE, 0x7F, 0xF1, 0xF7, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE7,
  0xFE, 0x3F, 0xE1, 0xFC, 0x00, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x87, 0x9F, 0x3C, 0x00, 0x06, 0x0F, 0x0F, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x38, 0x78, 0x70, 0xE0,
  0xE0, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0x1C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0x80, 0x0C,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80,
  0x06, 0x00, 0x3C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0E, 0x00, 0x40, 0x00, 0x04, 0x0F,
  0xF3, 0xFF, 0x38, 0xF0, 0x1E, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x1E, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x78, 0x0F, 0x03, 0x80,
  0x1E, 0x1C, 0x00, 0x38, 0xE0, 0xFC, 0x63, 0x0F, 0xF1, 0xDC, 0x71, 0xC7,
  0x63, 0x87, 0x1D, 0x8E, 0x18, 0x6E, 0x30, 0xE1, 0xB9, 0xC3, 0x8E, 0xE7,
  0x0E, 0x3B, 0x8C, 0x79, 0xCE, 0x3F, 0x7E, 0x1C, 0x79, 0xF0, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x30, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0E, 0xE0, 0x07,
  0x70, 0x07, 0x38, 0x07, 0x9E, 0x03, 0x87, 0x03, 0xC3, 0x81, 0xC1, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07,
  0x3C, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0xF0,
  0xF1, 0xC0, 0xE3, 0x81, 0xCF, 0x07, 0x9E, 0x3E, 0x3F, 0xF8, 0x7F, 0xE0,
  0xE1, 0xE3, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x9C, 0x0F, 0x38, 0x3C, 0xFF,
  0xF9, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x20, 0x07, 0xFC, 0x3F, 0xF8, 0xFC,
  0xF3, 0xE0, 0x27, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x10, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xFE, 0x1E, 0x1F, 0x1C, 0x0F, 0x1C, 0x07, 0x3C, 0x07, 0x3C, 0x07, 0x3C,
  0x07, 0x38, 0x07, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x70, 0x1E, 0x70,
  0x3C, 0x70, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F,
  0xF1, 0xFF, 0xC7, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3F,
  0xF0, 0xFF, 0xC3, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF,
  0xC7, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x0F, 0xFF, 0x1F,
  0xDE, 0x3E, 0x02, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0xFE, 0xE0, 0xFE, 0xE0, 0xFE, 0xE0, 0x1E, 0xE0, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF8, 0x3C, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0E, 0x03, 0xC3,
  0x80, 0xE1, 0xE0, 0x38, 0x78, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xE3, 0xC0,
  0x70, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x80, 0xF1, 0xE0, 0x38,
  0x78, 0x0E, 0x1C, 0x07, 0x87, 0x01, 0xE1, 0xC0, 0x70, 0xF0, 0x1C, 0x3C,
  0x07, 0x0E, 0x03, 0xC0, 0x0F, 0xF0, 0xFF, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x5F, 0x83, 0xF8, 0x1F, 0x80,
  0x0E, 0x07, 0xC3, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x1C, 0x78, 0x07,
  0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x38, 0x07, 0x0F, 0x01, 0xC3, 0xC0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC,
  0x7E, 0x06, 0xE3, 0xF8, 0x3B, 0x8E, 0xE0, 0xCE, 0x39, 0x87, 0x78, 0xE6,
  0x19, 0xC3, 0x98, 0xE7, 0x1E, 0x67, 0x1C, 0x71, 0xDC, 0x71, 0xC7, 0xE3,
  0xC7, 0x1F, 0x8E, 0x1C, 0x7C, 0x38, 0xE1, 0xF0, 0xE3, 0x87, 0x83, 0x8E,
  0x1E, 0x1E, 0x00, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x7E, 0x07, 0x8F, 0xC0,
  0xE1, 0xF8, 0x1C, 0x3B, 0x83, 0x8F, 0x70, 0xF1, 0xCE, 0x1C, 0x38, 0xE3,
  0x87, 0x1C, 0x70, 0xE3, 0x8E, 0x3C, 0x3B, 0xC7, 0x07, 0x70, 0xE0, 0xFE,
  0x1C, 0x0F, 0xC3, 0x81, 0xF8, 0xF0, 0x3F, 0x1C, 0x03, 0xC3, 0x80, 0x78,
  0x00, 0x00, 0x60, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xF7, 0xE3, 0xC0, 0xF3,
  0xC0, 0x3D, 0xE0, 0x1E, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xEE, 0x00, 0xF7, 0x00, 0x7B, 0x80, 0x39, 0xE0, 0x3C, 0xF8,
  0x3C, 0x3F, 0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xF8, 0xF0, 0xF1, 0xC0, 0xE3, 0x81, 0xCF, 0x07, 0x9E, 0x0F, 0x38,
  0x3C, 0x7F, 0xF8, 0xFF, 0xC3, 0xFE, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x60, 0x03, 0xFE,
  0x03, 0xFF, 0x83, 0xF7, 0xE3, 0xC0, 0xF3, 0xC0, 0x3D, 0xE0, 0x1E, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0xF7,
  0x00, 0x7B, 0x80, 0x39, 0xE0, 0x3C, 0xF8, 0x3C, 0x3F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0xF0, 0xF1, 0xC1, 0xE3,
  0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0xFC, 0x7F, 0xF0, 0xFF, 0x83, 0xCF,
  0x07, 0x8E, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0xF0, 0x79, 0xE0, 0xF3,
  0x80, 0xF0, 0x01, 0x80, 0x7F, 0xC7, 0xFE, 0x7C, 0xF3, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x81, 0xE7, 0xFE, 0x3F, 0xF1, 0xFE, 0x00, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x9E,
  0x03, 0x8F, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38,
  0xF0, 0x1C, 0x70, 0x1E, 0x38, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0x8F, 0x01,
  0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xE0, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xF0, 0x00, 0xF0, 0x0F, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x3C, 0x70, 0x3C,
  0x70, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x70, 0xE0, 0x71, 0xE0, 0x79, 0xC0,
  0x39, 0xC0, 0x3B, 0x80, 0x3B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x3B, 0x81, 0xE0,
  0x77, 0x07, 0xC1, 0xEE, 0x0F, 0x83, 0x9C, 0x3F, 0x0F, 0x38, 0x7E, 0x1C,
  0x71, 0xDC, 0x78, 0xE3, 0xB8, 0xE1, 0xCE, 0x71, 0xC3, 0x9C, 0x67, 0x07,
  0x70, 0xCE, 0x0E, 0xE1, 0xBC, 0x1D, 0xC3, 0x70, 0x3F, 0x06, 0xE0, 0x7E,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x03, 0xE0, 0xE0, 0x70, 0x1C, 0x1E, 0x03, 0xC7, 0x80, 0x39, 0xE0, 0x07,
  0x38, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xF7, 0x80, 0x1C, 0x70, 0x07, 0x8F, 0x01, 0xE1,
  0xE0, 0x78, 0x1C, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0xE0,
  0x79, 0xE0, 0xE3, 0xC3, 0xC3, 0x8F, 0x07, 0x1C, 0x0E, 0x78, 0x1F, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x3F, 0x0F, 0xC0, 0xE3, 0x8E, 0x18, 0x71, 0xC7,
  0x1C, 0x71, 0xC3, 0x0E, 0x38, 0xE3, 0x8E, 0x38, 0x71, 0xC0, 0x07, 0xE0,
  0xFC, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xF8, 0x3F, 0x00, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x0D,
  0x80, 0xEC, 0x0E, 0x70, 0x71, 0x87, 0x0E, 0x30, 0x73, 0x81, 0x98, 0x0F,
  0xC0, 0x70, 0xFF, 0xFF, 0xF8, 0xF7, 0x9C, 0x71, 0x80, 0x07, 0x8C, 0x3F,
  0x71, 0xFF, 0xCF, 0x1F, 0x78, 0x39, 0xE0, 0xE7, 0x03, 0xBC, 0x0E, 0xF0,
  0x7B, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0x7F, 0xF1, 0xFD, 0xC3, 0xEE, 0x00,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xCE,
  0x0F, 0xFE, 0x3B, 0xF8, 0xF8, 0xE3, 0xC3, 0xCE, 0x0F, 0x78, 0x3D, 0xC0,
  0xE7, 0x03, 0x9C, 0x1E, 0x70, 0x7B, 0xC3, 0xCF, 0xFF, 0x3F, 0xF8, 0xCF,
  0xC0, 0x03, 0xE0, 0xFF, 0x1F, 0xE3, 0xC2, 0x78, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7F, 0xC7, 0xFC, 0x1F, 0x80,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x07, 0x9C, 0x0F, 0xDC, 0x1F, 0xFC, 0x3C, 0x7C, 0x78, 0x38, 0x78, 0x38,
  0x70, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0xF0, 0xF0,
  0x7F, 0xF0, 0x7F, 0x70, 0x3E, 0x60, 0x03, 0xE0, 0x7F, 0x87, 0xFC, 0x78,
  0xF7, 0x87, 0xB8, 0x39, 0xDF, 0xDF, 0xFC, 0xFF, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x07, 0xCE, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xBE, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x07, 0x8C, 0x3F, 0x71, 0xFF, 0xCF, 0x1F, 0x78, 0x39, 0xE0, 0xE7,
  0x03, 0xBC, 0x0E, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F, 0x3C, 0x7C, 0x7F, 0xF1,
  0xFF, 0xC3, 0xEE, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x8C, 0x3C, 0x3F, 0xE0,
  0xFF, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xCF, 0x0F, 0xFE, 0x3B, 0xF8, 0xF8, 0xF3, 0xC3, 0xCE, 0x0F, 0x78,
  0x39, 0xE0, 0xE7, 0x03, 0x9C, 0x1E, 0x70, 0x73, 0xC1, 0xCF, 0x07, 0x38,
  0x3C, 0xE0, 0xF0, 0x0E, 0x3C, 0x78, 0x00, 0x03, 0x8F, 0x1E, 0x38, 0x70,
  0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xE3, 0x87, 0x00, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x05, 0xE0, 0xFC, 0x1F, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x9E, 0x1E,
  0x3C, 0x78, 0x71, 0xE0, 0xE7, 0x81, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3D, 0xE0, 0x73, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x07, 0x0E, 0x0F,
  0x00, 0x0E, 0x1C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x3C, 0x70, 0xE1, 0xC7,
  0x8F, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x00, 0x18, 0xF0, 0xF0, 0xEF,
  0xE7, 0xE3, 0xBF, 0xBF, 0x8F, 0x8F, 0x8F, 0x3C, 0x3C, 0x3C, 0xE0, 0xF0,
  0xF7, 0x83, 0x83, 0x9E, 0x1E, 0x0E, 0x70, 0x78, 0x39, 0xC1, 0xC1, 0xE7,
  0x07, 0x07, 0xBC, 0x1C, 0x1C, 0xF0, 0xF0, 0x73, 0x83, 0xC1, 0xCE, 0x0E,
  0x0F, 0x00, 0x18, 0xF0, 0xEF, 0xE3, 0xBF, 0x8F, 0x8F, 0x3C, 0x3C, 0xE0,
  0xF7, 0x83, 0x9E, 0x0E, 0x70, 0x79, 0xC1, 0xEF, 0x07, 0xBC, 0x1C, 0xF0,
  0x73, 0x83, 0xCE, 0x0F, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFE, 0x78, 0xF7,
  0x83, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1D, 0xE1,
  0xE7, 0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0x06, 0x38, 0x0E, 0xFE, 0x0F, 0xFE,
  0x0F, 0x8E, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E,
  0x1C, 0x1E, 0x1C, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x3B, 0xF8, 0x3B, 0xF0,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x07, 0x8C, 0x3F, 0x71, 0xFF, 0xCF, 0x1F, 0x78, 0x39, 0xE0, 0xE7, 0x03,
  0xBC, 0x0E, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0x7F, 0xF1, 0xFF,
  0xC3, 0xEE, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x18, 0xE7, 0x7C, 0xEF, 0x9F, 0x83, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x07, 0xC1,
  0xFF, 0x3F, 0xE3, 0x82, 0x38, 0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE8, 0x1C, 0xE7, 0xCF, 0xFC, 0xFF, 0x00, 0x06, 0x03, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE3, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x70, 0x1C, 0x07, 0x01, 0xE8, 0x7E, 0x0F, 0x80, 0x3C, 0x1C, 0xF0, 0x73,
  0x81, 0xCE, 0x0F, 0x38, 0x3D, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0x70, 0x79,
  0xC1, 0xEF, 0x0F, 0x3C, 0x7C, 0x7F, 0xF1, 0xFD, 0xC3, 0xE6, 0x00, 0xF0,
  0x3F, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0xF1, 0xC3, 0x87, 0x1E, 0x1C,
  0x70, 0x73, 0x81, 0xCE, 0x03, 0x70, 0x0D, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0xE0, 0xE0, 0xFE, 0x1E, 0x0E, 0xE1, 0xE1, 0xEE, 0x3E, 0x1C,
  0xE3, 0xF1, 0xCE, 0x77, 0x38, 0xE7, 0x73, 0x8E, 0x67, 0x78, 0xEE, 0x77,
  0x0E, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x0E, 0x1E, 0x0E, 0x3C, 0x0F, 0x38,
  0x07, 0x78, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x1C, 0xF0, 0x3C, 0x70, 0x78, 0x78, 0xF0, 0x78, 0x1E, 0x07,
  0x87, 0x03, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x38,
  0xF0, 0x1C, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xE0, 0x7C, 0x1F,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC1, 0xF0, 0x78,
  0x0F, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1F, 0x80, 0xE0, 0x7C, 0x1E, 0x03, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x81, 0xF0, 0x3C, 0x00, 0x10, 0x0F,
  0xF0, 0xFF, 0xFF, 0x0F, 0xE8, 0x04, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 9, 7, 12, 3, -19 },
  { 28, 17, 19, 17, 1, -19 },
  { 69, 14, 23, 15, 1, -21 },
  { 110, 19, 20, 23, 2, -20 },
  { 158, 17, 20, 19, 1, -20 },
  { 201, 4, 7, 7, 3, -19 },
  { 205, 10, 23, 9, 1, -19 },
  { 234, 10, 24, 9, -2, -20 },
  { 264, 13, 13, 15, 2, -21 },
  { 286, 13, 13, 15, 2, -16 },
  { 308, 6, 6, 7, -1, -3 },
  { 313, 7, 3, 9, 1, -9 },
  { 316, 5, 4, 7, 0, -4 },
  { 319, 14, 19, 11, -1, -19 },
  { 353, 14, 20, 15, 1, -20 },
  { 388, 10, 19, 15, 3, -19 },
  { 412, 14, 20, 15, 0, -20 },
  { 447, 14, 20, 15, 0, -20 },
  { 482, 14, 19, 15, 0, -19 },
  { 516, 14, 19, 15, 1, -19 },
  { 550, 14, 20, 15, 1, -20 },
  { 585, 15, 19, 15, 1, -19 },
  { 621, 14, 20, 15, 1, -20 },
  { 656, 13, 20, 15, 1, -20 },
  { 689, 7, 15, 7, 0, -15 },
  { 703, 8, 18, 7, -1, -15 },
  { 721, 13, 14, 15, 2, -17 },
  { 744, 12, 7, 15, 2, -13 },
  { 755, 13, 14, 15, 2, -17 },
  { 778, 11, 20, 12, 2, -20 },
  { 806, 22, 21, 23, 1, -19 },
  { 864, 17, 19, 16, -2, -19 },
  { 905, 15, 19, 17, 1, -19 },
  { 941, 15, 20, 16, 2, -20 },
  { 979, 16, 19, 18, 1, -19 },
  { 1017, 14, 19, 14, 1, -19 },
  { 1051, 14, 19, 14, 1, -19 },
  { 1085, 16, 20, 19, 2, -20 },
  { 1125, 18, 19, 19, 1, -19 },
  { 1168, 12, 19, 10, -1, -19 },
  { 1197, 13, 24, 8, -4, -19 },
  { 1236, 18, 19, 16, 1, -19 },
  { 1279, 11, 19, 14, 1, -19 },
  { 1306, 22, 19, 23, 1, -19 },
  { 1359, 19, 19, 20, 1, -19 },
  { 1405, 17, 20, 20, 2, -20 },
  { 1448, 15, 19, 16, 1, -19 },
  { 1484, 17, 25, 20, 2, -20 },
  { 1538, 15, 19, 16, 1, -19 },
  { 1574, 13, 20, 14, 1, -20 },
  { 1607, 14, 19, 14, 2, -19 },
  { 1641, 17, 19, 19, 2, -19 },
  { 1682, 16, 19, 16, 2, -19 },
  { 1720, 23, 19, 24, 3, -19 },
  { 1775, 19, 19, 16, -1, -19 },
  { 1821, 15, 19, 15, 2, -19 },
  { 1857, 17, 19, 14, -1, -19 },
  { 1898, 10, 23, 9, 0, -19 },
  { 1927, 6, 19, 11, 3, -19 },
  { 1942, 11, 23, 9, -2, -19 },
  { 1974, 13, 12, 15, 1, -19 },
  { 1994, 11, 2, 11, -2, 2 },
  { 1997, 5, 5, 8, 4, -21 },
  { 2001, 14, 15, 16, 1, -15 },
  { 2028, 14, 21, 16, 1, -21 },
  { 2065, 12, 15, 13, 1, -15 },
  { 2088, 16, 21, 16, 1, -21 },
  { 2130, 13, 15, 14, 1, -15 },
  { 2155, 16, 27, 10, -3, -21 },
  { 2209, 14, 21, 16, 1, -15 },
  { 2246, 14, 21, 16, 1, -21 },
  { 2283, 7, 20, 8, 1, -20 },
  { 2301, 11, 26, 8, -3, -20 },
  { 2337, 15, 21, 15, 1, -21 },
  { 2377, 7, 21, 8, 1, -21 },
  { 2396, 22, 15, 24, 1, -15 },
  { 2438, 14, 15, 16, 1, -15 },
  { 2465, 13, 15, 16, 1, -15 },
  { 2490, 16, 21, 16, -1, -15 },
  { 2532, 14, 21, 16, 1, -15 },
  { 2569, 11, 15, 11, 1, -15 },
  { 2590, 12, 15, 12, 0, -15 },
  { 2613, 10, 18, 10, 1, -18 },
  { 2636, 14, 15, 16, 1, -15 },
  { 2663, 14, 15, 13, 1, -15 },
  { 2690, 20, 15, 21, 2, -15 },
  { 2728, 16, 15, 14, -1, -15 },
  { 2758, 17, 21, 13, -2, -15 },
  { 2803, 13, 15, 12, 0, -15 },
  { 2828, 11, 23, 10, 0, -19 },
  { 2860, 3, 26, 15, 6, -20 },
  { 2870, 11, 23, 10, -1, -19 },
  { 2902, 13, 5, 15, 2, -12 },
};

const GFXfont NotoSans_SemiBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMIBOLDITALIC27PT7B_H_
