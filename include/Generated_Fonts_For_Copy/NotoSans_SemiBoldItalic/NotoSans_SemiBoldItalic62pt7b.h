#ifndef _NOTOSANS_SEMIBOLDITALIC62PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0xC3,
  0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0,
  0x7E, 0x1F, 0x81, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8,
  0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x7E,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB, 0xC7,
  0xE0, 0x7F, 0xC7, 0x81, 0x80, 0xFF, 0x0F, 0x00, 0x01, 0xFC, 0x3E, 0x00,
  0x03, 0xF8, 0x78, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x0F, 0xE1, 0xE0, 0x00,
  0x1F, 0xE3, 0xC0, 0x00, 0x3F, 0xEF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x01,
  0xE3, 0xFC, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x1E,
  0x0F, 0xE0, 0x00, 0x3C, 0x3F, 0xC4, 0x00, 0x78, 0x7F, 0x8E, 0x00, 0xF1,
  0xFF, 0x1F, 0x83, 0xEF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x0F, 0xE0,
  0x00, 0x3F, 0x03, 0xF8, 0x7E, 0x1F, 0xE1, 0xF8, 0x1F, 0xC7, 0xE3, 0xFF,
  0xCF, 0xE1, 0xFC, 0x7F, 0x3F, 0xFF, 0x7F, 0x0F, 0xE7, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0x1F, 0xFF, 0xEF, 0xFF, 0xE3, 0xF1, 0xFE, 0x7F, 0x7F,
  0xFF, 0x3F, 0x9F, 0xC1, 0xF9, 0xFF, 0xF3, 0xF8, 0xFE, 0x0F, 0xC7, 0xFE,
  0x1F, 0x8F, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x03, 0xF0, 0x00, 0x1F,
  0xC3, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC1,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7E,
  0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x80,
  0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0x80, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x9F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0x0F, 0xFF, 0xFE, 0x01,
  0xFE, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x7F,
  0xC0, 0xFF, 0x87, 0xF8, 0x7F, 0x80, 0x7F, 0xCF, 0xF0, 0x7F, 0x80, 0x3F,
  0xEF, 0xF0, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x3F, 0xE0, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xC3, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xC8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0xC0, 0x1F, 0x80, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0x07, 0xC0, 0x03, 0xFE,
  0x3E, 0x00, 0x3F, 0xF9, 0xE0, 0x01, 0xFF, 0xFF, 0x03, 0xF3, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xC0, 0xFF, 0xF8, 0x00, 0x0F,
  0xE7, 0xC0, 0x00, 0xFF, 0x3F, 0x00, 0x0F, 0xF1, 0xF8, 0x01, 0xFF, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x38, 0x0F, 0xE0,
  0x00, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x1E, 0x1F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xE0,
  0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x7F, 0x3F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFE, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x07,
  0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFE,
  0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xDF, 0xCF, 0xFE, 0xFF,
  0x1F, 0xE3, 0xFC, 0x3F, 0x0F, 0xF0, 0xF0, 0x3F, 0x81, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x0E, 0x00,
  0x0F, 0xF0, 0x01, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x03, 0xFF, 0x00, 0x70, 0x01, 0xFF, 0x00, 0x40, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0x1F, 0xF0, 0xE0,
  0x00, 0x3F, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7A, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0,
  0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x02, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x10, 0x00, 0x03, 0xFE, 0x0E, 0x00, 0x03, 0xFF, 0x07, 0xE0, 0x0F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFD, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xCF, 0xFF, 0x80, 0x3F,
  0x9F, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xF8,
  0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFE, 0x7F, 0x00, 0xFF,
  0xF3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x0C, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7C, 0x01,
  0xFE, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0xFF,
  0xC1, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0xE0, 0x7E, 0x3F, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0x9F, 0x80, 0xFF, 0x01,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x00,
  0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xFB, 0xF0, 0x3F, 0x80,
  0x3F, 0x00, 0xFD, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0xF8, 0x1F, 0xC0,
  0x1F, 0x80, 0x7E, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0xBF, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xDF, 0x81, 0xF8,
  0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0xFC, 0x03, 0xF8, 0x07, 0xE7, 0xE0, 0x7E,
  0x01, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x01, 0xFE, 0x07, 0xF1, 0xF8, 0x1F,
  0xC1, 0xFF, 0x07, 0xF0, 0xFC, 0x0F, 0xF1, 0xFF, 0xC7, 0xF8, 0x7F, 0x03,
  0xFF, 0xF7, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F, 0xC0,
  0x7F, 0xF8, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xF8,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x01,
  0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xFC, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0x00, 0x3F, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x3F,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF8,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x11, 0xFE, 0x00, 0x3F, 0xFF, 0x8F, 0xF8, 0x01,
  0xFF, 0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0x1F, 0xFF, 0xE3,
  0xFC, 0x00, 0x7F, 0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x03, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x03,
  0xF9, 0xFF, 0x00, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0xFD,
  0xFC, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xDF, 0x80, 0x01,
  0xFB, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0x80,
  0x03, 0xF3, 0xF8, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F,
  0x80, 0x07, 0xE7, 0xF8, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x9F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFF,
  0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFC, 0x07, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFC,
  0x1F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xC3, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFC, 0x3F, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F, 0x80,
  0x3F, 0x80, 0xFE, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0x80, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x80,
  0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xC0, 0x01,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xDF, 0xC0, 0x03, 0xFC,
  0x01, 0xF9, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x03, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0xBF, 0x80, 0x3F, 0xC0, 0x03, 0xFB, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xF0,
  0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x03, 0xFD, 0xFF, 0x00,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF8,
  0x1F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFE, 0x00, 0x08, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x80, 0x00,
  0x3F, 0xE0, 0xF0, 0x00, 0x7F, 0xC0, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xE0,
  0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFD, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x9F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x7E, 0x01, 0xFE, 0x01, 0xFC, 0x07,
  0xF1, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x7E, 0x07, 0xF8,
  0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x80, 0x07, 0xF1,
  0xFC, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x1F, 0xCF, 0xF0, 0x00,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x00, 0x07, 0xF3, 0xF0, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x1F,
  0xDF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xEF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xC0,
  0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x7F, 0xC3, 0xFC,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03,
  0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07,
  0xE0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0xF8, 0x3F,
  0x00, 0xFF, 0xFC, 0x7F, 0x01, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8,
  0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0x9F, 0xC0,
  0x1F, 0xFE, 0x1F, 0x80, 0x07, 0xFC, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8,
  0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0xF8, 0x01, 0xFC, 0xFF, 0xFE, 0x00, 0xFE,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xEF, 0xFF,
  0xF8, 0x07, 0xE3, 0xFF, 0xF8, 0x03, 0xF0, 0xFF, 0xF8, 0x03, 0xF0, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0x81, 0xE0, 0x7F, 0xC0, 0x04, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x10, 0x3F, 0xF0, 0x1E, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xC0, 0x07,
  0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0xDF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xEF, 0xE0, 0x03, 0xFF, 0xF9, 0xFC, 0x00, 0x3F, 0xFE,
  0x3F, 0x00, 0x01, 0xFF, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x00, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0x8F,
  0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0,
  0x3F, 0xF1, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x40, 0xFF, 0x80, 0x1E, 0x07, 0xFF, 0xCF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x20, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x07, 0xFF, 0x83, 0xF0, 0x03, 0xFF, 0xF1, 0xFC, 0x01, 0xFF,
  0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF8, 0x7F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0x3F,
  0xC0, 0x07, 0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x02, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x80,
  0x00, 0x7F, 0x80, 0x3C, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x07, 0xF8, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFE,
  0x00, 0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x01,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x03, 0xFE, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x06, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFE, 0x7F,
  0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xE1, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0x9F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x07, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0xBF, 0x0F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0xFC, 0x1F, 0xFE, 0x00, 0x7E, 0x1F, 0xFF, 0x80, 0x3F, 0x1F,
  0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF, 0xF8, 0x0F, 0xFF,
  0x87, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x83, 0xFF,
  0x80, 0x3F, 0xC1, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x03, 0xFE,
  0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xFE, 0x1F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03,
  0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0x1F, 0xFF, 0x80, 0x03, 0xF3, 0xFF, 0xFC,
  0x00, 0x3F, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF,
  0xF8, 0x00, 0xFE, 0x7F, 0xFF, 0x00, 0x0F, 0xE3, 0xFF, 0xE0, 0x01, 0xFE,
  0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0xFF, 0xFC, 0x7F, 0x01,
  0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x0F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x1F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F,
  0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xC0, 0x3F,
  0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0x3F, 0xC0, 0x1F, 0xFE, 0x3F, 0x80, 0x07,
  0xFC, 0x3F, 0x80, 0x00, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x07, 0xF1,
  0xFF, 0x00, 0xFC, 0x7F, 0xE0, 0x1F, 0x9F, 0xFC, 0x07, 0xF7, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x02, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xF0, 0x7F, 0xC0, 0x04,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x88, 0x00,
  0x1F, 0xE3, 0x80, 0x0F, 0xF8, 0xFF, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x10, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFE, 0xFE, 0x03,
  0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF, 0x3F, 0x00, 0x7F, 0xFF, 0x1F, 0x80,
  0x1F, 0xFE, 0x0F, 0xC0, 0x07, 0xFE, 0x0F, 0xE0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE,
  0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F,
  0xC0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE,
  0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF1,
  0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xF8, 0x01, 0xFE,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF3, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xCF,
  0xE0, 0x0F, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF8, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0x0F, 0xE0,
  0x3F, 0x7E, 0x03, 0xF8, 0x3F, 0x81, 0xFD, 0xF8, 0x1F, 0xE0, 0xFE, 0x07,
  0xE7, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0x9F, 0x83, 0xFC, 0x0F, 0xE0, 0xFC,
  0x7E, 0x0F, 0xF0, 0x3F, 0x83, 0xF1, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC7,
  0xE1, 0xFE, 0x03, 0xF8, 0x7E, 0x1F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x7E,
  0x3F, 0xC0, 0x3F, 0x8F, 0xC1, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x07, 0xE3,
  0xF8, 0x01, 0xF9, 0xF8, 0x1F, 0x9F, 0xC0, 0x07, 0xE7, 0xE0, 0x7E, 0x7F,
  0x00, 0x1F, 0xBF, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x07, 0xEF, 0xE0,
  0x01, 0xFB, 0xF0, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x03,
  0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xBF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x08, 0xFF, 0xC0, 0x00, 0x5F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x80, 0x01, 0xFF, 0xE4, 0x00,
  0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 45, 17, 1, -44 },
  { 103, 22, 16, 27, 6, -44 },
  { 147, 39, 44, 40, 1, -44 },
  { 362, 31, 51, 34, 2, -47 },
  { 560, 45, 46, 52, 4, -45 },
  { 819, 40, 46, 43, 2, -45 },
  { 1049, 10, 16, 15, 6, -44 },
  { 1069, 22, 54, 20, 2, -44 },
  { 1218, 22, 55, 20, -4, -45 },
  { 1370, 29, 29, 34, 6, -47 },
  { 1476, 29, 30, 35, 4, -37 },
  { 1585, 14, 15, 17, -3, -7 },
  { 1612, 17, 7, 20, 1, -20 },
  { 1627, 9, 10, 17, 1, -9 },
  { 1639, 33, 45, 25, -3, -45 },
  { 1825, 30, 46, 34, 3, -45 },
  { 1998, 22, 44, 34, 7, -44 },
  { 2119, 34, 45, 34, -1, -45 },
  { 2311, 32, 46, 34, 1, -45 },
  { 2495, 33, 44, 34, 0, -44 },
  { 2677, 33, 45, 34, 1, -44 },
  { 2863, 32, 46, 34, 3, -45 },
  { 3047, 33, 44, 34, 3, -44 },
  { 3229, 32, 46, 34, 2, -45 },
  { 3413, 30, 46, 34, 3, -45 },
  { 3586, 15, 35, 17, 1, -34 },
  { 3652, 19, 42, 17, -3, -34 },
  { 3752, 29, 31, 35, 4, -38 },
  { 3865, 29, 18, 35, 4, -31 },
  { 3931, 29, 31, 35, 4, -38 },
  { 4044, 25, 46, 28, 5, -45 },
  { 4188, 49, 50, 53, 3, -44 },
  { 4495, 38, 44, 37, -4, -44 },
  { 4704, 35, 44, 38, 2, -44 },
  { 4897, 36, 46, 37, 4, -45 },
  { 5104, 38, 44, 42, 2, -44 },
  { 5313, 33, 44, 33, 2, -44 },
  { 5495, 33, 44, 32, 2, -44 },
  { 5677, 38, 46, 43, 4, -45 },
  { 5896, 41, 44, 43, 2, -44 },
  { 6122, 28, 44, 22, -2, -44 },
  { 6276, 30, 57, 19, -10, -44 },
  { 6490, 40, 44, 37, 2, -44 },
  { 6710, 25, 44, 31, 2, -44 },
  { 6848, 52, 44, 54, 2, -44 },
  { 7134, 44, 44, 46, 2, -44 },
  { 7376, 39, 46, 45, 4, -45 },
  { 7601, 35, 44, 37, 2, -44 },
  { 7794, 39, 56, 45, 4, -45 },
  { 8067, 34, 44, 37, 2, -44 },
  { 8254, 32, 46, 32, 1, -45 },
  { 8438, 32, 44, 32, 5, -44 },
  { 8614, 39, 45, 43, 4, -44 },
  { 8834, 35, 44, 36, 6, -44 },
  { 9027, 54, 44, 55, 6, -44 },
  { 9324, 44, 44, 36, -3, -44 },
  { 9566, 33, 44, 34, 6, -44 },
  { 9748, 37, 44, 33, -1, -44 },
  { 9952, 25, 54, 20, -1, -44 },
  { 10121, 13, 45, 25, 7, -45 },
  { 10195, 25, 54, 20, -4, -44 },
  { 10364, 31, 29, 35, 2, -45 },
  { 10477, 26, 4, 25, -6, 6 },
  { 10490, 12, 9, 19, 9, -47 },
  { 10504, 32, 35, 36, 3, -34 },
  { 10644, 33, 48, 37, 1, -47 },
  { 10842, 27, 35, 29, 3, -34 },
  { 10961, 35, 48, 36, 3, -47 },
  { 11171, 29, 35, 33, 3, -34 },
  { 11298, 36, 62, 22, -7, -47 },
  { 11577, 34, 49, 37, 1, -34 },
  { 11786, 33, 47, 37, 1, -47 },
  { 11980, 18, 47, 18, 1, -47 },
  { 12086, 27, 62, 18, -8, -47 },
  { 12296, 35, 47, 33, 1, -47 },
  { 12502, 18, 47, 18, 1, -47 },
  { 12608, 51, 34, 55, 1, -34 },
  { 12825, 33, 34, 37, 1, -34 },
  { 12966, 30, 35, 36, 3, -34 },
  { 13098, 36, 49, 37, -2, -34 },
  { 13319, 32, 49, 36, 3, -34 },
  { 13515, 27, 34, 26, 1, -34 },
  { 13630, 26, 35, 28, 1, -34 },
  { 13744, 22, 42, 24, 3, -41 },
  { 13860, 33, 35, 37, 3, -34 },
  { 14005, 31, 34, 31, 3, -34 },
  { 14137, 46, 34, 47, 4, -34 },
  { 14333, 37, 34, 32, -3, -34 },
  { 14491, 39, 49, 31, -5, -34 },
  { 14730, 30, 34, 29, -1, -34 },
  { 14858, 26, 54, 22, 0, -44 },
  { 15034, 5, 61, 34, 15, -47 },
  { 15073, 25, 54, 22, -3, -44 },
  { 15242, 29, 10, 35, 4, -27 },
};

const GFXfont NotoSans_SemiBoldItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMIBOLDITALIC62PT7B_H_
