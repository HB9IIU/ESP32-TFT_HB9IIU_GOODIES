#ifndef _NOTOSANS_SEMIBOLDITALIC54PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x1C, 0x00, 0x7F, 0x0F, 0xDF, 0xC7, 0xF7, 0xE1, 0xF9, 0xF8,
  0x7E, 0x7E, 0x1F, 0x9F, 0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x3F,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x3E, 0x3C, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xCF, 0x0E, 0x07,
  0xF1, 0xE0, 0x40, 0xFE, 0x3C, 0x00, 0x1F, 0x87, 0x00, 0x03, 0xF0, 0xE0,
  0x00, 0x7F, 0x3C, 0x00, 0x0F, 0xE7, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xDF, 0xE0, 0x00, 0x79, 0xFC, 0x00, 0x0E, 0x1F, 0x80, 0x01, 0xC3, 0xF0,
  0x00, 0x78, 0x7E, 0x20, 0x0F, 0x1F, 0xC6, 0x01, 0xE3, 0xF8, 0xF8, 0x39,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xFC, 0x00, 0x07,
  0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xFC, 0x00, 0x7E, 0x03, 0xFF,
  0xF8, 0x00, 0xF8, 0x07, 0xE3, 0xF0, 0x03, 0xE0, 0x1F, 0x83, 0xE0, 0x0F,
  0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x01, 0xF8,
  0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x0F,
  0x80, 0x0F, 0x81, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0xFC, 0x00, 0x3E,
  0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x87, 0xC1, 0xE0, 0xF8, 0x3F, 0x1F,
  0x1F, 0xF1, 0xF0, 0x7C, 0x7E, 0x7F, 0xF3, 0xE1, 0xF9, 0xF9, 0xFF, 0xF7,
  0xFF, 0xE3, 0xE7, 0xFF, 0xEF, 0xFF, 0xCF, 0x8F, 0xC7, 0xEF, 0xFF, 0x3F,
  0x3F, 0x0F, 0xCF, 0xFC, 0xFC, 0x7E, 0x1F, 0x8F, 0xE1, 0xF1, 0xF8, 0x3F,
  0x00, 0x07, 0xC3, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0xFC, 0x00, 0x7E,
  0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x7C,
  0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x0F, 0xC3,
  0xF0, 0x1F, 0x80, 0x1F, 0xCF, 0xC0, 0x3E, 0x00, 0x1F, 0xFF, 0x00, 0xF8,
  0x00, 0x3F, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0xFE, 0x01, 0xFC, 0x3F, 0xFF,
  0xC0, 0x3F, 0x8F, 0xF9, 0xFC, 0x0F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F,
  0x03, 0xFC, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xC3, 0xF8, 0x07, 0xFB, 0xF8,
  0x7F, 0x00, 0x7F, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0x81, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0x80, 0x0F, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0xC3, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x08, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x01, 0xF8, 0x7C,
  0x00, 0x7F, 0x9F, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF8,
  0x0F, 0xFC, 0x02, 0x07, 0xEF, 0x80, 0x03, 0xFB, 0xE0, 0x01, 0xFC, 0xFC,
  0x01, 0xFE, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xE0,
  0x3E, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xC0, 0x0C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x30, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF3, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFB, 0xF9, 0xFC, 0x7E, 0x3F,
  0x1F, 0xC3, 0x83, 0xF8, 0x20, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x1E, 0x00, 0xFF,
  0x00, 0x60, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0xF0, 0x0C, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x88, 0x00, 0x07,
  0xF0, 0xC0, 0x00, 0xFF, 0x0F, 0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xC3, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x88, 0x00, 0x07, 0xF0, 0xE0, 0x01, 0xFF, 0x0F, 0xC0,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x05, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0xF0, 0x01, 0xF8, 0xFF, 0xC0, 0x7F, 0x7F, 0xFC, 0x0F, 0xDF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xFC, 0x0F, 0xF1, 0xFF, 0x00,
  0xFE, 0x3F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F,
  0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07,
  0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFF,
  0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0xC0,
  0x3F, 0xCF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFF,
  0x00, 0x7F, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01,
  0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0xC7, 0xF0, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xBF, 0x03, 0xFF, 0xF7, 0xE0, 0x3F, 0xF9, 0xFC,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x1C, 0x07, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0F, 0xC0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xC0, 0x3F, 0xC4,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x7F, 0xE0, 0x3F, 0x1F, 0x80, 0x7F,
  0xFF, 0x0F, 0xCF, 0xC0, 0x3F, 0xFF, 0x81, 0xF3, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7D, 0xF8, 0x1F, 0xE0, 0xF8, 0x1F, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xDF,
  0x03, 0xF0, 0x1F, 0x01, 0xFF, 0xC1, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x7E,
  0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xFE, 0x0F, 0xC0, 0x3E,
  0x03, 0xFF, 0x83, 0xE0, 0x0F, 0x80, 0xFB, 0xE0, 0xF8, 0x03, 0xE0, 0x3E,
  0xF8, 0x3E, 0x01, 0xF8, 0x0F, 0xBE, 0x0F, 0x80, 0x7C, 0x07, 0xCF, 0x83,
  0xE0, 0x3F, 0x03, 0xF3, 0xE0, 0xF8, 0x1F, 0xC0, 0xF8, 0xF8, 0x3F, 0x0F,
  0xF8, 0xFE, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0x81, 0xFF, 0xEF, 0xFF,
  0x83, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0x7C, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xE0,
  0x03, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x03,
  0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7E, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x01,
  0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x80, 0x3C, 0x03, 0xFE, 0x00, 0x08, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0x80, 0x1F, 0xFC,
  0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x7F, 0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x03,
  0xF8, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0xC0, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x78, 0x07, 0xFE, 0x00, 0x0C,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F, 0xE0, 0x0F,
  0xFF, 0xC7, 0xF0, 0x07, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xF3, 0xFC, 0x01,
  0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x07, 0xF0, 0x3F, 0xE0, 0x07, 0xF0, 0x0F, 0xFF, 0x1F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x07, 0xF8, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00,
  0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0x80, 0x0F, 0xDF, 0xC0, 0x7E,
  0x7C, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0x00, 0x3F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xC0,
  0x1F, 0x9F, 0xC0, 0x7E, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x07, 0xE3,
  0xF8, 0x0F, 0xE3, 0xF0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC,
  0x03, 0xF0, 0x7C, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE1, 0xF0, 0x7F, 0x00,
  0xFC, 0x1F, 0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xF8, 0xF8, 0x1F, 0xC0, 0x7E,
  0x07, 0xCF, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x7C, 0x07, 0xE0, 0x1F, 0x81,
  0xF7, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x03, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0xE0,
  0x00, 0x7F, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xE0,
  0x1F, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xC0,
  0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0x7E, 0x00, 0x3F, 0x01,
  0xF9, 0xF8, 0x01, 0xFC, 0x07, 0xE7, 0xF0, 0x07, 0xF0, 0x1F, 0x8F, 0xC0,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x0F,
  0xE1, 0xF8, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x1F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7F,
  0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xE0, 0x1F, 0xC7,
  0xE0, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x7E, 0x03, 0xF8,
  0x03, 0xFB, 0xF8, 0x0F, 0xC0, 0x0F, 0xEF, 0xC0, 0x3F, 0x00, 0x1F, 0xBF,
  0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xC0,
  0x03, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xF8,
  0x07, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0xFE, 0x00,
  0x07, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0x80, 0xFE,
  0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0xE0, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0xFE, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xC0, 0x7F, 0x80, 0x04,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x0F, 0xE0,
  0xE0, 0x03, 0xFE, 0x0F, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F,
  0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x03,
  0xF0, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xC1, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xDF, 0x00, 0x7F,
  0x07, 0xE0, 0x1F, 0xBE, 0x01, 0xFC, 0x0F, 0xC0, 0x3E, 0x7C, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF9, 0xF0, 0x1F, 0xC0,
  0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC7, 0xC0, 0xFE, 0x01,
  0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x1F, 0x87, 0xF0, 0x07,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x1F,
  0xE0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF9, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x1F, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC,
  0x1F, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x3F, 0xFC, 0x7C,
  0x03, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F,
  0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x87, 0xFF, 0x03, 0xFF, 0xFD, 0xF0, 0x0F,
  0xFF, 0xDF, 0x80, 0x7F, 0xFC, 0xFC, 0x01, 0xFF, 0xC7, 0xE0, 0x07, 0xFC,
  0x3F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xC0,
  0x03, 0xF8, 0xFF, 0x80, 0x3F, 0xBF, 0xFC, 0x03, 0xF7, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0x07, 0xFC, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE1,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0x80,
  0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7C, 0xFF, 0xFC, 0x0F, 0xC7,
  0xFF, 0x80, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x0C, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x10, 0x7F, 0xC0, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x78, 0x1F, 0xC0, 0x07, 0xFE, 0x3F, 0x00, 0x1F, 0xFE, 0x7E,
  0x00, 0x7F, 0xFC, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01,
  0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x3F,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF7, 0xC0, 0x0F, 0xFF, 0xDF,
  0x80, 0x0F, 0xFF, 0x3F, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFC, 0x3F, 0xC0, 0x7E, 0x1F,
  0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x0F, 0xF7, 0xF0, 0x1F, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x10, 0x7F, 0xC0, 0x38, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xC3, 0xF0, 0x07, 0xFF, 0x8F, 0x80, 0x7F, 0xFF, 0x7E, 0x01,
  0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFB,
  0xF0, 0x07, 0xFF, 0xDF, 0xC0, 0x0F, 0xFE, 0x7F, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x20, 0x00, 0xFF, 0x00, 0xE0,
  0x07, 0xF8, 0x03, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xE0, 0x03, 0xF8, 0xFF, 0x80,
  0x3F, 0x9F, 0xFC, 0x03, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0x07, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F,
  0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x18, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0x80, 0xFF, 0x00, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xF8, 0x7F, 0x80, 0x0F, 0xE3,
  0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xF7, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xC0, 0x03,
  0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0x0F, 0xF8,
  0x0F, 0xFC, 0x03, 0xE3, 0xFF, 0xC1, 0xFF, 0xE0, 0x3E, 0x7F, 0xFC, 0x3F,
  0xFE, 0x03, 0xE7, 0xFF, 0xE7, 0xFF, 0xF0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFF,
  0x07, 0xFE, 0x0F, 0xFF, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0x07,
  0xF8, 0x07, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0x0F, 0xF8, 0x03, 0xF3, 0xFF, 0xE0, 0x3E,
  0x7F, 0xFE, 0x03, 0xEF, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF, 0x07, 0xFF, 0x07,
  0xF0, 0x7F, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x80, 0x7F, 0x0F,
  0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0xFF, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xFB, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFF, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x3F, 0xE0, 0x01,
  0xF1, 0xFF, 0xE0, 0x03, 0xE7, 0xFF, 0xE0, 0x07, 0xDF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x00, 0xFF,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0x00,
  0x7E, 0x7F, 0xFC, 0x01, 0xFC, 0xFF, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x07,
  0xF0, 0x18, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x3F, 0xFC,
  0x7C, 0x03, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xF8,
  0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x81, 0xFC, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x87, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xDF, 0x80, 0x7F, 0xFD, 0xFC, 0x01, 0xFF, 0xCF, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x02, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE1, 0xFC, 0x0F, 0xCF, 0xF8, 0x1F,
  0xBF, 0xF0, 0x3E, 0x7F, 0xC0, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x7C, 0x0F,
  0xE0, 0x0C, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0xC0, 0x03, 0xF8, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x82, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFF,
  0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x07, 0xFE, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xFF, 0x7E, 0x07, 0xFF, 0xE7, 0xC0, 0x7F, 0xFC, 0x7C, 0x03, 0xFF, 0x87,
  0xC0, 0x1F, 0xF0, 0x7C, 0x00, 0x10, 0x08, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x07,
  0xF1, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0x7E,
  0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x03, 0xF8,
  0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFE, 0x00,
  0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xBF, 0x80, 0x7F, 0xC0,
  0x1F, 0x9F, 0xC0, 0x3F, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0xF0, 0x0F, 0xE7,
  0xF0, 0x1F, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xFC, 0x07, 0xF0, 0xFC, 0x0F,
  0xBE, 0x07, 0xF0, 0x7E, 0x07, 0xDF, 0x03, 0xF8, 0x3F, 0x07, 0xCF, 0x83,
  0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xFC, 0x0F, 0xC3, 0xF3, 0xE0, 0xFC, 0x07,
  0xE1, 0xF1, 0xF0, 0xFE, 0x03, 0xF1, 0xF8, 0xF8, 0x7E, 0x01, 0xF8, 0xF8,
  0x7C, 0x7F, 0x00, 0xFC, 0xFC, 0x3E, 0x3F, 0x00, 0x7E, 0x7E, 0x1F, 0x3F,
  0x80, 0x3F, 0x3E, 0x0F, 0x9F, 0x80, 0x1F, 0xBF, 0x07, 0xCF, 0xC0, 0x0F,
  0xDF, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x81, 0xF7, 0xE0, 0x03, 0xFF, 0x80,
  0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xF0, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x00, 0x3E, 0xFE, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x10, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0A, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x4F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFA,
  0x00, 0x07, 0xF8,
};

const GFXglyph NotoSans_SemiBoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 40, 15, 1, -39 },
  { 76, 18, 14, 23, 6, -39 },
  { 108, 34, 39, 35, 1, -39 },
  { 274, 27, 44, 30, 2, -41 },
  { 423, 39, 39, 45, 4, -39 },
  { 614, 35, 40, 38, 2, -39 },
  { 789, 8, 14, 13, 6, -39 },
  { 803, 19, 48, 17, 2, -39 },
  { 917, 19, 48, 17, -4, -39 },
  { 1031, 26, 25, 30, 5, -41 },
  { 1113, 26, 26, 31, 3, -32 },
  { 1198, 12, 13, 15, -2, -6 },
  { 1218, 15, 5, 17, 1, -17 },
  { 1228, 8, 9, 15, 1, -8 },
  { 1237, 28, 39, 21, -2, -39 },
  { 1374, 27, 40, 30, 2, -39 },
  { 1509, 19, 39, 30, 6, -39 },
  { 1602, 30, 39, 30, -1, -39 },
  { 1749, 28, 40, 30, 1, -39 },
  { 1889, 29, 39, 30, 0, -39 },
  { 2031, 28, 40, 30, 1, -39 },
  { 2171, 27, 40, 30, 3, -39 },
  { 2306, 28, 39, 30, 3, -39 },
  { 2443, 28, 40, 30, 2, -39 },
  { 2583, 27, 40, 30, 2, -39 },
  { 2718, 13, 31, 15, 1, -30 },
  { 2769, 17, 37, 15, -3, -30 },
  { 2848, 26, 27, 31, 3, -33 },
  { 2936, 26, 16, 31, 3, -27 },
  { 2988, 26, 27, 31, 3, -33 },
  { 3076, 22, 40, 24, 4, -39 },
  { 3186, 42, 44, 46, 3, -39 },
  { 3417, 33, 39, 33, -3, -39 },
  { 3578, 31, 39, 33, 2, -39 },
  { 3730, 32, 40, 33, 3, -39 },
  { 3890, 33, 39, 36, 2, -39 },
  { 4051, 29, 39, 29, 2, -39 },
  { 4193, 29, 39, 28, 2, -39 },
  { 4335, 33, 40, 37, 3, -39 },
  { 4500, 36, 39, 37, 2, -39 },
  { 4676, 24, 39, 20, -1, -39 },
  { 4793, 26, 50, 17, -9, -39 },
  { 4956, 35, 39, 32, 2, -39 },
  { 5127, 22, 39, 27, 2, -39 },
  { 5235, 45, 39, 47, 2, -39 },
  { 5455, 38, 39, 40, 2, -39 },
  { 5641, 35, 40, 39, 3, -39 },
  { 5816, 30, 39, 32, 2, -39 },
  { 5963, 35, 48, 39, 3, -39 },
  { 6173, 30, 39, 33, 2, -39 },
  { 6320, 28, 40, 28, 1, -39 },
  { 6460, 27, 39, 28, 5, -39 },
  { 6592, 34, 40, 37, 4, -39 },
  { 6762, 31, 39, 31, 5, -39 },
  { 6914, 47, 39, 48, 5, -39 },
  { 7144, 39, 39, 31, -3, -39 },
  { 7335, 29, 39, 29, 5, -39 },
  { 7477, 32, 39, 29, -1, -39 },
  { 7633, 22, 48, 17, -1, -39 },
  { 7765, 12, 39, 21, 6, -39 },
  { 7824, 22, 48, 17, -4, -39 },
  { 7956, 28, 25, 30, 1, -39 },
  { 8044, 22, 4, 21, -5, 5 },
  { 8055, 10, 8, 17, 8, -41 },
  { 8065, 29, 31, 31, 2, -30 },
  { 8178, 28, 42, 32, 1, -41 },
  { 8325, 24, 31, 25, 2, -30 },
  { 8418, 31, 42, 32, 2, -41 },
  { 8581, 25, 31, 29, 2, -30 },
  { 8678, 31, 54, 19, -6, -41 },
  { 8888, 30, 43, 32, 1, -30 },
  { 9050, 28, 41, 32, 1, -41 },
  { 9194, 15, 41, 15, 1, -41 },
  { 9271, 23, 54, 15, -7, -41 },
  { 9427, 30, 41, 29, 1, -41 },
  { 9581, 16, 41, 15, 1, -41 },
  { 9663, 44, 30, 48, 1, -30 },
  { 9828, 28, 30, 32, 1, -30 },
  { 9933, 27, 30, 31, 2, -30 },
  { 10035, 31, 43, 32, -2, -30 },
  { 10202, 29, 43, 32, 2, -30 },
  { 10358, 23, 30, 22, 1, -30 },
  { 10445, 24, 31, 25, 0, -30 },
  { 10538, 20, 37, 21, 2, -36 },
  { 10631, 28, 30, 32, 3, -29 },
  { 10736, 27, 29, 27, 3, -29 },
  { 10834, 41, 29, 41, 3, -29 },
  { 10983, 32, 29, 28, -2, -29 },
  { 11099, 34, 42, 27, -4, -29 },
  { 11278, 26, 29, 25, -1, -29 },
  { 11373, 22, 48, 19, 0, -39 },
  { 11505, 5, 54, 30, 13, -41 },
  { 11539, 21, 48, 19, -2, -39 },
  { 11665, 26, 8, 31, 3, -23 },
};

const GFXfont NotoSans_SemiBoldItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMIBOLDITALIC54PT7B_H_
