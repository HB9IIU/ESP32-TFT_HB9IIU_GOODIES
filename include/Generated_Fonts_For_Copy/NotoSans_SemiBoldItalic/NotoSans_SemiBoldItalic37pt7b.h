#ifndef _NOTOSANS_SEMIBOLDITALIC37PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x7C, 0xFB,
  0xC7, 0x9E, 0x3C, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9C, 0x38, 0xE1,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x87,
  0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x07, 0x0F, 0x00, 0x1E, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1,
  0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C,
  0x00, 0x78, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xF9, 0xC6, 0x1F,
  0x30, 0x03, 0xC6, 0x00, 0x7C, 0xC0, 0x0F, 0xB8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0x3E, 0x00, 0x63, 0xC0, 0x1C, 0xF9, 0x83, 0x9F, 0x3E, 0x6F, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x41, 0xFC, 0x00, 0xF0, 0x7F,
  0xC0, 0x3C, 0x1F, 0x78, 0x07, 0x03, 0xC7, 0x81, 0xE0, 0xF0, 0xF0, 0x78,
  0x1E, 0x1E, 0x1E, 0x03, 0xC3, 0xC3, 0x80, 0x70, 0x70, 0xF0, 0x1E, 0x1E,
  0x3C, 0x03, 0xC3, 0xCF, 0x00, 0x78, 0x79, 0xC7, 0xCF, 0x1E, 0x7B, 0xFC,
  0xF7, 0xDE, 0xFF, 0xDF, 0xF7, 0x9E, 0x79, 0xFC, 0xF7, 0x87, 0x0E, 0x3C,
  0xF0, 0xE0, 0x0F, 0x1E, 0x1C, 0x03, 0xC7, 0x87, 0x80, 0x78, 0xF0, 0xF0,
  0x1E, 0x1E, 0x1E, 0x07, 0x83, 0xC3, 0xC0, 0xE0, 0x78, 0xF0, 0x3C, 0x0F,
  0x1E, 0x0F, 0x00, 0xFF, 0x83, 0xC0, 0x1F, 0xE0, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xE3, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xC7, 0xC0, 0x03, 0xDF, 0x80, 0x03, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0x1F, 0xF8, 0x1F, 0x3F, 0x7C, 0x1E,
  0x7E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0xF8, 0x1F, 0x78, 0xF8, 0x0F, 0xF8,
  0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFC, 0xF8, 0x1F, 0xF0, 0x7C, 0x7D, 0xE7, 0x9C,
  0xF3, 0xCF, 0x38, 0xE0, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x01, 0x03, 0xC0, 0x70, 0xF0, 0x1F, 0x38, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0x04, 0x3D, 0xC0, 0x1E, 0x70, 0x1F,
  0x9E, 0x01, 0xC3, 0x80, 0x20, 0xF0, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x3D, 0xFF, 0xFF, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F,
  0x7C, 0x07, 0xDF, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x00,
  0xFB, 0xC0, 0x7C, 0xF0, 0x1F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x1F, 0xC1, 0xFE,
  0x3F, 0xF3, 0xFF, 0x7F, 0x79, 0xF7, 0xCE, 0x3E, 0x21, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3E, 0x3F, 0x01, 0xC0, 0xFC, 0x04, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0x83, 0xF0, 0x20, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0xC0, 0x1F, 0x8F, 0xCF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x7B, 0xC0, 0x0F, 0xBC, 0x01, 0xF3, 0xC0, 0x1E, 0x7C, 0x03, 0xC7,
  0x80, 0x78, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0,
  0xF0, 0x78, 0x0F, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x10, 0x7F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF9, 0x00, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF3, 0xE0, 0x3C, 0xFF, 0x07, 0xBF, 0xF1, 0xFF,
  0xFE, 0x3F, 0x87, 0xE7, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0,
  0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0x83, 0xF7,
  0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0,
  0xF8, 0x3E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1,
  0xF0, 0x78, 0x1F, 0x3F, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x81, 0xFD, 0xF8, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x1E, 0x7C,
  0x03, 0xCF, 0x80, 0x79, 0xF0, 0x0F, 0x3F, 0x03, 0xE3, 0xF1, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0x79, 0xF0,
  0x1F, 0x78, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x3E, 0x7C, 0x1F,
  0x9F, 0x8F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xCF, 0x00, 0xC3, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x01, 0x07, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x3E, 0x3F, 0x1F, 0x87, 0x80, 0x00, 0x40, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x70, 0x1E, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xC0, 0x7F,
  0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0x87, 0xC8, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC7, 0x81, 0xFF, 0x0F, 0x3C, 0x1F, 0xFC, 0x7B, 0xC1, 0xFF, 0xC3,
  0xDE, 0x1E, 0x0E, 0x1E, 0xE1, 0xE0, 0xF0, 0xFF, 0x0E, 0x07, 0x87, 0xF8,
  0xF0, 0x38, 0x3F, 0x87, 0x83, 0xC1, 0xFC, 0x3C, 0x1E, 0x0E, 0xE1, 0xC0,
  0xF0, 0xF7, 0x0E, 0x0F, 0x07, 0x38, 0x78, 0xFC, 0x79, 0xE3, 0xFE, 0xFF,
  0x8F, 0x0F, 0xE7, 0xF8, 0x78, 0x3E, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x01,
  0xE3, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x78, 0x0F, 0x81,
  0xE0, 0x3E, 0x07, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x78, 0x0F, 0x83,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x0F,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x78,
  0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x8F, 0x00, 0x78,
  0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x07, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0xF8, 0x3F, 0x00, 0x41,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x08, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x78, 0x0F,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x07, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x01, 0xF0, 0xF0, 0x07, 0xE1, 0xE0, 0x1F, 0x87, 0xC0, 0x7F, 0x0F, 0x83,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0x87, 0xC1, 0xFC, 0x01, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFF,
  0xCF, 0x81, 0xFF, 0x1E, 0x03, 0xFE, 0x7C, 0x0F, 0xFC, 0xF8, 0x00, 0xF9,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0xC0, 0x3E, 0x1F, 0xC0, 0x78, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0x81,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0xF8,
  0x3E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x1F,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x78, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xC0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xF8,
  0x07, 0x83, 0xF0, 0x07, 0x87, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x80,
  0x0F, 0x9F, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x78, 0x07, 0xC0,
  0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x7F,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0xF7, 0x83, 0xDE, 0x01, 0xFF, 0x07, 0xBC,
  0x07, 0xBE, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0xF0, 0x3C, 0xF0, 0x7D, 0xE0,
  0x7B, 0xE0, 0xF3, 0xC1, 0xE7, 0xC1, 0xE7, 0x83, 0xCF, 0x03, 0xCF, 0x0F,
  0x1E, 0x07, 0x8E, 0x1E, 0x3C, 0x1F, 0x1C, 0x78, 0xF8, 0x3C, 0x38, 0xF1,
  0xF0, 0x78, 0x7B, 0xC3, 0xC0, 0xF0, 0xF7, 0x87, 0x81, 0xE1, 0xFE, 0x0F,
  0x07, 0xC3, 0xFC, 0x3E, 0x0F, 0x07, 0xF0, 0x7C, 0x1E, 0x0F, 0xE0, 0xF0,
  0x3C, 0x1F, 0x81, 0xE0, 0xF8, 0x3E, 0x03, 0xC1, 0xF0, 0x7C, 0x0F, 0x80,
  0x03, 0xE0, 0x03, 0xE0, 0xFE, 0x00, 0x78, 0x1F, 0xC0, 0x0F, 0x03, 0xF8,
  0x03, 0xE0, 0x7F, 0x80, 0x7C, 0x1E, 0xF0, 0x0F, 0x03, 0xDE, 0x01, 0xE0,
  0x7B, 0xE0, 0x7C, 0x0F, 0x3C, 0x0F, 0x81, 0xE7, 0x81, 0xE0, 0x7C, 0xF8,
  0x3C, 0x0F, 0x8F, 0x07, 0x81, 0xE1, 0xE1, 0xF0, 0x3C, 0x3E, 0x3E, 0x07,
  0x83, 0xC7, 0x81, 0xF0, 0x7C, 0xF0, 0x3C, 0x0F, 0x9E, 0x07, 0x80, 0xF7,
  0xC0, 0xF0, 0x1F, 0xF8, 0x1E, 0x03, 0xFE, 0x07, 0xC0, 0x3F, 0xC0, 0xF0,
  0x07, 0xF8, 0x1E, 0x00, 0xFF, 0x03, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF1, 0xFC, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x03,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x78, 0x1F, 0x83, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF1,
  0xFC, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0x9F, 0xE0,
  0x78, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80,
  0xF0, 0x78, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x1F, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF8,
  0x0F, 0x07, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFC, 0x3C, 0x3F, 0x01,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x30, 0x0F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x7C,
  0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x80,
  0x1E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x87,
  0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x81, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0xFD, 0xE0,
  0x03, 0xE7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x03, 0xE1, 0xE0, 0x0F,
  0x87, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC7,
  0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xDF, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0xF0, 0x07, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0x7C,
  0xF0, 0x1F, 0xC0, 0x7C, 0xF0, 0x1F, 0xC0, 0x78, 0xF0, 0x3F, 0xC0, 0xF8,
  0xF0, 0x3F, 0xC0, 0xF0, 0xF0, 0x7B, 0xC1, 0xF0, 0xF0, 0x7B, 0xC1, 0xF0,
  0xF0, 0x7B, 0xC3, 0xE0, 0xF0, 0xF3, 0xC3, 0xE0, 0xF0, 0xF3, 0xC3, 0xC0,
  0xF1, 0xE1, 0xC7, 0xC0, 0xF1, 0xE1, 0xC7, 0x80, 0xF3, 0xC1, 0xCF, 0x80,
  0xF3, 0xC1, 0xCF, 0x00, 0xF7, 0x81, 0xCF, 0x00, 0xF7, 0x81, 0xDE, 0x00,
  0xF7, 0x81, 0xDE, 0x00, 0xFF, 0x01, 0xDE, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0xF8, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xFB, 0xE0, 0x1F, 0x1F, 0x01,
  0xF8, 0xF8, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0xF7,
  0x00, 0x1C, 0xF0, 0x07, 0x8E, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x03,
  0x81, 0xC0, 0x78, 0x78, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x1E, 0xF0, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0xF1, 0xE1, 0xFF, 0x3C, 0x7F, 0xFF, 0x1F, 0xDF, 0xE3, 0xE0,
  0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0xF8, 0x07, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x0F,
  0xC7, 0xC3, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0x78, 0x1F, 0x8F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x3F, 0x81, 0xEF,
  0xF8, 0x3F, 0xFF, 0x0F, 0xF3, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x01,
  0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xE3, 0xF0, 0xFC, 0x7F, 0x3F,
  0x1E, 0xFF, 0xE3, 0xDF, 0xF0, 0x79, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFE, 0x3F, 0x9E, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x08, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xF3, 0xE0,
  0x7F, 0xDF, 0x07, 0xFF, 0xF0, 0x7F, 0x3F, 0x83, 0xE0, 0xFC, 0x3F, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0xFC,
  0x1F, 0x07, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xF7, 0x80, 0x7F,
  0x3C, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xC3, 0xE1, 0xF3, 0xE0,
  0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0, 0x3E, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x08,
  0xFE, 0x3C, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0x20, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0xF0, 0x7F, 0xCF, 0x0F, 0xFF, 0xE1, 0xFC, 0xFE, 0x1F, 0x07, 0xE3,
  0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0x7C, 0x1F,
  0x87, 0xC3, 0xF8, 0x7F, 0xFF, 0x07, 0xFE, 0xF0, 0x3F, 0xCF, 0x01, 0xF9,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0xC0,
  0x7C, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x1F, 0x81, 0xEF, 0xF8,
  0x3F, 0xFF, 0x8F, 0xF3, 0xF1, 0xFC, 0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF9,
  0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x80, 0x03, 0x81, 0xF0, 0x7C, 0x1F,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x01, 0x0F, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0xC1,
  0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0x79, 0xF0, 0x07,
  0xDF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xEF, 0x80, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x07, 0xC0, 0x78,
  0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x03, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0x0F, 0x1F, 0x83,
  0xF0, 0x3D, 0xFF, 0x3F, 0xE0, 0xEF, 0xFC, 0xFF, 0xC7, 0xB9, 0xF7, 0x3F,
  0x1F, 0xC3, 0xF8, 0x7C, 0x7E, 0x0F, 0xC1, 0xF1, 0xF0, 0x3E, 0x07, 0xCF,
  0x80, 0xF8, 0x1F, 0x3E, 0x03, 0xC0, 0x7C, 0xF8, 0x1F, 0x01, 0xE3, 0xC0,
  0x7C, 0x07, 0x8F, 0x01, 0xF0, 0x3E, 0x7C, 0x07, 0x80, 0xF9, 0xF0, 0x1E,
  0x03, 0xE7, 0xC0, 0xF8, 0x0F, 0x1E, 0x03, 0xE0, 0x3C, 0x78, 0x0F, 0x81,
  0xF3, 0xE0, 0x3C, 0x07, 0xCF, 0x80, 0xF0, 0x1F, 0x3E, 0x07, 0xC0, 0x78,
  0x0F, 0x3F, 0x81, 0xEF, 0xF8, 0x7B, 0xFF, 0x8F, 0xFB, 0xF1, 0xFC, 0x3E,
  0x3F, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x78,
  0xF8, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xE3,
  0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x80,
  0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFE, 0x7E, 0x3E, 0x0F, 0x9F,
  0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0xBC, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0xFC,
  0x7E, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0xCF, 0xE0,
  0x1C, 0xFF, 0x80, 0xEF, 0xFC, 0x0F, 0xF3, 0xF0, 0x7E, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC3,
  0xC0, 0x3E, 0x1E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F,
  0x83, 0xF0, 0xFC, 0x1F, 0xCF, 0xC1, 0xFF, 0xFE, 0x0F, 0xBF, 0xC0, 0x78,
  0xFC, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF1, 0xE1, 0xFF, 0x3C, 0x7F, 0xFF, 0x1F, 0xCF, 0xE3,
  0xE0, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3C, 0xF8, 0x07, 0x9F,
  0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x3E, 0x3C,
  0x0F, 0xC7, 0xC1, 0xF8, 0xFF, 0xFE, 0x0F, 0xFB, 0xC1, 0xFF, 0x78, 0x1F,
  0x9F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F,
  0x3F, 0x0F, 0x7E, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x0E, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x80, 0x7C, 0xF0,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xC8, 0x7F, 0xC1, 0xFE, 0x07, 0xF0, 0x1E, 0x03,
  0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC3, 0xF8,
  0xFD, 0xEF, 0x1F, 0xFD, 0xE1, 0xFF, 0x78, 0x1F, 0x8F, 0x00, 0xF0, 0x07,
  0xFC, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x0F, 0x87,
  0x83, 0xE1, 0xE1, 0xF0, 0x78, 0x7C, 0x1E, 0x3E, 0x07, 0x8F, 0x81, 0xE7,
  0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x1F, 0x01, 0xFF, 0x81,
  0xF0, 0x1E, 0xF8, 0x3F, 0x03, 0xEF, 0x83, 0xF0, 0x3C, 0xF8, 0x7F, 0x07,
  0xCF, 0x87, 0x78, 0x78, 0xF8, 0xF7, 0x8F, 0x87, 0x8F, 0x78, 0xF0, 0x78,
  0xE7, 0x9F, 0x07, 0x9E, 0x79, 0xE0, 0x79, 0xC7, 0x9E, 0x07, 0xBC, 0x7B,
  0xE0, 0x7B, 0xC7, 0xBC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0x81, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x1E, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xF3, 0xC0,
  0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x7C, 0x01,
  0xE0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x9F, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF0,
  0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x03, 0xF0, 0x1F, 0xC0, 0x3C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x5F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xA0, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 26, 10, 1, -26 },
  { 34, 13, 9, 16, 4, -26 },
  { 49, 23, 26, 24, 1, -26 },
  { 124, 19, 30, 20, 1, -28 },
  { 196, 27, 27, 31, 2, -27 },
  { 288, 24, 27, 26, 1, -27 },
  { 369, 6, 9, 9, 4, -26 },
  { 376, 14, 32, 12, 1, -26 },
  { 432, 13, 33, 12, -3, -27 },
  { 486, 18, 17, 20, 3, -28 },
  { 525, 18, 18, 21, 2, -22 },
  { 566, 9, 9, 10, -2, -4 },
  { 577, 10, 4, 12, 1, -12 },
  { 582, 6, 5, 10, 0, -5 },
  { 586, 20, 27, 15, -2, -27 },
  { 654, 18, 27, 20, 2, -27 },
  { 715, 13, 26, 20, 4, -26 },
  { 758, 21, 27, 20, -1, -27 },
  { 829, 20, 27, 20, 0, -27 },
  { 897, 20, 26, 20, 0, -26 },
  { 962, 19, 26, 20, 1, -26 },
  { 1024, 19, 27, 20, 2, -27 },
  { 1089, 20, 26, 20, 2, -26 },
  { 1154, 19, 27, 20, 1, -27 },
  { 1219, 18, 27, 20, 2, -27 },
  { 1280, 9, 21, 10, 0, -21 },
  { 1304, 11, 26, 10, -2, -21 },
  { 1340, 18, 19, 21, 2, -23 },
  { 1383, 18, 10, 21, 2, -18 },
  { 1406, 18, 19, 21, 2, -23 },
  { 1449, 15, 27, 17, 3, -27 },
  { 1500, 29, 29, 32, 2, -26 },
  { 1606, 22, 26, 22, -2, -26 },
  { 1678, 21, 26, 23, 1, -26 },
  { 1747, 22, 27, 22, 2, -27 },
  { 1822, 23, 26, 25, 1, -26 },
  { 1897, 20, 26, 20, 1, -26 },
  { 1962, 20, 26, 19, 1, -26 },
  { 2027, 23, 27, 25, 2, -27 },
  { 2105, 25, 26, 26, 1, -26 },
  { 2187, 16, 26, 13, -1, -26 },
  { 2239, 18, 34, 12, -6, -26 },
  { 2316, 24, 26, 22, 1, -26 },
  { 2394, 15, 26, 19, 1, -26 },
  { 2443, 31, 26, 32, 1, -26 },
  { 2544, 27, 26, 27, 1, -26 },
  { 2632, 24, 27, 27, 2, -27 },
  { 2713, 21, 26, 22, 1, -26 },
  { 2782, 24, 33, 27, 2, -27 },
  { 2881, 21, 26, 22, 1, -26 },
  { 2950, 19, 27, 19, 1, -27 },
  { 3015, 19, 26, 19, 3, -26 },
  { 3077, 23, 26, 25, 3, -26 },
  { 3152, 22, 26, 21, 3, -26 },
  { 3224, 32, 26, 33, 4, -26 },
  { 3328, 26, 26, 21, -2, -26 },
  { 3413, 21, 26, 20, 3, -26 },
  { 3482, 23, 26, 20, -1, -26 },
  { 3557, 15, 32, 12, -1, -26 },
  { 3617, 8, 27, 15, 4, -27 },
  { 3644, 15, 32, 12, -3, -26 },
  { 3704, 19, 17, 21, 1, -27 },
  { 3745, 15, 3, 15, -3, 3 },
  { 3751, 8, 6, 11, 5, -28 },
  { 3757, 19, 20, 22, 2, -20 },
  { 3805, 19, 28, 22, 1, -28 },
  { 3872, 16, 20, 17, 2, -20 },
  { 3912, 21, 28, 22, 2, -28 },
  { 3986, 17, 20, 20, 2, -20 },
  { 4029, 21, 37, 13, -4, -28 },
  { 4127, 20, 29, 22, 1, -20 },
  { 4200, 19, 28, 22, 1, -28 },
  { 4267, 10, 28, 10, 1, -28 },
  { 4302, 16, 37, 10, -5, -28 },
  { 4376, 21, 28, 20, 1, -28 },
  { 4450, 10, 28, 10, 1, -28 },
  { 4485, 30, 20, 33, 1, -20 },
  { 4560, 19, 20, 22, 1, -20 },
  { 4608, 18, 20, 21, 2, -20 },
  { 4653, 21, 29, 22, -1, -20 },
  { 4730, 19, 29, 22, 2, -20 },
  { 4799, 16, 20, 15, 1, -20 },
  { 4839, 16, 20, 17, 0, -20 },
  { 4879, 13, 24, 14, 2, -24 },
  { 4918, 19, 20, 22, 2, -20 },
  { 4966, 18, 20, 18, 2, -20 },
  { 5011, 28, 20, 28, 2, -20 },
  { 5081, 23, 20, 19, -2, -20 },
  { 5139, 23, 29, 18, -3, -20 },
  { 5223, 18, 20, 17, -1, -20 },
  { 5268, 15, 32, 13, 0, -26 },
  { 5328, 3, 37, 20, 9, -28 },
  { 5342, 15, 32, 13, -2, -26 },
  { 5402, 18, 6, 21, 2, -16 },
};

const GFXfont NotoSans_SemiBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMIBOLDITALIC37PT7B_H_
