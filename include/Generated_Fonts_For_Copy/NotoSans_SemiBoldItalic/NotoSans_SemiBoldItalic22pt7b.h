#ifndef _NOTOSANS_SEMIBOLDITALIC22PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x60, 0xC0, 0x00,
  0x0E, 0x3C, 0x70, 0x77, 0x66, 0x66, 0x66, 0xC6, 0xCC, 0x06, 0x30, 0x31,
  0x81, 0x98, 0x18, 0xC0, 0xC6, 0x3F, 0xFD, 0xFF, 0xE3, 0x18, 0x18, 0xC0,
  0xCC, 0x3F, 0xFD, 0xFF, 0xE3, 0x30, 0x19, 0x81, 0x8C, 0x0C, 0xE0, 0x01,
  0x00, 0x60, 0x3F, 0x1F, 0xF3, 0xAC, 0xE4, 0x1D, 0x81, 0xF0, 0x3F, 0x01,
  0xF0, 0x3F, 0x06, 0xE0, 0x9D, 0x97, 0x3F, 0xE7, 0xF0, 0x18, 0x02, 0x00,
  0x1C, 0x06, 0x3E, 0x0C, 0x77, 0x0C, 0x67, 0x18, 0x67, 0x30, 0xE6, 0x70,
  0xE6, 0x6E, 0x6E, 0xDF, 0x7D, 0xBB, 0x3B, 0xB3, 0x03, 0x33, 0x06, 0x73,
  0x0C, 0x63, 0x1C, 0x77, 0x18, 0x7E, 0x70, 0x3C, 0x07, 0x80, 0x3F, 0x01,
  0xCE, 0x06, 0x38, 0x18, 0xE0, 0x77, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x1D,
  0xDC, 0xEE, 0x3B, 0xB8, 0x7C, 0xE1, 0xE3, 0x8F, 0x8F, 0xFF, 0x1F, 0x9E,
  0x76, 0x66, 0xCC, 0x07, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x70, 0x60, 0xE0,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x06, 0x06,
  0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x0E,
  0x0C, 0x1C, 0x18, 0x38, 0xF0, 0x06, 0x01, 0x88, 0x63, 0x90, 0xFD, 0xC7,
  0xF1, 0xE4, 0xD8, 0x77, 0x08, 0xC0, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x0F, 0xFF, 0xFF, 0xC1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x39,
  0xDC, 0xC6, 0x60, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0x07, 0x83, 0xF8, 0xF7, 0x1C, 0x77, 0x0E,
  0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1B, 0x87, 0x70, 0xEE, 0x39, 0xC7,
  0x1F, 0xC1, 0xF0, 0x03, 0x0F, 0x3F, 0xFF, 0x76, 0x46, 0x0E, 0x0E, 0x0E,
  0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x07, 0xC1, 0xFE, 0x3C, 0xE1,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xC1, 0xFE, 0x1C, 0xF1,
  0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0xF8, 0x0F, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0xEC, 0x1C, 0xFF, 0x87, 0xF0, 0x00, 0x70, 0x0E, 0x01, 0xE0,
  0x3E, 0x07, 0xE0, 0xEE, 0x0C, 0xC1, 0x8C, 0x39, 0xC7, 0x1C, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xC0, 0x1C, 0x01, 0x80, 0x3F, 0x03, 0xFC, 0x13, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xEC, 0x3C, 0xFF, 0x87, 0xF0, 0x03, 0xE1, 0xFC, 0x78, 0x9C,
  0x03, 0x00, 0xE0, 0x19, 0xE3, 0xFE, 0xF1, 0xDC, 0x3B, 0x87, 0x70, 0xEE,
  0x1D, 0xE7, 0x1F, 0xE1, 0xF0, 0x3F, 0xF7, 0xFF, 0x7F, 0xE0, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x0F, 0x00, 0x0F, 0x83, 0xF8, 0xE3, 0x9C, 0x73, 0x8E,
  0x71, 0xC7, 0xF0, 0xF8, 0x3F, 0x8E, 0x73, 0x87, 0x70, 0xEE, 0x1D, 0xC3,
  0xBF, 0xE3, 0xF8, 0x0F, 0x07, 0xF8, 0xE7, 0x38, 0x77, 0x0E, 0xC1, 0xD8,
  0x3B, 0x8E, 0x7F, 0xC7, 0xF8, 0x07, 0x00, 0xC0, 0x39, 0x0E, 0x3F, 0x87,
  0xE0, 0x18, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x38, 0x0C, 0x3C,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xC3, 0x86, 0x1C, 0x30, 0x00,
  0x00, 0x20, 0x0C, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x80, 0x1C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x78,
  0x3E, 0x1F, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x3E, 0x7F, 0xB9, 0xC0, 0x70,
  0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x00, 0x00, 0x07, 0x03, 0x81,
  0xC0, 0x00, 0xF0, 0x03, 0xFF, 0x03, 0xC1, 0xC3, 0x00, 0x73, 0x00, 0x1B,
  0x8F, 0xCD, 0x8E, 0x67, 0xCC, 0x73, 0xC6, 0x31, 0xE6, 0x18, 0xF3, 0x1C,
  0x79, 0xCE, 0x6C, 0x7F, 0xE3, 0x18, 0xE1, 0x80, 0x00, 0x70, 0x10, 0x1F,
  0xF0, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x37,
  0x03, 0xB8, 0x18, 0xC1, 0xC6, 0x0C, 0x30, 0xFF, 0x87, 0xFC, 0x7F, 0xF3,
  0x03, 0xB8, 0x1F, 0x80, 0xFC, 0x07, 0x1F, 0x81, 0xFE, 0x1F, 0xF3, 0x87,
  0x38, 0x73, 0x87, 0x30, 0xE3, 0xFC, 0x7F, 0xC7, 0x0E, 0x70, 0xE6, 0x0E,
  0xE0, 0xEE, 0x3E, 0xFF, 0xCF, 0xF0, 0x03, 0xF0, 0x7F, 0xC7, 0xDE, 0x78,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x20, 0xFF, 0x03, 0xF8, 0x1F, 0x80, 0xFF, 0x07,
  0xFC, 0x70, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0xEE, 0x07, 0x70, 0x3B, 0x81,
  0xDC, 0x1C, 0xC0, 0xEE, 0x0E, 0x71, 0xF3, 0xFE, 0x1F, 0xC0, 0x1F, 0xF1,
  0xFE, 0x1F, 0xE3, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0xFC, 0x7F, 0x87,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x7F, 0x9C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xFE, 0x7F, 0x8F, 0xF1,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x03, 0xF0, 0x3F, 0xF1,
  0xFB, 0x8F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x7E, 0x61, 0xFB,
  0x87, 0xEE, 0x03, 0x38, 0x1C, 0x70, 0x71, 0xE1, 0xC3, 0xFE, 0x07, 0xF8,
  0x1C, 0x0C, 0x70, 0x71, 0x81, 0xCE, 0x07, 0x38, 0x18, 0xE0, 0xE3, 0x83,
  0x8F, 0xFE, 0x7F, 0xF9, 0xC0, 0xC7, 0x07, 0x18, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x06, 0x38, 0x38, 0x0F, 0xC7, 0xF0, 0x70, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x07, 0xE3, 0xF8,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x0F, 0xC3,
  0xE0, 0x1C, 0x1C, 0x70, 0xE1, 0x87, 0x0E, 0x38, 0x39, 0xC0, 0xEE, 0x03,
  0x70, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x38, 0x18, 0xE0, 0xE3, 0x83,
  0x87, 0x0E, 0x1C, 0x38, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0xFF, 0xFE, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0D, 0x8D, 0x87,
  0xE3, 0x61, 0xB9, 0xD8, 0xEE, 0x76, 0x33, 0x1D, 0xDC, 0xC6, 0x76, 0x71,
  0x9F, 0x9C, 0xE3, 0xC7, 0x38, 0xF1, 0x8E, 0x38, 0x63, 0x0E, 0x38, 0x1C,
  0x06, 0x3C, 0x0C, 0x78, 0x39, 0xF0, 0x73, 0xF0, 0xC6, 0xE1, 0x8C, 0xC7,
  0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x31, 0x87, 0x63, 0x0E, 0xCE, 0x0F, 0x9C,
  0x1F, 0x38, 0x3C, 0x60, 0x38, 0x03, 0xE0, 0x3F, 0xE1, 0xF7, 0x8F, 0x07,
  0x38, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x60, 0x1F, 0x80, 0x7E, 0x01,
  0xD8, 0x0E, 0x70, 0x79, 0xE3, 0xC3, 0xFE, 0x07, 0xF0, 0x1F, 0x81, 0xFE,
  0x1F, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x30, 0x73, 0x0E, 0x7F, 0xE7, 0xF8,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xE0, 0x3F,
  0xE1, 0xF7, 0x8F, 0x07, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x60,
  0x1F, 0x80, 0x7E, 0x01, 0xD8, 0x0E, 0x70, 0x79, 0xE3, 0xC3, 0xFE, 0x07,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x1F, 0x81, 0xFE, 0x1F,
  0xF3, 0x87, 0x38, 0x73, 0x87, 0x38, 0xE7, 0x3E, 0x7F, 0xC7, 0xF0, 0x73,
  0x86, 0x38, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x0E, 0x07, 0xC0, 0xFF, 0x1E,
  0xE3, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xC0, 0x1C, 0x01, 0xCC, 0x3C, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x38, 0x39, 0x81, 0xDC, 0x0E, 0xE0,
  0x77, 0x03, 0x38, 0x39, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x38, 0x39,
  0x81, 0xCE, 0x0E, 0x71, 0xE3, 0xFE, 0x0F, 0xE0, 0xE0, 0x3F, 0x03, 0xB8,
  0x1D, 0xC1, 0xCE, 0x0C, 0x70, 0xE1, 0x86, 0x0C, 0x70, 0x63, 0x03, 0x38,
  0x19, 0x80, 0xDC, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0xE0,
  0xFC, 0x1C, 0x1F, 0x87, 0x83, 0x70, 0xF0, 0xEE, 0x1E, 0x19, 0xC6, 0xC7,
  0x38, 0xD8, 0xE7, 0x3B, 0x38, 0xE6, 0x67, 0x1D, 0xCC, 0xC3, 0xB1, 0xB8,
  0x7E, 0x36, 0x07, 0x86, 0xC0, 0xF0, 0xF0, 0x1C, 0x1E, 0x03, 0x83, 0xC0,
  0x1C, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0x31, 0xC0, 0x77, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3B, 0x80, 0xE7, 0x03, 0x8E,
  0x07, 0x0E, 0x1C, 0x1C, 0x70, 0x3C, 0xE0, 0x7E, 0x0E, 0x61, 0xC7, 0x1C,
  0x73, 0x87, 0x30, 0x37, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0x87, 0x87, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x7C, 0x3E, 0x00, 0xE3, 0x18, 0xC6, 0x39, 0xCE, 0x31,
  0x8C, 0x63, 0x9C, 0x63, 0x07, 0x87, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x3E,
  0x3E, 0x00, 0x06, 0x00, 0xC0, 0x3C, 0x07, 0x81, 0xB0, 0x63, 0x0C, 0x63,
  0x0E, 0x60, 0xD8, 0x1C, 0xFF, 0x80, 0xE7, 0x31, 0x1F, 0x67, 0xED, 0xE7,
  0xB8, 0x76, 0x0F, 0xC1, 0xB8, 0x77, 0x0E, 0xE3, 0xDC, 0x73, 0xFE, 0x3E,
  0xC0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xDE, 0x1B, 0xE3,
  0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07, 0x70, 0x67, 0x0E, 0x79, 0xE7,
  0xFC, 0xEF, 0x80, 0x0F, 0xCF, 0xE7, 0x89, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3C, 0x47, 0xF0, 0xFC, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x71, 0xF6, 0x3F, 0x67, 0x9E, 0x70, 0xE6, 0x0E, 0xE0, 0xCE, 0x1C,
  0xE1, 0xCE, 0x1C, 0xE3, 0x87, 0xF8, 0x7D, 0x80, 0x0F, 0x8F, 0xF3, 0x9D,
  0xC7, 0x61, 0xFF, 0xEF, 0xE3, 0x80, 0xE0, 0x38, 0x27, 0xF8, 0xFC, 0x00,
  0xF0, 0x1F, 0x03, 0x90, 0x38, 0x03, 0x00, 0xFE, 0x1F, 0xC0, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0xF8, 0x0F, 0x00, 0x0F, 0xB8, 0xFD, 0x8F,
  0x3C, 0x70, 0xE3, 0x87, 0x38, 0x31, 0xC3, 0x8E, 0x1C, 0x71, 0xE3, 0x8E,
  0x1F, 0xB0, 0x7B, 0x80, 0x1C, 0x00, 0xE2, 0x0E, 0x1F, 0xF0, 0xFE, 0x00,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xDE, 0x1B, 0xF3, 0xE7,
  0x3C, 0x73, 0x87, 0x38, 0x73, 0x06, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E,
  0xE1, 0xC0, 0x04, 0x1C, 0x30, 0x00, 0x03, 0x86, 0x0C, 0x38, 0x70, 0xE1,
  0x87, 0x0E, 0x1C, 0x38, 0xE0, 0x00, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0xF8, 0x3C, 0x00, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x3C, 0x63, 0x87, 0x38, 0x3B, 0x81,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xB8, 0x39, 0xC1, 0xC7, 0x0E, 0x38, 0xE1,
  0xE0, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE1, 0x87,
  0x0E, 0x1C, 0x38, 0xE0, 0x19, 0xE7, 0xC3, 0x7D, 0xF8, 0x79, 0xE7, 0x1E,
  0x38, 0x73, 0x87, 0x0C, 0x70, 0xC3, 0x8C, 0x38, 0x73, 0x87, 0x0E, 0x70,
  0xE1, 0xCE, 0x1C, 0x31, 0xC3, 0x0E, 0x70, 0xE1, 0xC0, 0x19, 0xE1, 0xBF,
  0x3E, 0x73, 0xC7, 0x38, 0x73, 0x87, 0x30, 0x67, 0x0E, 0x70, 0xE7, 0x0E,
  0x70, 0xEE, 0x1C, 0x0F, 0x87, 0xF9, 0xE7, 0x38, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0E, 0xE1, 0xDC, 0x71, 0xFE, 0x1F, 0x00, 0x0C, 0xF0, 0x7F, 0x83,
  0x8E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x60, 0xE7, 0x06, 0x38, 0x71, 0xE7,
  0x8D, 0xF8, 0x6F, 0x87, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x00,
  0x1F, 0x67, 0xED, 0xE7, 0xB8, 0x76, 0x0F, 0xC1, 0xB8, 0x77, 0x0E, 0xE1,
  0xDC, 0x71, 0xF6, 0x3D, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0x19, 0xC6, 0xF1, 0xF8, 0xF0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0x80, 0x1F, 0xCF, 0xE3, 0x89, 0xC0, 0x38, 0x0F, 0x80, 0xF0,
  0x1C, 0x03, 0xA1, 0xCF, 0xF3, 0xF8, 0x08, 0x18, 0x18, 0x7F, 0xFF, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xFC, 0x7C, 0x38, 0x73, 0x06,
  0x70, 0xE7, 0x0E, 0x70, 0xE6, 0x0C, 0x61, 0xCE, 0x1C, 0xE3, 0xCE, 0x3C,
  0xFF, 0x87, 0x98, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xC6, 0x38, 0xCE, 0x19,
  0xC3, 0x70, 0x6E, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0xE1, 0xC3, 0xF1, 0xE3,
  0xB8, 0xF1, 0xDC, 0xF9, 0xCE, 0x6C, 0xE3, 0x36, 0x61, 0xB3, 0x70, 0xD9,
  0xB0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0xE3, 0x83, 0x38, 0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x01, 0xF0, 0x1D,
  0x81, 0xCE, 0x1C, 0x71, 0xE1, 0xC0, 0x1C, 0x1C, 0x70, 0xE1, 0xC3, 0x83,
  0x1C, 0x0C, 0x70, 0x33, 0x80, 0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0x78, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x3F, 0x00, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C,
  0x0F, 0xF3, 0xFC, 0x01, 0x83, 0xC3, 0xC1, 0xC0, 0xC0, 0x60, 0x70, 0x38,
  0x38, 0x78, 0x3C, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x3C, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x0F, 0x03, 0x80, 0xC0,
  0x60, 0x30, 0x38, 0x1C, 0x0E, 0x03, 0xC3, 0xC3, 0x81, 0xC0, 0xC0, 0x60,
  0x70, 0x38, 0x78, 0x3C, 0x00, 0x7E, 0x3F, 0xFE, 0x0F, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 8, 6, 9, 2, -16 },
  { 21, 13, 16, 14, 1, -16 },
  { 47, 11, 18, 12, 1, -17 },
  { 72, 16, 16, 18, 1, -16 },
  { 104, 14, 16, 15, 1, -16 },
  { 132, 4, 6, 5, 2, -16 },
  { 135, 8, 19, 7, 1, -16 },
  { 154, 8, 19, 7, -2, -16 },
  { 173, 10, 11, 12, 2, -17 },
  { 187, 11, 11, 13, 1, -13 },
  { 203, 5, 6, 6, -1, -3 },
  { 207, 6, 2, 7, 0, -7 },
  { 209, 4, 3, 6, 0, -3 },
  { 211, 11, 16, 9, -1, -16 },
  { 233, 11, 16, 12, 1, -16 },
  { 255, 8, 16, 12, 2, -16 },
  { 271, 12, 16, 12, 0, -16 },
  { 295, 12, 16, 12, 0, -16 },
  { 319, 12, 16, 12, 0, -16 },
  { 343, 12, 16, 12, 0, -16 },
  { 367, 11, 16, 12, 1, -16 },
  { 389, 12, 16, 12, 1, -16 },
  { 413, 11, 16, 12, 1, -16 },
  { 435, 11, 16, 12, 1, -16 },
  { 457, 6, 12, 6, 0, -12 },
  { 466, 7, 15, 6, -1, -12 },
  { 480, 11, 12, 13, 1, -14 },
  { 497, 11, 6, 13, 1, -11 },
  { 506, 11, 12, 13, 1, -14 },
  { 523, 9, 16, 10, 2, -16 },
  { 541, 17, 18, 19, 1, -16 },
  { 580, 13, 16, 13, -1, -16 },
  { 606, 12, 16, 13, 1, -16 },
  { 630, 13, 16, 13, 1, -16 },
  { 656, 13, 16, 15, 1, -16 },
  { 682, 12, 16, 12, 1, -16 },
  { 706, 11, 16, 11, 1, -16 },
  { 728, 14, 16, 15, 1, -16 },
  { 756, 14, 16, 15, 1, -16 },
  { 784, 10, 16, 8, -1, -16 },
  { 804, 10, 20, 7, -3, -16 },
  { 829, 14, 16, 13, 1, -16 },
  { 857, 9, 16, 11, 1, -16 },
  { 875, 18, 16, 19, 1, -16 },
  { 911, 15, 16, 16, 1, -16 },
  { 941, 14, 16, 16, 1, -16 },
  { 969, 12, 16, 13, 1, -16 },
  { 993, 14, 20, 16, 1, -16 },
  { 1028, 12, 16, 13, 1, -16 },
  { 1052, 12, 16, 11, 0, -16 },
  { 1076, 11, 16, 11, 2, -16 },
  { 1098, 13, 16, 15, 2, -16 },
  { 1124, 13, 16, 13, 2, -16 },
  { 1150, 19, 16, 19, 2, -16 },
  { 1188, 15, 16, 13, -1, -16 },
  { 1218, 12, 16, 12, 2, -16 },
  { 1242, 13, 16, 12, 0, -16 },
  { 1268, 9, 19, 7, 0, -16 },
  { 1290, 5, 16, 9, 2, -16 },
  { 1300, 9, 19, 7, -2, -16 },
  { 1322, 11, 10, 12, 1, -16 },
  { 1336, 9, 1, 9, -2, 2 },
  { 1338, 4, 4, 7, 3, -17 },
  { 1340, 11, 12, 13, 1, -12 },
  { 1357, 12, 17, 13, 0, -17 },
  { 1383, 10, 12, 10, 1, -12 },
  { 1398, 12, 17, 13, 1, -17 },
  { 1424, 10, 12, 12, 1, -12 },
  { 1439, 12, 22, 8, -2, -17 },
  { 1472, 13, 17, 13, 0, -12 },
  { 1500, 12, 17, 13, 0, -17 },
  { 1526, 7, 17, 6, 0, -17 },
  { 1541, 10, 22, 6, -3, -17 },
  { 1569, 13, 17, 12, 0, -17 },
  { 1597, 7, 17, 6, 0, -17 },
  { 1612, 19, 12, 20, 0, -12 },
  { 1641, 12, 12, 13, 0, -12 },
  { 1659, 11, 12, 13, 1, -12 },
  { 1676, 13, 17, 13, -1, -12 },
  { 1704, 11, 17, 13, 1, -12 },
  { 1728, 10, 12, 9, 0, -12 },
  { 1743, 10, 12, 10, 0, -12 },
  { 1758, 8, 15, 8, 1, -15 },
  { 1773, 12, 12, 13, 1, -12 },
  { 1791, 11, 12, 11, 1, -12 },
  { 1808, 17, 12, 17, 1, -12 },
  { 1834, 13, 12, 11, -1, -12 },
  { 1854, 14, 17, 11, -2, -12 },
  { 1884, 10, 12, 10, 0, -12 },
  { 1899, 9, 19, 8, 0, -16 },
  { 1921, 2, 22, 12, 5, -17 },
  { 1927, 9, 19, 8, -1, -16 },
  { 1949, 11, 3, 13, 1, -9 },
};

const GFXfont NotoSans_SemiBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMIBOLDITALIC22PT7B_H_
