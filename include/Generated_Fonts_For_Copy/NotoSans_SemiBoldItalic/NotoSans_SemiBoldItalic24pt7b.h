#ifndef _NOTOSANS_SEMIBOLDITALIC24PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE1, 0x80,
  0x00, 0x1C, 0x78, 0xF0, 0x73, 0xB9, 0x99, 0xCC, 0xE6, 0x67, 0x30, 0x03,
  0x18, 0x0E, 0x70, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x0F, 0xFF, 0xDF, 0xFF,
  0x86, 0x30, 0x1C, 0xE0, 0x31, 0x83, 0xFF, 0xE7, 0xFF, 0xC3, 0x9C, 0x06,
  0x30, 0x0C, 0x60, 0x39, 0xC0, 0x63, 0x00, 0x01, 0x80, 0x18, 0x0F, 0xF1,
  0xFF, 0x3B, 0x23, 0xB0, 0x3B, 0x03, 0xA0, 0x3F, 0x01, 0xFC, 0x07, 0xC0,
  0x5E, 0x04, 0xE8, 0xCE, 0xFF, 0xCF, 0xF8, 0x7E, 0x00, 0x80, 0x18, 0x00,
  0x3E, 0x07, 0x3F, 0x07, 0x39, 0x87, 0x1C, 0xE3, 0x0C, 0x63, 0x06, 0x33,
  0x83, 0x39, 0x99, 0x9D, 0xBE, 0xFD, 0xBF, 0xFD, 0xDC, 0xC0, 0xCC, 0x60,
  0xCE, 0x70, 0xE7, 0x38, 0xE3, 0x9C, 0x61, 0xDC, 0x60, 0xFE, 0x70, 0x3E,
  0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9C,
  0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x0E, 0xFF, 0x1F, 0xCE, 0x77, 0x0F, 0xEE,
  0x1F, 0x9C, 0x1E, 0x3C, 0xFC, 0x3F, 0xFC, 0x3F, 0x3C, 0x77, 0x66, 0x6E,
  0x07, 0x0E, 0x0C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x06, 0x03, 0x80,
  0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x00, 0x03, 0x00, 0x70,
  0x47, 0x07, 0x60, 0xFF, 0xF0, 0xFE, 0x1E, 0x23, 0xB0, 0x73, 0x03, 0x38,
  0x03, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x39, 0xDC, 0xE6, 0x70, 0x7E,
  0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0xC1, 0xFE, 0x3C, 0xF3, 0x87,
  0x78, 0x77, 0x07, 0x70, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x0E,
  0xE1, 0xEE, 0x1C, 0xF3, 0xC7, 0xF8, 0x3E, 0x00, 0x07, 0x1F, 0x3F, 0xFF,
  0xEE, 0x4E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x07, 0xE0, 0xFF, 0x87, 0x1E, 0x10, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0x83, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0xC1, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x73, 0x87, 0x9F, 0xF8, 0x7F, 0x80, 0x00, 0x78, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xB8, 0x39, 0x83, 0x9C, 0x38, 0xE1,
  0x87, 0x1C, 0x39, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0x80, 0x38, 0x03, 0x80, 0x37, 0x07,
  0xFC, 0x3F, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0xC7, 0xCF,
  0xF8, 0xFE, 0x00, 0x03, 0xF0, 0xFF, 0x1F, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x77, 0x87, 0xFC, 0x7D, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E,
  0x73, 0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0xF9, 0xFF, 0xD0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xE1, 0xFF,
  0x3C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x1D, 0xE0, 0xFC, 0x1F, 0x87, 0xBC,
  0xF1, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xC7, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xFE, 0x38, 0xE7, 0x07, 0x70, 0x77, 0x07, 0x70, 0xF7, 0x0F, 0x7F,
  0xE3, 0xFE, 0x1C, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x8F, 0x8F, 0xF0, 0xFC,
  0x00, 0x1C, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3C, 0xF0, 0x0E,
  0x3C, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xC7, 0x0E, 0x38,
  0x60, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x70, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x0E, 0x00,
  0x7F, 0x7F, 0xD8, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x3C, 0x3C, 0x1C, 0x1C,
  0x0E, 0x00, 0x00, 0x03, 0x81, 0xE0, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xF0, 0x3C, 0x0F, 0x0E, 0x00, 0x63, 0x82, 0x0E, 0xE3, 0xF8, 0xD8, 0xF7,
  0x1B, 0x18, 0xE3, 0xE7, 0x1C, 0x7C, 0xC3, 0x1F, 0x18, 0x63, 0xE3, 0x1C,
  0x6E, 0x77, 0xB9, 0xCF, 0xBE, 0x18, 0x41, 0x03, 0x80, 0x00, 0x38, 0x04,
  0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x80,
  0x7E, 0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0x61,
  0xFF, 0x8F, 0xFF, 0x38, 0x1D, 0xE0, 0x77, 0x01, 0xFC, 0x07, 0xE0, 0x1C,
  0x1F, 0xF0, 0xFF, 0xC7, 0x1E, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xE7,
  0xFC, 0x3F, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x78, 0x7B, 0xFF,
  0xDF, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0xCF, 0xCE, 0x70, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xF7, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1,
  0xCF, 0x87, 0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1D,
  0xC0, 0x77, 0x01, 0xDC, 0x0E, 0x70, 0x7B, 0xC3, 0xCF, 0xFE, 0x3F, 0xF0,
  0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x87, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0xFC, 0x3F, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xFF, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x87, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xC3, 0xFE, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0xFC,
  0x7F, 0xF3, 0xE1, 0x8F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE1, 0xFB, 0x87, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0xC1, 0xCF, 0x8F,
  0x1F, 0xFC, 0x1F, 0xE0, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E,
  0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x3F, 0xFC, 0x3F, 0xFC, 0x70, 0x1C,
  0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x70,
  0xE0, 0x70, 0x0F, 0xE1, 0xFC, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0x1C,
  0x1E, 0x38, 0x78, 0x71, 0xE0, 0xE3, 0x83, 0x8E, 0x07, 0x38, 0x0E, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xCE, 0x03, 0x8E, 0x07, 0x1C, 0x1E,
  0x3C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0F, 0xFF, 0xFE, 0xFF, 0x80, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03,
  0xE1, 0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xB0, 0x6E, 0x3B, 0x0E, 0xC3, 0xB0,
  0xDC, 0x33, 0x1D, 0xC7, 0x33, 0x9C, 0x73, 0x39, 0xC7, 0x37, 0x18, 0x63,
  0x73, 0x8E, 0x3E, 0x38, 0xE3, 0xC3, 0x8E, 0x3C, 0x38, 0xE3, 0x87, 0x00,
  0x1E, 0x03, 0x8F, 0x01, 0xC7, 0xC1, 0xC3, 0xE0, 0xE3, 0xB0, 0x71, 0xDC,
  0x38, 0xEE, 0x18, 0x73, 0x1C, 0x31, 0xCE, 0x38, 0xE7, 0x1C, 0x33, 0x8E,
  0x1D, 0x87, 0x0F, 0xC7, 0x03, 0xE3, 0x81, 0xF1, 0xC0, 0xF8, 0xE0, 0x38,
  0x00, 0x07, 0xF0, 0x3F, 0xF0, 0xF8, 0xF3, 0xC0, 0xE7, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xEE,
  0x03, 0x9E, 0x0F, 0x3F, 0x7C, 0x3F, 0xF0, 0x1F, 0x80, 0x1F, 0xE0, 0xFF,
  0x87, 0x3E, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x3F, 0xF3,
  0xFF, 0x1F, 0x80, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x00, 0x07, 0xF0, 0x3F, 0xF0, 0xF8, 0xF3, 0xC0, 0xE7, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xEE,
  0x03, 0x9E, 0x0F, 0x3F, 0x7C, 0x3F, 0xF0, 0x3F, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0xFF, 0x87, 0x3E, 0x38, 0x73,
  0x83, 0x9C, 0x1C, 0xE1, 0xE7, 0x1E, 0x3F, 0xE3, 0xFC, 0x1C, 0xE0, 0xE3,
  0x87, 0x1C, 0x78, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0x70, 0x07, 0xF8, 0x7F,
  0x87, 0x8C, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x40, 0xF3, 0x8F, 0x1F, 0xF8, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x00, 0x38, 0x1E, 0x70, 0x38, 0xE0, 0x73, 0xC0, 0xE7, 0x01,
  0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xC7,
  0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x3E, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0xE0,
  0x3F, 0x80, 0xEE, 0x07, 0x98, 0x1C, 0x60, 0xF1, 0xC3, 0x87, 0x1E, 0x1C,
  0x70, 0x73, 0xC1, 0xCE, 0x07, 0x70, 0x1D, 0xC0, 0x76, 0x01, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x3F, 0x03, 0x83, 0xF8, 0x3C,
  0x1D, 0xC1, 0xE0, 0xEE, 0x1F, 0x0E, 0x70, 0xD8, 0x71, 0x8E, 0xC7, 0x0C,
  0x76, 0x38, 0x67, 0x31, 0x83, 0x39, 0x9C, 0x19, 0x8E, 0xE0, 0xDC, 0x7E,
  0x06, 0xC3, 0xF0, 0x3E, 0x1B, 0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x70,
  0x3C, 0x00, 0x0E, 0x07, 0x87, 0x07, 0x81, 0xC7, 0x80, 0xE3, 0x80, 0x73,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xDE, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xE0, 0xE0, 0x70,
  0xE0, 0x3C, 0x00, 0xE0, 0x7B, 0x83, 0x9C, 0x38, 0xE3, 0xC7, 0x1C, 0x1D,
  0xC0, 0xEE, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xF0, 0x0F, 0x87, 0xC3, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38,
  0x1F, 0x0F, 0x80, 0xC6, 0x39, 0xCE, 0x71, 0x8C, 0x73, 0x9C, 0xE3, 0x18,
  0xC7, 0x38, 0x07, 0xC3, 0xF0, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x01, 0xC1, 0xF0, 0xFC, 0x00, 0x03, 0x00, 0x70, 0x0F, 0x80, 0xD8, 0x1D,
  0x81, 0x9C, 0x30, 0xC3, 0x0C, 0x60, 0x6E, 0x06, 0xC0, 0x70, 0xFF, 0xFF,
  0xE0, 0xF1, 0x8E, 0x0F, 0x38, 0xFD, 0x8F, 0x3C, 0xF1, 0xE7, 0x07, 0x78,
  0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x3C, 0xF0, 0xFD, 0x87, 0xDC,
  0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0xBE, 0x3F, 0xE3,
  0xCF, 0x38, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0xFF, 0x0E, 0xF0, 0xEF,
  0x3C, 0xDF, 0xCC, 0xF0, 0x0F, 0xE3, 0xF8, 0xF1, 0x3C, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC6, 0x3F, 0xC3, 0xF0, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3C, 0xE1, 0xFF, 0x0F, 0x3C,
  0x78, 0xF1, 0xC1, 0xCF, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x1E,
  0x3C, 0xF0, 0x7E, 0xC0, 0xF3, 0x00, 0x0F, 0xC3, 0xFC, 0xE3, 0xB8, 0x77,
  0x0F, 0xFF, 0xBF, 0xE7, 0xC0, 0xE0, 0x1C, 0x03, 0xC2, 0x3F, 0xC3, 0xF8,
  0x00, 0x7C, 0x03, 0xF0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x1F, 0xC0, 0xFF,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0x9C, 0x3F, 0x61, 0xE7, 0x8F,
  0x1E, 0x38, 0x39, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xC7,
  0x9E, 0x0F, 0xF8, 0x3E, 0xE0, 0x03, 0x80, 0x1C, 0x20, 0x70, 0xFF, 0xC3,
  0xFE, 0x03, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0xBE, 0x3F, 0xF3, 0xEF, 0x38, 0x77, 0x87, 0x70, 0x77, 0x07, 0x70, 0xEE,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0x1C, 0x71, 0xC0, 0x00, 0xE3,
  0x8E, 0x39, 0xC7, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x80, 0x01, 0xC0, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x3F,
  0x0F, 0x83, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0xF1, 0xC7, 0x07, 0x38, 0x1D, 0xC0, 0xEF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xEF, 0x07, 0x1C, 0x1C, 0x70, 0x70, 0xE3, 0xC3, 0xC0, 0x0E,
  0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x8F, 0x1C,
  0x38, 0x71, 0xE0, 0x3B, 0xE3, 0xC6, 0xFD, 0xFC, 0xFB, 0xF3, 0x9C, 0x3C,
  0x77, 0x87, 0x0E, 0xE0, 0xE1, 0xDC, 0x38, 0x3B, 0x87, 0x0E, 0xE0, 0xE1,
  0xDC, 0x1C, 0x3B, 0x87, 0x07, 0x70, 0xE0, 0xEE, 0x1C, 0x38, 0x1D, 0xF0,
  0xFF, 0xC7, 0xDE, 0x78, 0x73, 0xC3, 0x9C, 0x1C, 0xE1, 0xE7, 0x0E, 0x78,
  0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xCF, 0x0E, 0x00, 0x0F, 0xC1, 0xFE, 0x3C,
  0xE7, 0x07, 0x70, 0x7F, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1E, 0x73,
  0xC7, 0xF8, 0x3F, 0x00, 0x0E, 0xF8, 0x37, 0xE0, 0xF3, 0xC3, 0x87, 0x1C,
  0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0xCF, 0x0F,
  0xFC, 0x3B, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x0F, 0x38, 0xFD, 0x8F, 0x3C, 0xF1, 0xE7, 0x07, 0x78, 0x73,
  0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x3C, 0xF0, 0xFF, 0x87, 0xDC, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x3B, 0xCF, 0xE3,
  0xF8, 0xF0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0xE1, 0x1C, 0x03, 0x80, 0x7C, 0x07, 0xC0,
  0x3C, 0x03, 0x80, 0x73, 0x0E, 0x7F, 0xCF, 0xE0, 0x0C, 0x0E, 0x07, 0x0F,
  0xFF, 0xF1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x91,
  0xF0, 0xF8, 0x38, 0x39, 0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39,
  0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x0F, 0x3C, 0xF8, 0xFD, 0x87, 0xCC, 0x00,
  0xE0, 0x7E, 0x0E, 0xE0, 0xE6, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x87, 0x70,
  0x77, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x38, 0x00, 0xE1, 0xE1, 0xF8, 0x78,
  0x76, 0x1E, 0x39, 0x8D, 0x8E, 0x63, 0x67, 0x19, 0xD9, 0xC6, 0x66, 0xE1,
  0xB9, 0xB8, 0x6C, 0x6C, 0x1B, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x00, 0x1C, 0x3C, 0x78, 0xE0, 0xE7, 0x03, 0xB8, 0x07, 0xE0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x77, 0x03, 0x8E, 0x1E, 0x38, 0xF0,
  0xF0, 0x1C, 0x0E, 0x38, 0x38, 0x30, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xCE,
  0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0x80,
  0x00, 0x1F, 0xE7, 0xFC, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0x7F, 0xCF, 0xF8, 0x03, 0xC1, 0xF0, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x3E, 0x0F, 0x01, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0xC0, 0xF0, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x0F, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x1C, 0x06, 0x03, 0xC0, 0xE1, 0xF1, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C,
  0x3E, 0x1E, 0x0C, 0x00, 0x7E, 0x1F, 0xFF, 0xC7, 0xF0,
};

const GFXglyph NotoSans_SemiBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 17, 7, 0, -17 },
  { 16, 9, 6, 10, 2, -17 },
  { 23, 15, 17, 16, 1, -17 },
  { 55, 12, 19, 13, 1, -18 },
  { 84, 17, 17, 20, 2, -17 },
  { 121, 15, 17, 17, 1, -17 },
  { 153, 4, 6, 6, 2, -17 },
  { 156, 8, 21, 8, 1, -17 },
  { 177, 9, 21, 8, -2, -17 },
  { 201, 12, 11, 13, 2, -18 },
  { 218, 12, 11, 14, 1, -14 },
  { 235, 5, 6, 7, -1, -3 },
  { 239, 7, 3, 8, 0, -8 },
  { 242, 4, 3, 7, 0, -3 },
  { 244, 12, 17, 10, -1, -17 },
  { 270, 12, 17, 13, 1, -17 },
  { 296, 8, 17, 13, 3, -17 },
  { 313, 13, 17, 13, 0, -17 },
  { 341, 13, 17, 13, 0, -17 },
  { 369, 13, 17, 13, 0, -17 },
  { 397, 12, 17, 13, 1, -17 },
  { 423, 12, 17, 13, 1, -17 },
  { 449, 13, 17, 13, 1, -17 },
  { 477, 12, 17, 13, 1, -17 },
  { 503, 12, 17, 13, 1, -17 },
  { 529, 6, 13, 7, 0, -13 },
  { 539, 7, 16, 7, -1, -13 },
  { 553, 12, 12, 14, 1, -15 },
  { 571, 12, 7, 14, 1, -12 },
  { 582, 12, 12, 14, 1, -15 },
  { 600, 9, 17, 11, 2, -17 },
  { 620, 19, 19, 20, 1, -17 },
  { 666, 14, 17, 14, -1, -17 },
  { 696, 13, 17, 15, 1, -17 },
  { 724, 13, 17, 14, 2, -17 },
  { 752, 14, 17, 16, 1, -17 },
  { 782, 13, 17, 13, 1, -17 },
  { 810, 13, 17, 12, 1, -17 },
  { 838, 14, 17, 16, 2, -17 },
  { 868, 16, 17, 17, 1, -17 },
  { 902, 11, 17, 9, -1, -17 },
  { 926, 12, 22, 7, -4, -17 },
  { 959, 15, 17, 14, 1, -17 },
  { 991, 10, 17, 12, 1, -17 },
  { 1013, 20, 17, 21, 1, -17 },
  { 1056, 17, 17, 18, 1, -17 },
  { 1093, 15, 17, 17, 2, -17 },
  { 1125, 13, 17, 14, 1, -17 },
  { 1153, 15, 21, 17, 2, -17 },
  { 1193, 13, 17, 14, 1, -17 },
  { 1221, 13, 17, 13, 0, -17 },
  { 1249, 12, 17, 12, 2, -17 },
  { 1275, 15, 17, 16, 2, -17 },
  { 1307, 14, 17, 14, 2, -17 },
  { 1337, 21, 17, 21, 2, -17 },
  { 1382, 17, 17, 14, -1, -17 },
  { 1419, 13, 17, 13, 2, -17 },
  { 1447, 15, 17, 13, -1, -17 },
  { 1479, 9, 21, 8, 0, -17 },
  { 1503, 5, 17, 10, 3, -17 },
  { 1514, 10, 21, 8, -2, -17 },
  { 1541, 12, 11, 13, 1, -17 },
  { 1558, 10, 2, 10, -2, 2 },
  { 1561, 5, 3, 7, 3, -18 },
  { 1563, 13, 13, 14, 1, -13 },
  { 1585, 12, 18, 14, 1, -18 },
  { 1612, 11, 13, 11, 1, -13 },
  { 1630, 14, 18, 14, 1, -18 },
  { 1662, 11, 13, 13, 1, -13 },
  { 1680, 14, 24, 8, -3, -18 },
  { 1722, 14, 19, 14, 0, -13 },
  { 1756, 12, 18, 14, 1, -18 },
  { 1783, 6, 18, 7, 1, -18 },
  { 1797, 10, 24, 7, -3, -18 },
  { 1827, 14, 18, 13, 0, -18 },
  { 1859, 7, 18, 7, 0, -18 },
  { 1875, 19, 13, 21, 1, -13 },
  { 1906, 13, 13, 14, 0, -13 },
  { 1928, 12, 13, 14, 1, -13 },
  { 1948, 14, 19, 14, -1, -13 },
  { 1982, 13, 19, 14, 1, -13 },
  { 2013, 10, 13, 10, 1, -13 },
  { 2030, 11, 13, 11, 0, -13 },
  { 2048, 9, 16, 9, 1, -16 },
  { 2066, 13, 13, 14, 1, -13 },
  { 2088, 12, 13, 12, 1, -13 },
  { 2108, 18, 13, 18, 1, -13 },
  { 2138, 14, 13, 12, -1, -13 },
  { 2161, 15, 19, 12, -2, -13 },
  { 2197, 11, 13, 11, 0, -13 },
  { 2215, 10, 21, 8, 0, -17 },
  { 2242, 2, 24, 13, 6, -18 },
  { 2248, 9, 21, 8, -1, -17 },
  { 2272, 12, 3, 14, 1, -10 },
};

const GFXfont NotoSans_SemiBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMIBOLDITALIC24PT7B_H_
