#ifndef _NOTOSANS_SEMIBOLDITALIC10PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x30, 0xF4, 0x14, 0x51, 0xF9, 0x4F, 0xCA, 0x14, 0x00,
  0x11, 0xD6, 0xC3, 0x17, 0xEC, 0x20, 0xE5, 0x52, 0xC6, 0xF2, 0xA9, 0x73,
  0x00, 0x38, 0x50, 0xE3, 0xBD, 0x59, 0x1D, 0x00, 0xE0, 0x32, 0x44, 0xCC,
  0xC4, 0x40, 0x21, 0x11, 0x12, 0x24, 0x80, 0x25, 0x3E, 0xCB, 0x00, 0x44,
  0xF4, 0x40, 0xE0, 0xE0, 0xC0, 0x18, 0x88, 0x44, 0x62, 0x00, 0x3A, 0x53,
  0x9C, 0xED, 0xC0, 0x3E, 0x22, 0x66, 0x40, 0x7A, 0x42, 0x22, 0x23, 0xE0,
  0x78, 0x42, 0x60, 0x8F, 0xC0, 0x18, 0xCA, 0xBF, 0x88, 0x40, 0x3B, 0x10,
  0xF0, 0x8F, 0xC0, 0x7E, 0x29, 0xE9, 0x4B, 0x80, 0xF8, 0x8C, 0x44, 0x62,
  0x00, 0x3B, 0x5A, 0xEC, 0xE5, 0xC0, 0x7A, 0x52, 0xF0, 0x8B, 0xC0, 0x4C,
  0x01, 0x80, 0x23, 0x00, 0x06, 0xC0, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86,
  0x16, 0x80, 0xF1, 0x24, 0x80, 0x80, 0x1E, 0x21, 0x5D, 0x55, 0xA5, 0x5E,
  0x40, 0x3C, 0x0C, 0x71, 0x4D, 0x3D, 0x9C, 0x40, 0x3D, 0x96, 0xDE, 0x4D,
  0x2F, 0x80, 0x7E, 0x21, 0x08, 0x43, 0xC0, 0x3D, 0x96, 0x51, 0x45, 0x3F,
  0x00, 0x3D, 0x86, 0x1E, 0x41, 0x0F, 0x00, 0x3D, 0x86, 0x1E, 0x41, 0x0C,
  0x00, 0x7F, 0x08, 0x26, 0x8A, 0x2F, 0x80, 0x22, 0xCD, 0x93, 0xE4, 0x48,
  0xB3, 0x00, 0x72, 0x26, 0x44, 0xE0, 0x08, 0x46, 0x21, 0x08, 0xC6, 0xE0,
  0x26, 0xD1, 0xC3, 0x85, 0x0B, 0x32, 0x00, 0x26, 0x64, 0x44, 0xF0, 0x31,
  0xB9, 0x94, 0xCA, 0xA5, 0xD2, 0xDB, 0x48, 0x22, 0xE5, 0x4A, 0xF4, 0xC9,
  0xB3, 0x00, 0x7B, 0x38, 0x61, 0x8E, 0x2F, 0x00, 0x3D, 0x96, 0x5E, 0x41,
  0x0C, 0x00, 0x7B, 0x38, 0x61, 0x8E, 0x2F, 0x04, 0x18, 0x39, 0x96, 0xDE,
  0x51, 0x2C, 0x80, 0x3A, 0x18, 0x61, 0x8B, 0xC0, 0xF9, 0x18, 0x84, 0x23,
  0x00, 0x47, 0x38, 0xA2, 0x8A, 0x6F, 0x00, 0x8E, 0x29, 0x24, 0xA3, 0x84,
  0x00, 0x99, 0xCC, 0xA6, 0xD5, 0x4A, 0xE6, 0x63, 0x30, 0x33, 0x14, 0x1C,
  0x18, 0x38, 0x2C, 0xC4, 0x8E, 0x9C, 0xC4, 0x23, 0x00, 0x7C, 0x21, 0x08,
  0x63, 0x0F, 0x80, 0x34, 0x44, 0x4C, 0x88, 0xC0, 0xAD, 0x54, 0x31, 0x13,
  0x22, 0x22, 0xC0, 0x11, 0x93, 0x90, 0xF0, 0xD0, 0x15, 0xE4, 0xB2, 0xD9,
  0xA0, 0x21, 0x1C, 0xF4, 0xA5, 0x36, 0x13, 0xD1, 0x8C, 0x38, 0x04, 0x11,
  0xDE, 0x4B, 0x2D, 0x9A, 0x13, 0x53, 0xEC, 0x38, 0x0C, 0x41, 0x1E, 0x20,
  0x82, 0x08, 0x63, 0x00, 0x11, 0xF4, 0xB2, 0xD9, 0xE1, 0x3C, 0x21, 0x1A,
  0xF4, 0xA5, 0x3B, 0x24, 0xA4, 0x96, 0x11, 0x12, 0x22, 0x26, 0x4C, 0x20,
  0x86, 0x56, 0x51, 0xC5, 0x36, 0x25, 0xA4, 0x96, 0x09, 0x7F, 0x49, 0x49,
  0x49, 0xDB, 0x0B, 0xD2, 0x94, 0xEC, 0x13, 0xD3, 0x9C, 0xB8, 0x13, 0xD2,
  0x94, 0xFA, 0x10, 0x15, 0xE4, 0xB2, 0xD9, 0xE1, 0x04, 0x17, 0x44, 0x4C,
  0x25, 0x43, 0x1E, 0x22, 0xF4, 0x44, 0x60, 0xDC, 0xA5, 0x6D, 0x00, 0xCA,
  0x94, 0xC6, 0x00, 0xB7, 0x6B, 0x56, 0xC9, 0x80, 0x5C, 0xC2, 0x14, 0x98,
  0x66, 0x50, 0xA1, 0x83, 0x04, 0x38, 0x00, 0x79, 0x98, 0x8F, 0x00, 0x32,
  0x24, 0xC4, 0x44, 0x40, 0xFF, 0xC0, 0x62, 0x27, 0x24, 0x4C, 0x80, 0xF0,
};

const GFXglyph NotoSans_SemiBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 7, 7, 6, 0, -7 },
  { 12, 5, 9, 6, 0, -8 },
  { 18, 7, 7, 8, 1, -7 },
  { 25, 7, 7, 7, 0, -7 },
  { 32, 2, 2, 2, 1, -7 },
  { 33, 4, 9, 3, 0, -7 },
  { 38, 4, 9, 3, -1, -7 },
  { 43, 5, 5, 5, 1, -8 },
  { 47, 4, 5, 6, 1, -6 },
  { 50, 2, 2, 3, 0, -1 },
  { 51, 3, 1, 3, 0, -3 },
  { 52, 2, 1, 3, 0, -1 },
  { 53, 5, 7, 4, 0, -7 },
  { 58, 5, 7, 6, 0, -7 },
  { 63, 4, 7, 6, 1, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 0, -7 },
  { 77, 5, 7, 6, 0, -7 },
  { 82, 5, 7, 6, 0, -7 },
  { 87, 5, 7, 6, 1, -7 },
  { 92, 5, 7, 6, 1, -7 },
  { 97, 5, 7, 6, 0, -7 },
  { 102, 5, 7, 6, 0, -7 },
  { 107, 3, 6, 3, 0, -6 },
  { 110, 4, 7, 3, -1, -6 },
  { 114, 4, 5, 6, 1, -6 },
  { 117, 4, 3, 6, 1, -5 },
  { 119, 4, 5, 6, 1, -6 },
  { 122, 4, 7, 4, 1, -7 },
  { 126, 8, 8, 9, 0, -7 },
  { 134, 6, 7, 6, -1, -7 },
  { 140, 6, 7, 6, 0, -7 },
  { 146, 5, 7, 6, 1, -7 },
  { 151, 6, 7, 7, 0, -7 },
  { 157, 6, 7, 5, 0, -7 },
  { 163, 6, 7, 5, 0, -7 },
  { 169, 6, 7, 7, 1, -7 },
  { 175, 7, 7, 7, 0, -7 },
  { 182, 4, 7, 4, 0, -7 },
  { 186, 5, 9, 3, -2, -7 },
  { 192, 7, 7, 6, 0, -7 },
  { 199, 4, 7, 5, 0, -7 },
  { 203, 9, 7, 9, 0, -7 },
  { 211, 7, 7, 7, 0, -7 },
  { 218, 6, 7, 7, 1, -7 },
  { 224, 6, 7, 6, 0, -7 },
  { 230, 6, 9, 7, 1, -7 },
  { 237, 6, 7, 6, 0, -7 },
  { 243, 5, 7, 5, 0, -7 },
  { 248, 5, 7, 5, 1, -7 },
  { 253, 6, 7, 7, 1, -7 },
  { 259, 6, 7, 6, 1, -7 },
  { 265, 9, 7, 9, 1, -7 },
  { 273, 8, 7, 6, -1, -7 },
  { 280, 5, 7, 5, 1, -7 },
  { 285, 6, 7, 5, 0, -7 },
  { 291, 4, 9, 3, 0, -7 },
  { 296, 2, 7, 4, 1, -7 },
  { 298, 4, 9, 3, -1, -7 },
  { 303, 5, 4, 6, 0, -7 },
  { 306, 4, 1, 4, -1, 1 },
  { 307, 2, 2, 3, 1, -8 },
  { 308, 6, 6, 6, 0, -6 },
  { 313, 5, 8, 6, 0, -8 },
  { 318, 5, 6, 5, 0, -6 },
  { 322, 6, 8, 6, 0, -8 },
  { 328, 5, 6, 5, 0, -6 },
  { 332, 6, 10, 4, -1, -8 },
  { 340, 6, 8, 6, 0, -6 },
  { 346, 5, 8, 6, 0, -8 },
  { 351, 3, 8, 3, 0, -8 },
  { 354, 4, 10, 3, -1, -8 },
  { 359, 6, 8, 5, 0, -8 },
  { 365, 3, 8, 3, 0, -8 },
  { 368, 8, 6, 9, 0, -6 },
  { 374, 5, 6, 6, 0, -6 },
  { 378, 5, 6, 6, 0, -6 },
  { 382, 5, 8, 6, 0, -6 },
  { 387, 6, 8, 6, 0, -6 },
  { 393, 4, 6, 4, 0, -6 },
  { 396, 4, 6, 5, 0, -6 },
  { 399, 4, 7, 4, 0, -7 },
  { 403, 5, 5, 6, 1, -5 },
  { 407, 5, 5, 5, 0, -5 },
  { 411, 7, 5, 8, 1, -5 },
  { 416, 6, 5, 5, 0, -5 },
  { 420, 7, 7, 5, -1, -5 },
  { 427, 5, 5, 5, 0, -5 },
  { 431, 4, 9, 4, 0, -7 },
  { 436, 1, 10, 6, 2, -8 },
  { 438, 4, 9, 4, 0, -7 },
  { 443, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_SemiBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMIBOLDITALIC10PT7B_H_
