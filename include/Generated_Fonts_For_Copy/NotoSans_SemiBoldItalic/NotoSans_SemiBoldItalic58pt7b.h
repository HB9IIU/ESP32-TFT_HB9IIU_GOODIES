#ifndef _NOTOSANS_SEMIBOLDITALIC58PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x87, 0xF3, 0xF0, 0x7E,
  0x3F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F,
  0xF1, 0xE1, 0xC0, 0x7F, 0x1E, 0x02, 0x07, 0xF8, 0xF0, 0x00, 0x3F, 0x87,
  0x80, 0x01, 0xFC, 0x3C, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x7F, 0x9E, 0x00,
  0x01, 0xFE, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x7F,
  0x80, 0x00, 0xF1, 0xFC, 0x00, 0x07, 0x8F, 0xE0, 0x00, 0x38, 0x7F, 0x00,
  0x03, 0xC3, 0xF8, 0x00, 0x1E, 0x1F, 0xC4, 0x00, 0xF1, 0xFE, 0x3C, 0x07,
  0x9F, 0xF1, 0xFE, 0x3B, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0xF8, 0x00,
  0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xF0,
  0x07, 0xF3, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x81, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x0F,
  0xC3, 0xE0, 0x00, 0x3F, 0x07, 0xE1, 0xF8, 0xFF, 0x8F, 0xC1, 0xF8, 0xFC,
  0x7F, 0xF3, 0xF0, 0xFE, 0x7E, 0x3F, 0xFE, 0xFE, 0x7F, 0x1F, 0x1F, 0xFF,
  0xBF, 0xFF, 0x8F, 0xCF, 0xFF, 0xF7, 0xFF, 0xE7, 0xE7, 0xF0, 0xFC, 0xFF,
  0xF3, 0xF1, 0xF8, 0x3F, 0x3F, 0xF0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x3F,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x01, 0xFC, 0x1F, 0xFF, 0xC0, 0x1F, 0xE3, 0xFF, 0xFF, 0x00, 0xFE, 0x1F,
  0xF3, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0x87,
  0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x8F, 0xF0, 0x07, 0xFB, 0xF8, 0x7F, 0x80,
  0x3F, 0xFF, 0xC3, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xC0,
  0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x9F,
  0xF0, 0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC,
  0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x02, 0x00, 0x7C,
  0x00, 0x38, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7F, 0x87, 0x80, 0x07,
  0xFE, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x17, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFE,
  0x01, 0xFF, 0xC0, 0x20, 0x3F, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE,
  0x3E, 0x00, 0x1F, 0xE3, 0xF0, 0x03, 0xFC, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xF0, 0x1F, 0x80, 0x03, 0x01, 0xF8, 0x00, 0x20, 0x1F, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0x3F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x38, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFD,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x01,
  0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0x7F, 0x1F, 0xE3, 0xF8, 0x7E, 0x1F, 0xC1,
  0xC1, 0xFE, 0x0C, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x7E, 0x01, 0xFF,
  0x00, 0x78, 0x00, 0xFF, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xC0, 0x3C, 0x01, 0xFF, 0x00, 0x40,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x88,
  0x00, 0x03, 0xFC, 0x3C, 0x00, 0x3F, 0xF0, 0xFF, 0x9F, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7E,
  0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x30,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC1, 0x80, 0x00, 0xFF,
  0x83, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x40, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x3F, 0x8F, 0xFC, 0x01, 0xFC, 0xFF,
  0xF0, 0x1F, 0xCF, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFC, 0x3F, 0xE3, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x03, 0xF8, 0xFF,
  0x80, 0x1F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F,
  0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x7F,
  0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7,
  0xF8, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xDF, 0xC0, 0x7F, 0xF9, 0xFC,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x08, 0x01, 0xFF, 0x80, 0xFD,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x38, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0x81, 0xFE, 0x1C, 0x00, 0xFF, 0x10, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFF, 0xC0, 0x7E,
  0x1F, 0xC0, 0x1F, 0xFF, 0xC1, 0xF8, 0x7E, 0x01, 0xFF, 0xFF, 0x03, 0xE3,
  0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0x8F, 0xC0, 0x7F, 0xC7, 0xF0, 0x3E, 0x3E,
  0x03, 0xF8, 0x0F, 0x80, 0xFD, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF7, 0xE0,
  0x7E, 0x01, 0xF8, 0x0F, 0xDF, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0xFC, 0x0F,
  0xC0, 0x1F, 0x00, 0xFB, 0xF0, 0x3E, 0x00, 0xFC, 0x03, 0xEF, 0xC1, 0xF8,
  0x03, 0xF0, 0x1F, 0xBF, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0xF8, 0x1F, 0x80,
  0x7E, 0x01, 0xF3, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xCF, 0x81, 0xF0, 0x07,
  0xE0, 0x3F, 0x3E, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0xF8, 0x1F, 0x81, 0xFE,
  0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xF8, 0x7F, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE,
  0x01, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xFC, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xF8, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F,
  0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC,
  0x1F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC3, 0xFC, 0x07,
  0xFF, 0x00, 0x1C, 0x07, 0xFE, 0x00, 0x02, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x10, 0x07, 0xFE, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x0F,
  0xE0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0x80, 0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x04, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFE, 0x1F, 0xE0, 0x1F, 0xFC, 0x00, 0x3C, 0x07, 0xFE, 0x00,
  0x00, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0x3F, 0xC0,
  0x1F, 0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0xF8, 0xFE, 0x00, 0x7F, 0xFF, 0x1F,
  0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x01, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0x81, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x01, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0xFF,
  0x80, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0xC0,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x7F, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC,
  0x03, 0xFB, 0xE0, 0x00, 0xFD, 0xFC, 0x03, 0xF3, 0xE0, 0x00, 0xFD, 0xFC,
  0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xFC,
  0x07, 0xF3, 0xF0, 0x03, 0xF3, 0xF8, 0x07, 0xF3, 0xF0, 0x03, 0xF3, 0xF8,
  0x07, 0xF3, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xF0,
  0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xE0,
  0x3F, 0x81, 0xF9, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFB, 0xF8, 0x1F, 0xC0,
  0x3F, 0x81, 0xFB, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFF, 0xF0, 0x1F, 0xC0,
  0x3F, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x80, 0x3F, 0x80,
  0x7E, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xF8,
  0x00, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x0F,
  0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0x0F,
  0xE3, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x7F,
  0x01, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x07, 0xF1, 0xF8,
  0x03, 0xF0, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0xFF, 0xE0,
  0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x07,
  0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFF, 0x81, 0xFE, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x07,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0x00, 0xFF, 0x80,
  0x1C, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x0C, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xDF, 0x80, 0x3F, 0x83,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xF8,
  0x3F, 0x80, 0x7E, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0xFF,
  0x03, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF1, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x1F, 0x81,
  0xFC, 0x03, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x1F,
  0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x81,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F, 0x80, 0x07, 0xE7, 0xF0,
  0x1F, 0x9F, 0xC0, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E,
  0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF,
  0xC0, 0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x03, 0xFE, 0x7F,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x3F,
  0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x7E, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xF8, 0x3F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFF, 0x83, 0xF0, 0x1F, 0xFF, 0x1F, 0x80, 0xFF, 0xFE,
  0x7E, 0x07, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF,
  0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFF, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8,
  0x3F, 0x80, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x83, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xBF, 0x00, 0xFF,
  0xFC, 0xFC, 0x01, 0xFF, 0xC3, 0xF0, 0x03, 0xFE, 0x1F, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x8F, 0xFC, 0x00, 0x7F, 0x3F, 0xFC,
  0x01, 0xFD, 0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xC0,
  0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7E, 0xFF, 0xFF, 0x00, 0xFC, 0xFF, 0xFE, 0x01, 0xF0, 0xFF, 0xF0,
  0x07, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF0, 0x38, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x18, 0x1F, 0xFC, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0xF7, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x0F, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0x00, 0x1F, 0xFF, 0x9F, 0x80, 0x07, 0xFF,
  0x8F, 0xC0, 0x01, 0xFF, 0x07, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0x9F, 0xF0, 0xFF, 0x81, 0xFC, 0x7F, 0x80,
  0x7F, 0x1F, 0xE0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFE,
  0x00, 0xFF, 0x7F, 0x00, 0x7F, 0x9F, 0xC0, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0x07,
  0xFC, 0x07, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x38,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x10, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x7F, 0xFE, 0x7F, 0x00,
  0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F,
  0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F,
  0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xDF, 0xC0, 0x0F, 0xFF, 0x9F, 0xC0, 0x07,
  0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF1, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0x80,
  0xFE, 0x7F, 0xFE, 0x03, 0xFB, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF8, 0x3F, 0xC1, 0xFF, 0xC0, 0x7F, 0x07, 0xFE, 0x01, 0xFC, 0x1F, 0xF0,
  0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x01,
  0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0x0C, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x10, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x08, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xF0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF8,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x00,
  0x00, 0x08, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x01, 0xF0, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x03, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xFB, 0xFF, 0xFE,
  0x03, 0xFF, 0x87, 0xFB, 0xE1, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0xFF, 0xE0, 0x0F, 0xC3, 0xFF, 0xE0,
  0x1F, 0x9F, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0x80,
  0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0x80, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x0F,
  0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0,
  0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xE3,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0xCF, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x0F, 0xF0, 0x7F,
  0xE7, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x03, 0xF0, 0x00, 0x0F, 0x83, 0xFF, 0x00, 0x03, 0xE3, 0xFF,
  0xE0, 0x01, 0xF9, 0xFF, 0xFC, 0x00, 0x7E, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xEF, 0xFF, 0xF0, 0x03, 0xFB, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0xF8, 0x00,
  0x7F, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x20, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xC3, 0xF0,
  0x1F, 0xFF, 0x8F, 0x80, 0xFF, 0xFE, 0x7E, 0x07, 0xFF, 0xFD, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE,
  0x3F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xE0, 0xFF, 0x00,
  0xFF, 0x83, 0xFC, 0x0F, 0xFE, 0x0F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x7F, 0x00, 0xFF, 0xF9, 0xFC, 0x01, 0xFF, 0xC7, 0xF0,
  0x03, 0xFE, 0x3F, 0x80, 0x00, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x3F, 0xC0, 0x7E, 0x3F, 0xE0, 0x7F, 0x3F, 0xE0, 0x3F, 0x3F,
  0xF0, 0x1F, 0xBF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFD, 0xFE, 0x1F, 0xE0, 0x0E, 0x1F, 0xE0,
  0x02, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x80, 0x03, 0xF8, 0xC0, 0x07, 0xF8, 0xF8, 0x1F, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x8E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F,
  0xC3, 0xF8, 0x01, 0xFF, 0x0F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x3F, 0xFE, 0x07, 0xFF, 0xFB, 0xF8, 0x1F,
  0xFF, 0xCF, 0xC0, 0x3F, 0xFE, 0x3F, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0xFF,
  0x83, 0xF0, 0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x1F, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF7, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x7E, 0x00,
  0x7F, 0xC0, 0x1F, 0xE7, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFF,
  0xC0, 0x3F, 0xC7, 0xE0, 0x1F, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF7, 0xC0,
  0x7F, 0x87, 0xE0, 0x3F, 0x7C, 0x07, 0xF0, 0x7E, 0x03, 0xF7, 0xC0, 0x7F,
  0x07, 0xE0, 0x3E, 0x7C, 0x0F, 0xE0, 0x7E, 0x07, 0xE7, 0xC0, 0xFE, 0x07,
  0xE0, 0x7C, 0x7C, 0x1F, 0xC0, 0x7F, 0x0F, 0xC7, 0xC1, 0xFC, 0x07, 0xF0,
  0xFC, 0x7C, 0x3F, 0x80, 0x7F, 0x1F, 0x87, 0xC3, 0xF8, 0x07, 0xF1, 0xF8,
  0x7C, 0x7F, 0x80, 0x7F, 0x3F, 0x07, 0xC7, 0xF0, 0x07, 0xF3, 0xF0, 0x7C,
  0x7F, 0x00, 0x7F, 0x3E, 0x07, 0xCF, 0xE0, 0x07, 0xF7, 0xE0, 0x7C, 0xFE,
  0x00, 0x7E, 0x7E, 0x07, 0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x7D, 0xFC, 0x00,
  0x7E, 0xFC, 0x07, 0xDF, 0x80, 0x07, 0xEF, 0x80, 0x7D, 0xF8, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x11, 0xFF, 0xC0,
  0x01, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x80, 0x00,
  0x7F, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 17, 42, 16, 1, -41 },
  { 91, 20, 15, 25, 6, -41 },
  { 129, 37, 41, 37, 1, -41 },
  { 319, 29, 47, 32, 2, -44 },
  { 490, 42, 43, 48, 4, -42 },
  { 716, 37, 43, 40, 2, -42 },
  { 915, 9, 15, 14, 6, -41 },
  { 932, 21, 50, 19, 2, -41 },
  { 1064, 20, 51, 19, -4, -42 },
  { 1192, 28, 27, 32, 5, -44 },
  { 1287, 28, 29, 33, 3, -35 },
  { 1389, 13, 14, 16, -3, -7 },
  { 1412, 16, 7, 19, 1, -19 },
  { 1426, 9, 9, 16, 1, -8 },
  { 1437, 31, 42, 23, -3, -42 },
  { 1600, 29, 43, 32, 2, -42 },
  { 1756, 21, 41, 32, 6, -41 },
  { 1864, 32, 42, 32, -1, -42 },
  { 2032, 30, 43, 32, 1, -42 },
  { 2194, 31, 41, 32, 0, -41 },
  { 2353, 31, 42, 32, 1, -41 },
  { 2516, 29, 43, 32, 3, -42 },
  { 2672, 31, 41, 32, 3, -41 },
  { 2831, 30, 43, 32, 2, -42 },
  { 2993, 28, 43, 32, 3, -42 },
  { 3144, 14, 33, 16, 1, -32 },
  { 3202, 18, 39, 16, -3, -32 },
  { 3290, 28, 30, 33, 3, -36 },
  { 3395, 27, 17, 33, 4, -29 },
  { 3453, 28, 30, 33, 3, -36 },
  { 3558, 24, 43, 26, 4, -42 },
  { 3687, 46, 46, 49, 3, -41 },
  { 3952, 35, 41, 35, -3, -41 },
  { 4132, 33, 41, 36, 2, -41 },
  { 4302, 33, 43, 35, 4, -42 },
  { 4480, 35, 41, 39, 2, -41 },
  { 4660, 31, 41, 31, 2, -41 },
  { 4819, 31, 41, 30, 2, -41 },
  { 4978, 35, 43, 40, 4, -42 },
  { 5167, 38, 41, 40, 2, -41 },
  { 5362, 26, 41, 21, -2, -41 },
  { 5496, 27, 53, 18, -9, -41 },
  { 5675, 38, 41, 34, 2, -41 },
  { 5870, 23, 41, 29, 2, -41 },
  { 5988, 48, 41, 50, 2, -41 },
  { 6234, 41, 41, 43, 2, -41 },
  { 6445, 36, 43, 42, 4, -42 },
  { 6639, 33, 41, 34, 2, -41 },
  { 6809, 36, 52, 42, 4, -42 },
  { 7043, 32, 41, 35, 2, -41 },
  { 7207, 30, 43, 30, 1, -42 },
  { 7369, 30, 41, 30, 5, -41 },
  { 7523, 36, 42, 40, 4, -41 },
  { 7712, 34, 41, 33, 5, -41 },
  { 7887, 50, 41, 51, 6, -41 },
  { 8144, 41, 41, 34, -3, -41 },
  { 8355, 32, 41, 32, 5, -41 },
  { 8519, 35, 41, 31, -1, -41 },
  { 8699, 24, 50, 18, -1, -41 },
  { 8849, 13, 42, 23, 6, -42 },
  { 8918, 23, 50, 18, -4, -41 },
  { 9062, 30, 27, 32, 1, -42 },
  { 9164, 24, 4, 23, -5, 5 },
  { 9176, 12, 9, 18, 8, -44 },
  { 9190, 30, 33, 34, 3, -32 },
  { 9314, 31, 45, 34, 1, -44 },
  { 9489, 25, 33, 27, 3, -32 },
  { 9593, 33, 45, 34, 3, -44 },
  { 9779, 26, 33, 31, 3, -32 },
  { 9887, 33, 58, 20, -6, -44 },
  { 10127, 32, 46, 34, 1, -32 },
  { 10311, 30, 44, 35, 1, -44 },
  { 10476, 17, 44, 16, 1, -44 },
  { 10570, 25, 58, 16, -7, -44 },
  { 10752, 33, 44, 31, 1, -44 },
  { 10934, 17, 44, 16, 1, -44 },
  { 11028, 48, 32, 52, 1, -32 },
  { 11220, 31, 32, 35, 1, -32 },
  { 11344, 28, 33, 33, 3, -32 },
  { 11460, 34, 46, 34, -2, -32 },
  { 11656, 30, 46, 34, 3, -32 },
  { 11829, 25, 32, 24, 1, -32 },
  { 11929, 24, 33, 27, 1, -32 },
  { 12028, 20, 39, 22, 3, -38 },
  { 12126, 30, 32, 35, 3, -31 },
  { 12246, 29, 31, 29, 3, -31 },
  { 12359, 44, 31, 44, 3, -31 },
  { 12530, 35, 31, 30, -3, -31 },
  { 12666, 37, 45, 29, -5, -31 },
  { 12875, 28, 31, 27, -1, -31 },
  { 12984, 24, 50, 20, 0, -41 },
  { 13134, 5, 57, 32, 14, -44 },
  { 13170, 23, 50, 20, -3, -41 },
  { 13314, 28, 9, 33, 3, -25 },
};

const GFXfont NotoSans_SemiBoldItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMIBOLDITALIC58PT7B_H_
