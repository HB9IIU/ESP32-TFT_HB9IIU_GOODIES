#ifndef _NOTOSANS_SEMIBOLDITALIC57PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x38,
  0x00, 0x3F, 0x8F, 0xE7, 0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xE0,
  0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83,
  0xF3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0x80, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x78, 0xF8, 0x0F, 0xE3,
  0xC0, 0x80, 0xFE, 0x1E, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x3F, 0x87, 0x00,
  0x01, 0xFC, 0x78, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x7F, 0x9E, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xDF, 0xF0, 0x00, 0x1E, 0x7F, 0x80,
  0x00, 0xE1, 0xFC, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x78, 0x7F, 0x00, 0x03,
  0xC3, 0xF8, 0x80, 0x1E, 0x3F, 0x87, 0x00, 0xE3, 0xFC, 0x3F, 0x8F, 0x7F,
  0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xFF,
  0x80, 0x00, 0x7E, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0x03, 0xFF, 0xF8, 0x00,
  0x7E, 0x01, 0xFF, 0xFC, 0x00, 0x3E, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x00,
  0xFC, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x1F,
  0x80, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x87, 0xC1, 0xF8, 0x7E, 0x0F, 0xC7, 0xE3,
  0xFF, 0x3F, 0x0F, 0xC7, 0xE7, 0xFF, 0xDF, 0x8F, 0xE7, 0xE7, 0xFF, 0xEF,
  0xFF, 0xE3, 0xE3, 0xFF, 0xFB, 0xFF, 0xF3, 0xF3, 0xF8, 0xFD, 0xFF, 0xF3,
  0xF1, 0xF8, 0x7E, 0x7F, 0xF3, 0xF1, 0xF8, 0x3F, 0x1F, 0xE1, 0xF8, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x1F, 0xC0, 0x3F, 0x00,
  0x1F, 0xDF, 0xC0, 0x3F, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x03, 0xFF,
  0xE0, 0x1F, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x83, 0xFF, 0xF8, 0x03, 0xF8, 0x3F,
  0xFF, 0xE0, 0x1F, 0xC3, 0xFE, 0xFF, 0x01, 0xFC, 0x3F, 0xC3, 0xFC, 0x0F,
  0xE3, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xE1, 0xFE, 0x01,
  0xFE, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xFF, 0x03,
  0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xEF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xFE, 0x0F, 0xF0, 0x07, 0xFF,
  0xC0, 0x7F, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x9F, 0xCF,
  0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x08, 0x03, 0xF0, 0x01, 0xC0,
  0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xF1, 0xF0, 0x01, 0xFF, 0xBE, 0x00,
  0x7F, 0xFF, 0x87, 0xF1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xE0, 0x3F, 0xF8, 0x00,
  0x1F, 0xDF, 0x00, 0x07, 0xF3, 0xF0, 0x01, 0xFE, 0x3E, 0x00, 0x7F, 0x87,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x78, 0x1F, 0x80, 0x07, 0x01, 0xF8, 0x00,
  0x40, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x00, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x80,
  0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFB, 0xFC, 0x00,
  0x3F, 0xDF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFF,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00,
  0x3F, 0xCF, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0xCF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0x7F, 0x1F, 0xF3, 0xF8, 0x7E, 0x3F,
  0x83, 0xE1, 0xFC, 0x0C, 0x0F, 0xE0, 0x40, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x3E, 0x00, 0xFF,
  0x00, 0x30, 0x00, 0xFE, 0x00, 0x40, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0x1C, 0x00,
  0xFF, 0x00, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC4, 0x00, 0x03, 0xFE, 0x38,
  0x00, 0x3F, 0xE1, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0x80, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC3, 0x00, 0x01, 0xFF, 0x0F, 0x00,
  0x1F, 0xF8, 0x3F, 0xE7, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x3F, 0x9F, 0xFC, 0x03, 0xF9, 0xFF, 0xF8, 0x1F, 0xDF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F,
  0xE3, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xC0,
  0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7,
  0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x3F, 0xC0, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0xC0,
  0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB,
  0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x07, 0xFD, 0xFE, 0x00,
  0xFF, 0xBF, 0xE0, 0x3F, 0xF3, 0xFE, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0x9F, 0x80, 0x7F, 0xC7,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x82, 0x00, 0x7F, 0xE0, 0x7C, 0x7F, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03,
  0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x38,
  0x00, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7,
  0x80, 0x7F, 0x8C, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0x0F, 0xC0, 0x3F, 0xFF,
  0xE0, 0xF8, 0x7C, 0x03, 0xFF, 0xFE, 0x07, 0xC7, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0x3E, 0x03, 0xFC, 0x1F, 0x81, 0xFB, 0xF0, 0x3F, 0x80, 0xF8, 0x0F,
  0xDF, 0x81, 0xF8, 0x07, 0xC0, 0x7E, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xFF,
  0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0xFE, 0x0F, 0xC0, 0x1F, 0x00, 0xFB, 0xF0,
  0x7E, 0x00, 0xF8, 0x07, 0xDF, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0xF8, 0x1F,
  0x00, 0x7E, 0x03, 0xF7, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x3E, 0x07, 0xC0,
  0x3F, 0x01, 0xF9, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0xCF, 0x81, 0xF0, 0x1F,
  0xC0, 0xFC, 0x7C, 0x0F, 0xC1, 0xFE, 0x0F, 0xC3, 0xF0, 0x7F, 0x3F, 0xF9,
  0xFE, 0x1F, 0x83, 0xFF, 0xF7, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x3F, 0xFE,
  0x03, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x20, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x07,
  0xFF, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFE, 0x07, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF8, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xF8, 0x0F, 0xFE,
  0x00, 0x18, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x40, 0x1F, 0xFC, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFC, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xE0,
  0x00, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x0F, 0xFC, 0x0F,
  0xF0, 0x07, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xF0, 0x0F, 0xFC, 0x00, 0x0C, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0x00, 0x7F, 0xFF,
  0x3F, 0xC0, 0x1F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0xF3, 0xF8, 0x01, 0xFF,
  0xF8, 0xFE, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xF8, 0x1F, 0xF0, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0xC0,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0x3F, 0xBF, 0xE0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFC, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x01, 0xFD,
  0xF8, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xF3,
  0xF8, 0x07, 0xF3, 0xE0, 0x03, 0xF3, 0xF8, 0x07, 0xF3, 0xE0, 0x07, 0xE3,
  0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xE7, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0x87,
  0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F,
  0xE0, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0xFC, 0x1F,
  0xC0, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xF1, 0xF8, 0x1F,
  0xC0, 0x3F, 0x81, 0xF1, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFB, 0xF0, 0x1F,
  0x80, 0x3F, 0x81, 0xFB, 0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xFF, 0xE0, 0x3F,
  0x80, 0x3F, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFF, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x7F,
  0x00, 0x7E, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x00,
  0x7E, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x01,
  0xFF, 0xE0, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xF7, 0xF0,
  0x01, 0xFC, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0x03, 0xF3, 0xF8, 0x01, 0xFC,
  0x03, 0xF3, 0xF8, 0x01, 0xFC, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x07, 0xF1,
  0xFC, 0x03, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x3F, 0x87, 0xE0,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x1F, 0x80,
  0x1F, 0xCF, 0xE0, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x3F, 0x80, 0x0F, 0xEF,
  0xC0, 0x3F, 0x80, 0x0F, 0xEF, 0xC0, 0x3F, 0x00, 0x0F, 0xEF, 0xC0, 0x3F,
  0x00, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0xFF, 0x80,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x3F,
  0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x0F, 0xFE, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x01,
  0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x01, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0xFF,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF0,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0x80, 0x7F, 0x80, 0x04, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x86, 0x00, 0x07, 0xF8, 0x3C, 0x00, 0x7F,
  0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xDF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xF1, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFD, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xDF, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xC0, 0x7F,
  0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F, 0x00,
  0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x3E, 0x0F, 0xE0,
  0x07, 0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0x01, 0xFC, 0x7F, 0x03, 0xE1, 0xFC,
  0x00, 0x7F, 0x1F, 0x80, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x3F, 0x3F,
  0x80, 0x07, 0xF3, 0xF0, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x03,
  0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x08, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xE0,
  0x00, 0x3F, 0xC0, 0xF8, 0x07, 0xFF, 0x8F, 0xC0, 0x7F, 0xFC, 0x7E, 0x07,
  0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x7F, 0xF8, 0x7F, 0xC0,
  0xFF, 0xC3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F,
  0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F,
  0x80, 0x07, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFE, 0x1F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF,
  0xEF, 0xC0, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xE7, 0xE0, 0x0F, 0xFE, 0x3F,
  0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFF,
  0x80, 0x3F, 0x9F, 0xFF, 0x00, 0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0xC3, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF0,
  0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F,
  0xE0, 0x3F, 0xC1, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xBF,
  0xFF, 0xC0, 0x7E, 0x7F, 0xFE, 0x01, 0xF0, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0x7E, 0x1F,
  0xF0, 0x04, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x30, 0x7F, 0xE1, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0xE3,
  0xF8, 0x01, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x0F,
  0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F,
  0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF,
  0x80, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x7F, 0xFF, 0xBF, 0x00, 0x7F, 0xFF, 0xBF, 0x00, 0x3F, 0xFF, 0x3E,
  0x00, 0x1F, 0xFC, 0x7E, 0x00, 0x0F, 0xF8, 0x7E, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xF1, 0xFF, 0x01, 0xFC,
  0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF7, 0xF8, 0x03,
  0xF9, 0xFC, 0x01, 0xFE, 0x7F, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x0C, 0x1F, 0xF0,
  0x1F, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFE, 0x08, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x10, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x3E, 0x00, 0x7F, 0xF8, 0xFC, 0x01, 0xFF, 0xF9, 0xF8, 0x0F, 0xFF, 0xF7,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF0,
  0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE7,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0xFE, 0x00, 0xFF, 0xFB,
  0xF8, 0x00, 0xFF, 0xE7, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x18, 0x00, 0x3F, 0xC0,
  0x3E, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xFF, 0xC0, 0x3F, 0x9F, 0xFF,
  0x00, 0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF, 0xF0,
  0x7F, 0xF0, 0x3F, 0xC1, 0xFF, 0x80, 0x7F, 0x07, 0xFC, 0x01, 0xFC, 0x1F,
  0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE,
  0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x87, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x07,
  0xF0, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x00, 0x01, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xE1, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0x9F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF,
  0x7E, 0x7F, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0xC0,
  0xFF, 0x00, 0x3F, 0x0F, 0xFF, 0x00, 0xFC, 0x7F, 0xFE, 0x03, 0xF3, 0xFF,
  0xF8, 0x0F, 0xDF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0x07, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1,
  0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFD, 0xFF, 0x87, 0xFC, 0x0F, 0xF1, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x0F,
  0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xE7,
  0xF8, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0xF0, 0x00, 0x1F,
  0x0F, 0xFE, 0x00, 0x1F, 0x9F, 0xFF, 0x80, 0x0F, 0xDF, 0xFF, 0xC0, 0x07,
  0xEF, 0xFF, 0xF0, 0x03, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xC0,
  0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xF8, 0x07, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFE, 0xFF, 0xFC, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0x7F, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0x40, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0xF8, 0x07, 0xFF, 0x8F, 0xC0, 0x7F, 0xFE, 0x7E, 0x07,
  0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xF8, 0x7F, 0xC0,
  0xFF, 0xC3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F,
  0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F,
  0x80, 0x07, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFE, 0x1F,
  0xC0, 0x3F, 0xE0, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xEF, 0xE0, 0x0F, 0xFE, 0x7F,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x30, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x80,
  0xF8, 0x7F, 0x80, 0xFC, 0x7F, 0xC0, 0x7E, 0x7F, 0xE0, 0x3F, 0x7F, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x08, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xF0, 0x3C, 0x1F, 0xE0, 0x04, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x80, 0x07, 0xF8,
  0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x8E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF8, 0x3F, 0x80, 0x7F, 0xE0, 0xFF, 0x03, 0xFF, 0x83, 0xFE, 0x3F, 0xFC,
  0x07, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xCF, 0xC0, 0x7F, 0xFE, 0x3F, 0x00,
  0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x87,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x07, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0,
  0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x3F, 0x80,
  0x03, 0xF3, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0xE7, 0xE0, 0x0F,
  0xF8, 0x03, 0xF8, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x1F, 0x80, 0x7F, 0xE0,
  0x1F, 0xC3, 0xF0, 0x1F, 0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xEF, 0xC0, 0xFE,
  0x0F, 0xC0, 0xFD, 0xF8, 0x1F, 0xC1, 0xF8, 0x1F, 0xBF, 0x07, 0xF0, 0x3F,
  0x07, 0xE7, 0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0xFC, 0x3F, 0x80, 0xFC, 0x1F,
  0x1F, 0x87, 0xF0, 0x1F, 0x87, 0xE3, 0xF1, 0xFC, 0x03, 0xF0, 0xFC, 0x7E,
  0x3F, 0x80, 0x7E, 0x3F, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xE1, 0xF9, 0xFC,
  0x01, 0xF9, 0xF8, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x07, 0xEF, 0xE0, 0x07,
  0xE7, 0xC0, 0xFD, 0xFC, 0x00, 0xFD, 0xF8, 0x1F, 0xBF, 0x00, 0x1F, 0xBE,
  0x03, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x80,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFC,
  0xFF, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x21, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x41,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x13, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0xC0, 0x07, 0xFF, 0xC8,
  0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_SemiBoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 16, 42, 16, 1, -41 },
  { 85, 19, 15, 25, 6, -41 },
  { 121, 36, 41, 37, 1, -41 },
  { 306, 29, 46, 31, 2, -43 },
  { 473, 41, 42, 48, 4, -41 },
  { 689, 37, 42, 40, 2, -41 },
  { 884, 9, 15, 14, 6, -41 },
  { 901, 20, 50, 18, 2, -41 },
  { 1026, 20, 50, 18, -4, -41 },
  { 1151, 27, 28, 31, 5, -44 },
  { 1246, 28, 28, 33, 3, -34 },
  { 1344, 13, 14, 16, -3, -7 },
  { 1367, 16, 6, 18, 1, -18 },
  { 1379, 9, 9, 16, 1, -8 },
  { 1390, 30, 41, 23, -3, -41 },
  { 1544, 29, 42, 31, 2, -41 },
  { 1697, 21, 41, 31, 6, -41 },
  { 1805, 31, 41, 31, -1, -41 },
  { 1964, 29, 42, 31, 1, -41 },
  { 2117, 30, 41, 31, 0, -41 },
  { 2271, 30, 42, 31, 1, -41 },
  { 2429, 29, 42, 31, 3, -41 },
  { 2582, 30, 41, 31, 3, -41 },
  { 2736, 29, 42, 31, 2, -41 },
  { 2889, 27, 42, 31, 3, -41 },
  { 3031, 13, 33, 16, 1, -32 },
  { 3085, 17, 39, 16, -3, -32 },
  { 3168, 28, 29, 33, 3, -35 },
  { 3270, 27, 16, 33, 4, -28 },
  { 3324, 28, 29, 33, 3, -35 },
  { 3426, 23, 42, 26, 4, -41 },
  { 3547, 45, 46, 49, 3, -41 },
  { 3806, 34, 41, 34, -3, -41 },
  { 3981, 32, 41, 35, 2, -41 },
  { 4145, 33, 42, 34, 4, -41 },
  { 4319, 35, 41, 38, 2, -41 },
  { 4499, 30, 41, 30, 2, -41 },
  { 4653, 30, 41, 29, 2, -41 },
  { 4807, 34, 42, 39, 4, -41 },
  { 4986, 38, 41, 40, 2, -41 },
  { 5181, 25, 41, 21, -1, -41 },
  { 5310, 27, 53, 18, -9, -41 },
  { 5489, 37, 41, 34, 2, -41 },
  { 5679, 23, 41, 29, 2, -41 },
  { 5797, 48, 41, 49, 2, -41 },
  { 6043, 40, 41, 42, 2, -41 },
  { 6248, 36, 42, 41, 4, -41 },
  { 6437, 32, 41, 34, 2, -41 },
  { 6601, 36, 51, 41, 4, -41 },
  { 6831, 31, 41, 34, 2, -41 },
  { 6990, 29, 42, 30, 1, -41 },
  { 7143, 29, 41, 30, 5, -41 },
  { 7292, 36, 42, 39, 4, -41 },
  { 7481, 33, 41, 33, 5, -41 },
  { 7651, 50, 41, 50, 5, -41 },
  { 7908, 41, 41, 33, -3, -41 },
  { 8119, 31, 41, 31, 5, -41 },
  { 8278, 34, 41, 30, -1, -41 },
  { 8453, 23, 50, 18, -1, -41 },
  { 8597, 13, 41, 23, 6, -41 },
  { 8664, 23, 50, 18, -4, -41 },
  { 8808, 29, 26, 32, 1, -41 },
  { 8903, 23, 4, 23, -5, 5 },
  { 8915, 11, 9, 18, 8, -44 },
  { 8928, 29, 32, 33, 3, -31 },
  { 9044, 30, 44, 34, 1, -43 },
  { 9209, 24, 32, 27, 3, -31 },
  { 9305, 32, 44, 34, 3, -43 },
  { 9481, 26, 32, 31, 3, -31 },
  { 9585, 33, 58, 20, -6, -44 },
  { 9825, 31, 45, 34, 1, -31 },
  { 10000, 30, 43, 34, 1, -43 },
  { 10162, 16, 43, 16, 1, -43 },
  { 10248, 24, 57, 16, -7, -43 },
  { 10419, 32, 43, 31, 1, -43 },
  { 10591, 17, 43, 16, 1, -43 },
  { 10683, 47, 31, 51, 1, -31 },
  { 10866, 30, 32, 34, 1, -32 },
  { 10986, 27, 32, 33, 3, -31 },
  { 11094, 33, 45, 34, -2, -31 },
  { 11280, 29, 45, 34, 3, -31 },
  { 11444, 25, 31, 24, 1, -31 },
  { 11541, 24, 32, 26, 1, -31 },
  { 11637, 20, 39, 22, 3, -38 },
  { 11735, 30, 32, 34, 3, -31 },
  { 11855, 28, 31, 28, 3, -31 },
  { 11964, 43, 31, 43, 3, -31 },
  { 12131, 35, 31, 29, -3, -31 },
  { 12267, 35, 45, 28, -4, -31 },
  { 12464, 27, 31, 26, -1, -31 },
  { 12569, 23, 50, 20, 0, -41 },
  { 12713, 6, 56, 31, 13, -43 },
  { 12755, 23, 50, 20, -3, -41 },
  { 12899, 28, 8, 33, 3, -24 },
};

const GFXfont NotoSans_SemiBoldItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMIBOLDITALIC57PT7B_H_
