#ifndef _NOTOSANS_SEMIBOLDITALIC49PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x0C, 0x00, 0x3F, 0x1F, 0xBF, 0x0F, 0x9F, 0x87, 0xCF, 0xC7,
  0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0x78, 0x3C, 0x7C,
  0x1E, 0x3E, 0x1F, 0x1E, 0x0F, 0x8F, 0x07, 0x80, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x81, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xF9, 0xC3, 0x81, 0xF8, 0xE0, 0x01, 0xF8,
  0xF0, 0x00, 0xFC, 0x78, 0x00, 0x7E, 0x38, 0x00, 0x3F, 0x9C, 0x00, 0x0F,
  0xEE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x39, 0xFC, 0x00, 0x1C, 0x7E, 0x00, 0x0E, 0x3F, 0x00, 0x0F, 0x1F,
  0x90, 0x07, 0x0F, 0xCE, 0x03, 0x8F, 0xC7, 0xE1, 0xDF, 0xE3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xE0,
  0x01, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x03, 0xE0, 0x3F,
  0x1F, 0x00, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8,
  0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0,
  0x7C, 0x00, 0xFC, 0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0xF8, 0x00, 0xF8,
  0x1F, 0x1F, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x40, 0xF8, 0x3E, 0x3E, 0x3F,
  0x8F, 0x87, 0xE7, 0xCF, 0xFC, 0xFC, 0xFC, 0xF9, 0xFF, 0xE7, 0xFF, 0x8F,
  0xBF, 0xFF, 0x7F, 0xF9, 0xF3, 0xF3, 0xF3, 0xFF, 0x3E, 0x7E, 0x1F, 0x1F,
  0xC7, 0xC7, 0xC1, 0xF0, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x0F, 0x8F, 0xC1,
  0xF0, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0xF8, 0x3E, 0x01,
  0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x0F, 0x8F,
  0xC0, 0x7C, 0x00, 0xFF, 0xF8, 0x0F, 0x80, 0x07, 0xFF, 0x00, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xF8, 0x7F, 0xFC, 0x03,
  0xF1, 0xFF, 0xFC, 0x0F, 0xC7, 0xF1, 0xF8, 0x1F, 0x9F, 0xC3, 0xF8, 0x7E,
  0x7F, 0x03, 0xF9, 0xF8, 0xFC, 0x03, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0xC3,
  0xF0, 0x07, 0xFF, 0x07, 0xE0, 0x07, 0xFE, 0x0F, 0xC0, 0x0F, 0xF8, 0x1F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFE, 0x1F, 0xC0, 0x7F,
  0xF0, 0x3F, 0xC0, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x04, 0x03, 0xE0, 0x0E, 0x07, 0x80, 0x3F, 0x0F, 0x00, 0x7F, 0x9E, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0x83, 0x81, 0xFF, 0x80, 0x0F, 0xCF, 0x00, 0x3F,
  0x9E, 0x00, 0xFE, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xE0, 0x7C, 0x00, 0xC0,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xFB, 0xFF, 0x7C, 0x7F,
  0xBF, 0x1F, 0xCF, 0xC3, 0xC3, 0xF0, 0x40, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x38, 0x03, 0xF8,
  0x02, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1E, 0x01, 0xFC, 0x06, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x88, 0x00, 0x1F, 0xC7, 0x00, 0x3F, 0xE3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x00,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x3F,
  0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x60, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x80, 0x01, 0xFC, 0x3C, 0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x80,
  0x7E, 0xFF, 0xF0, 0x3E, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFD, 0xFF,
  0x0F, 0xF8, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x83, 0xF0, 0x0F, 0xE7, 0xF0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x07,
  0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F,
  0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F, 0x81, 0xFE, 0x3F,
  0xEF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0x7E, 0x0F, 0xFE, 0x7E, 0x07,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x80,
  0x3F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x18, 0x00, 0x00, 0x3C, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0x70, 0x1F, 0xC8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x0C, 0x00, 0xF8, 0x3E, 0x01, 0xFF, 0xF0, 0xF8, 0xF8,
  0x0F, 0xFF, 0xC1, 0xF1, 0xF0, 0x3F, 0xFF, 0x83, 0xE7, 0xC0, 0xFE, 0x3F,
  0x07, 0xCF, 0x83, 0xF0, 0x3E, 0x0F, 0xBE, 0x07, 0xC0, 0x78, 0x1F, 0x7C,
  0x1F, 0x01, 0xF0, 0x3E, 0xF8, 0x3E, 0x03, 0xE0, 0x7D, 0xE0, 0xF8, 0x07,
  0xC0, 0xFB, 0xC1, 0xF0, 0x0F, 0x01, 0xFF, 0x83, 0xE0, 0x3E, 0x07, 0xDF,
  0x07, 0xC0, 0x7C, 0x0F, 0xBE, 0x0F, 0x01, 0xF8, 0x1F, 0x7C, 0x1F, 0x03,
  0xE0, 0x7C, 0xF8, 0x3E, 0x0F, 0xC1, 0xF9, 0xF0, 0x7C, 0x3F, 0xC7, 0xE1,
  0xE0, 0xFF, 0xF7, 0xFF, 0x83, 0xE0, 0xFF, 0xCF, 0xFE, 0x07, 0xC0, 0xFF,
  0x0F, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x20, 0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x03,
  0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xF8,
  0x1F, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x3F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0xF0, 0x1F, 0xE0, 0x01, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x40, 0x1F, 0xF0, 0x0E, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xF8, 0x3F, 0xF8,
  0x0F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x3F,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0xFF,
  0x1F, 0xC0, 0x0F, 0xF0, 0xFC, 0x00, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x04, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x03, 0xC0, 0x7F, 0xC0, 0x01, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0xF3, 0xF8, 0x07, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0x3F, 0x80, 0x7F, 0xF8,
  0xFE, 0x01, 0xFF, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x80,
  0x7E, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xE7, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xF0,
  0x03, 0xF0, 0x1F, 0xE0, 0x03, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80,
  0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x0F, 0xDF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x01, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xDF, 0x00,
  0x1F, 0xFE, 0x03, 0xEF, 0x80, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x0F, 0xDF,
  0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0xFD, 0xF0, 0x07, 0xCF, 0xC0, 0x7E,
  0xF8, 0x03, 0xE7, 0xE0, 0x3F, 0x3C, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x1F, 0x8F, 0x81, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0xF8, 0xFC,
  0x07, 0xE3, 0xE0, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x7C, 0x3F, 0x01, 0xF0,
  0xF8, 0x7C, 0x3F, 0x01, 0xF8, 0x7C, 0x3E, 0x1F, 0x80, 0xFC, 0x3E, 0x3E,
  0x0F, 0xC0, 0x7E, 0x1F, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x9F, 0x03, 0xE0,
  0x1F, 0x07, 0xCF, 0x83, 0xF0, 0x1F, 0x81, 0xEF, 0x81, 0xF8, 0x0F, 0xC0,
  0xFF, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF8, 0x07, 0xE0, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x03,
  0xF0, 0x3F, 0xE0, 0x00, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0x03, 0xFE, 0x00,
  0x0F, 0xC0, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x1F, 0xFE,
  0x00, 0x7E, 0x07, 0xDF, 0x80, 0x1F, 0x81, 0xF7, 0xE0, 0x07, 0xC0, 0x7C,
  0xFC, 0x03, 0xF0, 0x3F, 0x3F, 0x00, 0xFC, 0x0F, 0xCF, 0xC0, 0x3F, 0x03,
  0xF1, 0xF8, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xE0, 0x3E, 0x1F, 0x81, 0xF8,
  0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x01, 0xF8, 0xFC, 0x0F, 0xC0, 0x7E,
  0x3F, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0xFC, 0x03, 0xF3, 0xF0, 0x3E, 0x00,
  0xFC, 0xF8, 0x0F, 0x80, 0x1F, 0xBE, 0x07, 0xE0, 0x07, 0xFF, 0x81, 0xF8,
  0x01, 0xFF, 0xE0, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x0F, 0xFC, 0x0F,
  0xC0, 0x03, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xE0,
  0x7F, 0x80, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0x7E, 0x01, 0xFE, 0x1F,
  0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xE0, 0x7F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xE0,
  0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0,
  0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xF0, 0x7E, 0x03,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0,
  0x70, 0x1F, 0xC0, 0x08, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x08, 0x00, 0x3F,
  0x87, 0x80, 0x7F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xFC,
  0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x1F, 0x80, 0x7C, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xFE,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xFE, 0x00,
  0x7E, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xF8, 0x03, 0xF0,
  0xFC, 0x03, 0xFF, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0xE0, 0x1F, 0x83, 0xF0,
  0x1F, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xEF, 0x80, 0xFC, 0x0F, 0xC0, 0x7D,
  0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xE7, 0xC0,
  0xFC, 0x07, 0xE0, 0xFC, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x1F, 0x07, 0xE0,
  0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x03, 0xF0, 0xF8, 0x3E, 0x3F, 0x00, 0x7E,
  0x3F, 0x07, 0xC7, 0xE0, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x01, 0xF9, 0xF8,
  0x1F, 0x3F, 0x00, 0x3F, 0x3E, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x7D,
  0xF8, 0x00, 0x7D, 0xF0, 0x0F, 0xBF, 0x00, 0x0F, 0xBE, 0x01, 0xF7, 0xC0,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x80,
  0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x81,
  0xF8, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x1F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFB, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x3C,
  0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x3F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x3F,
  0xE1, 0xF0, 0x3F, 0xFC, 0xF8, 0x1F, 0xFF, 0xBE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE,
  0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0,
  0xFE, 0x03, 0xFC, 0x1F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFB,
  0xE0, 0x3F, 0xFC, 0xF8, 0x07, 0xFE, 0x7C, 0x00, 0xFE, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xF8, 0x07, 0xEF, 0xFF, 0x01, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xF0, 0xFE, 0x0F, 0xF0, 0x1F, 0x83, 0xFC, 0x07, 0xE0, 0xFE, 0x01,
  0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xE3,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0xC7, 0xF8, 0x0F, 0xE1, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x07, 0xDF, 0xFF, 0x03, 0xE3, 0xFF, 0x80, 0xF8, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xC0, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x03,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xF8, 0xFC, 0x03, 0xFF, 0xDF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xEF, 0x80, 0x3F, 0xFC, 0xF8, 0x01, 0xFF, 0x8F, 0x00, 0x0F, 0xF1, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE1, 0xFC, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x3F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xFC, 0x07, 0xF3, 0xF0, 0xFF, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x0C, 0x1F, 0xF1, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x08, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x83, 0xE0, 0x0F, 0xF8, 0x7C, 0x07, 0xFF, 0x9F, 0x01, 0xFF, 0xFB,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xC0,
  0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFC, 0x03,
  0xFF, 0xBF, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x80,
  0x07, 0xE0, 0x1F, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x02, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x1F,
  0x8F, 0xF8, 0x07, 0xE7, 0xFF, 0x01, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xF0, 0xFE, 0x0F, 0xF8, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x01,
  0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0x87, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x70, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0x3F, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00,
  0x0F, 0x9F, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xC0, 0xF8, 0x01, 0xF8, 0x07, 0xC3,
  0xFE, 0x07, 0xFC, 0x07, 0xC7, 0xFF, 0x1F, 0xFE, 0x07, 0xCF, 0xFF, 0x3F,
  0xFF, 0x07, 0xDF, 0xFF, 0x3F, 0xFF, 0x07, 0xFC, 0x3F, 0xF8, 0x7F, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0xFE, 0x01,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0xFC, 0x01,
  0xF0, 0xFF, 0x80, 0x7C, 0x7F, 0xF0, 0x1F, 0x3F, 0xFE, 0x07, 0xDF, 0xFF,
  0x81, 0xFF, 0x8F, 0xE0, 0xFF, 0x81, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFC,
  0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x7E,
  0x00, 0x1F, 0x1F, 0xF8, 0x01, 0xF3, 0xFF, 0xC0, 0x1F, 0x7F, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0xC0,
  0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x81, 0xFF,
  0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x7F, 0xFC,
  0x03, 0xF3, 0xFF, 0x80, 0x3F, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0xE1, 0xF0, 0x3F, 0xFC, 0xF8,
  0x1F, 0xFF, 0xBE, 0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFC, 0x07,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F,
  0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0xC1,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xF8, 0x07,
  0xFE, 0x7C, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0xF8,
  0x3F, 0x1F, 0xC1, 0xF9, 0xFC, 0x0F, 0x9F, 0xE0, 0x7D, 0xFF, 0x03, 0xFF,
  0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0x01,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE3, 0x00, 0x3F, 0x8F, 0xC3, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xFF,
  0xF3, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFE, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE,
  0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x03,
  0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80,
  0xFF, 0x0F, 0xC0, 0x7F, 0x87, 0xE0, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFB, 0xE0, 0x7F, 0xF9, 0xF0, 0x3F, 0xF8, 0xF8, 0x07, 0xF0, 0x7C, 0x00,
  0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F,
  0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03,
  0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xC0,
  0xFC, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xDF, 0x80, 0x03,
  0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xBF, 0x00,
  0xFE, 0x01, 0xFD, 0xF8, 0x0F, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x80, 0x7E,
  0x7E, 0x07, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0xE0, 0x3F, 0x1F, 0x81, 0xEF,
  0x83, 0xF0, 0xFC, 0x1F, 0x7C, 0x1F, 0x87, 0xE0, 0xFB, 0xE1, 0xF8, 0x3F,
  0x0F, 0x9F, 0x0F, 0xC1, 0xF8, 0x7C, 0xF8, 0xFC, 0x0F, 0xC7, 0xC7, 0xC7,
  0xE0, 0x7E, 0x3E, 0x3E, 0x3F, 0x01, 0xF3, 0xE1, 0xF3, 0xF0, 0x0F, 0x9F,
  0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x7D, 0xF8, 0x03, 0xEF, 0x83, 0xEF, 0xC0,
  0x1F, 0x7C, 0x1F, 0x7C, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x03, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x04, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x03, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 36, 14, 1, -35 },
  { 64, 17, 13, 21, 5, -35 },
  { 92, 31, 35, 32, 1, -35 },
  { 228, 25, 40, 27, 1, -37 },
  { 353, 36, 35, 41, 3, -35 },
  { 511, 31, 36, 34, 2, -36 },
  { 651, 8, 13, 12, 5, -35 },
  { 664, 17, 43, 16, 2, -35 },
  { 756, 18, 43, 16, -4, -35 },
  { 853, 23, 23, 27, 5, -37 },
  { 920, 23, 24, 28, 3, -29 },
  { 989, 11, 12, 13, -2, -6 },
  { 1006, 13, 6, 16, 1, -16 },
  { 1016, 7, 8, 13, 1, -7 },
  { 1023, 25, 35, 20, -2, -35 },
  { 1133, 24, 36, 27, 2, -36 },
  { 1241, 18, 35, 27, 5, -35 },
  { 1320, 27, 35, 27, -1, -35 },
  { 1439, 25, 35, 27, 1, -35 },
  { 1549, 26, 35, 27, 0, -35 },
  { 1663, 26, 35, 27, 1, -35 },
  { 1777, 25, 36, 27, 2, -36 },
  { 1890, 26, 35, 27, 3, -35 },
  { 2004, 25, 36, 27, 2, -36 },
  { 2117, 24, 36, 27, 2, -36 },
  { 2225, 11, 28, 13, 1, -27 },
  { 2264, 15, 33, 13, -3, -27 },
  { 2326, 23, 25, 28, 3, -30 },
  { 2398, 23, 14, 28, 3, -24 },
  { 2439, 23, 25, 28, 3, -30 },
  { 2511, 19, 36, 22, 4, -35 },
  { 2597, 39, 39, 42, 2, -35 },
  { 2788, 30, 35, 30, -3, -35 },
  { 2920, 28, 35, 30, 2, -35 },
  { 3043, 29, 35, 30, 3, -35 },
  { 3170, 29, 35, 33, 2, -35 },
  { 3297, 26, 35, 26, 2, -35 },
  { 3411, 26, 35, 25, 2, -35 },
  { 3525, 30, 35, 34, 3, -35 },
  { 3657, 32, 35, 34, 2, -35 },
  { 3797, 21, 35, 18, -1, -35 },
  { 3889, 24, 45, 15, -8, -35 },
  { 4024, 32, 35, 29, 2, -35 },
  { 4164, 20, 35, 25, 2, -35 },
  { 4252, 41, 35, 42, 2, -35 },
  { 4432, 34, 35, 36, 2, -35 },
  { 4581, 31, 36, 36, 3, -36 },
  { 4721, 27, 35, 29, 2, -35 },
  { 4840, 31, 44, 36, 3, -36 },
  { 5011, 27, 35, 30, 2, -35 },
  { 5130, 25, 35, 26, 1, -35 },
  { 5240, 25, 35, 25, 4, -35 },
  { 5350, 30, 35, 34, 4, -35 },
  { 5482, 29, 35, 28, 4, -35 },
  { 5609, 43, 35, 43, 5, -35 },
  { 5798, 35, 35, 28, -3, -35 },
  { 5952, 27, 35, 27, 4, -35 },
  { 6071, 29, 35, 26, -1, -35 },
  { 6198, 20, 43, 15, -1, -35 },
  { 6306, 11, 35, 20, 5, -35 },
  { 6355, 19, 43, 15, -3, -35 },
  { 6458, 25, 22, 27, 1, -35 },
  { 6527, 20, 4, 20, -4, 4 },
  { 6537, 10, 8, 15, 7, -38 },
  { 6547, 26, 27, 29, 2, -27 },
  { 6635, 26, 37, 29, 1, -37 },
  { 6756, 22, 27, 23, 2, -27 },
  { 6831, 28, 37, 29, 2, -37 },
  { 6961, 23, 27, 26, 2, -27 },
  { 7039, 28, 49, 17, -5, -37 },
  { 7211, 27, 39, 29, 1, -27 },
  { 7343, 26, 37, 29, 1, -37 },
  { 7464, 14, 37, 14, 1, -37 },
  { 7529, 21, 49, 14, -6, -37 },
  { 7658, 28, 37, 26, 1, -37 },
  { 7788, 14, 37, 14, 1, -37 },
  { 7853, 40, 27, 44, 1, -27 },
  { 7988, 26, 27, 29, 1, -27 },
  { 8076, 24, 27, 28, 2, -27 },
  { 8157, 28, 39, 29, -1, -27 },
  { 8294, 26, 39, 29, 2, -27 },
  { 8421, 21, 27, 20, 1, -27 },
  { 8492, 22, 27, 22, 0, -27 },
  { 8567, 18, 32, 19, 2, -32 },
  { 8639, 25, 27, 29, 3, -27 },
  { 8724, 25, 27, 24, 2, -27 },
  { 8809, 37, 27, 37, 3, -27 },
  { 8934, 29, 27, 25, -2, -27 },
  { 9032, 31, 39, 24, -4, -27 },
  { 9184, 24, 27, 23, -1, -27 },
  { 9265, 20, 43, 17, 0, -35 },
  { 9373, 4, 48, 27, 12, -37 },
  { 9397, 19, 43, 17, -2, -35 },
  { 9500, 23, 7, 28, 3, -21 },
};

const GFXfont NotoSans_SemiBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMIBOLDITALIC49PT7B_H_
