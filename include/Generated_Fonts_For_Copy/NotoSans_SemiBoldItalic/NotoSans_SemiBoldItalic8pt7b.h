#ifndef _NOTOSANS_SEMIBOLDITALIC8PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xB8, 0x29, 0x9E, 0xAF, 0xB0, 0x27, 0x63, 0xB6, 0xCE,
  0xBB, 0x75, 0xCC, 0x32, 0x8C, 0xD9, 0xBC, 0xC0, 0x29, 0x49, 0x30, 0x24,
  0x92, 0x70, 0x4F, 0xC2, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x12, 0x24, 0x88,
  0x35, 0x59, 0x96, 0x3D, 0x24, 0x80, 0x35, 0x12, 0x4F, 0x71, 0x17, 0x1E,
  0x13, 0x59, 0xF2, 0x74, 0x61, 0x1E, 0x34, 0x6D, 0x96, 0x78, 0x84, 0x44,
  0x60, 0x35, 0x57, 0x97, 0x35, 0x57, 0x1E, 0x42, 0x42, 0x80, 0x16, 0xE1,
  0xFF, 0xC2, 0x3C, 0xC5, 0x41, 0x00, 0x18, 0xC9, 0xED, 0x5B, 0xC8, 0x0E,
  0x00, 0x33, 0x55, 0xB9, 0x72, 0x56, 0xE5, 0x78, 0x78, 0x88, 0x8E, 0x72,
  0x52, 0x95, 0xF8, 0x7A, 0x10, 0xE4, 0x78, 0x7A, 0x10, 0xE4, 0x40, 0x7C,
  0x8B, 0x9F, 0x45, 0x24, 0x9E, 0x4A, 0x40, 0x69, 0x25, 0x80, 0x32, 0x22,
  0x24, 0x48, 0x4A, 0x98, 0xC5, 0x48, 0x44, 0x44, 0x4F, 0x66, 0xCD, 0xAB,
  0x67, 0x56, 0x80, 0x65, 0x96, 0x56, 0x5A, 0x60, 0x74, 0xA3, 0x29, 0x70,
  0x72, 0x52, 0xE4, 0x40, 0x74, 0xA3, 0x29, 0x70, 0xC0, 0x72, 0x56, 0xC5,
  0x48, 0x34, 0x42, 0x1E, 0xF4, 0x44, 0x88, 0x9C, 0xA5, 0x29, 0x70, 0x99,
  0xAA, 0xCC, 0x93, 0x6A, 0xD6, 0xCD, 0x92, 0x00, 0x4A, 0x8C, 0xC5, 0x48,
  0x9A, 0xA4, 0x48, 0x78, 0x88, 0xC4, 0x78, 0x69, 0x29, 0x30, 0xAA, 0x90,
  0x32, 0x22, 0x22, 0xC0, 0x26, 0x59, 0xF0, 0xC0, 0x7E, 0xA4, 0xE0, 0x44,
  0x75, 0xDF, 0x7C, 0x86, 0x08, 0x5D, 0xA9, 0x38, 0x7F, 0x86, 0x19, 0x1C,
  0x42, 0x21, 0x18, 0x7E, 0xA4, 0xE2, 0x70, 0x44, 0x75, 0x99, 0x45, 0xE0,
  0x20, 0x92, 0x96, 0x42, 0x54, 0xCE, 0x48, 0x55, 0xA0, 0x7E, 0xA6, 0x54,
  0xA0, 0x75, 0x99, 0x7D, 0x96, 0x75, 0xDF, 0x88, 0x7E, 0xA4, 0xE1, 0x10,
  0x74, 0x88, 0x74, 0x2E, 0x5D, 0x2C, 0x5A, 0xA4, 0xE0, 0x96, 0x64, 0x96,
  0xD5, 0x96, 0x56, 0x6B, 0x49, 0x8C, 0x42, 0x60, 0x72, 0x4E, 0x29, 0x64,
  0x90, 0xFF, 0x49, 0x34, 0xA0, 0xF0,
};

const GFXglyph NotoSans_SemiBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 5, 6, 7, 1, -6 },
  { 15, 5, 6, 6, 0, -6 },
  { 19, 1, 2, 2, 1, -6 },
  { 20, 3, 7, 3, 0, -6 },
  { 23, 3, 7, 3, -1, -6 },
  { 26, 4, 4, 4, 1, -6 },
  { 28, 4, 4, 5, 0, -5 },
  { 30, 1, 2, 2, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 4, 6, 3, 0, -6 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 3, 6, 4, 1, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 5, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 4, 6, 4, 0, -6 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 2, 5, 2, 0, -4 },
  { 70, 4, 4, 5, 0, -5 },
  { 72, 4, 2, 5, 0, -4 },
  { 73, 4, 4, 5, 0, -5 },
  { 75, 3, 6, 4, 1, -6 },
  { 78, 7, 7, 7, 0, -6 },
  { 85, 4, 6, 5, 0, -6 },
  { 88, 5, 6, 5, 0, -6 },
  { 92, 4, 6, 5, 1, -6 },
  { 95, 5, 6, 5, 0, -6 },
  { 99, 5, 6, 4, 0, -6 },
  { 103, 5, 6, 4, 0, -6 },
  { 107, 4, 6, 5, 1, -6 },
  { 110, 6, 6, 6, 0, -6 },
  { 115, 3, 6, 3, 0, -6 },
  { 118, 4, 8, 2, -1, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 4, 6, 4, 0, -6 },
  { 129, 7, 6, 7, 0, -6 },
  { 135, 6, 6, 6, 0, -6 },
  { 140, 5, 6, 6, 1, -6 },
  { 144, 5, 6, 5, 0, -6 },
  { 148, 5, 7, 6, 1, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 4, 6, 4, 1, -6 },
  { 163, 5, 6, 5, 1, -6 },
  { 167, 4, 6, 5, 1, -6 },
  { 170, 7, 6, 7, 1, -6 },
  { 176, 5, 6, 5, 0, -6 },
  { 180, 4, 6, 4, 1, -6 },
  { 183, 5, 6, 4, 0, -6 },
  { 187, 3, 7, 3, 0, -6 },
  { 190, 2, 6, 3, 1, -6 },
  { 192, 4, 7, 3, -1, -6 },
  { 196, 4, 4, 4, 0, -6 },
  { 198, 4, 1, 3, -1, 0 },
  { 199, 2, 1, 2, 1, -6 },
  { 200, 5, 4, 5, 0, -4 },
  { 203, 4, 6, 5, 0, -6 },
  { 206, 4, 4, 4, 0, -4 },
  { 208, 5, 6, 5, 0, -6 },
  { 212, 4, 4, 4, 0, -4 },
  { 214, 5, 8, 3, -1, -6 },
  { 219, 5, 6, 5, 0, -4 },
  { 223, 4, 6, 5, 0, -6 },
  { 226, 2, 6, 2, 0, -6 },
  { 228, 3, 8, 2, -1, -6 },
  { 231, 5, 6, 4, 0, -6 },
  { 235, 2, 6, 2, 0, -6 },
  { 237, 7, 4, 7, 0, -4 },
  { 241, 4, 4, 5, 0, -4 },
  { 243, 4, 4, 5, 0, -4 },
  { 245, 4, 6, 5, 0, -4 },
  { 248, 5, 6, 5, 0, -4 },
  { 252, 4, 4, 3, 0, -4 },
  { 254, 4, 4, 4, 0, -4 },
  { 256, 3, 5, 3, 0, -5 },
  { 258, 5, 4, 5, 0, -4 },
  { 261, 4, 4, 4, 0, -4 },
  { 263, 6, 4, 6, 0, -4 },
  { 266, 4, 4, 4, 0, -4 },
  { 268, 5, 6, 4, -1, -4 },
  { 272, 4, 4, 4, 0, -4 },
  { 274, 3, 7, 3, 0, -6 },
  { 277, 1, 8, 4, 2, -6 },
  { 278, 3, 7, 3, 0, -6 },
  { 281, 4, 1, 5, 0, -3 },
};

const GFXfont NotoSans_SemiBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMIBOLDITALIC8PT7B_H_
