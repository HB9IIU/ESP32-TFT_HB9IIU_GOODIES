#ifndef _NOTOSANS_SEMIBOLDITALIC6PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x5E, 0xFA, 0x2D, 0x3C, 0xF6, 0x8A, 0xA0, 0x66, 0xBF,
  0x80, 0x6A, 0x80, 0x56, 0x80, 0x6C, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x2A,
  0x40, 0x76, 0xF0, 0xDA, 0x65, 0x70, 0x6C, 0xF0, 0x2F, 0x90, 0x68, 0xF0,
  0x7E, 0xF0, 0x65, 0x60, 0x6E, 0xF0, 0x75, 0xE0, 0xC8, 0xCA, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0xE9, 0x40, 0x7D, 0xF7, 0x47, 0x00, 0x2F, 0xD0, 0x76,
  0xAE, 0x78, 0x86, 0x75, 0x9E, 0x6E, 0x70, 0x6E, 0x40, 0x7A, 0x96, 0x57,
  0x9A, 0x69, 0x60, 0x25, 0x2C, 0x76, 0xAA, 0x4A, 0x70, 0x4A, 0xEB, 0x50,
  0x57, 0xB9, 0x79, 0x96, 0x77, 0x88, 0x79, 0x96, 0x30, 0x76, 0xAA, 0x68,
  0xF0, 0xF2, 0x40, 0x55, 0x96, 0xBB, 0x40, 0xEF, 0xAD, 0x40, 0x76, 0x6A,
  0xFA, 0x40, 0x69, 0x70, 0x6A, 0x80, 0xF0, 0x56, 0x80, 0x54, 0xE0, 0x80,
  0x77, 0x80, 0x49, 0xDE, 0x73, 0x00, 0x11, 0x6A, 0xE0, 0x7B, 0x80, 0x12,
  0x64, 0x4C, 0x77, 0xF0, 0x49, 0xDA, 0x46, 0x80, 0x20, 0xA5, 0x80, 0x49,
  0xEA, 0x56, 0x80, 0x7D, 0x6A, 0x76, 0x80, 0x77, 0x80, 0x77, 0xC0, 0x77,
  0x90, 0x72, 0x00, 0xEB, 0x00, 0x7B, 0xF7, 0x80, 0xB9, 0x00, 0xAF, 0xBC,
  0xEA, 0x80, 0xB9, 0x40, 0x6B, 0x00, 0x5A, 0x80, 0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiBoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 1, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 2, 3, 3, 1, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 2, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 2, 0, -1 },
  { 23, 3, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 1, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 2, 3, 2, 0, -3 },
  { 45, 2, 4, 2, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 3, 4, 3, 0, -4 },
  { 53, 5, 5, 5, 0, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 4, 4, 4, 0, -4 },
  { 61, 4, 4, 4, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 4, 4, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 3, 4, 2, 0, -4 },
  { 75, 3, 5, 2, -1, -4 },
  { 77, 4, 4, 4, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 5, 4, 5, 0, -4 },
  { 84, 4, 4, 4, 0, -4 },
  { 86, 4, 4, 4, 0, -4 },
  { 88, 4, 4, 4, 0, -4 },
  { 90, 4, 5, 4, 0, -4 },
  { 93, 4, 4, 4, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 1, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 3, 4, 3, 1, -4 },
  { 103, 5, 4, 5, 1, -4 },
  { 106, 4, 4, 3, 0, -4 },
  { 108, 3, 4, 3, 1, -4 },
  { 110, 3, 4, 3, 0, -4 },
  { 112, 2, 5, 2, 0, -4 },
  { 114, 1, 4, 2, 1, -4 },
  { 115, 2, 5, 2, 0, -4 },
  { 117, 3, 2, 3, 0, -4 },
  { 118, 3, 1, 2, -1, 0 },
  { 119, 1, 1, 2, 1, -5 },
  { 120, 3, 3, 4, 0, -3 },
  { 122, 3, 5, 4, 0, -5 },
  { 124, 3, 3, 3, 0, -3 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 3, 3, 3, 0, -3 },
  { 131, 4, 6, 2, -1, -5 },
  { 134, 3, 4, 4, 0, -3 },
  { 136, 3, 5, 4, 0, -5 },
  { 138, 2, 5, 2, 0, -5 },
  { 140, 3, 6, 2, -1, -5 },
  { 143, 3, 5, 3, 0, -5 },
  { 145, 2, 5, 2, 0, -5 },
  { 147, 5, 3, 5, 0, -3 },
  { 149, 3, 3, 4, 0, -3 },
  { 151, 3, 3, 3, 0, -3 },
  { 153, 3, 4, 4, 0, -3 },
  { 155, 3, 4, 4, 0, -3 },
  { 157, 3, 3, 2, 0, -3 },
  { 159, 3, 3, 3, 0, -3 },
  { 161, 2, 4, 2, 0, -4 },
  { 162, 3, 3, 4, 0, -3 },
  { 164, 3, 3, 3, 0, -3 },
  { 166, 5, 3, 5, 0, -3 },
  { 168, 3, 3, 3, 0, -3 },
  { 170, 3, 4, 3, 0, -3 },
  { 172, 3, 3, 3, 0, -3 },
  { 174, 2, 5, 2, 0, -4 },
  { 176, 1, 6, 3, 1, -5 },
  { 177, 2, 5, 2, 0, -4 },
  { 179, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiBoldItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMIBOLDITALIC6PT7B_H_
