#ifndef _NOTOSANS_SEMIBOLDITALIC72PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x8F, 0xF0, 0x7F,
  0xCF, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07,
  0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF8,
  0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xDF, 0xF0, 0x07, 0xFE, 0x3E, 0x0F, 0x00,
  0x7F, 0xE1, 0xF0, 0x08, 0x03, 0xFE, 0x0F, 0x00, 0x00, 0x1F, 0xF0, 0xF8,
  0x00, 0x00, 0xFF, 0x87, 0xC0, 0x00, 0x07, 0xF8, 0x3E, 0x00, 0x00, 0x3F,
  0xE1, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0xF8, 0x00,
  0x00, 0x7F, 0xF7, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0xFF, 0xE0, 0x00, 0x01, 0xE3, 0xFF,
  0x00, 0x00, 0x1F, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0x07,
  0xC3, 0xFE, 0x00, 0x00, 0x3C, 0x1F, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0x84,
  0x00, 0x1F, 0x07, 0xFC, 0x38, 0x00, 0xF8, 0x7F, 0xC1, 0xF8, 0x07, 0xC7,
  0xFE, 0x0F, 0xFE, 0x3D, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC,
  0x1F, 0xC0, 0x38, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x3F, 0xF0, 0xFE, 0x03,
  0xF8, 0x7F, 0x0F, 0xFF, 0x8F, 0xE0, 0x7F, 0x8F, 0xF1, 0xFF, 0xFC, 0xFF,
  0x0F, 0xF0, 0xFE, 0x3F, 0xFF, 0xEF, 0xF1, 0xFF, 0x1F, 0xC7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE3, 0xF8, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0x7F, 0x8F, 0xF0,
  0xFF, 0x7F, 0xFF, 0x87, 0xF1, 0xFE, 0x07, 0xF3, 0xFF, 0xF0, 0xFE, 0x1F,
  0xE0, 0x7F, 0x1F, 0xFE, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC,
  0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xC1, 0xFF,
  0xEF, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xF7, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x3F,
  0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x80, 0x07, 0xF0, 0x00, 0x38, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x07, 0xF8, 0x1F, 0x80, 0x01, 0xFF, 0x87, 0xE0, 0x00, 0xFF, 0xF9, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0x80,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xC0, 0x00, 0x1F, 0xF3, 0xF0, 0x00,
  0x0F, 0xF8, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0x80, 0x03, 0xFF, 0x07, 0xF0,
  0x00, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xF0, 0x0F,
  0xE0, 0x00, 0x38, 0x03, 0xFC, 0x00, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1F,
  0x87, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF7,
  0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xDF, 0xF3, 0xFF, 0xE7, 0xF8, 0x7F, 0xF3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x83, 0xF8, 0x3F, 0xE0, 0x78, 0x0F, 0xF8, 0x1C, 0x07, 0xFC, 0x04, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x60, 0x00, 0x1F, 0xF0,
  0x00, 0x40, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFE, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x01, 0xE0, 0x00,
  0xFF, 0xC0, 0x04, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x00, 0xFF, 0xE1, 0xE0, 0x00,
  0x0F, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x78, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x04, 0x00, 0x00,
  0x3F, 0xF8, 0x38, 0x00, 0x07, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFD, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x1E, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0xE0, 0x03,
  0xFE, 0x7F, 0xFF, 0x80, 0x3F, 0xCF, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xCF, 0xF8, 0x00,
  0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF,
  0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xBF,
  0xE0, 0x0F, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x01, 0x40,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x0E, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF, 0x3F, 0x00, 0x3F, 0xF1,
  0xC0, 0x01, 0xFF, 0x10, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x06, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x87,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xC7, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE3, 0xF8, 0x03, 0xFF, 0x07, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xFE,
  0x01, 0xFC, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xBF, 0x80, 0xFF, 0x00,
  0x1F, 0xC0, 0x1F, 0xDF, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xEF, 0xE0,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF7, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x07,
  0xF3, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xF9, 0xF8, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFD, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0xFE, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x80, 0x7F,
  0xC0, 0x7F, 0x87, 0xF0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0x83, 0xF8, 0x0F,
  0xF0, 0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0xC0,
  0xFE, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0xFF, 0xF8, 0x00, 0x0E, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x80, 0x00, 0xE0, 0x03, 0xFF,
  0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0x00,
  0x00, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x04, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x9F, 0xF8,
  0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xC0, 0x01,
  0xFF, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x1F,
  0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x30, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xEF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF3, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xF7, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFF, 0x1F, 0xC0,
  0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xFC, 0x00,
  0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x1F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F,
  0xE0, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xF0,
  0x01, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xC3,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0xE0, 0x03,
  0xFC, 0x07, 0xF1, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0,
  0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x0F, 0xF7, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xC0, 0x03, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF7, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF3, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80,
  0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xCF, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xDF,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x00,
  0x7F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x8F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x0F,
  0xFE, 0x00, 0x06, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x04, 0x00, 0x00, 0x3F, 0xF0, 0x30, 0x00, 0x01, 0xFF, 0x81,
  0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xBF, 0xE0,
  0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F,
  0xFC, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xF8,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xF3,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xE0, 0x07,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x07, 0xF0,
  0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0x81,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x8F,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFE,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xE0,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x01,
  0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0,
  0xFE, 0x00, 0x7F, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xFF, 0xDF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xFE, 0x7F, 0x80, 0x1F, 0xFF, 0xF9,
  0xFC, 0x00, 0x7F, 0xFF, 0x87, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xC0, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0x00, 0x00,
  0xFF, 0x87, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xCF, 0xFF,
  0xF0, 0x03, 0xFE, 0xFF, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xFE, 0x00, 0xFF,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xDF, 0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF,
  0xFF, 0x00, 0x7F, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0x38, 0x07, 0xFF, 0x00, 0x08, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xC0,
  0x7F, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC3, 0xFE, 0x00, 0x0F, 0xFF, 0xF1,
  0xFE, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFF,
  0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFF, 0x1F,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x40, 0x7F, 0xF0, 0x00, 0xF0, 0x0F, 0xFF, 0x83, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x0C,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xC3, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xFF, 0xF9,
  0xFE, 0x00, 0x3F, 0xFF, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xFD, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xF9, 0xFF, 0x00, 0x03, 0xFF,
  0xE1, 0xFF, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x0C, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0x00, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xFE, 0x00, 0x7F, 0xC7, 0xFF,
  0xF8, 0x03, 0xFE, 0xFF, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xFF, 0x00, 0xFF,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xE0,
  0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x41, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0xFF,
  0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03,
  0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x1F, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x03, 0xF9, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0,
  0x1F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0xFE, 0x00, 0x3F, 0xC7, 0xFF, 0xFC, 0x00, 0xFF,
  0x3F, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xFF, 0xE0, 0x0F, 0xE7, 0xFF, 0xFF,
  0x80, 0x7F, 0xBF, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x01, 0xFF,
  0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0,
  0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x7F,
  0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0x7F,
  0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x07, 0xFE,
  0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0B, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xF0, 0x00,
  0x03, 0xF8, 0x7F, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0xFF, 0x80, 0x01, 0xFC,
  0x7F, 0xFF, 0xE0, 0x00, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x9F, 0xFF, 0xF8, 0x00, 0x7F,
  0xCF, 0xFF, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xF0,
  0xFE, 0x00, 0x7F, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xFF, 0xDF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF3,
  0xFC, 0x00, 0x3F, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xFC, 0x7F, 0xC0, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x78, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0xFF,
  0xC0, 0x7F, 0x8F, 0xFF, 0x01, 0xFE, 0x7F, 0xF8, 0x07, 0xF9, 0xFF, 0xE0,
  0x1F, 0xEF, 0xFF, 0x80, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x81, 0xFC, 0x0F, 0xFC, 0x00, 0x70, 0x1F, 0xF0, 0x00, 0x20, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x40, 0x00, 0x3F, 0xF0, 0xF0,
  0x00, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x20, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xC0, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFD, 0xFC, 0x03, 0xFF,
  0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xC7, 0xF8,
  0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0xF8,
  0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0x80,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC3,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x01,
  0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xBF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xC7, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x07, 0xF8,
  0x07, 0xF7, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x7F, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x1F,
  0xC0, 0xFF, 0x80, 0x7F, 0x81, 0xFC, 0x7F, 0x03, 0xFE, 0x01, 0xFE, 0x0F,
  0xF1, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0xC0, 0x1F,
  0xE1, 0xFE, 0x1F, 0xC3, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF8,
  0x01, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFE, 0x07, 0xF1,
  0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xC0,
  0x7F, 0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xFB,
  0xF8, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x0F, 0xDF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x3F, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFD, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xDF, 0xF0, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x81, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x23, 0xFF, 0xF0, 0x00, 0x0C, 0xFF,
  0xFF, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x98, 0x00, 0x07, 0xFF, 0xE2, 0x00, 0x00,
  0x1F, 0xF0, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 21, 52, 20, 1, -51 },
  { 138, 25, 18, 31, 7, -51 },
  { 195, 45, 51, 47, 2, -51 },
  { 482, 37, 59, 40, 2, -55 },
  { 755, 52, 53, 60, 5, -52 },
  { 1100, 47, 53, 50, 2, -52 },
  { 1412, 12, 18, 17, 7, -51 },
  { 1439, 25, 62, 23, 3, -51 },
  { 1633, 25, 63, 23, -5, -52 },
  { 1830, 34, 34, 39, 7, -55 },
  { 1975, 35, 35, 41, 4, -43 },
  { 2129, 16, 17, 20, -3, -8 },
  { 2163, 20, 8, 23, 1, -23 },
  { 2183, 11, 11, 20, 1, -10 },
  { 2199, 37, 52, 29, -3, -52 },
  { 2440, 36, 53, 40, 3, -52 },
  { 2679, 26, 51, 40, 8, -51 },
  { 2845, 39, 52, 40, -1, -52 },
  { 3099, 37, 53, 40, 1, -52 },
  { 3345, 38, 51, 40, 0, -51 },
  { 3588, 37, 52, 40, 2, -51 },
  { 3829, 36, 53, 40, 4, -52 },
  { 4068, 38, 51, 40, 4, -51 },
  { 4311, 37, 53, 40, 2, -52 },
  { 4557, 35, 53, 40, 3, -52 },
  { 4789, 17, 41, 20, 1, -40 },
  { 4877, 22, 49, 20, -4, -40 },
  { 5012, 35, 37, 41, 4, -45 },
  { 5174, 35, 21, 41, 4, -36 },
  { 5266, 35, 37, 41, 4, -45 },
  { 5428, 28, 53, 32, 6, -52 },
  { 5614, 57, 58, 61, 3, -51 },
  { 6028, 43, 51, 43, -4, -51 },
  { 6303, 41, 51, 44, 2, -51 },
  { 6565, 41, 53, 43, 5, -52 },
  { 6837, 44, 51, 48, 2, -51 },
  { 7118, 39, 51, 38, 2, -51 },
  { 7367, 39, 51, 37, 2, -51 },
  { 7616, 43, 53, 49, 5, -52 },
  { 7901, 48, 51, 50, 2, -51 },
  { 8207, 32, 51, 26, -2, -51 },
  { 8411, 34, 66, 22, -11, -51 },
  { 8692, 47, 51, 43, 2, -51 },
  { 8992, 30, 51, 36, 2, -51 },
  { 9184, 61, 51, 62, 2, -51 },
  { 9573, 52, 51, 53, 2, -51 },
  { 9905, 45, 53, 52, 5, -52 },
  { 10204, 41, 51, 43, 2, -51 },
  { 10466, 45, 64, 52, 5, -52 },
  { 10826, 40, 51, 43, 2, -51 },
  { 11081, 37, 53, 38, 1, -52 },
  { 11327, 37, 51, 37, 6, -51 },
  { 11563, 45, 52, 49, 5, -51 },
  { 11856, 41, 51, 41, 7, -51 },
  { 12118, 63, 51, 63, 7, -51 },
  { 12520, 51, 51, 42, -4, -51 },
  { 12846, 39, 51, 39, 7, -51 },
  { 13095, 44, 51, 38, -2, -51 },
  { 13376, 29, 62, 23, -1, -51 },
  { 13601, 16, 52, 29, 8, -52 },
  { 13705, 29, 62, 23, -5, -51 },
  { 13930, 36, 33, 40, 2, -52 },
  { 14079, 30, 5, 29, -7, 6 },
  { 14098, 14, 11, 22, 10, -55 },
  { 14118, 38, 41, 42, 3, -40 },
  { 14313, 37, 56, 42, 2, -55 },
  { 14572, 32, 41, 34, 3, -40 },
  { 14736, 41, 56, 42, 3, -55 },
  { 15023, 34, 41, 39, 3, -40 },
  { 15198, 42, 72, 25, -8, -55 },
  { 15576, 40, 57, 42, 1, -40 },
  { 15861, 37, 55, 43, 2, -55 },
  { 16116, 20, 54, 20, 2, -54 },
  { 16251, 31, 71, 20, -9, -54 },
  { 16527, 40, 55, 39, 2, -55 },
  { 16802, 20, 55, 20, 2, -55 },
  { 16940, 59, 40, 64, 2, -40 },
  { 17235, 38, 40, 43, 1, -40 },
  { 17425, 35, 41, 42, 3, -40 },
  { 17605, 41, 57, 42, -2, -40 },
  { 17898, 38, 57, 42, 3, -40 },
  { 18169, 30, 40, 30, 2, -40 },
  { 18319, 31, 41, 33, 1, -40 },
  { 18478, 26, 49, 27, 3, -48 },
  { 18638, 37, 40, 43, 4, -39 },
  { 18823, 36, 39, 36, 4, -39 },
  { 18999, 54, 39, 55, 4, -39 },
  { 19263, 43, 39, 37, -3, -39 },
  { 19473, 46, 56, 36, -6, -39 },
  { 19795, 34, 39, 33, -1, -39 },
  { 19961, 30, 62, 25, 0, -51 },
  { 20194, 7, 72, 40, 17, -55 },
  { 20257, 28, 62, 25, -3, -51 },
  { 20474, 35, 11, 41, 4, -31 },
};

const GFXfont NotoSans_SemiBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMIBOLDITALIC72PT7B_H_
