#ifndef _NOTOSANS_SEMIBOLDITALIC61PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xC0,
  0x00, 0x3F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0xFC, 0x3E,
  0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE3, 0xC3, 0xC0, 0x7F, 0x8F, 0x81, 0x00, 0xFE, 0x1E, 0x00,
  0x01, 0xFC, 0x3C, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x07, 0xF0, 0xF0, 0x00,
  0x0F, 0xE3, 0xC0, 0x00, 0x1F, 0xE7, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7B, 0xFF, 0x00, 0x00,
  0xF1, 0xFE, 0x00, 0x01, 0xE3, 0xFC, 0x00, 0x07, 0x87, 0xF8, 0x00, 0x0F,
  0x0F, 0xF0, 0x00, 0x1E, 0x1F, 0xE2, 0x00, 0x3C, 0x3F, 0x87, 0x00, 0xF8,
  0xFF, 0x0F, 0xC1, 0xE7, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF8,
  0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x0F, 0xC1,
  0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x7F, 0xE1, 0xF8, 0x3F, 0x8F, 0xC7, 0xFF,
  0x8F, 0xE1, 0xF8, 0xFE, 0x7F, 0xFE, 0x7F, 0x1F, 0xC7, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFC, 0x7E, 0x3F, 0xFF, 0xCF, 0xFF, 0xE7, 0xE3, 0xF8, 0x7E, 0x3F,
  0xFE, 0x7F, 0x1F, 0x83, 0xF0, 0xFF, 0xC3, 0xF1, 0xFC, 0x1F, 0x83, 0xFC,
  0x3F, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0x00, 0x3F,
  0x87, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x81,
  0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x7F, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x00,
  0x3F, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0x83, 0xFF, 0xFE, 0x00, 0xFF, 0x0F, 0xFF, 0xFC, 0x01, 0xFC,
  0x3F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x1F, 0xE3, 0xFE, 0x07,
  0xF8, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0xFF, 0x0F, 0xE0, 0x0F, 0xFB, 0xFC,
  0x3F, 0xC0, 0x0F, 0xFF, 0xF8, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0xFF, 0x00,
  0x1F, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xFC,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F,
  0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF1, 0xFC,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x07,
  0xE0, 0x07, 0x00, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0xFF, 0xCF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFC, 0x3F, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x0F,
  0xF7, 0xE0, 0x01, 0xFE, 0x3E, 0x00, 0x3F, 0xC3, 0xF0, 0x07, 0xF8, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF0, 0x1F, 0x80, 0x06, 0x01, 0xFC, 0x00,
  0x20, 0x1F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xFC, 0x0C,
  0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xE3, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0xCF, 0xFE, 0xFF, 0x3F, 0xF3, 0xF8, 0x7F,
  0x0F, 0xE0, 0xF8, 0x7F, 0x83, 0x81, 0xFE, 0x04, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF8, 0x01, 0xFC, 0x03,
  0xFE, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x0E, 0x00, 0x1F, 0xE0, 0x01, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x60, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0x1F, 0xF0, 0xC0, 0x00,
  0x3F, 0xE0, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0x1F, 0xF0,
  0xE0, 0x00, 0x3F, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFE, 0x03, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x8F, 0xFE, 0x00, 0xFE, 0x7F,
  0xFE, 0x01, 0xFD, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F,
  0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x03,
  0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF3,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x03,
  0xFE, 0xFF, 0x00, 0x3F, 0xF3, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x3F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF7, 0xF0, 0x7F,
  0xFF, 0x7F, 0x81, 0xFF, 0xF3, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x40, 0x0F, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0x83,
  0xFF, 0x3C, 0x00, 0xFF, 0x10, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x7E, 0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0x1F, 0xFF, 0xF0,
  0x3F, 0x1F, 0x80, 0x3F, 0xFF, 0xF0, 0x3F, 0x3F, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0x3F, 0x00, 0xFF, 0x07, 0xE0, 0x3F, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x7C, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3E, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0xFC, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0xFC, 0x0F, 0xC0, 0x3F, 0x80,
  0xFC, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0xFC, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0xFC, 0x0F, 0xC0, 0xFF, 0x03, 0xF8, 0xFC, 0x0F, 0xE1, 0xFF, 0x8F,
  0xF0, 0xFC, 0x0F, 0xFF, 0xEF, 0xFF, 0xE0, 0xFE, 0x07, 0xFF, 0xCF, 0xFF,
  0xC0, 0x7E, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x01, 0x80,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x06, 0x00, 0x7F, 0xF8, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x83, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0xC1, 0xFE, 0x00,
  0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xFE, 0x07,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x00, 0x40, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xF3, 0xFC,
  0x00, 0x7F, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFF,
  0xC7, 0xF8, 0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF, 0xF1, 0xFE, 0x00,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0xC0, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x06, 0x0F,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0xFF, 0x80,
  0x00, 0x03, 0xF9, 0xFF, 0x00, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF8, 0x07, 0xF3, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xC0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0xFF, 0x00, 0xFE,
  0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x03,
  0xF8, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0,
  0x0F, 0xE3, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x0F, 0xC1,
  0xFC, 0x01, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xC7,
  0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0xFD, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xBF, 0x00, 0xFE, 0x00, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x00,
  0x01, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0xFD, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x03,
  0xF8, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x00,
  0xFF, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x07, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x3F, 0x80, 0x07, 0xFB, 0xF8,
  0x07, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x1F,
  0xC0, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xFE, 0x07,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xFC, 0x07,
  0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0x00,
  0x38, 0x03, 0xFE, 0x00, 0x08, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x80, 0x00, 0x3F, 0xC0, 0xE0, 0x00, 0x7F, 0xC0, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xF8,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF8, 0x1F, 0xC0,
  0x1F, 0xDF, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE,
  0x00, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x7E, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x1F, 0x8F, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x00,
  0x07, 0xF3, 0xF8, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x3F,
  0x80, 0x01, 0xFD, 0xFC, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x0F,
  0xDF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xF0,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F,
  0xC7, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x0F,
  0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x7F,
  0x00, 0x7F, 0xF8, 0x7E, 0x01, 0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0xFE, 0xFE,
  0x07, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0x9F, 0x80, 0x3F, 0xFF, 0x1F, 0x80,
  0x1F, 0xFE, 0x1F, 0x80, 0x0F, 0xFC, 0x3F, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x07, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFC, 0x7F, 0xF8,
  0x01, 0xFC, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0x7F, 0xFF, 0xC0, 0x7E, 0x3F, 0xFF, 0x80, 0x7E, 0x3F, 0xFE, 0x00,
  0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF0, 0x0C, 0x1F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x41,
  0xFF, 0x00, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0x80, 0x07, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0xF3, 0xF8, 0x03, 0xFF,
  0xFE, 0xFE, 0x01, 0xFF, 0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8,
  0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFD, 0xF8, 0x00, 0xFF, 0xFE, 0x7E, 0x00, 0x1F, 0xFE, 0x1F,
  0x80, 0x01, 0xFF, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x1F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x0F,
  0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x03, 0xFE, 0x7F,
  0x81, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0x07, 0xFC, 0x00, 0xE0,
  0x7F, 0xF8, 0x7E, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF9, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x07,
  0xF0, 0x03, 0xFF, 0xE1, 0xF8, 0x01, 0xFF, 0xFC, 0x7E, 0x00, 0xFF, 0xFF,
  0xBF, 0x80, 0x7F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x83, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x3F, 0x80, 0x07, 0xFF, 0x9F, 0xE0,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x80, 0x00, 0xFF, 0x80, 0x3C, 0x00,
  0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x03,
  0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xFC, 0x7F, 0xFC, 0x01, 0xFC, 0xFF,
  0xFC, 0x01, 0xFD, 0xFF, 0xFE, 0x03, 0xFB, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07,
  0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x02, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x01, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF0,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x7E,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xE3, 0xFF, 0xF0, 0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0xFC, 0x7F, 0xFF, 0x80,
  0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0xF0, 0x01, 0xF8, 0x7F,
  0xFC, 0x01, 0xF8, 0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0xFE, 0x03, 0xFB, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x07,
  0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xE7,
  0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0x80, 0x00, 0xFC, 0x3F,
  0xFC, 0x00, 0x1F, 0x9F, 0xFF, 0xC0, 0x03, 0xF7, 0xFF, 0xF8, 0x00, 0xFE,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0xF8, 0x03,
  0xFB, 0xFF, 0xFE, 0x00, 0x7F, 0x3F, 0xFF, 0x80, 0x0F, 0xE3, 0xFF, 0xC0,
  0x03, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x7F, 0xF8, 0x7E, 0x01,
  0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0x3F, 0x80, 0x1F, 0xFE, 0x7F, 0x80, 0x0F,
  0xF8, 0x7F, 0x80, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0x87,
  0xFC, 0x07, 0xE3, 0xFF, 0x01, 0xF9, 0xFF, 0x80, 0xFE, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFF, 0x81, 0xF0, 0x7F, 0xC0, 0x1C, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x88, 0x00, 0x3F, 0xC3, 0x80, 0x1F,
  0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x04, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03,
  0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xDF,
  0xC0, 0x7F, 0xFF, 0x9F, 0xC0, 0x3F, 0xFF, 0x1F, 0x80, 0x1F, 0xFE, 0x1F,
  0x80, 0x0F, 0xFC, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFE,
  0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x07, 0xF0,
  0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x07,
  0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x7F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFD, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xEF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xF3, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x3E, 0xF8, 0x07, 0xF8, 0xFE, 0x03,
  0xF7, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xBF, 0x03, 0xFC, 0x3F, 0x81, 0xF9,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xCF, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x7E,
  0x0F, 0xF0, 0x7F, 0x07, 0xE3, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x1F, 0x87,
  0xF8, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x87, 0xE3, 0xFC,
  0x07, 0xF1, 0xF8, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC1, 0xF9, 0xFE, 0x01,
  0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x00, 0x3F,
  0x3F, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x1F, 0xBF, 0x80, 0x0F, 0xDF,
  0x80, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x0B, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xD8, 0x00,
  0x7F, 0xFC, 0x80, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_SemiBoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 17, 45, 17, 1, -44 },
  { 97, 21, 16, 26, 6, -44 },
  { 139, 39, 44, 39, 1, -44 },
  { 354, 31, 50, 34, 2, -46 },
  { 548, 45, 45, 51, 4, -44 },
  { 802, 39, 45, 42, 2, -44 },
  { 1022, 10, 16, 15, 6, -44 },
  { 1042, 22, 54, 20, 2, -44 },
  { 1191, 21, 54, 20, -4, -44 },
  { 1333, 28, 29, 33, 6, -47 },
  { 1435, 29, 29, 35, 4, -36 },
  { 1541, 14, 15, 17, -3, -7 },
  { 1568, 17, 7, 19, 1, -20 },
  { 1583, 9, 10, 17, 1, -9 },
  { 1595, 32, 44, 24, -3, -44 },
  { 1771, 31, 45, 34, 2, -44 },
  { 1946, 22, 44, 34, 7, -44 },
  { 2067, 34, 44, 34, -1, -44 },
  { 2254, 32, 45, 34, 1, -44 },
  { 2434, 33, 44, 34, 0, -44 },
  { 2616, 32, 45, 34, 1, -44 },
  { 2796, 31, 45, 34, 3, -44 },
  { 2971, 33, 44, 34, 3, -44 },
  { 3153, 31, 45, 34, 2, -44 },
  { 3328, 29, 45, 34, 3, -44 },
  { 3492, 15, 35, 17, 1, -34 },
  { 3558, 19, 42, 17, -3, -34 },
  { 3658, 29, 32, 35, 4, -38 },
  { 3774, 29, 17, 35, 4, -30 },
  { 3836, 29, 32, 35, 4, -38 },
  { 3952, 24, 45, 27, 5, -44 },
  { 4087, 48, 50, 52, 3, -44 },
  { 4387, 37, 44, 37, -4, -44 },
  { 4591, 35, 44, 37, 2, -44 },
  { 4784, 35, 45, 37, 4, -44 },
  { 4981, 37, 44, 41, 2, -44 },
  { 5185, 33, 44, 32, 2, -44 },
  { 5367, 33, 44, 31, 2, -44 },
  { 5549, 37, 45, 42, 4, -44 },
  { 5758, 41, 44, 42, 2, -44 },
  { 5984, 27, 44, 22, -2, -44 },
  { 6133, 29, 56, 19, -10, -44 },
  { 6336, 40, 44, 36, 2, -44 },
  { 6556, 25, 44, 31, 2, -44 },
  { 6694, 51, 44, 53, 2, -44 },
  { 6975, 43, 44, 45, 2, -44 },
  { 7212, 38, 45, 44, 4, -44 },
  { 7426, 34, 44, 36, 2, -44 },
  { 7613, 38, 54, 44, 4, -44 },
  { 7870, 34, 44, 37, 2, -44 },
  { 8057, 32, 45, 32, 1, -44 },
  { 8237, 31, 44, 32, 5, -44 },
  { 8408, 38, 45, 42, 4, -44 },
  { 8622, 35, 44, 35, 6, -44 },
  { 8815, 53, 44, 54, 6, -44 },
  { 9107, 43, 44, 35, -3, -44 },
  { 9344, 33, 44, 33, 6, -44 },
  { 9526, 36, 44, 33, -1, -44 },
  { 9724, 25, 54, 19, -1, -44 },
  { 9893, 13, 44, 24, 7, -44 },
  { 9965, 24, 54, 19, -4, -44 },
  { 10127, 30, 28, 34, 2, -44 },
  { 10232, 26, 5, 24, -6, 5 },
  { 10249, 12, 10, 19, 9, -47 },
  { 10264, 32, 35, 36, 3, -34 },
  { 10404, 32, 47, 36, 1, -46 },
  { 10592, 26, 35, 29, 3, -34 },
  { 10706, 34, 47, 36, 3, -46 },
  { 10906, 28, 35, 33, 3, -34 },
  { 11029, 36, 62, 22, -7, -47 },
  { 11308, 34, 49, 36, 1, -34 },
  { 11517, 32, 46, 36, 1, -46 },
  { 11701, 17, 46, 17, 1, -46 },
  { 11799, 26, 61, 17, -8, -46 },
  { 11998, 35, 46, 33, 1, -46 },
  { 12200, 18, 46, 17, 1, -46 },
  { 12304, 50, 34, 55, 1, -34 },
  { 12517, 32, 34, 36, 1, -34 },
  { 12653, 29, 35, 35, 3, -34 },
  { 12780, 35, 49, 36, -2, -34 },
  { 12995, 32, 49, 36, 3, -34 },
  { 13191, 26, 34, 25, 1, -34 },
  { 13302, 26, 35, 28, 1, -34 },
  { 13416, 22, 41, 23, 3, -40 },
  { 13529, 32, 34, 36, 3, -33 },
  { 13665, 30, 33, 30, 3, -33 },
  { 13789, 45, 33, 47, 4, -33 },
  { 13975, 37, 33, 31, -3, -33 },
  { 14128, 39, 48, 30, -5, -33 },
  { 14362, 29, 33, 28, -1, -33 },
  { 14482, 25, 54, 22, 0, -44 },
  { 14651, 6, 60, 34, 14, -46 },
  { 14696, 25, 54, 22, -3, -44 },
  { 14865, 29, 9, 35, 4, -26 },
};

const GFXfont NotoSans_SemiBoldItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_SEMIBOLDITALIC61PT7B_H_
