#ifndef _NOTOSANS_SEMIBOLDITALIC55PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x7F, 0x0F, 0xEF,
  0xE1, 0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F,
  0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFD, 0xE7,
  0xC0, 0xFF, 0x1C, 0x0C, 0x0F, 0xE3, 0xC0, 0x00, 0xFE, 0x3C, 0x00, 0x0F,
  0xE3, 0xC0, 0x00, 0xFE, 0x3C, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0xFF, 0x78,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x7F, 0x80, 0x01, 0xE3, 0xF8,
  0x00, 0x1E, 0x3F, 0x80, 0x01, 0xE3, 0xF8, 0x00, 0x1C, 0x3F, 0x88, 0x03,
  0xC3, 0xF8, 0xC0, 0x3C, 0x7F, 0x0F, 0x83, 0xDF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xFF,
  0x00, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x07,
  0xC0, 0x3F, 0x9F, 0x80, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0,
  0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x1F,
  0x87, 0xE0, 0x00, 0xF8, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x1F, 0x0F, 0x87,
  0xF0, 0xF8, 0x3F, 0x1F, 0x9F, 0xF8, 0xF8, 0x3F, 0x3F, 0x3F, 0xFC, 0xFC,
  0x7E, 0x7E, 0x7F, 0xFE, 0xFF, 0xFC, 0x7C, 0x7F, 0xFE, 0x7F, 0xFC, 0xFC,
  0xFC, 0x3E, 0x7F, 0xF9, 0xF9, 0xFC, 0x3F, 0x3F, 0xE3, 0xF1, 0xF8, 0x3F,
  0x0F, 0x83, 0xE1, 0xF8, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xF0,
  0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xE0, 0x7E, 0x00,
  0x7C, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0xFC, 0x03, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xE0, 0x03, 0xF3, 0xF8,
  0x07, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0x80,
  0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0x1F, 0xFF, 0xC0,
  0x1F, 0xC7, 0xFF, 0xFC, 0x07, 0xF1, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F, 0x83,
  0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x87, 0xF3, 0xFC, 0x07, 0xF9, 0xFC, 0x7F,
  0x00, 0x7F, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xE1, 0xFC, 0x00, 0xFF, 0xF8,
  0x3F, 0x80, 0x0F, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF3, 0xFC, 0x07,
  0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8,
  0xF8, 0xF0, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x08, 0x03,
  0xE0, 0x03, 0x00, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7F, 0x0F, 0x00, 0x1F,
  0xF7, 0xC0, 0x0F, 0xFF, 0xE0, 0x7C, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0x03, 0xFF,
  0x80, 0x01, 0xFB, 0xE0, 0x00, 0xFE, 0x7C, 0x00, 0x7F, 0x1F, 0x00, 0x3F,
  0x87, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF0, 0x3F, 0x00, 0x18, 0x0F, 0xC0,
  0x02, 0x03, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0x80, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC3, 0xC1, 0xF8, 0x38, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0x00,
  0x70, 0x01, 0xFC, 0x00, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xF0,
  0x0E, 0x00, 0xFF, 0x00, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x80, 0x00, 0x7F, 0x8E, 0x00, 0x0F, 0xF0, 0xFC, 0x07,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00,
  0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x30, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x10, 0x00, 0x0F, 0xF0, 0xE0, 0x01, 0xFF, 0x07, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x20, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x3F, 0xFC, 0x07, 0xF7, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0xFF, 0x0F,
  0xFC, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x87, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF3, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFB, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x1F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07,
  0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0xFF,
  0x9F, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFE, 0xFE, 0x03, 0xFF, 0x1F, 0x80, 0x1F, 0x87, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x03, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xF8, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0xC6, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xFF, 0x03,
  0xE1, 0xF8, 0x07, 0xFF, 0xF0, 0x7E, 0x7E, 0x03, 0xFF, 0xFE, 0x07, 0xCF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFB, 0xF0, 0x3F, 0x81, 0xF0, 0x1F, 0x7C, 0x07,
  0xE0, 0x3E, 0x03, 0xEF, 0x81, 0xF8, 0x07, 0xC0, 0x7F, 0xF0, 0x3E, 0x01,
  0xF8, 0x0F, 0xFE, 0x0F, 0xC0, 0x3E, 0x01, 0xFF, 0x81, 0xF0, 0x07, 0xC0,
  0x7F, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0xBE, 0x0F, 0xC0, 0x3F, 0x01, 0xF7,
  0xC1, 0xF8, 0x07, 0xC0, 0x3E, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xDF, 0x07,
  0xC0, 0x3F, 0x01, 0xF3, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x7C, 0x1F, 0x81,
  0xFC, 0x1F, 0x8F, 0x83, 0xF8, 0xFF, 0x87, 0xE1, 0xF0, 0x3F, 0xFE, 0xFF,
  0xFC, 0x3F, 0x07, 0xFF, 0x9F, 0xFF, 0x07, 0xE0, 0x7F, 0xE1, 0xFF, 0x80,
  0x7C, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00,
  0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0xFC, 0x07,
  0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x80,
  0x0F, 0xF8, 0x7F, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0x00,
  0x0C, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x06, 0x00, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xF0,
  0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0x81, 0xF8, 0x0F, 0xFE, 0x00, 0x1C, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xFF, 0x9F, 0xC0, 0x0F, 0xFF, 0xCF, 0xE0, 0x07, 0xFF,
  0xE7, 0xF0, 0x07, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xF1, 0xFC, 0x01, 0xFF,
  0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xC1, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x07, 0xF0, 0x3F, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0xBF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x80,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x07, 0xE7, 0xF8, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xF0,
  0x0F, 0xDF, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0x7C, 0x00, 0x3F, 0x7F, 0x00,
  0xFD, 0xF0, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xC0, 0x07, 0xE7, 0xE0, 0x1F,
  0x9F, 0x80, 0x1F, 0xBF, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFE, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x9F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF1, 0xFC, 0x03, 0xF0, 0xF8,
  0x0F, 0x87, 0xF0, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0x81,
  0xF0, 0x7E, 0x01, 0xFC, 0x3E, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x3E,
  0x0F, 0xE0, 0x1F, 0x83, 0xE1, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xCF, 0xC0,
  0xFC, 0x03, 0xF8, 0x3F, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFD, 0xF8, 0x1F,
  0xC0, 0x3F, 0x03, 0xF7, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xFF, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x00, 0x07,
  0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x7F,
  0xF0, 0x00, 0x7F, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x01,
  0xF8, 0x07, 0xEF, 0xC0, 0x07, 0xF0, 0x0F, 0xDF, 0xC0, 0x0F, 0xE0, 0x1F,
  0xBF, 0x80, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x7F, 0x00,
  0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0xFE, 0x03,
  0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x3F, 0x00,
  0xFE, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0x01,
  0xFD, 0xF8, 0x07, 0xE0, 0x03, 0xFB, 0xF0, 0x1F, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0xFC, 0x00,
  0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xFC,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFE, 0x07, 0xE0, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0x81, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xF1, 0xFF, 0xE0, 0x1F,
  0xC0, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x3F,
  0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0x07, 0xE0, 0x7F, 0xC0, 0x0C, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0xFF, 0x0E, 0x00,
  0x1F, 0xE0, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF8, 0x7E, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x3F, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x7E, 0x00,
  0x7F, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0xFF, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x7E, 0x01,
  0xFB, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0xC0, 0x7E, 0x03,
  0xF3, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x00, 0x7E, 0x07,
  0xE3, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC3, 0xF0, 0x7F, 0x00, 0x7E, 0x0F,
  0xC1, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x81, 0xF0, 0xFE, 0x00, 0x7E, 0x1F,
  0x81, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x01, 0xF1, 0xFC, 0x00, 0x7E, 0x3F,
  0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x01, 0xF3, 0xF8, 0x00, 0x7E, 0x7E,
  0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x7C, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0xFC,
  0x01, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0xF8,
  0x01, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE0, 0xFC, 0x00,
  0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF,
  0x00, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F,
  0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0x7E,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x00,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0xF8, 0x03, 0xFF, 0x8F, 0xC0, 0x7F,
  0xFE, 0x7E, 0x07, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x3F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1,
  0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC,
  0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC7, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFE, 0x7C, 0x01, 0xFF, 0xE3, 0xE0,
  0x03, 0xFC, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0xFF, 0xE0, 0x0F,
  0xEF, 0xFF, 0x80, 0x7E, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8,
  0xFF, 0x81, 0xFF, 0x81, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F,
  0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFB, 0xFF, 0xF8, 0x0F, 0x9F, 0xFF, 0x80, 0x7C, 0x7F, 0xF8,
  0x07, 0xE1, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xF1, 0xF0, 0x3F, 0xE0, 0x08, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x20, 0x7F,
  0xE0, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00,
  0x1F, 0xFC, 0xFE, 0x00, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0xFB, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFE,
  0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xDF, 0x80, 0x1F, 0xFF, 0x3E, 0x00, 0x3F, 0xFC, 0x7C, 0x00,
  0x1F, 0xE0, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0x83, 0xFC, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F,
  0xBF, 0xC0, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xEF, 0xE0, 0xFF,
  0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x10, 0xFF,
  0x80, 0x78, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xCC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0xFF, 0xE3, 0xF0, 0x0F, 0xFF, 0xCF,
  0xC0, 0x7F, 0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F,
  0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC,
  0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0xFE, 0x01, 0xFF, 0x03,
  0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xCF, 0xC0, 0x0F, 0xFE,
  0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x20, 0x00, 0x7F, 0x00, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x7F, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC, 0xFF, 0xF0, 0x0F, 0xEF,
  0xFF, 0x80, 0x7E, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x7F,
  0xC1, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83,
  0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7E, 0x0F, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF9, 0xFE,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0x8F, 0xFE,
  0x07, 0xFF, 0x00, 0xFC, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xEF, 0xFF, 0xC7,
  0xFF, 0xE0, 0x3E, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xF7, 0xC7, 0xFF, 0xE3,
  0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC3,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x87, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x80, 0x1F, 0x8F, 0xFF, 0x00,
  0xFC, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xF7,
  0xE7, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x07, 0xF8, 0x03,
  0xF8, 0x7F, 0xC0, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFE, 0x3F,
  0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xDF, 0xE0,
  0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0xBF, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xF3, 0xFC, 0x07, 0xF8, 0x7F,
  0x87, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x7E, 0x3F, 0xF8, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0x7E,
  0xFF, 0xFC, 0x00, 0x7D, 0xFF, 0xFE, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0xFF,
  0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xFE,
  0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xC0, 0x0F, 0xCF,
  0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xC0,
  0x40, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x81, 0xF0, 0x0F, 0xFE, 0x3F, 0x03, 0xFF, 0xF3,
  0xF0, 0x7F, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xFE, 0x1F,
  0xE0, 0x3F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFE,
  0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xF8, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x01,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x7F,
  0x03, 0xF1, 0xFE, 0x03, 0xF3, 0xFE, 0x03, 0xF7, 0xFE, 0x03, 0xF7, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x82, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x1E, 0x0F, 0xE0, 0x04,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0xC0, 0x03, 0xF8, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE8, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x82, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x00, 0xFF, 0x83, 0xF8, 0x07, 0xFC, 0x1F, 0xC0, 0x7F, 0xE0,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xDF, 0x80, 0xFF,
  0xFC, 0xFC, 0x03, 0xFF, 0xC7, 0xE0, 0x0F, 0xF8, 0x3E, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x81,
  0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x07,
  0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF0, 0x07, 0xF3,
  0xF8, 0x07, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x3F, 0x80,
  0xFF, 0xC0, 0x3F, 0x87, 0xE0, 0x3E, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xFC,
  0x07, 0xF0, 0x7E, 0x07, 0xDF, 0x81, 0xFC, 0x1F, 0x81, 0xF7, 0xE0, 0xFE,
  0x07, 0xE0, 0xFD, 0xF8, 0x3F, 0x81, 0xF8, 0x3E, 0x7E, 0x1F, 0xC0, 0x7E,
  0x1F, 0x9F, 0x87, 0xF0, 0x1F, 0x87, 0xE7, 0xE1, 0xF8, 0x07, 0xE3, 0xF1,
  0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x1F, 0x9F,
  0xC0, 0x1F, 0x9F, 0x87, 0xE7, 0xE0, 0x07, 0xE7, 0xC1, 0xF9, 0xF8, 0x01,
  0xFB, 0xF0, 0x7E, 0xFC, 0x00, 0x7E, 0xF8, 0x0F, 0xBF, 0x00, 0x1F, 0xBE,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x23, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x02, 0x7F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x23, 0xFF, 0x00, 0x0D, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xF6, 0x00, 0x1F, 0xFC, 0x80, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 40, 15, 1, -39 },
  { 81, 19, 14, 24, 6, -39 },
  { 115, 35, 39, 36, 1, -39 },
  { 286, 28, 45, 30, 2, -42 },
  { 444, 40, 41, 46, 4, -40 },
  { 649, 35, 41, 38, 2, -40 },
  { 829, 8, 14, 13, 6, -39 },
  { 843, 20, 48, 18, 2, -39 },
  { 963, 20, 49, 18, -4, -40 },
  { 1086, 26, 26, 30, 5, -42 },
  { 1171, 27, 27, 31, 3, -33 },
  { 1263, 13, 13, 15, -3, -6 },
  { 1285, 15, 6, 18, 1, -18 },
  { 1297, 8, 9, 15, 1, -8 },
  { 1306, 28, 39, 22, -2, -39 },
  { 1443, 28, 41, 30, 2, -40 },
  { 1587, 20, 39, 30, 6, -39 },
  { 1685, 30, 40, 30, -1, -40 },
  { 1835, 28, 41, 30, 1, -40 },
  { 1979, 29, 39, 30, 0, -39 },
  { 2121, 29, 40, 30, 1, -39 },
  { 2266, 28, 41, 30, 3, -40 },
  { 2410, 29, 39, 30, 3, -39 },
  { 2552, 28, 41, 30, 2, -40 },
  { 2696, 27, 41, 30, 2, -40 },
  { 2835, 13, 31, 15, 1, -30 },
  { 2886, 17, 37, 15, -3, -30 },
  { 2965, 27, 28, 31, 3, -34 },
  { 3060, 26, 16, 31, 3, -27 },
  { 3112, 27, 28, 31, 3, -34 },
  { 3207, 22, 41, 25, 4, -40 },
  { 3320, 43, 44, 47, 3, -39 },
  { 3557, 33, 39, 33, -3, -39 },
  { 3718, 31, 39, 34, 2, -39 },
  { 3870, 31, 41, 33, 4, -40 },
  { 4029, 33, 39, 37, 2, -39 },
  { 4190, 29, 39, 29, 2, -39 },
  { 4332, 29, 39, 28, 2, -39 },
  { 4474, 33, 41, 38, 4, -40 },
  { 4644, 36, 39, 38, 2, -39 },
  { 4820, 24, 39, 20, -1, -39 },
  { 4937, 26, 50, 17, -9, -39 },
  { 5100, 36, 39, 33, 2, -39 },
  { 5276, 22, 39, 28, 2, -39 },
  { 5384, 46, 39, 48, 2, -39 },
  { 5609, 39, 39, 41, 2, -39 },
  { 5800, 34, 41, 40, 4, -40 },
  { 5975, 31, 39, 33, 2, -39 },
  { 6127, 34, 49, 40, 4, -40 },
  { 6336, 30, 39, 33, 2, -39 },
  { 6483, 28, 41, 29, 1, -40 },
  { 6627, 28, 39, 29, 5, -39 },
  { 6764, 34, 40, 38, 4, -39 },
  { 6934, 32, 39, 32, 5, -39 },
  { 7090, 48, 39, 48, 5, -39 },
  { 7324, 39, 39, 32, -3, -39 },
  { 7515, 30, 39, 30, 5, -39 },
  { 7662, 33, 39, 29, -1, -39 },
  { 7823, 22, 48, 17, -1, -39 },
  { 7955, 12, 39, 22, 6, -39 },
  { 8014, 22, 48, 17, -4, -39 },
  { 8146, 28, 25, 31, 1, -39 },
  { 8234, 23, 4, 22, -5, 5 },
  { 8246, 11, 9, 17, 8, -42 },
  { 8259, 29, 31, 32, 2, -30 },
  { 8372, 29, 43, 32, 1, -42 },
  { 8528, 25, 31, 26, 2, -30 },
  { 8625, 31, 43, 32, 3, -42 },
  { 8792, 25, 31, 29, 3, -30 },
  { 8889, 32, 55, 19, -6, -42 },
  { 9109, 30, 43, 32, 1, -30 },
  { 9271, 29, 42, 33, 1, -42 },
  { 9424, 16, 41, 16, 1, -41 },
  { 9506, 24, 54, 16, -7, -41 },
  { 9668, 31, 42, 30, 1, -42 },
  { 9831, 16, 42, 16, 1, -42 },
  { 9915, 45, 30, 49, 1, -30 },
  { 10084, 29, 30, 33, 1, -30 },
  { 10193, 26, 31, 32, 3, -30 },
  { 10294, 32, 43, 32, -2, -30 },
  { 10466, 28, 43, 32, 3, -30 },
  { 10617, 24, 30, 23, 1, -30 },
  { 10707, 24, 31, 25, 0, -30 },
  { 10800, 20, 37, 21, 2, -36 },
  { 10893, 29, 31, 33, 3, -30 },
  { 11006, 27, 30, 27, 3, -30 },
  { 11108, 42, 30, 42, 3, -30 },
  { 11266, 33, 30, 28, -2, -30 },
  { 11390, 34, 43, 27, -4, -30 },
  { 11573, 27, 30, 25, -1, -30 },
  { 11675, 23, 48, 19, 0, -39 },
  { 11813, 5, 55, 30, 13, -42 },
  { 11848, 22, 48, 19, -3, -39 },
  { 11980, 27, 9, 31, 3, -24 },
};

const GFXfont NotoSans_SemiBoldItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMIBOLDITALIC55PT7B_H_
