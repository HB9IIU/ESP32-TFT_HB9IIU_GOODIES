#ifndef _NOTOSANS_SEMIBOLDITALIC39PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x07, 0xC0, 0xFC, 0x1F,
  0x83, 0xE0, 0x7C, 0x02, 0x00, 0x7C, 0x7B, 0xE7, 0xDE, 0x3E, 0xF1, 0xE7,
  0x8F, 0x3C, 0x7B, 0xC3, 0xDE, 0x1C, 0xF0, 0xE7, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xC1,
  0xC0, 0x03, 0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x83,
  0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0x07,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x98, 0x41, 0xF1, 0x80, 0x1F,
  0x38, 0x01, 0xF3, 0x80, 0x1F, 0xB8, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0E, 0x7C,
  0x00, 0xE7, 0xC0, 0x0E, 0x7C, 0x80, 0xC7, 0xCE, 0x0C, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x03, 0xC1, 0xFE, 0x00,
  0x78, 0x3F, 0xF0, 0x0F, 0x07, 0xCF, 0x00, 0xF0, 0x78, 0xF0, 0x1E, 0x0F,
  0x8F, 0x03, 0xC0, 0xF0, 0xF0, 0x78, 0x0F, 0x0F, 0x07, 0x80, 0xF0, 0xF0,
  0xF0, 0x0F, 0x0F, 0x1E, 0x00, 0xF0, 0xF3, 0xC0, 0x0F, 0x1E, 0x3C, 0xFC,
  0xF1, 0xE7, 0x9F, 0xEF, 0x3C, 0xF3, 0xFE, 0xFF, 0xDE, 0x7D, 0xF7, 0xF9,
  0xEF, 0x8F, 0x3F, 0x3C, 0xF0, 0xF0, 0x07, 0x8F, 0x0F, 0x00, 0xF0, 0xF0,
  0xF0, 0x0F, 0x1E, 0x0F, 0x01, 0xE1, 0xE0, 0xF0, 0x3C, 0x1E, 0x1E, 0x07,
  0x81, 0xE1, 0xE0, 0x78, 0x1E, 0x3E, 0x0F, 0x01, 0xF3, 0xC1, 0xE0, 0x0F,
  0xFC, 0x1E, 0x00, 0xFF, 0x87, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3E, 0x1F, 0x00,
  0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xF0,
  0x01, 0xF3, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x3E, 0x3F, 0xFC, 0x1F, 0x3F, 0x3E,
  0x1F, 0x3F, 0x0F, 0x8F, 0x9F, 0x07, 0xEF, 0x9F, 0x01, 0xFF, 0x8F, 0x80,
  0x7F, 0xC7, 0xC0, 0x3F, 0xC3, 0xF0, 0x0F, 0xC0, 0xFC, 0x1F, 0xE0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0x9F, 0x81, 0xFF, 0x07, 0xE0,
  0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0x3C, 0xF3, 0x80, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x40, 0xF0, 0x3C, 0x38, 0x0F, 0xCE, 0x03,
  0xFF, 0x81, 0x7F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0x81, 0x1F,
  0xF0, 0x0F, 0x9C, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x18, 0x7C, 0x04, 0x0F,
  0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0x78,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0xF9, 0xFF, 0xFF,
  0xCF, 0x88, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F,
  0x7E, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7,
  0xE1, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00,
  0x00, 0x3C, 0x03, 0xF0, 0x3F, 0xC1, 0xFF, 0x1F, 0xF8, 0xFF, 0xEF, 0xFF,
  0x9F, 0x3E, 0x38, 0xF8, 0x83, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xE1, 0xFC, 0x06, 0x03, 0xF0, 0x10, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x38, 0x1F, 0x81, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF2, 0x00, 0x1F, 0x1C, 0x01, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x79, 0xE0, 0x07, 0x9F, 0x00, 0x7C,
  0xF8, 0x07, 0xC7, 0x80, 0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x03,
  0xC0, 0xF8, 0x3E, 0x07, 0x83, 0xE0, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x80, 0x0F, 0x8C, 0x03, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x7C, 0x07,
  0xDF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0x0F, 0xCF, 0xC0, 0x7C,
  0xFC, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F,
  0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xC7, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0x0F, 0x87, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x3C, 0xF8, 0x03,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0x3F, 0x83, 0xFF,
  0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x9F, 0x00, 0xF3, 0xE0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0,
  0xFC, 0xFC, 0x3F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xF7, 0xC1, 0xF9,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x03, 0x01, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x1F, 0x07,
  0xE3, 0xF8, 0xFC, 0x1F, 0x02, 0x00, 0x00, 0xC0, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x38, 0x3E,
  0x20, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x20, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1E, 0x1E, 0x07, 0xFC, 0x3C, 0x78,
  0x3F, 0xFC, 0x39, 0xE0, 0xFF, 0xF8, 0x7B, 0xC3, 0xE0, 0xE0, 0xF7, 0x87,
  0x83, 0xC1, 0xFE, 0x1E, 0x07, 0x83, 0xFC, 0x3C, 0x0F, 0x07, 0x78, 0x78,
  0x1C, 0x1E, 0xF1, 0xE0, 0x78, 0x3D, 0xE3, 0xC0, 0xF0, 0x7B, 0xC7, 0x83,
  0xE1, 0xE7, 0x8F, 0x07, 0xC3, 0xCF, 0x0F, 0x1F, 0x9F, 0x1E, 0x1F, 0xF7,
  0xFC, 0x3C, 0x1F, 0xCF, 0xF0, 0x3C, 0x1F, 0x0F, 0x80, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xDE,
  0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0,
  0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7C, 0x1F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x1F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x07, 0xF8, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x81,
  0xC1, 0xFC, 0x00, 0x87, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x60, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xC3, 0xFC, 0x07, 0xC0,
  0x7E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x01,
  0xF8, 0x7C, 0x03, 0xF8, 0x7C, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xF8, 0x1E, 0x0F, 0xE0, 0x02, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x07, 0xFE, 0x7C, 0x0F, 0xFE, 0x7C, 0x0F, 0xFC, 0x7C,
  0x0F, 0xFC, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x80, 0xF8, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1E,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x3F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x02, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x7C,
  0x3F, 0x00, 0x1E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0x7E, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xC7,
  0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF0, 0x07, 0xBC, 0x0F, 0xB8, 0x03, 0xDE, 0x07, 0xDE, 0x03, 0xDF, 0x03,
  0xCF, 0x03, 0xEF, 0x81, 0xE7, 0x81, 0xE7, 0xC1, 0xF3, 0xC1, 0xF3, 0xC0,
  0xF9, 0xE0, 0xF3, 0xE0, 0x7C, 0xF0, 0xF9, 0xF0, 0x3C, 0x78, 0x78, 0xF8,
  0x1E, 0x3C, 0x7C, 0x7C, 0x1F, 0x1E, 0x3C, 0x3C, 0x0F, 0x8F, 0x3C, 0x3E,
  0x07, 0xC7, 0x9E, 0x1F, 0x03, 0xC1, 0xDE, 0x0F, 0x81, 0xE0, 0xFF, 0x07,
  0x81, 0xF0, 0x7F, 0x03, 0xC0, 0xF8, 0x3F, 0x83, 0xE0, 0x78, 0x1F, 0x81,
  0xF0, 0x3C, 0x0F, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x01,
  0xF0, 0x7F, 0x80, 0x1E, 0x07, 0xF8, 0x03, 0xE0, 0x7F, 0xC0, 0x3E, 0x07,
  0xFC, 0x03, 0xE0, 0x7B, 0xC0, 0x3C, 0x0F, 0xBE, 0x03, 0xC0, 0xFB, 0xE0,
  0x7C, 0x0F, 0x1E, 0x07, 0xC0, 0xF1, 0xF0, 0x7C, 0x1F, 0x1F, 0x07, 0x81,
  0xF0, 0xF0, 0x78, 0x1F, 0x0F, 0x8F, 0x81, 0xE0, 0xF8, 0xF8, 0x1E, 0x07,
  0x8F, 0x83, 0xE0, 0x7C, 0xF0, 0x3E, 0x07, 0xCF, 0x03, 0xE0, 0x3D, 0xF0,
  0x3C, 0x03, 0xFF, 0x03, 0xC0, 0x3F, 0xF0, 0x7C, 0x01, 0xFE, 0x07, 0xC0,
  0x1F, 0xE0, 0x7C, 0x01, 0xFE, 0x07, 0x80, 0x0F, 0xE0, 0x78, 0x00, 0xFC,
  0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F,
  0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xC1, 0xFC, 0x1F, 0x03,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x01, 0xF8, 0x7C, 0x3F, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3E,
  0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF,
  0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x0F,
  0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x03,
  0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x7E,
  0x1F, 0x03, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x80, 0xF8, 0x3F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC0, 0xC1, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x80, 0x1F, 0x0C, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x1E, 0x07,
  0xC0, 0x78, 0x1F, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x00, 0x1F, 0x7C, 0x00, 0x7D,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xFC, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0x00, 0xFB, 0xE0, 0x1F,
  0x80, 0x7C, 0xF8, 0x0F, 0xE0, 0x1F, 0x3E, 0x03, 0xF8, 0x07, 0x8F, 0x80,
  0xFE, 0x03, 0xE3, 0xE0, 0x7F, 0x80, 0xF8, 0xF8, 0x1F, 0xE0, 0x7C, 0x3E,
  0x0F, 0x78, 0x1F, 0x0F, 0x83, 0xDE, 0x0F, 0x83, 0xE1, 0xF7, 0x83, 0xE0,
  0xF8, 0x79, 0xE0, 0xF0, 0x3E, 0x3E, 0x78, 0x7C, 0x0F, 0x8F, 0x0F, 0x1E,
  0x03, 0xE7, 0xC3, 0xCF, 0x80, 0xF9, 0xE0, 0xF3, 0xE0, 0x3E, 0x78, 0x3D,
  0xF0, 0x0F, 0xBC, 0x0F, 0x7C, 0x03, 0xEF, 0x03, 0xDE, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07,
  0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x78, 0x7E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x0F, 0x87, 0xC0, 0xFC, 0x3E,
  0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x04, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x40, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xF0, 0x7C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0x78,
  0x70, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x03, 0xC1, 0xC0, 0x3C, 0x3C,
  0x01, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x0F, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0xF9, 0xF1, 0xF1, 0xE3, 0xC3, 0xC0, 0x00, 0x60, 0x00, 0x3F,
  0x8F, 0x07, 0xFC, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xF0, 0x7E, 0x3E,
  0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0xC0, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8,
  0xF8, 0x1F, 0x8F, 0xC3, 0xF8, 0xFF, 0xFF, 0x07, 0xFE, 0xF0, 0x7F, 0xCF,
  0x03, 0xF8, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x82, 0x00, 0xF9, 0xFC, 0x0F, 0xBF, 0xE0, 0xF7, 0xFE, 0x0F, 0xF7, 0xF1,
  0xFC, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0xF3, 0xFE, 0x0F, 0x1F, 0xC0, 0x00, 0x20, 0x01, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0x09, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x06, 0x1F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x61, 0xF0, 0x0F, 0xE7, 0xC0, 0x7F, 0xDF, 0x03,
  0xFF, 0xFC, 0x1F, 0xDF, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x80,
  0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8,
  0x1F, 0x83, 0xE0, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFB, 0xC0, 0x7F, 0xCF,
  0x00, 0x7E, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0x8F, 0xCF, 0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x0F,
  0xBE, 0x1F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x87, 0xF3, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0x88, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xE3, 0xC0,
  0xFF, 0x9E, 0x0F, 0xFF, 0xF0, 0xFE, 0xFF, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F,
  0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8,
  0x7C, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFE,
  0xF8, 0x0F, 0xE7, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x20, 0x0F, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x83, 0x00, 0xF9, 0xFC, 0x0F, 0xBF, 0xE0, 0xF7, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFC, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xF0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0x03, 0xC0, 0xFC, 0x1F, 0x83,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x04, 0x3E, 0x07, 0xE0,
  0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF1,
  0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF0, 0x07, 0xE7, 0xC0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x00, 0x00, 0x02, 0x00, 0x20, 0x0F, 0x1F, 0xC1, 0xFC, 0x0F, 0x3F, 0xE3,
  0xFE, 0x0F, 0x7F, 0xE7, 0xFE, 0x0F, 0xF7, 0xEF, 0x7F, 0x1F, 0xC1, 0xFC,
  0x1F, 0x1F, 0x81, 0xF8, 0x1F, 0x1F, 0x81, 0xF8, 0x1F, 0x1F, 0x01, 0xF0,
  0x1F, 0x3F, 0x01, 0xF0, 0x1E, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0,
  0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x7C, 0x07, 0xC0,
  0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0,
  0x7C, 0x78, 0x07, 0x80, 0x7C, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80,
  0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x02, 0x00, 0xF1, 0xFC, 0x0F, 0x3F,
  0xE0, 0xF7, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0x1F, 0x1F, 0x81, 0xF1, 0xF8,
  0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xEF, 0xE3, 0xF0, 0x7C,
  0xFC, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xF7,
  0xC0, 0x7C, 0xFC, 0x1F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x80, 0x0F, 0x1F, 0xC0, 0x3C, 0xFF, 0x80, 0xF7,
  0xFE, 0x03, 0xFD, 0xFC, 0x1F, 0xC1, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x81,
  0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3E, 0xFF, 0x80,
  0xF9, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x8F, 0x07, 0xFC, 0xF0,
  0xFF, 0xFF, 0x1F, 0xDF, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE7, 0xE0, 0x3E,
  0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x83,
  0xF8, 0xFF, 0xFF, 0x07, 0xFE, 0xF0, 0x7F, 0xDF, 0x03, 0xF9, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0x0F, 0x1F, 0x0F, 0x3F, 0x0F, 0x7F, 0x0F, 0xFF, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x01, 0xFF, 0x83, 0xFF,
  0xE1, 0xFF, 0xF1, 0xF8, 0x70, 0xF8, 0x08, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x60, 0x1F, 0x3F, 0x7F, 0x9F, 0xFF,
  0x8F, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x00, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x0F, 0xCF,
  0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8,
  0x7F, 0xEF, 0x07, 0xFC, 0xF0, 0x3F, 0x8F, 0x00, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0xF0, 0x3E, 0x1E, 0x07,
  0xC3, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7C,
  0x07, 0xCF, 0x80, 0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0xFF, 0xE0, 0x7E, 0x03, 0xEF, 0x81, 0xF8, 0x1F, 0x3E, 0x0F, 0xE0,
  0x7C, 0x78, 0x3F, 0x83, 0xE1, 0xE0, 0xEF, 0x0F, 0x87, 0x87, 0xBC, 0x3C,
  0x1E, 0x1E, 0xF1, 0xF0, 0x78, 0xF3, 0xC7, 0xC1, 0xE3, 0xCF, 0x3E, 0x07,
  0x9E, 0x3C, 0xF8, 0x1E, 0x78, 0xF7, 0xC0, 0x7B, 0xC3, 0xDF, 0x01, 0xEF,
  0x0F, 0x78, 0x07, 0xBC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0xFC, 0x03, 0xF1, 0xF8, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xEF, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0x87, 0xC0, 0x1F, 0x87, 0xC0, 0x3F,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x03, 0xC0, 0x7C, 0x03,
  0xC0, 0xF8, 0x03, 0xC0, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03,
  0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x01,
  0xEF, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x80,
  0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x07, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 29, 11, 1, -28 },
  { 41, 13, 10, 17, 4, -28 },
  { 58, 24, 28, 25, 1, -28 },
  { 142, 20, 32, 21, 1, -30 },
  { 222, 28, 28, 33, 3, -28 },
  { 320, 25, 28, 27, 1, -28 },
  { 408, 6, 10, 9, 4, -28 },
  { 416, 14, 34, 13, 1, -28 },
  { 476, 14, 34, 13, -3, -28 },
  { 536, 18, 19, 21, 4, -30 },
  { 579, 19, 19, 22, 2, -23 },
  { 625, 9, 10, 11, -2, -5 },
  { 637, 10, 5, 12, 1, -13 },
  { 644, 7, 7, 11, 0, -6 },
  { 651, 21, 28, 16, -2, -28 },
  { 725, 19, 28, 21, 2, -28 },
  { 792, 14, 28, 21, 4, -28 },
  { 841, 22, 28, 21, -1, -28 },
  { 918, 21, 28, 21, 0, -28 },
  { 992, 21, 28, 21, 0, -28 },
  { 1066, 20, 28, 21, 1, -28 },
  { 1136, 20, 28, 21, 2, -28 },
  { 1206, 21, 28, 21, 2, -28 },
  { 1280, 20, 28, 21, 1, -28 },
  { 1350, 19, 28, 21, 2, -28 },
  { 1417, 10, 23, 11, 0, -22 },
  { 1446, 12, 27, 11, -2, -22 },
  { 1487, 19, 20, 22, 2, -24 },
  { 1535, 19, 11, 22, 2, -19 },
  { 1562, 19, 20, 22, 2, -24 },
  { 1610, 16, 29, 17, 3, -28 },
  { 1668, 31, 32, 33, 2, -28 },
  { 1792, 23, 28, 24, -2, -28 },
  { 1873, 23, 28, 24, 1, -28 },
  { 1954, 23, 28, 24, 2, -28 },
  { 2035, 24, 28, 26, 1, -28 },
  { 2119, 21, 28, 21, 1, -28 },
  { 2193, 21, 28, 20, 1, -28 },
  { 2267, 24, 28, 27, 2, -28 },
  { 2351, 26, 28, 27, 1, -28 },
  { 2442, 17, 28, 14, -1, -28 },
  { 2502, 18, 36, 12, -6, -28 },
  { 2583, 26, 28, 23, 1, -28 },
  { 2674, 16, 28, 20, 1, -28 },
  { 2730, 33, 28, 34, 1, -28 },
  { 2846, 28, 28, 29, 1, -28 },
  { 2944, 25, 28, 28, 2, -28 },
  { 3032, 22, 28, 23, 1, -28 },
  { 3109, 25, 35, 28, 2, -28 },
  { 3219, 22, 28, 23, 1, -28 },
  { 3296, 20, 28, 20, 1, -28 },
  { 3366, 20, 28, 20, 3, -28 },
  { 3436, 24, 28, 27, 3, -28 },
  { 3520, 22, 28, 22, 4, -28 },
  { 3597, 34, 28, 34, 4, -28 },
  { 3716, 28, 28, 23, -2, -28 },
  { 3814, 21, 28, 21, 4, -28 },
  { 3888, 24, 28, 21, -1, -28 },
  { 3972, 16, 34, 12, -1, -28 },
  { 4040, 9, 28, 16, 4, -28 },
  { 4072, 16, 34, 12, -3, -28 },
  { 4140, 20, 18, 22, 1, -28 },
  { 4185, 17, 2, 16, -4, 4 },
  { 4190, 7, 6, 12, 6, -30 },
  { 4196, 20, 22, 23, 2, -22 },
  { 4251, 20, 30, 23, 1, -30 },
  { 4326, 17, 22, 18, 2, -22 },
  { 4373, 22, 30, 23, 2, -30 },
  { 4456, 18, 22, 21, 2, -22 },
  { 4506, 22, 39, 14, -4, -30 },
  { 4614, 21, 31, 23, 1, -22 },
  { 4696, 20, 30, 23, 1, -30 },
  { 4771, 11, 29, 11, 1, -29 },
  { 4811, 17, 38, 11, -5, -29 },
  { 4892, 22, 30, 21, 1, -30 },
  { 4975, 11, 30, 11, 1, -30 },
  { 5017, 32, 22, 35, 1, -22 },
  { 5105, 20, 22, 23, 1, -22 },
  { 5160, 19, 21, 23, 2, -21 },
  { 5210, 22, 31, 23, -1, -22 },
  { 5296, 20, 31, 23, 2, -22 },
  { 5374, 16, 22, 16, 1, -22 },
  { 5418, 17, 22, 18, 0, -22 },
  { 5465, 14, 26, 15, 2, -26 },
  { 5511, 20, 21, 23, 2, -21 },
  { 5564, 19, 21, 19, 2, -21 },
  { 5614, 30, 21, 30, 2, -21 },
  { 5693, 24, 21, 20, -2, -21 },
  { 5756, 24, 30, 19, -3, -21 },
  { 5846, 19, 21, 18, -1, -21 },
  { 5896, 16, 34, 14, 0, -28 },
  { 5964, 4, 39, 21, 9, -30 },
  { 5984, 16, 34, 14, -2, -28 },
  { 6052, 19, 6, 22, 2, -17 },
};

const GFXfont NotoSans_SemiBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMIBOLDITALIC39PT7B_H_
