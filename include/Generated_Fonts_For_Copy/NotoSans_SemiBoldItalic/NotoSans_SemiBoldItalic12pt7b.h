#ifndef _NOTOSANS_SEMIBOLDITALIC12PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x64, 0x04, 0xC0, 0x5D, 0x9A, 0x1A, 0x12, 0x14, 0x7F,
  0x24, 0x24, 0xFE, 0x68, 0x58, 0x08, 0xF6, 0xDC, 0x38, 0x71, 0xFE, 0x20,
  0x80, 0x61, 0x79, 0x25, 0x17, 0x8A, 0xF2, 0xAC, 0x94, 0xCA, 0xC7, 0x00,
  0x1C, 0x34, 0x26, 0x3C, 0x30, 0x7B, 0xCE, 0xCC, 0x7F, 0x7A, 0x19, 0x88,
  0xC4, 0x23, 0x18, 0x42, 0x10, 0x31, 0x11, 0x11, 0x13, 0x26, 0xC0, 0x13,
  0x47, 0xDC, 0xD0, 0x60, 0x21, 0x3E, 0x42, 0x10, 0x6B, 0x00, 0xF0, 0x70,
  0x06, 0x08, 0x30, 0x41, 0x06, 0x08, 0x30, 0xC0, 0x18, 0xF6, 0x51, 0x45,
  0x1C, 0xD2, 0x78, 0x19, 0xB4, 0x23, 0x18, 0x84, 0x60, 0x19, 0xF0, 0x41,
  0x0C, 0x62, 0x31, 0xF8, 0x19, 0xF0, 0x43, 0x38, 0x30, 0xE3, 0xF8, 0x04,
  0x31, 0x4F, 0x6D, 0x2F, 0xC6, 0x18, 0x3E, 0x78, 0x83, 0x07, 0x81, 0x83,
  0x46, 0xF8, 0x1D, 0xE4, 0x34, 0xFA, 0x28, 0xA6, 0xF0, 0xFF, 0xF0, 0x86,
  0x30, 0x86, 0x10, 0xC0, 0x18, 0x78, 0x99, 0x23, 0x8D, 0xB3, 0x66, 0x78,
  0x33, 0xF3, 0x1D, 0xB4, 0x66, 0xE0, 0x2C, 0x00, 0xB0, 0x13, 0x00, 0x00,
  0x64, 0xC0, 0x09, 0xB1, 0xC1, 0x84, 0xF8, 0x3E, 0xC3, 0x86, 0x7E, 0x40,
  0x77, 0xC6, 0x26, 0x20, 0x18, 0xC0, 0x0C, 0x19, 0x90, 0x73, 0xDA, 0x4D,
  0x26, 0xB5, 0x6C, 0xC0, 0x3E, 0x00, 0x06, 0x0E, 0x0A, 0x1A, 0x12, 0x3E,
  0x3E, 0x62, 0xC3, 0x38, 0x7C, 0x89, 0x37, 0x8C, 0xD1, 0xA6, 0xF8, 0x1C,
  0xFD, 0x06, 0x08, 0x10, 0x20, 0x64, 0x78, 0x38, 0x3E, 0x23, 0x23, 0x63,
  0x62, 0x46, 0x4C, 0xF8, 0x3E, 0x7C, 0x81, 0x07, 0xCC, 0x10, 0x20, 0xF8,
  0x3E, 0x7C, 0x81, 0x07, 0xCF, 0x90, 0x20, 0xC0, 0x1C, 0xFD, 0x06, 0x08,
  0xF3, 0xA1, 0x66, 0x7C, 0x31, 0x31, 0x23, 0x23, 0x7E, 0x62, 0x42, 0x46,
  0xC6, 0x79, 0x8C, 0x42, 0x31, 0x8C, 0xE0, 0x0C, 0x30, 0x82, 0x18, 0x61,
  0x84, 0x10, 0xCE, 0x00, 0x33, 0x26, 0x24, 0x28, 0x78, 0x78, 0x48, 0x4C,
  0xC4, 0x31, 0x08, 0x46, 0x31, 0x08, 0xF8, 0x30, 0xCC, 0x33, 0x14, 0xC7,
  0x7A, 0xD6, 0xA4, 0xC9, 0x32, 0xC9, 0x80, 0x30, 0x98, 0xCE, 0x45, 0x26,
  0x93, 0x79, 0x1C, 0x8C, 0xC6, 0x00, 0x18, 0xFD, 0x0E, 0x18, 0x30, 0x61,
  0xE6, 0x78, 0x38, 0x7C, 0x89, 0x16, 0xEF, 0x10, 0x20, 0xC0, 0x1C, 0xFD,
  0x0E, 0x18, 0x30, 0x61, 0xE6, 0x78, 0x30, 0x30, 0x38, 0x7C, 0x99, 0x37,
  0xCF, 0x13, 0x26, 0xC6, 0x1C, 0xF6, 0x18, 0x30, 0x60, 0xA2, 0xF8, 0xFF,
  0xF3, 0x08, 0x21, 0x86, 0x18, 0x40, 0x62, 0x85, 0x1E, 0x3C, 0x58, 0xA3,
  0x66, 0x78, 0xC7, 0x8B, 0x36, 0x4D, 0x8A, 0x1C, 0x30, 0x60, 0xC4, 0x79,
  0x8B, 0x33, 0x6E, 0x4D, 0x59, 0xEA, 0x39, 0x47, 0x30, 0xC6, 0x00, 0x31,
  0x89, 0x86, 0x83, 0xC0, 0xC0, 0xE0, 0xD0, 0xCC, 0xC6, 0x00, 0xC7, 0x99,
  0x22, 0xC7, 0x0C, 0x18, 0x30, 0x40, 0x3E, 0xFC, 0x30, 0xC1, 0x06, 0x18,
  0x62, 0xF8, 0x39, 0x88, 0xC4, 0x21, 0x08, 0xC4, 0x38, 0xD9, 0x24, 0x9B,
  0x20, 0x39, 0xC6, 0x21, 0x08, 0xC4, 0x21, 0x38, 0x10, 0x62, 0x8A, 0x47,
  0x10, 0xF8, 0xD0, 0x25, 0xFC, 0xA2, 0x9A, 0x6F, 0x80, 0x30, 0x40, 0xA3,
  0xE6, 0x68, 0x91, 0x26, 0xF8, 0x33, 0xF1, 0x08, 0x4B, 0xC0, 0x04, 0x12,
  0xDF, 0xCA, 0x29, 0xA6, 0xF8, 0x33, 0xF3, 0xE8, 0x47, 0xC0, 0x0E, 0x30,
  0x71, 0xC3, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x86, 0x00, 0x12, 0x7D, 0x92,
  0x24, 0xC9, 0x9F, 0x04, 0x99, 0xE0, 0x30, 0x40, 0xB3, 0xE6, 0x6C, 0x91,
  0x26, 0xCC, 0x32, 0x26, 0x66, 0x44, 0xC0, 0x0C, 0x20, 0x86, 0x18, 0x61,
  0x04, 0x30, 0xC2, 0x38, 0x30, 0x40, 0x9B, 0x67, 0x8E, 0x1E, 0x2C, 0xCC,
  0x32, 0x26, 0x66, 0x44, 0xC0, 0x28, 0x9F, 0x76, 0x65, 0x93, 0x4C, 0xD3,
  0x2C, 0xC8, 0x2C, 0xF9, 0x9B, 0x24, 0x49, 0xB3, 0x00, 0x33, 0xF3, 0x18,
  0xCF, 0xC0, 0x28, 0xF9, 0x9A, 0x24, 0x49, 0xBE, 0x60, 0x81, 0x00, 0x25,
  0xFC, 0xA2, 0x9A, 0x6F, 0x84, 0x10, 0xC0, 0x2B, 0xD8, 0xC4, 0x23, 0x00,
  0x33, 0xD0, 0xE1, 0xCF, 0xC0, 0x67, 0xFC, 0xC8, 0x8E, 0x4F, 0x3C, 0xA2,
  0x9A, 0x6F, 0x80, 0x8E, 0x69, 0xAC, 0xA2, 0x8C, 0x00, 0x99, 0xCC, 0xAE,
  0xD5, 0x4A, 0xE6, 0x63, 0x30, 0x33, 0x36, 0x1C, 0x18, 0x18, 0x2C, 0xE4,
  0x23, 0x26, 0x26, 0x2C, 0x38, 0x38, 0x30, 0x30, 0x60, 0xC0, 0x7D, 0xE1,
  0x8C, 0x63, 0x2F, 0x00, 0x09, 0xCC, 0x42, 0x61, 0x88, 0x42, 0x18, 0xFF,
  0xF0, 0x21, 0x84, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0xFC, 0xC0,
};

const GFXglyph NotoSans_SemiBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 4, 4, 5, 1, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 6, 10, 7, 0, -9 },
  { 25, 9, 9, 10, 1, -9 },
  { 36, 8, 9, 8, 0, -9 },
  { 45, 2, 4, 3, 1, -9 },
  { 46, 5, 11, 4, 0, -9 },
  { 53, 4, 11, 4, -1, -9 },
  { 59, 6, 6, 7, 1, -9 },
  { 64, 5, 6, 7, 1, -7 },
  { 68, 3, 3, 3, -1, -1 },
  { 70, 4, 1, 4, 0, -4 },
  { 71, 2, 2, 3, 0, -2 },
  { 72, 7, 9, 5, -1, -9 },
  { 80, 6, 9, 7, 0, -9 },
  { 87, 5, 9, 7, 1, -9 },
  { 93, 6, 9, 7, 0, -9 },
  { 100, 6, 9, 7, 0, -9 },
  { 107, 6, 9, 7, 0, -9 },
  { 114, 7, 9, 7, 0, -9 },
  { 122, 6, 9, 7, 1, -9 },
  { 129, 6, 9, 7, 1, -9 },
  { 136, 7, 9, 7, 0, -9 },
  { 144, 5, 9, 7, 1, -9 },
  { 150, 3, 7, 3, 0, -7 },
  { 153, 4, 9, 3, -1, -7 },
  { 158, 5, 6, 7, 1, -7 },
  { 162, 5, 3, 7, 1, -6 },
  { 164, 5, 6, 7, 1, -7 },
  { 168, 5, 9, 5, 1, -9 },
  { 174, 9, 10, 10, 1, -9 },
  { 186, 8, 9, 7, -1, -9 },
  { 195, 7, 9, 7, 0, -9 },
  { 203, 7, 9, 7, 1, -9 },
  { 211, 8, 9, 8, 0, -9 },
  { 220, 7, 9, 6, 0, -9 },
  { 228, 7, 9, 6, 0, -9 },
  { 236, 7, 9, 8, 1, -9 },
  { 244, 8, 9, 8, 0, -9 },
  { 253, 5, 9, 4, 0, -9 },
  { 259, 6, 11, 4, -2, -9 },
  { 268, 8, 9, 7, 0, -9 },
  { 277, 5, 9, 6, 0, -9 },
  { 283, 10, 9, 10, 0, -9 },
  { 295, 9, 9, 9, 0, -9 },
  { 306, 7, 9, 9, 1, -9 },
  { 314, 7, 9, 7, 0, -9 },
  { 322, 7, 11, 9, 1, -9 },
  { 332, 7, 9, 7, 0, -9 },
  { 340, 6, 9, 6, 0, -9 },
  { 347, 6, 9, 6, 1, -9 },
  { 354, 7, 9, 8, 1, -9 },
  { 362, 7, 9, 7, 1, -9 },
  { 370, 11, 9, 11, 1, -9 },
  { 383, 9, 9, 7, -1, -9 },
  { 394, 7, 9, 7, 1, -9 },
  { 402, 7, 9, 6, 0, -9 },
  { 410, 5, 11, 4, 0, -9 },
  { 417, 3, 9, 5, 1, -9 },
  { 421, 5, 11, 4, -1, -9 },
  { 428, 6, 6, 7, 0, -9 },
  { 433, 5, 1, 5, -1, 1 },
  { 434, 2, 2, 4, 2, -9 },
  { 435, 6, 7, 7, 1, -7 },
  { 441, 7, 9, 7, 0, -9 },
  { 449, 5, 7, 6, 1, -7 },
  { 454, 6, 9, 7, 1, -9 },
  { 461, 5, 7, 6, 1, -7 },
  { 466, 7, 12, 4, -1, -9 },
  { 477, 7, 10, 7, 0, -7 },
  { 486, 7, 9, 7, 0, -9 },
  { 494, 4, 9, 3, 0, -9 },
  { 499, 6, 12, 3, -2, -9 },
  { 508, 7, 9, 6, 0, -9 },
  { 516, 4, 9, 3, 0, -9 },
  { 521, 10, 7, 11, 0, -7 },
  { 530, 7, 7, 7, 0, -7 },
  { 537, 5, 7, 7, 1, -7 },
  { 542, 7, 10, 7, 0, -7 },
  { 551, 6, 10, 7, 1, -7 },
  { 559, 5, 7, 5, 0, -7 },
  { 564, 5, 7, 6, 0, -7 },
  { 569, 4, 8, 5, 1, -8 },
  { 573, 6, 7, 7, 1, -7 },
  { 579, 6, 7, 6, 1, -7 },
  { 585, 9, 7, 9, 1, -7 },
  { 593, 8, 7, 6, -1, -7 },
  { 600, 8, 10, 6, -1, -7 },
  { 610, 6, 7, 6, 0, -7 },
  { 616, 5, 11, 4, 0, -9 },
  { 623, 1, 12, 7, 3, -9 },
  { 625, 5, 11, 4, -1, -9 },
  { 632, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_SemiBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMIBOLDITALIC12PT7B_H_
