#ifndef _NOTOSANS_SEMIBOLDITALIC31PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x0F,
  0x83, 0xC0, 0x79, 0xEF, 0x39, 0xC7, 0x38, 0xE7, 0x39, 0xC7, 0x38, 0xE7,
  0x1C, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x07, 0x0E, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xE1,
  0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC1, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE7, 0xFF, 0xFC, 0x1C, 0x30, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x38,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x1E, 0xE6, 0x3C, 0xC0, 0x3C, 0xC0,
  0x3C, 0xC0, 0x1E, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xBC, 0x03, 0x3C, 0x03, 0x3C, 0x83, 0x3C, 0xFB, 0xF8, 0xFF, 0xF8,
  0xFF, 0xE0, 0x1F, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1F, 0x80,
  0x78, 0x7F, 0x80, 0xE1, 0xEF, 0x03, 0x83, 0x8E, 0x0E, 0x07, 0x1C, 0x1C,
  0x1E, 0x38, 0x70, 0x38, 0x71, 0xC0, 0x70, 0xE7, 0x00, 0xE3, 0xCE, 0x61,
  0xC7, 0x3B, 0xFB, 0xDE, 0xEF, 0xF3, 0xFB, 0x9E, 0xF7, 0xE7, 0x79, 0xE0,
  0x1C, 0xE3, 0xC0, 0x71, 0xC7, 0x81, 0xE3, 0x8E, 0x03, 0x8F, 0x1C, 0x0E,
  0x1E, 0x38, 0x38, 0x3C, 0xE0, 0xF0, 0x3F, 0xC1, 0xC0, 0x7F, 0x0F, 0x00,
  0x7C, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x70, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0x73, 0xE0, 0x07, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x0F, 0x3F, 0xF1, 0xE7, 0x8F,
  0x1E, 0xF0, 0x7B, 0xCF, 0x07, 0xF8, 0xF0, 0x3F, 0x8F, 0x01, 0xF0, 0xF8,
  0x7F, 0x07, 0xFF, 0xF8, 0x7F, 0xF7, 0x81, 0xFC, 0x3E, 0x7B, 0xDC, 0xE7,
  0x73, 0x9C, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x81,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x03, 0x80, 0x07, 0x02,
  0x1C, 0x06, 0x38, 0x1F, 0x70, 0x3F, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x3F,
  0x00, 0xF7, 0x03, 0xCE, 0x07, 0x9E, 0x02, 0x1C, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x3E, 0x78, 0xF3, 0xC7, 0x8E, 0x38, 0x70, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFE, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x1E, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x78, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xF0, 0x3E,
  0x0F, 0xE3, 0xFE, 0xFF, 0xE7, 0x9C, 0x73, 0xC2, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFF,
  0xC1, 0xC1, 0xE0, 0x40, 0xF8, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0xC1, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3E,
  0x03, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x30, 0x1F, 0x1F, 0xFF, 0x8F,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0xB8, 0x07, 0xBC, 0x07, 0x9E, 0x07,
  0x8F, 0x03, 0x87, 0x03, 0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE3, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x18, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0xC0, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x01,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x73, 0xF1, 0xEF, 0xF3, 0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDE,
  0x07, 0xB8, 0x0F, 0x70, 0x1E, 0xE0, 0x79, 0xE0, 0xF3, 0xC3, 0xC3, 0xFF,
  0x87, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x7C, 0x07, 0xF8, 0x07, 0xE0, 0x1F,
  0xF0, 0x3E, 0x78, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0,
  0x3C, 0xF8, 0x3C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F,
  0xF8, 0x7F, 0xF9, 0xF0, 0xF3, 0xC1, 0xE7, 0x03, 0xDE, 0x03, 0xBC, 0x0F,
  0x78, 0x1E, 0xF0, 0x7D, 0xF1, 0xF9, 0xFF, 0xF1, 0xFD, 0xE1, 0xF3, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF2, 0x07, 0xC7, 0xFF, 0x0F, 0xFC,
  0x1F, 0xE0, 0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0x78, 0x03, 0xC1, 0xF0, 0x7C,
  0x1E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xC0, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3E, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x1F, 0x00,
  0x38, 0x00, 0x40, 0x00, 0x1F, 0xE3, 0xFF, 0x9F, 0xFC, 0x60, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0x7F, 0x00, 0xF8, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x70,
  0x7F, 0x0E, 0x70, 0xFF, 0xC7, 0x38, 0xF9, 0xC3, 0xB8, 0x70, 0xE1, 0xDC,
  0x70, 0x70, 0xEE, 0x38, 0x38, 0x77, 0x1C, 0x38, 0x3F, 0x1C, 0x1C, 0x3B,
  0x8E, 0x0E, 0x1C, 0xE7, 0x8F, 0x1C, 0x71, 0xFD, 0xFE, 0x38, 0xFE, 0xFE,
  0x1C, 0x1C, 0x3C, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x06,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00,
  0xF7, 0x00, 0x3C, 0xE0, 0x07, 0x9C, 0x01, 0xE3, 0x80, 0x3C, 0x78, 0x0F,
  0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1E, 0x01, 0xC3, 0xC0, 0x38, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80,
  0x1F, 0xF0, 0x03, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C,
  0x3F, 0x0F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F,
  0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xF8, 0x3C, 0x1F, 0x0F, 0x03, 0xC3,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC7, 0x87, 0xE1, 0xFF,
  0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7E, 0x06, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xE0,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0x87, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x3C, 0x78, 0x0F,
  0x8F, 0x03, 0xE1, 0xE7, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x02, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xE0, 0x61, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0xFF, 0x78, 0x3F, 0xCF, 0x07, 0xF9, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x3C, 0xF8, 0x0F, 0x0F, 0x01, 0xE1, 0xF8, 0x3C, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x07, 0x80, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0,
  0x3C, 0x1E, 0x01, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xF0, 0x78,
  0x07, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x1F,
  0xE0, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0x81,
  0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x01, 0xE1,
  0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0x78, 0x07,
  0x87, 0x80, 0x78, 0x7C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x03, 0xE0,
  0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x02,
  0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F,
  0xE1, 0xFC, 0x07, 0x78, 0x7F, 0x83, 0xDC, 0x1C, 0xE0, 0xEF, 0x07, 0x38,
  0x7B, 0xC3, 0xCE, 0x1C, 0xF0, 0xF3, 0x8F, 0x3C, 0x3C, 0xE3, 0x8E, 0x0E,
  0x39, 0xE7, 0x83, 0x8E, 0x71, 0xE1, 0xE3, 0xBC, 0x78, 0x78, 0xEE, 0x1C,
  0x1C, 0x3F, 0x07, 0x07, 0x0F, 0xC3, 0xC3, 0xC3, 0xE0, 0xF0, 0xF0, 0x78,
  0x3C, 0x3C, 0x1C, 0x0E, 0x00, 0x0F, 0x80, 0x3C, 0x3F, 0x00, 0xF0, 0xFC,
  0x03, 0xC3, 0xF0, 0x0E, 0x0F, 0xE0, 0x78, 0x7F, 0x81, 0xE1, 0xEE, 0x07,
  0x87, 0xBC, 0x1C, 0x1C, 0xF0, 0x70, 0x71, 0xC3, 0xC3, 0xC7, 0x8F, 0x0F,
  0x1E, 0x3C, 0x3C, 0x38, 0xE0, 0xE0, 0xF3, 0x83, 0x83, 0xDE, 0x1E, 0x07,
  0x78, 0x78, 0x1F, 0xE1, 0xE0, 0x7F, 0x07, 0x00, 0xFC, 0x3C, 0x03, 0xF0,
  0xF0, 0x0F, 0xC3, 0xC0, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC1, 0xF8, 0x7E, 0x1E, 0x03, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7,
  0x80, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF8, 0x07,
  0xC7, 0x80, 0xF8, 0x7E, 0x1F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x3E, 0x0F, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xE3,
  0xC7, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xF8,
  0x7E, 0x1E, 0x03, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1F, 0x78,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF8, 0x07, 0xC7, 0x80, 0xF8,
  0x7E, 0x3F, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x0F,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x0F, 0x8F, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x1E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF8, 0x03, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x04, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x80, 0x78, 0xC1, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80,
  0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x81, 0xE0, 0x7C,
  0x3E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0xF0, 0x07, 0xFC,
  0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03,
  0xC1, 0xC0, 0xF0, 0x70, 0x78, 0x1C, 0x1E, 0x07, 0x0F, 0x01, 0xC3, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x01, 0xFE, 0x03, 0xC0, 0x7B, 0xC0, 0xF8, 0x0F, 0x78, 0x1F, 0x01,
  0xCF, 0x03, 0xE0, 0x79, 0xE0, 0xFC, 0x0F, 0x3C, 0x1F, 0xC3, 0xC7, 0x87,
  0xF8, 0x78, 0xF0, 0xEF, 0x1E, 0x1E, 0x3D, 0xE3, 0xC3, 0xC7, 0x3C, 0x70,
  0x79, 0xE3, 0x9E, 0x0F, 0x38, 0x73, 0x81, 0xEF, 0x0E, 0xF0, 0x3D, 0xC1,
  0xDE, 0x03, 0xB8, 0x3B, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x78,
  0x7C, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F,
  0x00, 0x3C, 0x3E, 0x01, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x7C, 0x07, 0xC3,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0xF8, 0x0F, 0x9C, 0x07, 0x8F, 0x07, 0x87,
  0x87, 0xC3, 0xC3, 0xC0, 0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3F,
  0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xFE, 0x0F, 0xE0, 0xFC, 0x00,
  0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC7,
  0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF0, 0xE1, 0xC0, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x77, 0x00, 0xEE,
  0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x38, 0x70, 0x38, 0xE0, 0x73, 0x80, 0xE7,
  0x00, 0xFC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xF9, 0xE3, 0x87, 0x1C,
  0x03, 0xE7, 0x87, 0xFB, 0x87, 0xFD, 0xC3, 0xE7, 0xE3, 0xE1, 0xF1, 0xE0,
  0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x87, 0xC3, 0xC7, 0xE1, 0xFF, 0xF0, 0xFF, 0x70, 0x3F, 0x38,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x78, 0x1E, 0xFE, 0x1D, 0xFE, 0x1F, 0x1F, 0x3E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x3C, 0xFC, 0x7C, 0xFF, 0xF8, 0xEF, 0xF0, 0xE7,
  0xE0, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0x8F, 0xC2, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F,
  0x9E, 0x0F, 0xF7, 0x07, 0xFF, 0xC1, 0xE3, 0xF0, 0xF0, 0x7C, 0x7C, 0x1E,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x0F, 0x0F,
  0x03, 0xC3, 0xC1, 0xF0, 0x78, 0xFC, 0x1F, 0xFF, 0x07, 0xFB, 0x80, 0xFC,
  0xE0, 0x03, 0xF8, 0x0F, 0xF8, 0x7F, 0xF0, 0xF0, 0xF3, 0xC1, 0xEF, 0x83,
  0xDE, 0x0F, 0x3F, 0xFE, 0x7F, 0xF1, 0xFF, 0x83, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x02, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF2, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x9E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE7, 0x87, 0xFB, 0x87,
  0xFD, 0xC7, 0xE7, 0xE3, 0xC1, 0xF3, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x87, 0xC3, 0xC7,
  0xE1, 0xFF, 0xF0, 0xFF, 0x70, 0x3F, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x08, 0x0F, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x7C, 0x1E, 0xFE, 0x1D, 0xFE, 0x1F, 0x9F, 0x3E, 0x0F, 0x3E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x0F,
  0x0F, 0x06, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x1F, 0x1E, 0x1F, 0x0F, 0x1F, 0x07, 0x1F, 0x07, 0x9F, 0x03,
  0xDF, 0x01, 0xEF, 0x00, 0xEF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xF0,
  0x1E, 0x78, 0x0E, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE1, 0xE0,
  0xF8, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0x1C, 0x7C, 0x3E, 0x0E, 0x7F, 0x3F, 0x87, 0x7F,
  0xBF, 0xE3, 0xF3, 0xF8, 0xF3, 0xE0, 0xF8, 0x79, 0xF0, 0x78, 0x3C, 0xF0,
  0x7C, 0x1E, 0x78, 0x3C, 0x0F, 0x78, 0x1E, 0x07, 0x3C, 0x0F, 0x07, 0x9E,
  0x07, 0x03, 0xCF, 0x07, 0x81, 0xE7, 0x83, 0xC0, 0xF7, 0x81, 0xE0, 0x73,
  0xC0, 0xF0, 0x79, 0xE0, 0x70, 0x3C, 0xF0, 0x78, 0x1E, 0x00, 0x1C, 0x7C,
  0x1C, 0xFE, 0x1D, 0xFF, 0x3F, 0x9F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F,
  0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0x03, 0xF0, 0x1F, 0xF8,
  0x7F, 0xF1, 0xF1, 0xF3, 0xC1, 0xEF, 0x83, 0xDE, 0x03, 0xBC, 0x0F, 0x78,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x83, 0xCF, 0x0F, 0x9F, 0xFE,
  0x1F, 0xF8, 0x1F, 0xC0, 0x07, 0x1E, 0x01, 0xDF, 0xE0, 0x7F, 0xF8, 0x1F,
  0x1F, 0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x1E, 0x03,
  0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x0F, 0xC7, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3D, 0xF8, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE7,
  0x87, 0xFB, 0x87, 0xFF, 0xC3, 0xE7, 0xE3, 0xC1, 0xF1, 0xE0, 0xF1, 0xE0,
  0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x07, 0xC3, 0xC7, 0xE1, 0xFF, 0xF0, 0xFF, 0x70, 0x3F, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x1C, 0x78, 0xE7, 0xC7, 0x7C, 0x3F, 0xE3, 0xF0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0xF1, 0xFF, 0x8F, 0x06,
  0x3C, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF2, 0x03, 0xCF, 0xFE, 0x3F, 0xF8, 0x7F, 0x80, 0x07,
  0x00, 0x70, 0x0E, 0x01, 0xFF, 0x7F, 0xEF, 0xFE, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF1, 0xF8, 0xFF, 0xF8, 0xFF,
  0x78, 0x7E, 0x70, 0xE0, 0x1F, 0xC0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07,
  0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0x71, 0xE0, 0xE7, 0x81, 0xCE, 0x03,
  0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xE0,
  0x78, 0x1F, 0xE0, 0xF0, 0x3F, 0xC3, 0xE0, 0xF7, 0x87, 0xC1, 0xEF, 0x1D,
  0x87, 0x9E, 0x3B, 0x8F, 0x3C, 0xF7, 0x3C, 0x79, 0xCE, 0x78, 0xF7, 0x9D,
  0xE1, 0xEE, 0x3B, 0xC3, 0xDC, 0x77, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x1E, 0x00,
  0x1F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x1E, 0x78, 0x07, 0xBE, 0x00,
  0xEF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0x9E, 0x03, 0xC3, 0xC1, 0xE0, 0xF0,
  0xF8, 0x1E, 0x00, 0x0E, 0x01, 0xE1, 0xC0, 0x78, 0x3C, 0x0F, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x38, 0xF0, 0x07, 0x1E,
  0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x03, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x3F,
  0x00, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0xF8, 0x0F, 0xC0, 0x3C, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x3C, 0x03, 0xF0,
  0x0F, 0x07, 0xE0, 0xF8, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0xF8, 0x0F, 0x80, 0xE0, 0x00, 0x7E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 22, 9, 0, -22 },
  { 26, 11, 8, 13, 3, -22 },
  { 37, 19, 22, 20, 1, -22 },
  { 90, 16, 26, 17, 1, -24 },
  { 142, 23, 22, 26, 2, -22 },
  { 206, 20, 22, 22, 1, -22 },
  { 261, 5, 8, 8, 3, -22 },
  { 266, 11, 27, 10, 1, -22 },
  { 304, 11, 27, 10, -2, -22 },
  { 342, 15, 15, 17, 3, -24 },
  { 371, 15, 15, 18, 2, -18 },
  { 400, 7, 8, 9, -1, -4 },
  { 407, 8, 3, 10, 1, -10 },
  { 410, 5, 4, 9, 0, -4 },
  { 413, 16, 22, 12, -1, -22 },
  { 457, 16, 22, 17, 1, -22 },
  { 501, 12, 22, 17, 3, -22 },
  { 534, 17, 22, 17, 0, -22 },
  { 581, 17, 22, 17, 0, -22 },
  { 628, 17, 22, 17, 0, -22 },
  { 675, 16, 22, 17, 1, -22 },
  { 719, 15, 22, 17, 2, -22 },
  { 761, 16, 22, 17, 2, -22 },
  { 805, 16, 22, 17, 1, -22 },
  { 849, 15, 22, 17, 1, -22 },
  { 891, 8, 17, 9, 0, -17 },
  { 908, 10, 21, 9, -2, -17 },
  { 935, 15, 16, 18, 2, -19 },
  { 965, 15, 9, 18, 2, -15 },
  { 982, 15, 16, 18, 2, -19 },
  { 1012, 13, 22, 14, 2, -22 },
  { 1048, 25, 25, 26, 1, -22 },
  { 1127, 19, 22, 19, -2, -22 },
  { 1180, 18, 22, 19, 1, -22 },
  { 1230, 18, 22, 19, 2, -22 },
  { 1280, 19, 22, 21, 1, -22 },
  { 1333, 17, 22, 16, 1, -22 },
  { 1380, 17, 22, 16, 1, -22 },
  { 1427, 19, 22, 21, 2, -22 },
  { 1480, 21, 22, 21, 1, -22 },
  { 1538, 14, 22, 11, -1, -22 },
  { 1577, 15, 28, 10, -5, -22 },
  { 1630, 20, 22, 18, 1, -22 },
  { 1685, 13, 22, 16, 1, -22 },
  { 1721, 26, 22, 27, 1, -22 },
  { 1793, 22, 22, 23, 1, -22 },
  { 1854, 20, 22, 23, 2, -22 },
  { 1909, 18, 22, 18, 1, -22 },
  { 1959, 20, 27, 23, 2, -22 },
  { 2027, 17, 22, 19, 1, -22 },
  { 2074, 16, 22, 16, 1, -22 },
  { 2118, 16, 22, 16, 3, -22 },
  { 2162, 20, 22, 21, 2, -22 },
  { 2217, 18, 22, 18, 3, -22 },
  { 2267, 27, 22, 27, 3, -22 },
  { 2342, 22, 22, 18, -2, -22 },
  { 2403, 17, 22, 17, 3, -22 },
  { 2450, 19, 22, 17, -1, -22 },
  { 2503, 12, 27, 10, 0, -22 },
  { 2544, 7, 22, 12, 3, -22 },
  { 2564, 12, 27, 10, -2, -22 },
  { 2605, 15, 14, 17, 1, -22 },
  { 2632, 13, 2, 12, -3, 3 },
  { 2636, 6, 5, 10, 4, -24 },
  { 2640, 17, 17, 18, 1, -17 },
  { 2677, 16, 24, 18, 1, -24 },
  { 2725, 14, 17, 15, 1, -17 },
  { 2755, 18, 24, 18, 1, -24 },
  { 2809, 15, 17, 17, 1, -17 },
  { 2841, 18, 31, 11, -3, -24 },
  { 2911, 17, 24, 18, 1, -17 },
  { 2962, 16, 24, 18, 1, -24 },
  { 3010, 8, 23, 9, 1, -23 },
  { 3033, 13, 30, 9, -4, -23 },
  { 3082, 17, 24, 17, 1, -24 },
  { 3133, 9, 24, 9, 1, -24 },
  { 3160, 25, 17, 28, 1, -17 },
  { 3214, 16, 17, 18, 1, -17 },
  { 3248, 15, 17, 18, 1, -17 },
  { 3280, 18, 24, 18, -1, -17 },
  { 3334, 17, 24, 18, 1, -17 },
  { 3385, 13, 17, 13, 1, -17 },
  { 3413, 14, 17, 14, 0, -17 },
  { 3443, 12, 20, 12, 1, -20 },
  { 3473, 16, 17, 18, 2, -17 },
  { 3507, 15, 17, 15, 2, -17 },
  { 3539, 23, 17, 24, 2, -17 },
  { 3588, 18, 17, 16, -1, -17 },
  { 3627, 19, 24, 15, -2, -17 },
  { 3684, 15, 17, 14, -1, -17 },
  { 3716, 13, 27, 11, 0, -22 },
  { 3760, 3, 31, 17, 7, -24 },
  { 3772, 12, 27, 11, -1, -22 },
  { 3813, 15, 4, 18, 2, -13 },
};

const GFXfont NotoSans_SemiBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMIBOLDITALIC31PT7B_H_
