#ifndef _NOTOSANS_SEMIBOLDITALIC56PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x3F,
  0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0x1F, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0x9E, 0x1C, 0x0F, 0xF1, 0xE0, 0x40, 0xFE, 0x1C, 0x00, 0x0F, 0xE3,
  0xC0, 0x00, 0xFE, 0x3C, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0xFF, 0x3C, 0x00,
  0x0F, 0xFB, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xE7, 0xF8, 0x00,
  0x1E, 0x3F, 0x80, 0x01, 0xE3, 0xF8, 0x00, 0x1E, 0x1F, 0x80, 0x01, 0xE3,
  0xF8, 0x80, 0x1C, 0x3F, 0x8E, 0x03, 0xC7, 0xF8, 0xFC, 0x3D, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E,
  0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x01, 0xFF,
  0xF8, 0x00, 0x7E, 0x01, 0xFE, 0xFE, 0x00, 0x3E, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x7E, 0x0F,
  0x80, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x0F, 0xC0, 0x00,
  0xF8, 0x1F, 0x87, 0xC0, 0xC0, 0x7C, 0x0F, 0xC7, 0xE3, 0xFC, 0x3E, 0x0F,
  0xC7, 0xE7, 0xFF, 0x9F, 0x8F, 0xE7, 0xE7, 0xFF, 0xCF, 0xEF, 0xE3, 0xE7,
  0xFF, 0xF7, 0xFF, 0xE3, 0xF3, 0xFB, 0xF9, 0xFF, 0xF3, 0xF3, 0xF8, 0xFC,
  0x7F, 0xF3, 0xF1, 0xF8, 0x3E, 0x1F, 0xE1, 0xF1, 0xF8, 0x1F, 0x81, 0x01,
  0xF8, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3E,
  0x03, 0xE0, 0x00, 0xF8, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0x7C,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0xBF, 0x80,
  0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0x00,
  0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE7,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0x0F, 0xFF, 0xF0, 0x0F, 0xE1, 0xFF, 0x7F,
  0x80, 0xFE, 0x3F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF8, 0x3F, 0xC1, 0xFC, 0x7F,
  0x01, 0xFE, 0x3F, 0x8F, 0xF0, 0x0F, 0xF7, 0xF0, 0xFE, 0x00, 0xFF, 0xFF,
  0x0F, 0xE0, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xE0, 0x03,
  0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF,
  0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0x00, 0x00, 0x00, 0x3F,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xF8,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x0C, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7F, 0x0F,
  0x80, 0x0F, 0xF9, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x40, 0x7E, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x07,
  0xF3, 0xE0, 0x03, 0xFC, 0x7E, 0x00, 0x7F, 0x07, 0xC0, 0x07, 0xC0, 0xFC,
  0x00, 0x78, 0x1F, 0x80, 0x02, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x80, 0x1E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0x3F, 0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFC, 0xFC, 0x7F, 0x9F, 0xC3, 0xE1, 0xFC, 0x3C, 0x1F,
  0xC1, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0x01, 0xFF, 0x00, 0x78, 0x01, 0xFE, 0x00, 0x40, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0xFF,
  0xC0, 0x3E, 0x01, 0xFF, 0x00, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC4, 0x00,
  0x03, 0xFC, 0x38, 0x00, 0x3F, 0xE1, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F,
  0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x08, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x80, 0x00, 0x7F, 0x83, 0xC0, 0x07, 0xFE, 0x0F, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xE0,
  0x60, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x1C, 0x00, 0x3F, 0x8F, 0xF8, 0x07,
  0xF3, 0xFF, 0xE0, 0x7F, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0xFF, 0xC0, 0x3F, 0x8F, 0xF8, 0x03, 0xF8,
  0xFF, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x01, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x05, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xF3, 0xF8,
  0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F,
  0xE3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xEF, 0xE0, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xDF, 0xC0, 0x3F, 0xF1,
  0xFC, 0x00, 0x38, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x0F, 0x87, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xFE, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0xE1, 0xFF, 0x0E, 0x00, 0xFF, 0x10, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0xFF, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0xFF, 0x83, 0xE1, 0xF0, 0x0F, 0xFF,
  0xF8, 0x3F, 0x3F, 0x01, 0xFF, 0xFF, 0x03, 0xF3, 0xE0, 0x3F, 0xC3, 0xF0,
  0x3F, 0x7E, 0x07, 0xF0, 0x1F, 0x01, 0xF7, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x7C, 0x0F, 0xC0, 0x3E, 0x03, 0xFF, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0xFC,
  0x1F, 0x80, 0x7E, 0x03, 0xFF, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0xF8, 0x1F,
  0x00, 0x7C, 0x03, 0xEF, 0x83, 0xF0, 0x07, 0xC0, 0x7E, 0xF8, 0x3F, 0x00,
  0xFC, 0x07, 0xEF, 0x83, 0xF0, 0x0F, 0xC0, 0x7C, 0xF8, 0x3F, 0x01, 0xF8,
  0x0F, 0xCF, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0xF8, 0x1F, 0x03, 0xFC, 0x1F,
  0x8F, 0x81, 0xF8, 0xFF, 0xC7, 0xF0, 0xFC, 0x1F, 0xFF, 0x7F, 0xFE, 0x0F,
  0xC0, 0xFF, 0xF3, 0xFF, 0xC0, 0xFC, 0x07, 0xFE, 0x3F, 0xF8, 0x07, 0xE0,
  0x3F, 0x81, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xFE, 0x01,
  0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F,
  0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x3C, 0x07, 0xFE, 0x00, 0x04, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x80, 0x7F, 0xE0, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0x7F, 0xF0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0xC0, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xF8, 0x1F, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7C, 0x07,
  0xFE, 0x00, 0x02, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0xFC, 0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xE0,
  0x07, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xF8, 0xFE, 0x00, 0xFF, 0xFE, 0x3F,
  0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xF0, 0x01,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x03, 0xF8,
  0x0F, 0xF8, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x07, 0xF7,
  0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0xFE, 0xFC,
  0x00, 0x7E, 0xFE, 0x01, 0xFD, 0xF8, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0,
  0x03, 0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0xC7, 0xC0,
  0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0x80, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0x01,
  0xF8, 0x7F, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x07, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x7E,
  0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE3, 0xF0,
  0x3F, 0x00, 0x7E, 0x0F, 0xC7, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x9F, 0x81,
  0xFC, 0x03, 0xF8, 0x3F, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x3E, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x7D, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF,
  0x80, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x03, 0xF7, 0xE0,
  0x01, 0xFC, 0x03, 0xF7, 0xF0, 0x01, 0xF8, 0x03, 0xF7, 0xF0, 0x01, 0xF8,
  0x03, 0xF3, 0xF8, 0x03, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x07, 0xF3,
  0xF8, 0x03, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0x07, 0xE1, 0xFC, 0x03,
  0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x3F, 0x80, 0x1F, 0xDF,
  0xC0, 0x3F, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x07,
  0xFF, 0x80, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF8, 0x3F, 0x80,
  0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0,
  0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1C, 0x07,
  0xF8, 0x00, 0x20, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x04, 0x00, 0x07, 0xF8, 0x3C, 0x00, 0x7F,
  0x81, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x3F, 0x00,
  0x3F, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x7C, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0xBE, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xDF, 0x00, 0x7F, 0x03, 0xF0,
  0x0F, 0xCF, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xF3, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC0, 0x3F,
  0x01, 0xF8, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0xFC, 0x1F, 0x87, 0xF0, 0x03,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x00,
  0xFE, 0x3F, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x81, 0xF8, 0xFC, 0x00,
  0x3F, 0x9F, 0x80, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xC0, 0x7E, 0x7F, 0x00,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x80,
  0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x07,
  0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE,
  0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC,
  0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x81,
  0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3E, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x7F, 0xFC, 0x7C, 0x07, 0xFF,
  0xE7, 0xE0, 0x7F, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF,
  0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x80,
  0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F,
  0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0,
  0x3F, 0xE0, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xE7, 0xE0, 0x1F, 0xFE, 0x3F, 0x00,
  0x3F, 0xC1, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0xE0, 0x0F, 0xE7,
  0xFF, 0x80, 0x7F, 0x7F, 0xFE, 0x03, 0xF7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0x83,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xF8, 0x7F,
  0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xE0, 0x7E, 0x7F, 0xFE, 0x03,
  0xE3, 0xFF, 0xE0, 0x3F, 0x07, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF8, 0x0C, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x30, 0x7F, 0xC1, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x3F, 0x80, 0x0F, 0xF8, 0x7F, 0x00, 0x7F, 0xFC, 0xFC, 0x01, 0xFF, 0xFB,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFF,
  0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xBF, 0x00, 0x3F, 0xFE,
  0x7E, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x3F, 0xE1, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xE3, 0xFC, 0x3F, 0xC0, 0xFE,
  0x3F, 0xC0, 0x3F, 0x3F, 0xC0, 0x1F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F,
  0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x1F, 0xF7, 0xF9, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xD0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x08, 0x3F, 0xE0, 0x3C, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x8F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0xFC, 0x01, 0xFF,
  0xF1, 0xF0, 0x07, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07,
  0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0x80, 0xFF, 0xFF, 0x7E, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFB, 0xF8, 0x01, 0xFF, 0xC7, 0xF0, 0x00, 0xFF,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x08, 0x00, 0x1F,
  0xE0, 0x18, 0x00, 0x7F, 0x80, 0x3F, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC1, 0xF0, 0x01, 0xFC, 0x3F, 0xE0, 0x0F, 0xE7, 0xFF, 0xC0,
  0x7F, 0x7F, 0xFE, 0x03, 0xF7, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFE, 0x0F, 0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x83, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x8F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF8,
  0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0,
  0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC3, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0xFC, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xF7, 0xFF, 0xF3, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F,
  0xC1, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC3,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0x87, 0xFF, 0x00, 0xFC, 0x7F, 0xFC, 0x07, 0xE7, 0xFF, 0xE0, 0x3F, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x1F, 0xE0, 0xFF, 0xC0, 0x7F,
  0x07, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC3, 0xFE, 0x00, 0xFE, 0x1F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xFD, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x07, 0xF8, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x7E, 0x3F, 0xFC,
  0x00, 0x7E, 0x7F, 0xFE, 0x00, 0x7E, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xCF, 0xFF, 0xC0, 0x0F, 0xC7, 0xFF, 0x00,
  0x1F, 0xC3, 0xFE, 0x00, 0x1F, 0xC0, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xFF, 0x0F, 0xC0, 0x7F, 0xFC, 0x7C, 0x07, 0xFF, 0xF7, 0xE0, 0x7F,
  0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0xC3, 0xFC, 0x07,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8,
  0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x03, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xFF, 0xDF, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xEF, 0xE0, 0x1F, 0xFE, 0x7F, 0x00, 0x3F, 0xC3, 0xF0,
  0x00, 0x20, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0xFF, 0x03, 0xF1, 0xFF, 0x03, 0xF3, 0xFE,
  0x03, 0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xE3, 0xF0, 0x3F, 0xC0, 0x38, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0xC0, 0x03, 0xF8, 0x7C, 0x07, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x11, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x40, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x30, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xF8, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x07, 0xFC, 0x1F,
  0xE0, 0x7F, 0xE0, 0xFF, 0x8F, 0xBF, 0x07, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF,
  0xCF, 0x80, 0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0xC7, 0xE0, 0x0F, 0xF8, 0x3F,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xF0, 0x7E, 0x00, 0xFE,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFE,
  0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03,
  0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xEF, 0xE0, 0x0F, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x7E,
  0x01, 0xFF, 0x80, 0x7F, 0x1F, 0x80, 0x7F, 0xE0, 0x1F, 0xC7, 0xE0, 0x3E,
  0xF8, 0x0F, 0xE1, 0xF8, 0x0F, 0xBE, 0x03, 0xF8, 0x7E, 0x07, 0xEF, 0x81,
  0xFC, 0x1F, 0x81, 0xF3, 0xE0, 0x7F, 0x07, 0xE0, 0xFC, 0xF8, 0x3F, 0x81,
  0xF8, 0x3F, 0x3E, 0x0F, 0xE0, 0x7E, 0x1F, 0x8F, 0x87, 0xF0, 0x1F, 0x87,
  0xE3, 0xE1, 0xFC, 0x07, 0xE1, 0xF0, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x3E,
  0x3F, 0x80, 0x7E, 0x3E, 0x0F, 0x8F, 0xC0, 0x1F, 0x9F, 0x83, 0xE7, 0xF0,
  0x07, 0xE7, 0xE0, 0xF9, 0xFC, 0x01, 0xF9, 0xF0, 0x3E, 0x7E, 0x00, 0x7E,
  0xFC, 0x0F, 0xBF, 0x80, 0x1F, 0xBE, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x80,
  0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x27,
  0xFF, 0x80, 0x0D, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF6, 0x00, 0x0F, 0xFC, 0x80,
  0x00, 0x08, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 16, 41, 16, 1, -40 },
  { 83, 19, 14, 24, 6, -40 },
  { 117, 36, 40, 36, 1, -40 },
  { 297, 28, 46, 31, 2, -43 },
  { 458, 41, 42, 47, 4, -41 },
  { 674, 36, 42, 39, 2, -41 },
  { 863, 8, 14, 14, 6, -40 },
  { 877, 20, 49, 18, 2, -40 },
  { 1000, 20, 49, 18, -4, -40 },
  { 1123, 27, 27, 31, 5, -43 },
  { 1215, 27, 27, 32, 3, -33 },
  { 1307, 13, 14, 15, -3, -7 },
  { 1330, 15, 6, 18, 1, -18 },
  { 1342, 8, 9, 15, 1, -8 },
  { 1351, 30, 40, 22, -3, -40 },
  { 1501, 28, 42, 31, 2, -41 },
  { 1648, 20, 40, 31, 6, -40 },
  { 1748, 31, 41, 31, -1, -41 },
  { 1907, 29, 42, 31, 1, -41 },
  { 2060, 30, 40, 31, 0, -40 },
  { 2210, 30, 41, 31, 1, -40 },
  { 2364, 28, 42, 31, 3, -41 },
  { 2511, 30, 40, 31, 3, -40 },
  { 2661, 29, 42, 31, 2, -41 },
  { 2814, 28, 42, 31, 2, -41 },
  { 2961, 13, 32, 15, 1, -31 },
  { 3013, 17, 38, 15, -3, -31 },
  { 3094, 27, 29, 32, 3, -35 },
  { 3192, 27, 16, 32, 3, -28 },
  { 3246, 27, 29, 32, 3, -35 },
  { 3344, 23, 42, 25, 4, -41 },
  { 3465, 44, 45, 48, 3, -40 },
  { 3713, 34, 40, 34, -3, -40 },
  { 3883, 32, 40, 34, 2, -40 },
  { 4043, 32, 42, 34, 4, -41 },
  { 4211, 34, 40, 38, 2, -40 },
  { 4381, 30, 40, 30, 2, -40 },
  { 4531, 30, 40, 29, 2, -40 },
  { 4681, 34, 42, 38, 4, -41 },
  { 4860, 37, 40, 39, 2, -40 },
  { 5045, 24, 40, 20, -1, -40 },
  { 5165, 27, 51, 17, -9, -40 },
  { 5338, 36, 40, 33, 2, -40 },
  { 5518, 23, 40, 28, 2, -40 },
  { 5633, 47, 40, 48, 2, -40 },
  { 5868, 40, 40, 41, 2, -40 },
  { 6068, 35, 42, 41, 4, -41 },
  { 6252, 31, 40, 33, 2, -40 },
  { 6407, 35, 51, 41, 4, -41 },
  { 6631, 31, 40, 34, 2, -40 },
  { 6786, 29, 42, 29, 1, -41 },
  { 6939, 28, 40, 29, 5, -40 },
  { 7079, 35, 41, 38, 4, -40 },
  { 7259, 32, 40, 32, 5, -40 },
  { 7419, 49, 40, 49, 5, -40 },
  { 7664, 40, 40, 32, -3, -40 },
  { 7864, 31, 40, 30, 5, -40 },
  { 8019, 34, 40, 30, -1, -40 },
  { 8189, 23, 49, 18, -1, -40 },
  { 8330, 12, 40, 22, 6, -40 },
  { 8390, 23, 49, 18, -4, -40 },
  { 8531, 29, 26, 31, 1, -40 },
  { 8626, 23, 4, 22, -5, 5 },
  { 8638, 11, 9, 17, 8, -43 },
  { 8651, 29, 32, 33, 3, -31 },
  { 8767, 29, 44, 33, 1, -43 },
  { 8927, 24, 32, 26, 3, -31 },
  { 9023, 31, 44, 33, 3, -43 },
  { 9194, 25, 32, 30, 3, -31 },
  { 9294, 32, 56, 20, -6, -43 },
  { 9518, 31, 44, 33, 1, -31 },
  { 9689, 29, 43, 33, 1, -43 },
  { 9845, 16, 42, 16, 1, -42 },
  { 9929, 24, 55, 16, -7, -42 },
  { 10094, 32, 43, 30, 1, -43 },
  { 10266, 16, 43, 16, 1, -43 },
  { 10352, 46, 31, 50, 1, -31 },
  { 10531, 29, 31, 33, 1, -31 },
  { 10644, 27, 32, 32, 3, -31 },
  { 10752, 32, 44, 33, -2, -31 },
  { 10928, 29, 44, 33, 3, -31 },
  { 11088, 24, 31, 23, 1, -31 },
  { 11181, 25, 32, 26, 0, -31 },
  { 11281, 20, 38, 21, 3, -37 },
  { 11376, 29, 31, 33, 3, -30 },
  { 11489, 28, 30, 28, 3, -30 },
  { 11594, 42, 30, 43, 3, -30 },
  { 11752, 34, 30, 29, -3, -30 },
  { 11880, 35, 43, 28, -4, -30 },
  { 12069, 27, 30, 26, -1, -30 },
  { 12171, 23, 49, 20, 0, -40 },
  { 12312, 5, 55, 31, 13, -42 },
  { 12347, 23, 49, 20, -3, -40 },
  { 12488, 27, 9, 32, 3, -24 },
};

const GFXfont NotoSans_SemiBoldItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMIBOLDITALIC56PT7B_H_
