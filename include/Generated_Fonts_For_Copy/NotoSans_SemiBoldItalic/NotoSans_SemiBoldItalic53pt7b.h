#ifndef _NOTOSANS_SEMIBOLDITALIC53PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3F,
  0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x0C, 0x00, 0x00, 0x3F, 0x8F, 0xE7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xE0, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F,
  0x81, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x81, 0xF0, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xFC, 0x07, 0xF1, 0xE1, 0xC0, 0x7F, 0x1C,
  0x00, 0x07, 0xE1, 0xC0, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xE3, 0xC0, 0x00,
  0x7F, 0x3C, 0x00, 0x07, 0xFB, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xE3, 0xF8, 0x00, 0x0E, 0x3F, 0x80, 0x01, 0xE3, 0xF8, 0x00, 0x1E, 0x3F,
  0x80, 0x01, 0xE3, 0xF8, 0xC0, 0x1C, 0x3F, 0x0F, 0x81, 0xCF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xE0,
  0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0xFC, 0x00, 0x3E, 0x01, 0xFD, 0xFC,
  0x00, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC0,
  0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x1F,
  0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0xFC, 0x00, 0x3F, 0x07,
  0xE3, 0xF0, 0x00, 0x7E, 0x0F, 0xC7, 0xC7, 0xF8, 0xFC, 0x1F, 0x1F, 0x1F,
  0xF8, 0xF8, 0x7E, 0x7E, 0x7F, 0xF9, 0xF9, 0xF9, 0xF9, 0xFF, 0xF3, 0xFF,
  0xF3, 0xE7, 0xF7, 0xF3, 0xFF, 0xCF, 0x8F, 0xC7, 0xE7, 0xFF, 0x3F, 0x3F,
  0x07, 0xC3, 0xF8, 0xFC, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x1F, 0x00,
  0x07, 0xC3, 0xF0, 0x3E, 0x00, 0x1F, 0x87, 0xE0, 0xFC, 0x00, 0x3E, 0x0F,
  0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x03, 0xE1, 0xF8, 0x07, 0xE0, 0x07, 0xE7, 0xE0,
  0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0xFC, 0x00,
  0x1F, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x0F, 0xFF, 0xE0,
  0x1F, 0x87, 0xFB, 0xF8, 0x0F, 0xE3, 0xFC, 0x7F, 0x03, 0xF1, 0xFC, 0x0F,
  0xE1, 0xFC, 0x7F, 0x03, 0xFC, 0xFE, 0x3F, 0x80, 0x7F, 0x7F, 0x0F, 0xE0,
  0x0F, 0xFF, 0xC3, 0xF8, 0x03, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xF0, 0x3F,
  0x80, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xE1, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0x80, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE1,
  0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC0, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0x80, 0x7C, 0x00,
  0xF0, 0x3E, 0x00, 0x7E, 0x1E, 0x00, 0x7F, 0xCF, 0x00, 0x3F, 0xFF, 0x80,
  0x67, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFE, 0x1F, 0x03, 0xEF, 0x00, 0x07, 0xF7, 0xC0, 0x07, 0xF3,
  0xE0, 0x07, 0xF1, 0xF0, 0x07, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x38,
  0x1F, 0x80, 0x08, 0x0F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x80, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x30, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xC3, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0,
  0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x83, 0xF8, 0x1F, 0xE0,
  0x7F, 0x87, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xDF, 0x9F, 0xF3, 0xF1,
  0xF8, 0xFE, 0x1E, 0x1F, 0xC3, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xE0, 0x1F, 0xE0, 0x0E, 0x00, 0x7F,
  0x00, 0x40, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0xC0, 0x78, 0x03,
  0xF8, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x20, 0x00, 0x1F, 0xC6, 0x00, 0x07,
  0xF8, 0xF8, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE3, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x02, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x80,
  0x00, 0xFF, 0x0C, 0x00, 0x1F, 0xE0, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0x01, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x03, 0xF9, 0xFF,
  0xC0, 0x7E, 0x7F, 0xFC, 0x0F, 0xDF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF0, 0xFF, 0x8F, 0xF8, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xC7, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x1F, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF0,
  0x3F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x83, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFF,
  0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x1F, 0xF3, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xDF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xF3, 0xF0, 0x0F,
  0xF8, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xE0, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x03, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0x83, 0xFC, 0xE0,
  0x0F, 0xE4, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xD0, 0x07, 0xE3, 0xF0,
  0x07, 0xFF, 0x81, 0xF1, 0xF0, 0x0F, 0xFF, 0xE0, 0xF9, 0xF8, 0x0F, 0xFF,
  0xF0, 0x7C, 0xF8, 0x0F, 0xFF, 0xF0, 0x3E, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F,
  0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xBE, 0x0F, 0xC0, 0x3E, 0x07, 0xFE, 0x07,
  0xC0, 0x3E, 0x03, 0xFF, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0x83, 0xF0, 0x0F,
  0x80, 0xFF, 0xC1, 0xF0, 0x0F, 0xC0, 0x7F, 0xE0, 0xF8, 0x07, 0xC0, 0x7D,
  0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0xF8, 0x3E, 0x03, 0xF0, 0x3F, 0x7C, 0x1F,
  0x01, 0xF8, 0x1F, 0x3E, 0x0F, 0x81, 0xFC, 0x1F, 0x9F, 0x07, 0xE1, 0xFE,
  0x1F, 0x8F, 0x83, 0xFF, 0xEF, 0xFF, 0x87, 0xC0, 0xFF, 0xF7, 0xFF, 0xC3,
  0xF0, 0x7F, 0xF3, 0xFF, 0x81, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0x7C, 0x00,
  0x80, 0x0E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x7F, 0x80, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x03,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x00,
  0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE,
  0x7F, 0x80, 0xFF, 0xC0, 0x0E, 0x03, 0xFE, 0x00, 0x04, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0x80, 0x3F, 0xF8, 0x3F, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF8,
  0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80,
  0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80,
  0x07, 0xF8, 0x3F, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x1F, 0xF0, 0x7F, 0x00,
  0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xCF, 0xF0, 0x0F, 0xFC, 0x00,
  0x78, 0x0F, 0xFC, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0x1F, 0xC0,
  0x1F, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0x87, 0xF0, 0x07, 0xFF, 0xC7, 0xF0,
  0x07, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0xF1, 0xFC, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3F, 0x81,
  0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x20, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x00, 0x7C, 0xFC, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0xC0, 0x7E, 0xFC,
  0x00, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x9F, 0x80, 0xFC, 0x7C, 0x01,
  0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x80, 0xFC, 0x7C, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x1F, 0x87, 0xF0, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x3F, 0x07, 0xE0, 0x3F, 0x87,
  0xE3, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0x3F, 0x03, 0xE7,
  0xC0, 0xFE, 0x03, 0xF0, 0x3E, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xEF, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0xC0, 0x7F, 0xC0, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xF8,
  0x00, 0x3F, 0x81, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xC0,
  0x7F, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0x7E, 0x00,
  0x3F, 0x01, 0xFB, 0xF8, 0x01, 0xF8, 0x0F, 0xCF, 0xC0, 0x0F, 0xC0, 0x7E,
  0x7E, 0x00, 0x7E, 0x03, 0xF3, 0xF8, 0x07, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x01,
  0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0xFE, 0x03, 0xF0, 0x0F, 0xC7, 0xF0, 0x3F, 0x80, 0x7F, 0x3F, 0x01, 0xF8,
  0x01, 0xF9, 0xF8, 0x0F, 0xC0, 0x0F, 0xCF, 0xC0, 0x7E, 0x00, 0x7F, 0x7E,
  0x03, 0xF0, 0x01, 0xFB, 0xE0, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xF8, 0x00,
  0x7F, 0xF8, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xFE, 0x03,
  0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0x0F,
  0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF1, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0x80,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF8, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xFC,
  0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x0F, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x83, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x3F, 0x81, 0xFE, 0x00, 0x60, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x20, 0x00, 0x7F, 0x87, 0x00, 0x1F, 0xE0, 0xFC, 0x0F,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xCF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0x0F, 0xE0, 0x1F, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xE0,
  0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xDF, 0x80, 0xFE, 0x07,
  0xE0, 0x3E, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF9, 0xF8, 0x1F, 0xC0, 0x7E,
  0x07, 0xC7, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x1F, 0x83, 0xF8, 0x07, 0xE0,
  0xFC, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0xF8, 0x7F, 0x00, 0x7E, 0x1F,
  0x83, 0xE1, 0xF8, 0x01, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0x07, 0xE3, 0xF0,
  0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x03,
  0xE7, 0xF0, 0x01, 0xF9, 0xF0, 0x0F, 0x9F, 0x80, 0x07, 0xEF, 0xC0, 0x3E,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xF8, 0x03, 0xEF,
  0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xBF, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFF, 0x00, 0x3F,
  0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E,
  0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0x9F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x01, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF7, 0xE0, 0x00,
  0x1F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x3F,
  0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0x00, 0x3F,
  0x81, 0xF0, 0x0F, 0xFE, 0x3F, 0x01, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xBE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE,
  0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F,
  0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF0, 0x7F, 0x03, 0xFE, 0x07, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xF7, 0xE0, 0x3F, 0xFE, 0x7C, 0x01, 0xFF, 0xC7, 0xC0,
  0x0F, 0xF8, 0x7C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF1, 0xFF, 0x80, 0x3F, 0x3F, 0xFC, 0x03, 0xF7, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0xE0, 0x7F, 0xC0, 0xFE, 0x07, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F,
  0x80, 0x3F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xCF, 0xFF, 0xC0, 0xFC, 0x7F, 0xF0, 0x0F,
  0x83, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFC,
  0x3C, 0x0F, 0xF0, 0x04, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x20, 0x7F, 0xC0, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0xFF,
  0xE7, 0xF0, 0x07, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0x7E, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0xC0, 0x7E, 0x01, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x7E, 0x00, 0xFF, 0xF9, 0xF0, 0x01,
  0xFF, 0xC7, 0xC0, 0x03, 0xFE, 0x1F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x3F,
  0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F,
  0xE7, 0xF7, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x20, 0xFF,
  0x00, 0x70, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xF8, 0x03, 0xFF, 0x8F, 0xC0, 0x3F,
  0xFE, 0x7E, 0x03, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0x1F,
  0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xDF, 0xC0, 0x1F, 0xFC, 0xFC, 0x00, 0x7F, 0x87, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x20, 0x00, 0xFE, 0x01, 0xC0, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF1, 0xFF, 0x80, 0x3F, 0x3F,
  0xFC, 0x03, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xF0,
  0x7F, 0xE0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x0F, 0xF0,
  0x07, 0xF0, 0xFF, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x38, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xC3, 0xFC, 0x00, 0x7E, 0x1F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFD, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x01,
  0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0x3E,
  0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xE3, 0xFF, 0xC3, 0xFF, 0xC0, 0x3E, 0x7F,
  0xFC, 0x7F, 0xFE, 0x07, 0xEF, 0xFF, 0xEF, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF,
  0xF0, 0xFE, 0x07, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0xC0,
  0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x00, 0x7E,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0xFF,
  0x00, 0x3E, 0x1F, 0xFC, 0x03, 0xE3, 0xFF, 0xC0, 0x7E, 0x7F, 0xFE, 0x07,
  0xEF, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xC0,
  0x7F, 0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xE0,
  0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x1F, 0xE1, 0xFE,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0xF8, 0x7F, 0xE0, 0x01, 0xF3,
  0xFF, 0xE0, 0x03, 0xEF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xBF, 0xFF, 0x80, 0x3F, 0x7F, 0xFE, 0x00, 0xFE,
  0x7F, 0xF0, 0x01, 0xFC, 0x7F, 0xC0, 0x03, 0xF8, 0x08, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1,
  0xF0, 0x0F, 0xFE, 0x1F, 0x01, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xBE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x01,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x07, 0xE0,
  0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFC, 0x01, 0xFF, 0xCF, 0xC0, 0x0F,
  0xF0, 0xFC, 0x00, 0x08, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0xFE, 0x07, 0xE3, 0xF8, 0x0F, 0x8F, 0xF0, 0x1F, 0x3F, 0xE0,
  0x7E, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFE, 0x07, 0x83, 0xF8, 0x02, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x20, 0x01, 0xFC, 0x78, 0x07, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xC7, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x08, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x40, 0x00, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F,
  0x0F, 0xC0, 0x1F, 0xE1, 0xFC, 0x07, 0xFC, 0x3F, 0x81, 0xFF, 0x87, 0xF8,
  0x7F, 0xE0, 0xFF, 0xFF, 0x7C, 0x0F, 0xFF, 0xDF, 0x81, 0xFF, 0xF3, 0xF0,
  0x1F, 0xFC, 0x7E, 0x01, 0xFF, 0x0F, 0x80, 0x02, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xF8,
  0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0,
  0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0xFC,
  0x03, 0xFE, 0x01, 0xF8, 0xFC, 0x07, 0xDE, 0x03, 0xF8, 0xFE, 0x07, 0xDE,
  0x03, 0xF8, 0xFE, 0x0F, 0xDF, 0x07, 0xF0, 0x7E, 0x0F, 0x9F, 0x07, 0xF0,
  0x7E, 0x0F, 0x9F, 0x07, 0xE0, 0x7E, 0x1F, 0x1F, 0x0F, 0xE0, 0x7E, 0x1F,
  0x1F, 0x0F, 0xC0, 0x7E, 0x3F, 0x1F, 0x1F, 0xC0, 0x7E, 0x3E, 0x1F, 0x1F,
  0x80, 0x7E, 0x7E, 0x1F, 0x3F, 0x80, 0x7E, 0x7C, 0x1F, 0x3F, 0x00, 0x7E,
  0x7C, 0x1F, 0x3F, 0x00, 0x7E, 0xF8, 0x1F, 0x7E, 0x00, 0x7E, 0xF8, 0x1F,
  0x7E, 0x00, 0x7F, 0xF8, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x1F, 0xFC, 0x00,
  0x7D, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F,
  0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x07,
  0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x4F, 0xFE,
  0x00, 0x37, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xF2, 0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_SemiBoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 39, 15, 1, -38 },
  { 75, 19, 14, 23, 5, -38 },
  { 109, 34, 38, 34, 1, -38 },
  { 271, 28, 43, 29, 1, -40 },
  { 422, 39, 38, 44, 3, -38 },
  { 608, 34, 39, 37, 2, -38 },
  { 774, 9, 14, 13, 5, -38 },
  { 790, 19, 46, 17, 2, -38 },
  { 900, 19, 46, 17, -4, -38 },
  { 1010, 25, 26, 29, 5, -41 },
  { 1092, 26, 26, 30, 3, -32 },
  { 1177, 11, 13, 15, -2, -6 },
  { 1195, 14, 6, 17, 1, -17 },
  { 1206, 8, 9, 15, 1, -8 },
  { 1215, 27, 38, 21, -2, -38 },
  { 1344, 27, 39, 29, 2, -38 },
  { 1476, 19, 38, 29, 6, -38 },
  { 1567, 29, 38, 29, -1, -38 },
  { 1705, 27, 39, 29, 1, -38 },
  { 1837, 28, 38, 29, 0, -38 },
  { 1970, 28, 39, 29, 1, -38 },
  { 2107, 27, 39, 29, 3, -38 },
  { 2239, 28, 38, 29, 3, -38 },
  { 2372, 27, 39, 29, 2, -38 },
  { 2504, 26, 39, 29, 2, -38 },
  { 2631, 12, 30, 15, 1, -29 },
  { 2676, 16, 36, 15, -3, -29 },
  { 2748, 26, 27, 30, 3, -33 },
  { 2836, 25, 15, 30, 3, -26 },
  { 2883, 26, 27, 30, 3, -33 },
  { 2971, 21, 39, 24, 4, -38 },
  { 3074, 41, 43, 45, 3, -38 },
  { 3295, 32, 38, 32, -3, -38 },
  { 3447, 30, 38, 32, 2, -38 },
  { 3590, 31, 39, 32, 3, -38 },
  { 3742, 32, 38, 36, 2, -38 },
  { 3894, 28, 38, 28, 2, -38 },
  { 4027, 28, 38, 27, 2, -38 },
  { 4160, 33, 39, 36, 3, -38 },
  { 4321, 35, 38, 37, 2, -38 },
  { 4488, 23, 38, 19, -1, -38 },
  { 4598, 25, 49, 16, -8, -38 },
  { 4752, 34, 38, 31, 2, -38 },
  { 4914, 21, 38, 27, 2, -38 },
  { 5014, 44, 38, 46, 2, -38 },
  { 5223, 37, 38, 39, 2, -38 },
  { 5399, 34, 39, 39, 3, -38 },
  { 5565, 30, 38, 31, 2, -38 },
  { 5708, 34, 47, 39, 3, -38 },
  { 5908, 29, 38, 32, 2, -38 },
  { 6046, 27, 39, 28, 1, -38 },
  { 6178, 28, 38, 28, 4, -38 },
  { 6311, 33, 39, 36, 4, -38 },
  { 6472, 30, 38, 31, 5, -38 },
  { 6615, 46, 38, 47, 5, -38 },
  { 6834, 38, 38, 31, -3, -38 },
  { 7015, 29, 38, 29, 5, -38 },
  { 7153, 32, 38, 28, -1, -38 },
  { 7305, 22, 46, 17, -1, -38 },
  { 7432, 11, 38, 21, 6, -38 },
  { 7485, 22, 46, 17, -4, -38 },
  { 7612, 27, 24, 30, 1, -38 },
  { 7693, 22, 3, 21, -5, 5 },
  { 7702, 10, 9, 16, 8, -41 },
  { 7714, 28, 30, 31, 2, -29 },
  { 7819, 28, 41, 31, 1, -40 },
  { 7963, 24, 30, 25, 2, -29 },
  { 8053, 30, 41, 31, 2, -40 },
  { 8207, 25, 30, 28, 2, -29 },
  { 8301, 31, 54, 19, -6, -41 },
  { 8511, 29, 42, 31, 1, -29 },
  { 8664, 28, 40, 32, 1, -40 },
  { 8804, 15, 40, 15, 1, -40 },
  { 8879, 23, 53, 15, -7, -40 },
  { 9032, 30, 40, 29, 1, -40 },
  { 9182, 15, 40, 15, 1, -40 },
  { 9257, 44, 29, 47, 1, -29 },
  { 9417, 28, 29, 32, 1, -29 },
  { 9519, 26, 29, 31, 2, -29 },
  { 9614, 31, 42, 31, -2, -29 },
  { 9777, 28, 42, 31, 2, -29 },
  { 9924, 23, 29, 22, 1, -29 },
  { 10008, 23, 30, 24, 0, -29 },
  { 10095, 19, 36, 20, 2, -35 },
  { 10181, 27, 30, 32, 3, -29 },
  { 10283, 26, 29, 26, 3, -29 },
  { 10378, 40, 29, 40, 3, -29 },
  { 10523, 31, 29, 27, -2, -29 },
  { 10636, 33, 42, 26, -4, -29 },
  { 10810, 26, 29, 24, -1, -29 },
  { 10905, 22, 46, 19, 0, -38 },
  { 11032, 4, 52, 29, 13, -40 },
  { 11058, 21, 46, 19, -2, -38 },
  { 11179, 26, 8, 30, 3, -23 },
};

const GFXfont NotoSans_SemiBoldItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMIBOLDITALIC53PT7B_H_
