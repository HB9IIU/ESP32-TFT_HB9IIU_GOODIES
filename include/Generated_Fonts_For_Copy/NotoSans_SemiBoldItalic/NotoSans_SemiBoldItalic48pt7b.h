#ifndef _NOTOSANS_SEMIBOLDITALIC48PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x03, 0x00, 0x00, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0,
  0x78, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0x81, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFB, 0x9E, 0x03, 0xF1, 0xC1, 0x03, 0xF1, 0xE0, 0x01, 0xF8, 0xE0,
  0x00, 0xFC, 0x70, 0x00, 0x7E, 0x38, 0x00, 0x3F, 0xBC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x77, 0xF0, 0x00,
  0x39, 0xF8, 0x00, 0x3C, 0x7E, 0x00, 0x1C, 0x3E, 0x00, 0x0E, 0x3F, 0x18,
  0x07, 0x1F, 0x8F, 0x87, 0xBF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0xFF, 0x80, 0x03, 0xE0, 0x3F, 0xF8,
  0x00, 0x78, 0x0F, 0xFF, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x07, 0xC0, 0x7C,
  0x3E, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80,
  0x7C, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x1F,
  0x00, 0x7C, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xE1, 0xF0, 0x01, 0xF0, 0x7C,
  0x7C, 0x00, 0x3E, 0x0F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE7, 0xFC, 0xF8,
  0x7C, 0xF9, 0xFF, 0xDF, 0xFF, 0x3E, 0x7F, 0xFD, 0xFF, 0xE7, 0xCF, 0x9F,
  0xBF, 0xF9, 0xF3, 0xE1, 0xF3, 0xFE, 0x7C, 0x7C, 0x3E, 0x0E, 0x1F, 0x1F,
  0x07, 0xC0, 0x03, 0xE3, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x3E,
  0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x1F, 0x00,
  0x7C, 0x0F, 0x83, 0xE0, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x07, 0xE3, 0xE0, 0x3E, 0x00, 0x7F, 0xF8, 0x0F, 0x80, 0x0F,
  0xFF, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7C,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x1F,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0xFC, 0x3F, 0xFC, 0x03,
  0xF0, 0xFF, 0xFC, 0x07, 0xE3, 0xF9, 0xFC, 0x1F, 0x8F, 0xE1, 0xF8, 0x3F,
  0x3F, 0x83, 0xF8, 0xFC, 0x7E, 0x03, 0xFB, 0xF0, 0xFC, 0x03, 0xFF, 0xE1,
  0xF8, 0x03, 0xFF, 0x83, 0xF0, 0x07, 0xFE, 0x07, 0xE0, 0x07, 0xF8, 0x0F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x1F, 0xC0, 0x3F,
  0xF8, 0x1F, 0xC0, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xF3,
  0xC7, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x04, 0x03, 0xC0, 0x0E, 0x07, 0x80,
  0x3F, 0x0F, 0x00, 0x7F, 0xBC, 0x01, 0xFF, 0xF8, 0x3C, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFF, 0x80, 0x03,
  0xEF, 0x00, 0x0F, 0xDF, 0x00, 0x3F, 0x1E, 0x00, 0xFC, 0x3E, 0x00, 0xF0,
  0x7C, 0x00, 0xE0, 0x7C, 0x00, 0x80, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xE0, 0x7C,
  0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xE0,
  0x7E, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xF3, 0xFE, 0xFC, 0x7F, 0x3F, 0x0F, 0x8F, 0xC3,
  0x87, 0xE0, 0x41, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFE, 0xFF, 0x80, 0x7C, 0x07, 0xF0, 0x07, 0x00, 0x7F, 0x00, 0x40, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0x87, 0xF8,
  0x0E, 0x00, 0xFC, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x88, 0x00, 0x1F, 0xC7,
  0x00, 0x3F, 0xC3, 0xFD, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBF,
  0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF0, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x03, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x10, 0x00,
  0x7F, 0x0E, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFC, 0x18, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0xFF, 0xC0, 0x7D, 0xFF, 0xF0, 0x7E,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0x0F, 0xF0, 0x1F, 0x87,
  0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x7E, 0x07, 0xF1, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC7,
  0xF0, 0x7F, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFE, 0x3F,
  0x87, 0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0x80, 0x1F, 0xBF, 0x80, 0x7F, 0x3F, 0x01, 0xFE, 0x7F, 0x0F, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFB, 0xE0, 0xFF, 0xEF, 0xC0, 0xFF, 0x9F, 0x80, 0x38,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x10, 0x07, 0xF8, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF0, 0x10, 0x00, 0x00, 0x18, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFC, 0x3F,
  0xCC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0xFF, 0x01, 0xF1,
  0xF0, 0x0F, 0xFF, 0x87, 0xC7, 0xC0, 0xFF, 0xFE, 0x1F, 0x3E, 0x07, 0xFF,
  0xF0, 0x7C, 0xF8, 0x3F, 0x07, 0xC0, 0xF7, 0xC0, 0xF8, 0x1F, 0x03, 0xDF,
  0x07, 0xC0, 0x7C, 0x0F, 0x7C, 0x1F, 0x01, 0xE0, 0x7D, 0xE0, 0xF8, 0x0F,
  0x81, 0xF7, 0x83, 0xE0, 0x3E, 0x07, 0xFE, 0x0F, 0x00, 0xF8, 0x1F, 0xF8,
  0x7C, 0x07, 0xC0, 0xFB, 0xE1, 0xF0, 0x1F, 0x03, 0xEF, 0x87, 0xC0, 0x7C,
  0x0F, 0x3E, 0x1F, 0x03, 0xF0, 0x7C, 0xF8, 0x3E, 0x1F, 0xC3, 0xE1, 0xE0,
  0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xFF, 0xBF, 0xFC, 0x1F, 0x07, 0xFC, 0x7F,
  0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x10,
  0x00, 0x3F, 0xC0, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F,
  0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00,
  0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xE0,
  0x3F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x1F, 0x81, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC,
  0x3F, 0x00, 0x7F, 0x87, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x01,
  0xC0, 0xFF, 0x00, 0x04, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xE0,
  0x7F, 0xC0, 0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE0, 0xFC, 0x00, 0x7F, 0x83, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0,
  0x3F, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x01, 0x80, 0xFF, 0x00, 0x04, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0x3F, 0x80,
  0x7F, 0xF9, 0xFC, 0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xFE, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF8,
  0x01, 0xF8, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x01, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x7F, 0x80, 0x3F, 0x01, 0xFE, 0x00, 0x7E, 0x07, 0xF8,
  0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0xFC, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0x7E, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xBC, 0x00, 0x1F, 0xF8, 0x07, 0xDF,
  0x00, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x0F,
  0xBF, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x80, 0xFD, 0xF0, 0x07, 0xCF, 0x80,
  0x7E, 0xF8, 0x07, 0xEF, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3E,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0x81, 0xF0,
  0xF8, 0x07, 0xE3, 0xC0, 0xF8, 0xFC, 0x03, 0xE1, 0xE0, 0xF8, 0x7E, 0x01,
  0xF0, 0xF8, 0x7C, 0x3F, 0x01, 0xF8, 0x7C, 0x7C, 0x1F, 0x00, 0xFC, 0x3E,
  0x3E, 0x1F, 0x80, 0x7C, 0x1F, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x9F, 0x07,
  0xE0, 0x3F, 0x07, 0xDF, 0x03, 0xF0, 0x1F, 0x83, 0xEF, 0x81, 0xF0, 0x0F,
  0xC1, 0xFF, 0x81, 0xF8, 0x07, 0xC0, 0xFF, 0xC0, 0xFC, 0x03, 0xE0, 0x7F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x1F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0xC0,
  0x00, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x1F,
  0xF0, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0xE0, 0x03, 0xE0,
  0x1F, 0x7C, 0x00, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x80, 0x7D, 0xF8, 0x03,
  0xF0, 0x1F, 0x9F, 0x00, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0x80, 0x7E, 0x7E,
  0x03, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x01, 0xF0, 0xFC, 0x0F, 0xC0, 0x7E,
  0x1F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x0F, 0xC0,
  0x3E, 0x07, 0xE1, 0xF8, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF8, 0x0F, 0xC7,
  0xC0, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xE0, 0x1F, 0x3F, 0x00, 0xF8, 0x03,
  0xF7, 0xE0, 0x3F, 0x00, 0x7E, 0xFC, 0x07, 0xE0, 0x07, 0xDF, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x1F, 0xFC, 0x03, 0xE0, 0x01, 0xFF, 0x80,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x7F,
  0x80, 0x7C, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0x80, 0x7F,
  0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F,
  0xBF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x0F,
  0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x81, 0xF8,
  0x0F, 0xF0, 0x7F, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xF7,
  0xF0, 0x1F, 0xC0, 0x18, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x08, 0x00, 0x3F,
  0x07, 0x00, 0x7F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x7E, 0x7C, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xEF, 0x80, 0x0F, 0xE0, 0x03, 0xF3, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0xFF, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0x8F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xE3, 0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0x00,
  0xFC, 0x3F, 0x01, 0xF7, 0xC0, 0x7E, 0x0F, 0xC0, 0x7D, 0xF0, 0x1F, 0x83,
  0xF0, 0x3F, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x9F, 0x03, 0xF0, 0x3F, 0x07,
  0xE7, 0xC0, 0xF8, 0x0F, 0xC1, 0xF1, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x7C,
  0x1F, 0x80, 0xFC, 0x3E, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0x87, 0xC3, 0xF0,
  0x0F, 0xC7, 0xC1, 0xF1, 0xF8, 0x03, 0xF1, 0xF0, 0x7C, 0x7E, 0x00, 0xFC,
  0xFC, 0x1F, 0x1F, 0x00, 0x3F, 0x3E, 0x07, 0xCF, 0xC0, 0x0F, 0xDF, 0x81,
  0xF3, 0xE0, 0x03, 0xF7, 0xC0, 0x7D, 0xF8, 0x00, 0xFD, 0xF0, 0x1F, 0x7E,
  0x00, 0x1F, 0xF8, 0x07, 0xDF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07,
  0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x07,
  0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x9F, 0xC0,
  0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xF8, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xF9,
  0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x3C, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x7F, 0x1F, 0x87, 0xC3, 0xF0, 0xF8,
  0x3E, 0x0F, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x87, 0xC0, 0x7F, 0xE3, 0xE0,
  0x7F, 0xF9, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xDF, 0xF8, 0x7F, 0x83, 0xFC,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01,
  0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00,
  0x7F, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x7F, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xF0, 0x1F, 0xFC, 0xF8, 0x03,
  0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x20, 0x01, 0xF8,
  0xFF, 0x00, 0xFC, 0xFF, 0xC0, 0x7E, 0xFF, 0xF0, 0x3E, 0xFF, 0xF8, 0x1F,
  0xFB, 0xFC, 0x1F, 0xF0, 0x7F, 0x0F, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE3, 0xFC, 0x07,
  0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3E, 0xFF,
  0xF8, 0x3E, 0x3F, 0xF8, 0x1F, 0x0F, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x03,
  0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFC, 0xF8,
  0x7F, 0x80, 0x43, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x41, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0x03, 0xF0, 0x03, 0xFC, 0x7E, 0x00, 0xFF, 0xCF, 0xC0,
  0x3F, 0xFD, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0x07,
  0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8, 0x3F,
  0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x87, 0xF0, 0x03, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x03, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xBE, 0x00, 0x7F, 0xE7, 0xC0, 0x07, 0xF0, 0xF8, 0x00, 0x00, 0x02, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xC3, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xDF, 0x81, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0x87, 0xF8, 0x3E,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x84, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0D, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xE1, 0xF0, 0x0F,
  0xFC, 0x7C, 0x0F, 0xFF, 0x9F, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xFC,
  0x1F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFB, 0xE0, 0x1F, 0xFD,
  0xF8, 0x07, 0xFE, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0xC0, 0x0F, 0xE0, 0x3E, 0x0F, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x10, 0x01, 0xF8, 0xFF, 0x00, 0xFC, 0xFF,
  0xC0, 0x7E, 0xFF, 0xF0, 0x3E, 0xFF, 0xFC, 0x1F, 0xFD, 0xFE, 0x1F, 0xF0,
  0x7F, 0x0F, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xF8,
  0x03, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x37, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x01, 0xFB, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x80, 0x0F,
  0x87, 0xF8, 0x0F, 0xF0, 0x1F, 0x1F, 0xF8, 0x7F, 0xF0, 0x3E, 0x7F, 0xF1,
  0xFF, 0xE0, 0x7D, 0xFF, 0xF7, 0xFF, 0xE0, 0xFF, 0xDF, 0xEF, 0xBF, 0xC3,
  0xFE, 0x0F, 0xFC, 0x1F, 0x87, 0xF8, 0x1F, 0xF0, 0x3F, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0xFE, 0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x07,
  0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x07,
  0xE3, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x03, 0xE1, 0xFE,
  0x01, 0xF1, 0xFF, 0x80, 0xF9, 0xFF, 0xE0, 0x7D, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0xE0, 0xFE, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0,
  0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFB, 0xFC, 0x1F, 0xC0,
  0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xDF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x3E, 0x1F, 0xE0, 0x07, 0xC7, 0xFE, 0x00,
  0xFB, 0xFF, 0xE0, 0x1F, 0x7F, 0xFC, 0x03, 0xFF, 0x7F, 0x80, 0xFF, 0x83,
  0xF8, 0x1F, 0xE0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8,
  0x3F, 0xC0, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0xFB, 0xFF, 0xF0, 0x1F, 0x7F,
  0xFC, 0x07, 0xE7, 0xFF, 0x00, 0xFC, 0x7F, 0x80, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x87, 0xC0, 0x7F, 0xE3, 0xE0, 0x7F,
  0xF9, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xDF, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF1,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7F,
  0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F, 0xC1, 0xFE, 0xFF,
  0xE0, 0xFF, 0xFB, 0xE0, 0x3F, 0xFD, 0xF0, 0x1F, 0xF9, 0xF8, 0x03, 0xF8,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x28, 0x3E, 0x1F, 0x81, 0xF1, 0xFC, 0x0F,
  0x9F, 0xE0, 0x7D, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xF8, 0x41, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xF0, 0x78, 0x7F, 0x00, 0x83, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x60, 0x07, 0xE3,
  0xE0, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE7,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0x3F,
  0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFE, 0x1F, 0x81, 0xFE, 0x0F,
  0xC1, 0xFF, 0x07, 0xFB, 0xEF, 0x83, 0xFF, 0xF7, 0xC0, 0xFF, 0xF3, 0xE0,
  0x7F, 0xF3, 0xE0, 0x1F, 0xE1, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x7F, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0x3E, 0x0F, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x1F, 0xC0, 0x3E, 0x1F,
  0x80, 0x3E, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7E, 0xFC, 0x07,
  0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x80, 0xFC, 0xFC, 0x0F, 0xF8, 0x0F, 0xCF,
  0xC0, 0xF7, 0x81, 0xF8, 0xFC, 0x1F, 0x78, 0x1F, 0x8F, 0xC1, 0xF7, 0x83,
  0xF0, 0xFC, 0x1E, 0x78, 0x3F, 0x0F, 0xC3, 0xE7, 0x87, 0xE0, 0xFC, 0x3E,
  0x78, 0x7E, 0x0F, 0xC7, 0xC7, 0x87, 0xC0, 0xFC, 0x7C, 0x78, 0xFC, 0x0F,
  0xCF, 0x87, 0x8F, 0xC0, 0xFC, 0xF8, 0x79, 0xF8, 0x07, 0xDF, 0x07, 0x9F,
  0x80, 0x7D, 0xF0, 0x79, 0xF0, 0x07, 0xDE, 0x07, 0xBF, 0x00, 0x7F, 0xE0,
  0x7B, 0xE0, 0x07, 0xFE, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x3F,
  0x80, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE,
  0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x8F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x07, 0xF8,
  0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xF8, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x02, 0x7F, 0xC0, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x07, 0xFE, 0x40, 0x00, 0xF0,
};

const GFXglyph NotoSans_SemiBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 35, 13, 1, -34 },
  { 63, 16, 12, 21, 5, -34 },
  { 87, 30, 34, 31, 1, -34 },
  { 215, 25, 39, 26, 1, -36 },
  { 337, 35, 35, 40, 3, -35 },
  { 491, 31, 35, 33, 2, -35 },
  { 627, 7, 12, 12, 5, -34 },
  { 638, 17, 42, 15, 2, -34 },
  { 728, 17, 43, 15, -3, -35 },
  { 820, 23, 23, 26, 4, -37 },
  { 887, 23, 24, 27, 3, -29 },
  { 956, 11, 12, 13, -2, -6 },
  { 973, 13, 5, 15, 1, -15 },
  { 982, 7, 8, 13, 1, -7 },
  { 989, 25, 34, 19, -2, -34 },
  { 1096, 24, 35, 26, 2, -35 },
  { 1201, 18, 34, 26, 5, -34 },
  { 1278, 27, 35, 26, -1, -35 },
  { 1397, 25, 35, 26, 1, -35 },
  { 1507, 26, 34, 26, 0, -34 },
  { 1618, 25, 34, 26, 1, -34 },
  { 1725, 25, 35, 26, 2, -35 },
  { 1835, 25, 34, 26, 3, -34 },
  { 1942, 24, 35, 26, 2, -35 },
  { 2047, 23, 35, 26, 2, -35 },
  { 2148, 11, 28, 13, 1, -27 },
  { 2187, 15, 33, 13, -3, -27 },
  { 2249, 23, 25, 27, 3, -30 },
  { 2321, 23, 14, 27, 3, -24 },
  { 2362, 23, 25, 27, 3, -30 },
  { 2434, 19, 36, 22, 4, -35 },
  { 2520, 38, 38, 41, 2, -34 },
  { 2701, 29, 34, 29, -3, -34 },
  { 2825, 27, 34, 29, 2, -34 },
  { 2940, 28, 35, 29, 3, -35 },
  { 3063, 30, 34, 32, 1, -34 },
  { 3191, 26, 34, 26, 1, -34 },
  { 3302, 26, 34, 25, 1, -34 },
  { 3413, 29, 35, 33, 3, -35 },
  { 3540, 31, 34, 33, 2, -34 },
  { 3672, 21, 34, 17, -1, -34 },
  { 3762, 23, 44, 15, -8, -34 },
  { 3889, 31, 34, 29, 2, -34 },
  { 4021, 19, 34, 24, 2, -34 },
  { 4102, 41, 34, 42, 1, -34 },
  { 4277, 35, 34, 35, 1, -34 },
  { 4426, 30, 35, 35, 3, -35 },
  { 4558, 27, 34, 29, 2, -34 },
  { 4673, 30, 43, 35, 3, -35 },
  { 4835, 27, 34, 29, 1, -34 },
  { 4950, 25, 35, 25, 1, -35 },
  { 5060, 25, 34, 25, 4, -34 },
  { 5167, 30, 34, 33, 3, -34 },
  { 5295, 28, 34, 28, 4, -34 },
  { 5414, 42, 34, 42, 5, -34 },
  { 5593, 35, 34, 28, -3, -34 },
  { 5742, 26, 34, 26, 4, -34 },
  { 5853, 29, 34, 26, -1, -34 },
  { 5977, 20, 42, 15, -1, -34 },
  { 6082, 11, 34, 19, 5, -34 },
  { 6129, 19, 42, 15, -3, -34 },
  { 6229, 24, 22, 27, 1, -34 },
  { 6295, 20, 4, 19, -4, 4 },
  { 6305, 9, 8, 15, 7, -37 },
  { 6314, 25, 27, 28, 2, -27 },
  { 6399, 25, 36, 28, 1, -36 },
  { 6512, 21, 27, 23, 2, -27 },
  { 6583, 27, 36, 28, 2, -36 },
  { 6705, 22, 27, 26, 2, -27 },
  { 6780, 28, 49, 17, -5, -37 },
  { 6952, 26, 39, 28, 1, -27 },
  { 7079, 25, 36, 29, 1, -36 },
  { 7192, 14, 36, 14, 1, -36 },
  { 7255, 21, 48, 14, -6, -36 },
  { 7381, 27, 36, 26, 1, -36 },
  { 7503, 14, 36, 14, 1, -36 },
  { 7566, 39, 27, 43, 1, -27 },
  { 7698, 25, 27, 29, 1, -27 },
  { 7783, 24, 26, 28, 2, -26 },
  { 7861, 27, 39, 28, -1, -27 },
  { 7993, 25, 39, 28, 2, -27 },
  { 8115, 21, 27, 20, 1, -27 },
  { 8186, 21, 27, 22, 0, -27 },
  { 8257, 17, 32, 18, 2, -32 },
  { 8325, 25, 26, 29, 3, -26 },
  { 8407, 24, 26, 24, 2, -26 },
  { 8485, 36, 26, 37, 3, -26 },
  { 8602, 29, 26, 25, -2, -26 },
  { 8697, 30, 38, 24, -4, -26 },
  { 8840, 23, 26, 22, -1, -26 },
  { 8915, 20, 42, 17, 0, -34 },
  { 9020, 5, 47, 26, 11, -36 },
  { 9050, 19, 42, 17, -2, -34 },
  { 9150, 23, 8, 27, 3, -21 },
};

const GFXfont NotoSans_SemiBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMIBOLDITALIC48PT7B_H_
