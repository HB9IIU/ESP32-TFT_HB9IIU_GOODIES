#ifndef _NOTOSANS_SEMIBOLDITALIC11PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA4, 0x96, 0xDB, 0xA0, 0x14, 0x29, 0xF9, 0x22, 0x9F, 0xD2,
  0x28, 0x18, 0xF7, 0x1C, 0x18, 0xAF, 0x88, 0x20, 0x62, 0xA4, 0xA8, 0xAE,
  0xDD, 0x29, 0x4A, 0xCE, 0x1C, 0x48, 0xB1, 0xC7, 0x39, 0xF3, 0x3F, 0xE8,
  0x12, 0x64, 0x4C, 0xCC, 0x44, 0x31, 0x11, 0x11, 0x32, 0x4C, 0x37, 0x0F,
  0xA5, 0x00, 0x21, 0x09, 0xF2, 0x10, 0x78, 0xFC, 0x70, 0x04, 0x20, 0x84,
  0x30, 0x86, 0x30, 0x39, 0xB4, 0x53, 0x4F, 0x25, 0x9C, 0x37, 0xF2, 0x22,
  0x66, 0x39, 0xB0, 0xC2, 0x10, 0x84, 0x3E, 0x78, 0xB0, 0xCE, 0x18, 0x28,
  0xBC, 0x0C, 0x73, 0x8A, 0x4B, 0xF1, 0x84, 0x3C, 0x86, 0x1E, 0x08, 0x28,
  0xBC, 0x3B, 0x31, 0xE9, 0xCE, 0x5E, 0xF8, 0x44, 0x62, 0x33, 0x10, 0x38,
  0x96, 0x4E, 0x7B, 0x2C, 0x9E, 0x39, 0xB4, 0xD3, 0x7C, 0x21, 0xBC, 0x68,
  0x05, 0x80, 0x32, 0x00, 0x06, 0xC0, 0x09, 0xF1, 0x83, 0x04, 0xF8, 0x3E,
  0x86, 0x0C, 0x3E, 0x40, 0xF9, 0x12, 0x4C, 0x8C, 0x1C, 0x63, 0x9D, 0xA5,
  0xA5, 0xA9, 0xB6, 0x80, 0x7C, 0x0C, 0x18, 0x70, 0xB3, 0x67, 0xD8, 0xE1,
  0x3C, 0x4C, 0x9B, 0xE4, 0xC8, 0x93, 0x7C, 0x3D, 0x9C, 0x20, 0x82, 0x0C,
  0x1E, 0x3C, 0x4C, 0x8B, 0x14, 0x68, 0xD3, 0x7C, 0x3C, 0x82, 0x1E, 0x79,
  0x04, 0x3E, 0x3C, 0x82, 0x18, 0x79, 0x04, 0x30, 0x3D, 0x9C, 0x20, 0x9E,
  0x3C, 0x9E, 0x23, 0x22, 0x22, 0x7E, 0x7E, 0x46, 0x44, 0xC4, 0x79, 0x08,
  0x46, 0x31, 0x1C, 0x0C, 0x20, 0x86, 0x18, 0x41, 0x04, 0x33, 0x80, 0x23,
  0x24, 0x28, 0x78, 0x78, 0x58, 0x48, 0xCC, 0x21, 0x08, 0xC4, 0x21, 0x1F,
  0x31, 0xCC, 0x63, 0x39, 0xCA, 0x55, 0x95, 0x45, 0x93, 0x64, 0x31, 0x31,
  0x33, 0x7A, 0x4A, 0x4A, 0x4E, 0xC6, 0x3C, 0xCB, 0x1C, 0x38, 0x70, 0xB3,
  0x3C, 0x3C, 0x48, 0x9B, 0x27, 0x88, 0x10, 0x60, 0x3C, 0xCB, 0x1C, 0x38,
  0x70, 0xB3, 0x3C, 0x18, 0x10, 0x3C, 0x92, 0x5B, 0x79, 0x24, 0xB3, 0x3D,
  0x96, 0x1C, 0x18, 0x29, 0xBC, 0xFC, 0x82, 0x18, 0x61, 0x04, 0x10, 0x46,
  0x8B, 0x16, 0x28, 0xD1, 0xA2, 0x78, 0x86, 0x3C, 0xB6, 0xD1, 0xC6, 0x18,
  0x8C, 0xE3, 0x29, 0xDA, 0x74, 0xA7, 0x29, 0x8E, 0x63, 0x10, 0x33, 0x12,
  0x14, 0x1C, 0x18, 0x3C, 0x24, 0xC6, 0xCF, 0x25, 0x1C, 0x61, 0x84, 0x10,
  0x7C, 0x31, 0x84, 0x31, 0x8C, 0x3E, 0x32, 0x64, 0x44, 0x4C, 0x8C, 0x99,
  0x24, 0x93, 0x38, 0x84, 0x21, 0x18, 0x84, 0x27, 0x00, 0x10, 0xC2, 0x92,
  0xC4, 0xF8, 0xC0, 0x3D, 0xB4, 0xF2, 0x49, 0xE0, 0x20, 0x87, 0xDB, 0x45,
  0x34, 0xAE, 0x3B, 0x11, 0x84, 0x38, 0x06, 0x08, 0xF3, 0x64, 0xD9, 0x92,
  0x3C, 0x39, 0xB5, 0xB8, 0x41, 0xE0, 0x1C, 0x43, 0x8C, 0x30, 0x82, 0x08,
  0x63, 0x08, 0x00, 0x3D, 0xB4, 0xF3, 0x49, 0xE0, 0xAC, 0x60, 0x20, 0x87,
  0xD9, 0x4D, 0x34, 0xB2, 0x21, 0xB4, 0x96, 0x10, 0x33, 0x22, 0x26, 0x6C,
  0x80, 0x20, 0x86, 0xDE, 0x71, 0xC5, 0xB2, 0x25, 0xB4, 0x96, 0x7F, 0xB6,
  0x53, 0x29, 0x94, 0x9E, 0x48, 0x7D, 0x94, 0xD3, 0x4B, 0x20, 0x39, 0xB4,
  0xF3, 0x49, 0xE0, 0x7D, 0xB4, 0x53, 0x4B, 0xEC, 0x20, 0x80, 0x3D, 0xB4,
  0xD2, 0xC9, 0xE1, 0x86, 0x10, 0x7B, 0x10, 0x84, 0x60, 0x7A, 0x18, 0x61,
  0x78, 0x27, 0xE4, 0x44, 0x60, 0xCE, 0x67, 0x39, 0x78, 0x9C, 0xAD, 0x4E,
  0x60, 0x93, 0xB2, 0xBE, 0xFC, 0xCC, 0xC8, 0x26, 0x78, 0x60, 0xC2, 0x99,
  0x80, 0x26, 0x48, 0xB1, 0x43, 0x86, 0x0C, 0x70, 0xC0, 0x78, 0x8C, 0xC4,
  0x78, 0x19, 0x08, 0x4C, 0x21, 0x08, 0x43, 0x00, 0xFF, 0xE0, 0x30, 0x84,
  0x21, 0x9C, 0x84, 0x66, 0x00, 0xCD, 0xC0,
};

const GFXglyph NotoSans_SemiBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 5, 1, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 9, 6, 0, -8 },
  { 20, 8, 8, 9, 1, -8 },
  { 28, 7, 8, 8, 0, -8 },
  { 35, 2, 3, 3, 1, -8 },
  { 36, 4, 10, 4, 0, -8 },
  { 41, 4, 10, 4, -1, -8 },
  { 46, 5, 5, 6, 1, -8 },
  { 50, 5, 6, 6, 1, -7 },
  { 54, 3, 2, 3, -1, -1 },
  { 55, 3, 2, 4, 0, -4 },
  { 56, 2, 2, 3, 0, -2 },
  { 57, 6, 8, 4, -1, -8 },
  { 63, 6, 8, 6, 0, -8 },
  { 69, 4, 8, 6, 1, -8 },
  { 73, 6, 8, 6, 0, -8 },
  { 79, 6, 8, 6, 0, -8 },
  { 85, 6, 8, 6, 0, -8 },
  { 91, 6, 8, 6, 0, -8 },
  { 97, 5, 8, 6, 1, -8 },
  { 102, 5, 8, 6, 1, -8 },
  { 107, 6, 8, 6, 0, -8 },
  { 113, 6, 8, 6, 0, -8 },
  { 119, 3, 6, 3, 0, -6 },
  { 122, 4, 7, 3, -1, -6 },
  { 126, 5, 6, 6, 1, -7 },
  { 130, 5, 3, 6, 1, -5 },
  { 132, 5, 6, 6, 1, -7 },
  { 136, 4, 8, 5, 1, -8 },
  { 140, 8, 9, 9, 1, -8 },
  { 149, 7, 8, 7, -1, -8 },
  { 156, 7, 8, 7, 0, -8 },
  { 163, 6, 8, 7, 1, -8 },
  { 169, 7, 8, 7, 0, -8 },
  { 176, 6, 8, 6, 0, -8 },
  { 182, 6, 8, 6, 0, -8 },
  { 188, 6, 8, 8, 1, -8 },
  { 194, 8, 8, 8, 0, -8 },
  { 202, 5, 8, 4, 0, -8 },
  { 207, 6, 10, 3, -2, -8 },
  { 215, 8, 8, 7, 0, -8 },
  { 223, 5, 8, 6, 0, -8 },
  { 228, 10, 8, 10, 0, -8 },
  { 238, 8, 8, 8, 0, -8 },
  { 246, 7, 8, 8, 1, -8 },
  { 253, 7, 8, 7, 0, -8 },
  { 260, 7, 10, 8, 1, -8 },
  { 269, 6, 8, 7, 0, -8 },
  { 275, 6, 8, 6, 0, -8 },
  { 281, 6, 8, 6, 1, -8 },
  { 287, 7, 8, 8, 1, -8 },
  { 294, 6, 8, 6, 1, -8 },
  { 300, 10, 8, 10, 1, -8 },
  { 310, 8, 8, 6, -1, -8 },
  { 318, 6, 8, 6, 1, -8 },
  { 324, 6, 8, 6, 0, -8 },
  { 330, 4, 10, 3, 0, -8 },
  { 335, 3, 8, 4, 1, -8 },
  { 338, 5, 10, 3, -1, -8 },
  { 345, 6, 5, 6, 0, -8 },
  { 349, 5, 1, 4, -1, 1 },
  { 350, 2, 1, 3, 2, -8 },
  { 351, 6, 6, 6, 0, -6 },
  { 356, 6, 8, 6, 0, -8 },
  { 362, 5, 6, 5, 0, -6 },
  { 366, 7, 8, 6, 0, -8 },
  { 373, 6, 6, 6, 0, -6 },
  { 378, 6, 11, 4, -1, -8 },
  { 387, 6, 9, 6, 0, -6 },
  { 394, 6, 8, 7, 0, -8 },
  { 400, 3, 8, 3, 0, -8 },
  { 403, 4, 11, 3, -1, -8 },
  { 409, 6, 8, 6, 0, -8 },
  { 415, 3, 8, 3, 0, -8 },
  { 418, 9, 6, 10, 0, -6 },
  { 425, 6, 6, 7, 0, -6 },
  { 430, 6, 6, 6, 0, -6 },
  { 435, 6, 9, 6, 0, -6 },
  { 442, 6, 9, 6, 0, -6 },
  { 449, 5, 6, 5, 0, -6 },
  { 453, 5, 6, 5, 0, -6 },
  { 457, 4, 7, 4, 0, -7 },
  { 461, 5, 6, 7, 1, -6 },
  { 465, 5, 6, 5, 1, -6 },
  { 469, 8, 6, 8, 1, -6 },
  { 475, 7, 6, 6, -1, -6 },
  { 481, 7, 9, 5, -1, -6 },
  { 489, 5, 6, 5, 0, -6 },
  { 493, 5, 10, 4, 0, -8 },
  { 500, 1, 11, 6, 3, -8 },
  { 502, 5, 10, 4, -1, -8 },
  { 509, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_SemiBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMIBOLDITALIC11PT7B_H_
