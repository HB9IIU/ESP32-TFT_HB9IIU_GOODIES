#ifndef _NOTOSANS_SEMIBOLDITALIC25PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x30, 0x00, 0x20, 0x70, 0xF0, 0x70, 0xE7, 0xE7, 0xE6, 0xC6, 0xC6,
  0xCE, 0xCC, 0x03, 0x9C, 0x06, 0x30, 0x0C, 0x60, 0x39, 0xC0, 0x63, 0x8F,
  0xFF, 0xDF, 0xFF, 0x86, 0x38, 0x0C, 0x60, 0x18, 0xC0, 0x73, 0x87, 0xFF,
  0xEF, 0xFF, 0xC7, 0x18, 0x0C, 0x70, 0x18, 0xC0, 0x31, 0x80, 0xE7, 0x00,
  0x00, 0x80, 0x18, 0x07, 0xE1, 0xFF, 0x3F, 0xF3, 0xB0, 0x3B, 0x03, 0xB0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x06, 0xE0, 0x4E, 0x84, 0xEF, 0xFE,
  0xFF, 0xC7, 0xF0, 0x08, 0x01, 0x80, 0x3E, 0x03, 0x9F, 0x81, 0xC7, 0x70,
  0xE3, 0x9C, 0x30, 0xE7, 0x18, 0x31, 0xCE, 0x0C, 0x67, 0x03, 0x19, 0x9C,
  0xCE, 0xDF, 0xBF, 0x77, 0x77, 0xBB, 0x9C, 0x0C, 0xE7, 0x06, 0x31, 0xC3,
  0x8C, 0x71, 0xC3, 0x18, 0x60, 0xCE, 0x38, 0x3F, 0x1C, 0x07, 0x80, 0x03,
  0xE0, 0x0F, 0xF0, 0x0F, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0E,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x87, 0x7B, 0x8E, 0xF1, 0xDE, 0xE1,
  0xFC, 0xE0, 0xF8, 0xE0, 0x70, 0xFB, 0xF8, 0x7F, 0xFC, 0x3F, 0x1E, 0xFF,
  0xED, 0xB0, 0x03, 0x83, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x0E, 0x07,
  0x07, 0x07, 0x07, 0x00, 0x03, 0x80, 0x30, 0x43, 0x07, 0x30, 0xFE, 0x01,
  0xFF, 0x0F, 0xF1, 0xF0, 0x3B, 0x07, 0x38, 0x31, 0xC0, 0x10, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x39, 0xDC, 0xE6, 0x70, 0x7E, 0xFF, 0xF8, 0x27,
  0xFF, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x1E, 0xF3,
  0xC7, 0x38, 0x77, 0x87, 0x70, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xEE, 0x0E, 0xE1, 0xE7, 0x7C, 0x7F, 0x83, 0xF0, 0x03, 0x87,
  0xCF, 0xCF, 0xEF, 0x73, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE,
  0x10, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1F, 0xFE, 0xFF, 0xE7, 0xFF,
  0x00, 0x07, 0xE0, 0xFF, 0xC7, 0xFE, 0x10, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x3E, 0x0F, 0xC0, 0x7F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3A,
  0x03, 0xDE, 0x7C, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E,
  0x03, 0xF0, 0x3B, 0x01, 0xF8, 0x1D, 0xC1, 0xCE, 0x1C, 0x71, 0xC7, 0x1C,
  0x39, 0xC1, 0xCF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xF0, 0x7F, 0xC1, 0x9F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x72,
  0x07, 0x9C, 0xF8, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0xF8, 0x7F, 0xE3, 0xC7, 0xBC,
  0x1D, 0xE0, 0xEE, 0x0F, 0x70, 0x73, 0xC3, 0x8F, 0x78, 0x7F, 0xC1, 0xF8,
  0x00, 0x3F, 0xFC, 0xFF, 0xE7, 0xFF, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0xFF,
  0x87, 0x9C, 0x70, 0xF3, 0x83, 0x9E, 0x38, 0x73, 0xC3, 0xFC, 0x0F, 0x81,
  0xFE, 0x1E, 0x79, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9E, 0x3C, 0x7F,
  0xC1, 0xFC, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0x87, 0x70, 0x77, 0x07,
  0x70, 0x77, 0x07, 0x70, 0xF7, 0xFF, 0x3F, 0x70, 0xCE, 0x00, 0xE0, 0x1C,
  0x03, 0xC8, 0xF8, 0xFF, 0x0F, 0xE0, 0x1C, 0x73, 0xC7, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x1C, 0xF3, 0xC0, 0x0E, 0x1C, 0x78, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC3, 0x8E, 0x1C, 0x70, 0xE0, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x78, 0x1E, 0x07, 0x80, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x3F,
  0x0F, 0x87, 0xE0, 0xF8, 0x0C, 0x00, 0x3F, 0x3F, 0xE7, 0xFD, 0x07, 0x01,
  0xC0, 0xF0, 0x38, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x02,
  0x03, 0xC0, 0xF0, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xC3,
  0xC1, 0xE0, 0x0E, 0x1C, 0x00, 0x63, 0x87, 0xE7, 0x71, 0xFE, 0x76, 0x38,
  0xE3, 0x63, 0x0C, 0x7E, 0x70, 0xC7, 0xE7, 0x1C, 0x7E, 0x61, 0xC6, 0xE6,
  0x38, 0xEE, 0x7E, 0xFC, 0x63, 0xEF, 0x87, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x40, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x73, 0x00, 0xE6, 0x03, 0x8E, 0x07, 0x1C,
  0x1C, 0x38, 0x78, 0x70, 0xFF, 0xE3, 0xFF, 0xC7, 0x03, 0x9E, 0x07, 0x38,
  0x0E, 0xF0, 0x1F, 0xC0, 0x1C, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0x0F,
  0x1C, 0x1C, 0xF0, 0x73, 0x83, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0xC7, 0x87,
  0x1C, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x07, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE,
  0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0x8F, 0x02, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1F, 0x78, 0x7F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xF0, 0xE1, 0xE1, 0xC1, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x1D, 0xE0, 0x7B, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1C,
  0x3E, 0x7F, 0xF8, 0xFF, 0xE1, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F,
  0xF1, 0xF0, 0x27, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE1, 0xFD,
  0xC3, 0xFB, 0x87, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x3C, 0x1E, 0x3E,
  0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x1E, 0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x0F, 0x3C, 0x0E, 0x38, 0x0E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFC, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38, 0xF0,
  0x38, 0xE0, 0x38, 0xE0, 0x78, 0x0F, 0xE1, 0xFC, 0x1F, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x7F, 0x1F, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0xFE, 0x0F, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x1C, 0x1E, 0x1C, 0x3C, 0x1C,
  0x78, 0x1C, 0xF0, 0x3C, 0xE0, 0x39, 0xC0, 0x3B, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x71, 0xC0, 0x71, 0xC0, 0x71, 0xE0, 0x70, 0xE0, 0xE0,
  0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C,
  0x3E, 0x07, 0xE1, 0xB0, 0x3F, 0x1D, 0x83, 0xB8, 0xEC, 0x1F, 0x87, 0x61,
  0xDC, 0x3B, 0x8E, 0xE1, 0x9C, 0xE7, 0x1C, 0xE7, 0x38, 0xE7, 0x73, 0x87,
  0x3B, 0x1C, 0x39, 0xF8, 0xE1, 0x8F, 0x87, 0x1C, 0x3C, 0x38, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x00, 0x1E, 0x01, 0xC7, 0xC0, 0xE1, 0xF0, 0x38, 0x7C,
  0x0E, 0x1B, 0x83, 0x8E, 0xE0, 0xC3, 0xB8, 0x70, 0xE7, 0x1C, 0x39, 0xC7,
  0x0C, 0x71, 0xC7, 0x0E, 0xE1, 0xC3, 0xB8, 0x70, 0xEE, 0x1C, 0x1F, 0x86,
  0x07, 0xE3, 0x81, 0xF0, 0xE0, 0x3C, 0x38, 0x0F, 0x00, 0x03, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xE0, 0xF7, 0x80, 0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBC,
  0x1E, 0x3E, 0xFC, 0x7F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF,
  0x87, 0x0F, 0x1C, 0x1C, 0xF0, 0x73, 0x83, 0xCE, 0x0F, 0x38, 0xF8, 0xFF,
  0xC7, 0xFE, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF7, 0x80,
  0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBC, 0x1E, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x87, 0x0E, 0x1C, 0x3C, 0xF0, 0xF3, 0x83, 0x8E, 0x1E, 0x3F,
  0xF0, 0xFF, 0x87, 0xFC, 0x1C, 0x70, 0x71, 0xC1, 0xC3, 0x87, 0x0E, 0x3C,
  0x3C, 0xE0, 0x73, 0x81, 0xE0, 0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x38, 0x11,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xC0, 0x0E, 0x00, 0x72, 0x03, 0x9E, 0x7C, 0xFF, 0xC3, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x3C, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0,
  0xF7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x3D, 0xE0, 0x73,
  0x80, 0xE7, 0x01, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x7F, 0xF0, 0x7F,
  0xE0, 0x7F, 0x00, 0xE0, 0x1F, 0xC0, 0x39, 0xC0, 0xE3, 0x81, 0xC7, 0x07,
  0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x03,
  0x9C, 0x07, 0x70, 0x06, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x38, 0x1F, 0x81, 0xE0, 0xFE, 0x07, 0x83, 0x98, 0x3E, 0x0E,
  0x60, 0xF8, 0x71, 0xC7, 0xE1, 0xC7, 0x1F, 0x8E, 0x1C, 0xEE, 0x38, 0x73,
  0xB9, 0xE1, 0xCC, 0x67, 0x07, 0x71, 0x9C, 0x1D, 0x86, 0xE0, 0x7E, 0x1B,
  0x81, 0xF8, 0x6C, 0x06, 0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x78, 0x1E, 0x01,
  0xE0, 0x78, 0x00, 0x0E, 0x03, 0x87, 0x03, 0x81, 0xC3, 0xC0, 0xE3, 0xC0,
  0x71, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0xF1, 0xE0, 0xF0,
  0x70, 0x70, 0x3C, 0x78, 0x1E, 0x00, 0xF0, 0x3D, 0xC1, 0xE7, 0x07, 0x1C,
  0x3C, 0x70, 0xE0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x3F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xF0, 0x0F, 0xC3, 0xE0, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x90, 0xF8, 0x3E, 0x00, 0xC7, 0x39, 0xCE, 0x31, 0x8E, 0x73,
  0x9C, 0xE3, 0x18, 0xE7, 0x39, 0xC0, 0x07, 0xC1, 0xF0, 0x9C, 0x07, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x7C, 0x3F, 0x00, 0x03, 0x00,
  0x70, 0x07, 0x80, 0xF8, 0x0D, 0xC1, 0xCC, 0x18, 0xC3, 0x0E, 0x70, 0x66,
  0x06, 0xE0, 0x7C, 0x03, 0xFF, 0xFF, 0xF0, 0xE6, 0x73, 0x07, 0x18, 0xFD,
  0xCF, 0xFE, 0x71, 0xF7, 0x87, 0x38, 0x3B, 0xC1, 0xDE, 0x0E, 0xE0, 0xE7,
  0x07, 0x3C, 0x79, 0xE7, 0xC7, 0xEE, 0x1E, 0x60, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0xE0, 0xEF, 0xC7, 0xFE, 0x3C, 0x71, 0xC3,
  0xDE, 0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0xC3, 0xDE, 0x1C, 0xFB, 0xE7,
  0xFE, 0x33, 0xE0, 0x03, 0xC3, 0xFC, 0xFF, 0x1C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0xC7, 0xF8, 0x7F, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x1C, 0xE1, 0xFB, 0x8F,
  0xFE, 0x38, 0x79, 0xE1, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x73, 0x83, 0x8E,
  0x0E, 0x38, 0x78, 0xF3, 0xE1, 0xFF, 0x83, 0xCC, 0x00, 0x07, 0x81, 0xFE,
  0x3F, 0xF3, 0x87, 0x70, 0x77, 0x0E, 0xFF, 0xEF, 0xF8, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x8C, 0x7F, 0xC3, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xD0,
  0x0F, 0x00, 0x1C, 0x00, 0x3F, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xF0, 0x00, 0x03, 0x8C, 0x3F, 0x71, 0xFF, 0xC7, 0x0F,
  0x3C, 0x38, 0xE0, 0xE7, 0x83, 0x9E, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x8F,
  0x1E, 0x7C, 0x3F, 0x70, 0x7B, 0x80, 0x0E, 0x00, 0x38, 0x81, 0xE3, 0xFF,
  0x0F, 0xF8, 0x1F, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x60, 0xEF, 0xC7, 0xFE, 0x3C, 0x79, 0xC3, 0xDE, 0x1C, 0xE0, 0xE7,
  0x07, 0x38, 0x3B, 0xC3, 0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x78, 0x0C,
  0x3C, 0x70, 0x40, 0x07, 0x8E, 0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x3C,
  0x70, 0xE1, 0xC3, 0x80, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0x40, 0x00, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x3F, 0x07,
  0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0xF3, 0x87, 0x8E, 0x3C, 0x39, 0xE0, 0xEF, 0x07, 0x78, 0x1F, 0xC0,
  0x7F, 0x01, 0xFE, 0x0F, 0x38, 0x38, 0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x1E,
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87,
  0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x80, 0x38, 0xE1, 0xC3, 0xBF, 0x7E, 0x3F,
  0xF7, 0xF3, 0xC7, 0xC7, 0x38, 0x78, 0x77, 0x87, 0x07, 0x70, 0x70, 0x77,
  0x07, 0x0E, 0x70, 0xF0, 0xEF, 0x0E, 0x0E, 0xE0, 0xE0, 0xEE, 0x0E, 0x1E,
  0xE0, 0xE1, 0xCE, 0x1E, 0x1C, 0x1C, 0xE0, 0x77, 0xE1, 0xFF, 0x87, 0x8F,
  0x1C, 0x3C, 0xF0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x39, 0xE1, 0xE7, 0x07,
  0x1C, 0x1C, 0x70, 0x73, 0xC3, 0xC0, 0x03, 0x81, 0xFE, 0x3F, 0xF3, 0x87,
  0x70, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0xE7, 0xBE,
  0x7F, 0xC3, 0xF0, 0x0E, 0x70, 0x1D, 0xF8, 0x3F, 0xF0, 0x78, 0xE0, 0xE1,
  0xE3, 0xC3, 0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x78, 0x78, 0xF0, 0xE1,
  0xF7, 0xC3, 0xFF, 0x07, 0x7C, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x18, 0xFD, 0xCF, 0xFE, 0x70, 0xF7,
  0x87, 0x38, 0x3B, 0xC1, 0xDC, 0x0E, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xE7,
  0xC7, 0xEE, 0x1E, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x39, 0xCE, 0xF3, 0xFC, 0xF8, 0x3C, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x07, 0x83, 0xFC, 0xFF,
  0x1C, 0x23, 0x80, 0x78, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x61,
  0xCF, 0xF9, 0xFE, 0x00, 0x0C, 0x06, 0x07, 0x07, 0xFF, 0xFF, 0xFC, 0xE0,
  0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC8, 0xFC, 0x7E, 0x00,
  0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x87, 0x38, 0x39, 0xC1, 0xCE,
  0x0E, 0x70, 0xF7, 0x87, 0x38, 0x79, 0xE7, 0xC7, 0xEE, 0x3E, 0x70, 0xE0,
  0x7F, 0x03, 0xB8, 0x3C, 0xE1, 0xC7, 0x1E, 0x38, 0xE1, 0xCE, 0x0E, 0x70,
  0x77, 0x03, 0xB8, 0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0xE0,
  0xEC, 0x1C, 0x1D, 0x87, 0x87, 0x30, 0xF0, 0xE6, 0x3F, 0x38, 0xE6, 0xE7,
  0x1D, 0xDD, 0xC3, 0xB3, 0xB8, 0x7E, 0x76, 0x0F, 0xCF, 0xC1, 0xB1, 0xF8,
  0x3E, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF0, 0x00, 0x1C, 0x1E, 0x3C, 0x78,
  0x38, 0xE0, 0x73, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x73, 0x81, 0xC7, 0x07, 0x8F, 0x1E, 0x0E, 0x00, 0x1C,
  0x0F, 0x1C, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E,
  0x78, 0x0E, 0x70, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x3F, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x04, 0xFF, 0x8F, 0xF8,
  0x01, 0xC0, 0xF0, 0x7C, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x0F,
  0x0F, 0x83, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00,
  0xF0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x03, 0xC1, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0xC0,
  0x7C, 0x1F, 0x0F, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x83, 0xE0,
  0xF0, 0x38, 0x00, 0x38, 0x17, 0xF3, 0xFF, 0xF8, 0x3F,
};

const GFXglyph NotoSans_SemiBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 18, 7, 0, -18 },
  { 19, 8, 7, 11, 3, -18 },
  { 26, 15, 18, 16, 1, -18 },
  { 60, 12, 20, 14, 1, -19 },
  { 90, 18, 18, 21, 2, -18 },
  { 131, 16, 18, 17, 1, -18 },
  { 167, 3, 7, 6, 3, -18 },
  { 170, 9, 22, 8, 1, -18 },
  { 195, 9, 22, 8, -2, -18 },
  { 220, 12, 12, 14, 2, -19 },
  { 238, 12, 12, 14, 1, -15 },
  { 256, 5, 6, 7, -1, -3 },
  { 260, 7, 3, 8, 0, -8 },
  { 263, 4, 4, 7, 0, -4 },
  { 265, 13, 18, 10, -1, -18 },
  { 295, 12, 18, 14, 1, -18 },
  { 322, 9, 18, 14, 3, -18 },
  { 343, 13, 18, 14, 0, -18 },
  { 373, 13, 18, 14, 0, -18 },
  { 403, 13, 18, 14, 0, -18 },
  { 433, 13, 18, 14, 1, -18 },
  { 463, 13, 18, 14, 1, -18 },
  { 493, 14, 18, 14, 1, -18 },
  { 525, 13, 18, 14, 1, -18 },
  { 555, 12, 18, 14, 1, -18 },
  { 582, 6, 14, 7, 0, -14 },
  { 593, 7, 17, 7, -1, -14 },
  { 608, 12, 12, 14, 1, -15 },
  { 626, 11, 7, 14, 2, -12 },
  { 636, 12, 12, 14, 1, -15 },
  { 654, 10, 18, 11, 2, -18 },
  { 677, 20, 20, 21, 1, -18 },
  { 727, 15, 18, 15, -1, -18 },
  { 761, 14, 18, 15, 1, -18 },
  { 793, 14, 18, 15, 2, -18 },
  { 825, 15, 18, 17, 1, -18 },
  { 859, 13, 18, 13, 1, -18 },
  { 889, 13, 18, 13, 1, -18 },
  { 919, 15, 18, 17, 2, -18 },
  { 953, 16, 18, 17, 1, -18 },
  { 989, 11, 18, 9, -1, -18 },
  { 1014, 12, 23, 8, -4, -18 },
  { 1049, 16, 18, 15, 1, -18 },
  { 1085, 10, 18, 13, 1, -18 },
  { 1108, 21, 18, 22, 1, -18 },
  { 1156, 18, 18, 18, 1, -18 },
  { 1197, 15, 18, 18, 2, -18 },
  { 1231, 14, 18, 15, 1, -18 },
  { 1263, 15, 22, 18, 2, -18 },
  { 1305, 14, 18, 15, 1, -18 },
  { 1337, 13, 18, 13, 0, -18 },
  { 1367, 13, 18, 13, 2, -18 },
  { 1397, 15, 18, 17, 2, -18 },
  { 1431, 15, 18, 14, 2, -18 },
  { 1465, 22, 18, 22, 2, -18 },
  { 1515, 17, 18, 14, -1, -18 },
  { 1554, 14, 18, 14, 2, -18 },
  { 1586, 16, 18, 13, -1, -18 },
  { 1622, 10, 22, 8, 0, -18 },
  { 1650, 5, 18, 10, 3, -18 },
  { 1662, 10, 22, 8, -2, -18 },
  { 1690, 12, 12, 14, 1, -18 },
  { 1708, 10, 2, 10, -2, 2 },
  { 1711, 4, 4, 8, 4, -19 },
  { 1713, 13, 14, 15, 1, -14 },
  { 1736, 13, 19, 15, 1, -19 },
  { 1767, 11, 14, 12, 1, -14 },
  { 1787, 14, 19, 15, 1, -19 },
  { 1821, 12, 14, 13, 1, -14 },
  { 1842, 15, 25, 9, -3, -19 },
  { 1889, 14, 20, 15, 0, -14 },
  { 1924, 13, 19, 15, 1, -19 },
  { 1955, 7, 19, 7, 1, -19 },
  { 1972, 11, 25, 7, -3, -19 },
  { 2007, 14, 19, 14, 1, -19 },
  { 2041, 7, 19, 7, 1, -19 },
  { 2058, 20, 14, 22, 1, -14 },
  { 2093, 14, 14, 15, 0, -14 },
  { 2118, 12, 14, 14, 1, -14 },
  { 2139, 15, 20, 15, -1, -14 },
  { 2177, 13, 20, 15, 1, -14 },
  { 2210, 10, 14, 10, 1, -14 },
  { 2228, 11, 14, 11, 0, -14 },
  { 2248, 9, 17, 10, 1, -17 },
  { 2268, 13, 14, 15, 1, -14 },
  { 2291, 13, 14, 12, 1, -14 },
  { 2314, 19, 14, 19, 1, -14 },
  { 2348, 15, 14, 13, -1, -14 },
  { 2375, 16, 20, 12, -2, -14 },
  { 2415, 12, 14, 12, 0, -14 },
  { 2436, 10, 22, 9, 0, -18 },
  { 2464, 2, 25, 14, 6, -19 },
  { 2471, 10, 22, 9, -1, -18 },
  { 2499, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMIBOLDITALIC25PT7B_H_
