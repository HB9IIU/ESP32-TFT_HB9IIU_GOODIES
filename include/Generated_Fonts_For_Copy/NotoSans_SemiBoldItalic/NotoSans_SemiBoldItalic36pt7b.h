#ifndef _NOTOSANS_SEMIBOLDITALIC36PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x78, 0xF7,
  0x8F, 0x79, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE,
  0x38, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38,
  0x00, 0xF0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xF0, 0xE0, 0x03, 0x87,
  0x80, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC2, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x78,
  0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x07, 0xFE, 0x07, 0xFF,
  0xC3, 0xFF, 0xF1, 0xFB, 0x38, 0x7C, 0xC0, 0x1E, 0x30, 0x07, 0x9C, 0x01,
  0xF7, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0xDF, 0x00, 0x33, 0xE0, 0x1C, 0xF8, 0x07, 0x3E, 0x81, 0x8F,
  0x3C, 0x6F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x83, 0xFC,
  0x01, 0xE0, 0x7F, 0xC0, 0x38, 0x1E, 0x78, 0x0E, 0x07, 0x87, 0x03, 0xC0,
  0xF0, 0xE0, 0xF0, 0x1E, 0x3C, 0x1C, 0x03, 0x87, 0x87, 0x00, 0xF0, 0xF1,
  0xE0, 0x1E, 0x1E, 0x78, 0x03, 0xC3, 0x8E, 0x3C, 0x78, 0xF3, 0xDF, 0xC7,
  0x3C, 0xF7, 0xFC, 0xFF, 0xBC, 0xF7, 0x9F, 0xE7, 0x3C, 0x78, 0xF9, 0xE7,
  0x0F, 0x00, 0x79, 0xE1, 0xE0, 0x1E, 0x3C, 0x38, 0x03, 0x87, 0x87, 0x00,
  0xF0, 0xF1, 0xE0, 0x3C, 0x1C, 0x3C, 0x0F, 0x03, 0x87, 0x01, 0xC0, 0x79,
  0xE0, 0x78, 0x0F, 0xF8, 0x1E, 0x00, 0xFF, 0x07, 0x80, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xBE, 0x00, 0x7C,
  0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0xC7,
  0xC0, 0x07, 0xBF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x03, 0xCF, 0xFE, 0x0F, 0x9F, 0x3E, 0x1E, 0x7C, 0x3E, 0x7D,
  0xF0, 0x7F, 0xF3, 0xE0, 0x7F, 0xC7, 0xC0, 0x7F, 0x8F, 0x80, 0x7E, 0x1F,
  0x81, 0xF8, 0x1F, 0xDF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8, 0x3F,
  0xE1, 0xF8, 0x7B, 0xDF, 0xEF, 0x7B, 0x9C, 0xE7, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x06, 0x0E, 0x03, 0xC7, 0x01, 0xFB, 0x81, 0xFF, 0x9F, 0x1F, 0xFF,
  0x81, 0xFF, 0xC1, 0xF9, 0xE1, 0xFC, 0x01, 0xE7, 0x03, 0xF3, 0x80, 0xF1,
  0xE0, 0x30, 0xF0, 0x08, 0x3C, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0x1F, 0x1E,
  0x3E, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0x7F, 0xFF, 0xEF, 0xFB, 0xFE, 0x39,
  0xFF, 0xFF, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x0F, 0x87, 0xC7, 0xC0, 0xF1, 0xF0, 0x3C, 0xF8, 0x0F, 0x3E,
  0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x01,
  0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0xF9,
  0xE0, 0x7C, 0x78, 0x1F, 0x1F, 0x0F, 0x87, 0xEF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFC, 0x1F, 0xE3, 0xFF,
  0x3F, 0xFB, 0xF7, 0xCF, 0x3C, 0x61, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xC1, 0xF0,
  0x30, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x70, 0x3E, 0x04, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF9, 0x80, 0x3F, 0x3F, 0x3F, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x07,
  0xDE, 0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0xF0,
  0xF8, 0x3E, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x78, 0x1F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF1, 0x00, 0x7E,
  0x3E, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x9F, 0xC1, 0xEF,
  0xF8, 0xFF, 0xFF, 0x3F, 0x87, 0xCF, 0xC1, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x87,
  0xEF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE4, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xF7, 0xE0, 0xF8, 0x3E, 0x1E,
  0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xF0, 0xF0, 0x1F,
  0x7E, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xEF, 0x81, 0xF0,
  0xF8, 0x7C, 0x0F, 0x0F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xF0, 0x1E, 0x1F, 0x8F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xFB,
  0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x0F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03,
  0xEF, 0x03, 0xF7, 0xC3, 0xFB, 0xFF, 0xF8, 0xFF, 0xBC, 0x3F, 0x9E, 0x07,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC3,
  0x9F, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0x07, 0xC3,
  0xE3, 0xF0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x7C, 0x7E, 0x3F, 0x0F, 0x00, 0x01, 0xC0, 0x7C, 0x0F,
  0x83, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03,
  0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xE1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x70, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC3, 0xF8, 0x07,
  0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x3E,
  0x0F, 0x3C, 0x1F, 0xF8, 0xF7, 0x83, 0xFF, 0x87, 0x78, 0x7C, 0x78, 0x77,
  0x0F, 0x07, 0x07, 0xF0, 0xE0, 0x70, 0x7F, 0x1E, 0x0F, 0x07, 0xE1, 0xC0,
  0xF0, 0xFE, 0x1C, 0x0E, 0x0F, 0xE1, 0xC1, 0xE0, 0xEE, 0x1C, 0x1E, 0x1E,
  0xE1, 0xC3, 0xE3, 0xCE, 0x1F, 0xFF, 0xFC, 0xF1, 0xFE, 0xFF, 0x8F, 0x0F,
  0xC7, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x03, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x03, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3C,
  0x01, 0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xC0, 0x1E, 0x1E, 0x00,
  0x78, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x7F,
  0xE0, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x78, 0x1F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x87, 0xC1, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x78, 0xFF, 0x07, 0xC0, 0xFC, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE,
  0x07, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0x83, 0xF8, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF1,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC0,
  0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x07, 0xE1, 0xF0, 0x7F, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xE0, 0x38, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x0F,
  0xFB, 0xE0, 0x7F, 0xEF, 0x81, 0xFF, 0x3E, 0x07, 0xFC, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF8,
  0x0F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x78, 0x01,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0x81, 0xF8, 0x07, 0x83,
  0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x1F,
  0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8,
  0x3D, 0xC0, 0x1F, 0xE0, 0xF7, 0x00, 0x77, 0x83, 0xDC, 0x03, 0xDE, 0x0F,
  0x70, 0x0E, 0xF8, 0x3D, 0xC0, 0x7B, 0xC1, 0xF7, 0x83, 0xCF, 0x07, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x79, 0xF0, 0x79, 0xE1, 0xE7, 0xC1, 0xE7, 0x8F,
  0x1E, 0x0F, 0x1E, 0x3C, 0x78, 0x3C, 0x79, 0xE1, 0xE0, 0xF0, 0xE7, 0x8F,
  0x83, 0xC3, 0xBC, 0x3E, 0x1F, 0x0E, 0xF0, 0xF0, 0x78, 0x3F, 0x83, 0xC1,
  0xE0, 0xFE, 0x0F, 0x07, 0x83, 0xF0, 0x7C, 0x1E, 0x0F, 0xC1, 0xE0, 0xF8,
  0x3E, 0x07, 0x83, 0xC0, 0xF8, 0x1E, 0x00, 0x07, 0xE0, 0x07, 0xC1, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0x78, 0x1F, 0xC0, 0x1E, 0x07, 0xF0, 0x07, 0x83,
  0xFE, 0x03, 0xE0, 0xF7, 0x80, 0xF0, 0x3D, 0xE0, 0x3C, 0x0F, 0x7C, 0x0F,
  0x03, 0xCF, 0x03, 0xC1, 0xF3, 0xC1, 0xF0, 0x78, 0xF8, 0x78, 0x1E, 0x1E,
  0x1E, 0x07, 0x87, 0x87, 0x81, 0xE1, 0xF1, 0xE0, 0xF8, 0x3C, 0xF8, 0x3C,
  0x0F, 0x3C, 0x0F, 0x03, 0xEF, 0x03, 0xC0, 0x7B, 0xC1, 0xF0, 0x1E, 0xF0,
  0x78, 0x07, 0xFC, 0x1E, 0x00, 0xFE, 0x07, 0x80, 0x3F, 0x81, 0xE0, 0x0F,
  0xE0, 0xF8, 0x01, 0xF8, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x0F, 0xC3, 0xF0,
  0x0F, 0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0xC0, 0xFE, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0x83, 0xF0,
  0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x1F, 0x01, 0xF1, 0xF0, 0x3F, 0x1F, 0x0F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x0F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0xC0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x83,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0xF0,
  0x1F, 0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xE0, 0x3C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xF8, 0x78, 0x0F, 0x87, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0x81, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x20, 0x1F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01,
  0xF0, 0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xBE,
  0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x1F,
  0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF8,
  0x3C, 0x07, 0xC3, 0xE0, 0x1E, 0x1E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0xF8, 0x01, 0xE7, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1E, 0x78,
  0x07, 0xC0, 0x3E, 0x78, 0x07, 0xC0, 0x3E, 0x78, 0x0F, 0xC0, 0x7C, 0x78,
  0x0F, 0xC0, 0x7C, 0x78, 0x1F, 0xC0, 0x78, 0x78, 0x1F, 0xE0, 0xF8, 0x78,
  0x3D, 0xE0, 0xF0, 0x78, 0x3D, 0xE1, 0xF0, 0x78, 0x79, 0xE1, 0xE0, 0x78,
  0x79, 0xE1, 0xE0, 0x78, 0xF1, 0xE3, 0xE0, 0x78, 0xF1, 0xE3, 0xC0, 0x78,
  0xF1, 0xE7, 0xC0, 0x79, 0xE1, 0xE7, 0x80, 0x79, 0xE1, 0xEF, 0x80, 0x7B,
  0xC1, 0xEF, 0x00, 0x7B, 0xC1, 0xEF, 0x00, 0x7B, 0x81, 0xFE, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE7,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x78, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F,
  0x83, 0xC1, 0xF0, 0x3C, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x01, 0xE7,
  0xC0, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0x39, 0xC0, 0x1E, 0x78, 0x07, 0x0E, 0x03,
  0xC3, 0x81, 0xE0, 0xF0, 0x78, 0x1C, 0x3C, 0x07, 0x0E, 0x01, 0xE7, 0x80,
  0x39, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0,
  0xF8, 0xF1, 0xF1, 0xE1, 0xE1, 0xC0, 0x01, 0xE1, 0xC1, 0xFC, 0xF0, 0xFF,
  0xBC, 0x7F, 0xFF, 0x3F, 0x1F, 0xDF, 0x83, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E,
  0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C,
  0x07, 0xCF, 0x03, 0xE3, 0xE1, 0xF8, 0xFC, 0xFE, 0x3F, 0xF7, 0x87, 0xF9,
  0xE0, 0xFC, 0x70, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0xF0, 0x0F, 0x7F,
  0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xC3, 0xE1, 0xF0, 0x3C, 0x3E, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xF9, 0xF8,
  0xF7, 0xFE, 0x1E, 0xFF, 0x83, 0x8F, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF8, 0xFF, 0xE3, 0xF0, 0x4F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x04, 0xFE, 0x70, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x1E, 0x3C, 0x07, 0xF3, 0xC0, 0xFF, 0xBC, 0x1F,
  0xFF, 0xC3, 0xF1, 0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0,
  0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0xF8, 0x7E, 0x0F, 0xCF, 0xE0, 0xFF, 0xFE,
  0x07, 0xFD, 0xE0, 0x3F, 0x1C, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3E, 0x0F, 0x7C, 0x0F, 0x7C, 0x0F, 0x78, 0x1F, 0xF8, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x04, 0xFC, 0x1C, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF1, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0xE0, 0x7F, 0x3C, 0x3F, 0xF7, 0x87, 0xFF, 0xF1, 0xF8, 0xFE,
  0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x1E, 0x07, 0xC3,
  0xE1, 0xF8, 0x7E, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0x7C, 0x0F, 0xCF, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0xC0, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x78, 0x0F, 0x3F, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xE1, 0xE1, 0xF8, 0x3E, 0x3E, 0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x3E,
  0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF0,
  0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x01, 0xE3, 0xC0,
  0x7C, 0x00, 0x03, 0x81, 0xF0, 0x7C, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x0F, 0x03, 0xE1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x81, 0xF1, 0xF0, 0x1E, 0x3E, 0x01, 0xE7, 0xC0, 0x3E,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xEF, 0x80, 0x7C, 0x78, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x7C,
  0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x0E, 0x1E, 0x03, 0xE0, 0x71, 0xFC,
  0x7F, 0x87, 0xBF, 0xE7, 0xFE, 0x3D, 0xFF, 0xBF, 0xF1, 0xFC, 0x7F, 0x8F,
  0x8F, 0xC1, 0xF8, 0x3C, 0x7C, 0x0F, 0x81, 0xE7, 0xC0, 0xFC, 0x0F, 0x3E,
  0x07, 0xC0, 0xF9, 0xF0, 0x3E, 0x07, 0xCF, 0x01, 0xE0, 0x3C, 0x78, 0x0F,
  0x01, 0xE7, 0xC0, 0xF8, 0x0F, 0x3E, 0x07, 0xC0, 0xF9, 0xE0, 0x3E, 0x07,
  0xCF, 0x01, 0xE0, 0x3C, 0x78, 0x0F, 0x01, 0xE7, 0xC0, 0xF8, 0x1F, 0x3E,
  0x07, 0xC0, 0xF9, 0xE0, 0x3C, 0x07, 0xC0, 0x0E, 0x1F, 0x01, 0xCF, 0xF0,
  0x7B, 0xFF, 0x0F, 0x7F, 0xE1, 0xFC, 0x7C, 0x3F, 0x07, 0xC7, 0xC0, 0xF1,
  0xF8, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x1E, 0x03, 0xE7,
  0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F,
  0x01, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x03, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFB, 0xC0, 0x7D, 0xF0, 0x7C, 0xFE, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFC, 0x00, 0x03, 0x87, 0x80, 0x1C, 0xFF, 0x01, 0xEF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7E, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0xCF, 0xC1, 0xFF,
  0xFC, 0x0F, 0x7F, 0xC0, 0x79, 0xFC, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xC1, 0xFC, 0x70,
  0xFF, 0xBC, 0x7F, 0xFF, 0x3F, 0x1F, 0xDF, 0x83, 0xE7, 0xC0, 0xF9, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F,
  0x3C, 0x07, 0xCF, 0x03, 0xE3, 0xE1, 0xF8, 0xFC, 0xFE, 0x3F, 0xF7, 0x87,
  0xFB, 0xE0, 0xFC, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x0F, 0x1E, 0x1E, 0xFC, 0x7B, 0xF8, 0xF7, 0xE1, 0xFE, 0x43, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E,
  0x02, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x80, 0x7C, 0xE0,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x1E, 0x01, 0xFF, 0xBF, 0xFB, 0xFF, 0xDF, 0xFE, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xC8, 0x7F, 0xC1, 0xFE, 0x07, 0xF0, 0x1E, 0x03,
  0xE7, 0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F,
  0x9F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3E,
  0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x0F, 0xC7, 0xC3, 0xF0,
  0xFC, 0xFE, 0x1F, 0xFB, 0xC1, 0xFE, 0x78, 0x1F, 0x8F, 0x00, 0xF0, 0x07,
  0xFC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F,
  0x83, 0xE1, 0xE1, 0xF0, 0x78, 0x78, 0x1E, 0x3E, 0x07, 0x8F, 0x01, 0xE7,
  0xC0, 0x79, 0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x1F, 0x03, 0xFE, 0x03,
  0xE0, 0x7F, 0xC0, 0xFC, 0x0F, 0x78, 0x1F, 0x83, 0xEF, 0x07, 0xF0, 0x79,
  0xE0, 0xEE, 0x1F, 0x3C, 0x3D, 0xC3, 0xC7, 0xC7, 0x38, 0xF8, 0xF9, 0xE7,
  0x1E, 0x0F, 0x3C, 0xE7, 0xC1, 0xE7, 0x1C, 0xF0, 0x3D, 0xE3, 0x9E, 0x07,
  0xB8, 0x77, 0xC0, 0xFF, 0x0E, 0xF0, 0x1D, 0xC1, 0xDE, 0x03, 0xB8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x3C, 0x1F, 0x00,
  0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE3, 0xC0, 0x1F,
  0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0x7C, 0x3F, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xE0,
  0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x1C, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x02,
  0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x1F, 0xC0, 0x3E,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xF8, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x70,
  0x00, 0x7F, 0x80, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 26, 10, 1, -26 },
  { 34, 12, 10, 15, 4, -26 },
  { 49, 22, 26, 23, 1, -26 },
  { 121, 18, 29, 20, 1, -27 },
  { 187, 27, 26, 30, 2, -26 },
  { 275, 23, 26, 25, 1, -26 },
  { 350, 5, 10, 9, 4, -26 },
  { 357, 13, 32, 12, 1, -26 },
  { 409, 13, 32, 12, -3, -26 },
  { 461, 17, 18, 20, 3, -28 },
  { 500, 17, 17, 21, 2, -21 },
  { 537, 8, 9, 10, -2, -4 },
  { 546, 10, 4, 11, 1, -12 },
  { 551, 6, 5, 10, 0, -5 },
  { 555, 19, 26, 14, -2, -26 },
  { 617, 18, 26, 20, 1, -26 },
  { 676, 13, 26, 20, 4, -26 },
  { 719, 20, 26, 20, -1, -26 },
  { 784, 19, 26, 20, 0, -26 },
  { 846, 19, 26, 20, 0, -26 },
  { 908, 19, 26, 20, 1, -26 },
  { 970, 18, 26, 20, 2, -26 },
  { 1029, 19, 26, 20, 2, -26 },
  { 1091, 19, 26, 20, 1, -26 },
  { 1153, 17, 26, 20, 2, -26 },
  { 1209, 9, 20, 10, 0, -20 },
  { 1232, 11, 25, 10, -2, -20 },
  { 1267, 17, 18, 21, 2, -22 },
  { 1306, 17, 10, 21, 2, -18 },
  { 1328, 17, 18, 21, 2, -22 },
  { 1367, 14, 26, 16, 3, -26 },
  { 1413, 28, 29, 31, 2, -26 },
  { 1515, 22, 26, 22, -2, -26 },
  { 1587, 21, 26, 22, 1, -26 },
  { 1656, 21, 26, 22, 2, -26 },
  { 1725, 22, 26, 24, 1, -26 },
  { 1797, 19, 26, 19, 1, -26 },
  { 1859, 19, 26, 18, 1, -26 },
  { 1921, 22, 26, 25, 2, -26 },
  { 1993, 24, 26, 25, 1, -26 },
  { 2071, 16, 26, 13, -1, -26 },
  { 2123, 17, 33, 11, -6, -26 },
  { 2194, 24, 26, 21, 1, -26 },
  { 2272, 15, 26, 18, 1, -26 },
  { 2321, 30, 26, 31, 1, -26 },
  { 2419, 26, 26, 27, 1, -26 },
  { 2504, 23, 26, 26, 2, -26 },
  { 2579, 20, 26, 21, 1, -26 },
  { 2644, 23, 32, 26, 2, -26 },
  { 2736, 20, 26, 22, 1, -26 },
  { 2801, 18, 26, 19, 1, -26 },
  { 2860, 19, 26, 19, 3, -26 },
  { 2922, 22, 26, 25, 3, -26 },
  { 2994, 21, 26, 21, 3, -26 },
  { 3063, 32, 26, 32, 3, -26 },
  { 3167, 26, 26, 21, -2, -26 },
  { 3252, 20, 26, 20, 3, -26 },
  { 3317, 22, 26, 19, -1, -26 },
  { 3389, 15, 32, 11, -1, -26 },
  { 3449, 8, 26, 14, 4, -26 },
  { 3475, 14, 32, 11, -2, -26 },
  { 3531, 18, 17, 20, 1, -26 },
  { 3570, 15, 3, 14, -3, 3 },
  { 3576, 7, 6, 11, 5, -28 },
  { 3582, 18, 20, 21, 2, -20 },
  { 3627, 19, 27, 21, 1, -27 },
  { 3692, 15, 20, 17, 2, -20 },
  { 3730, 20, 27, 21, 2, -27 },
  { 3798, 16, 20, 19, 2, -20 },
  { 3838, 21, 37, 13, -4, -28 },
  { 3936, 19, 29, 21, 1, -20 },
  { 4005, 19, 27, 21, 1, -27 },
  { 4070, 10, 27, 10, 1, -27 },
  { 4104, 16, 36, 10, -5, -27 },
  { 4176, 20, 27, 19, 1, -27 },
  { 4244, 10, 27, 10, 1, -27 },
  { 4278, 29, 20, 32, 1, -20 },
  { 4351, 19, 20, 21, 1, -20 },
  { 4399, 17, 20, 21, 2, -20 },
  { 4442, 21, 29, 21, -1, -20 },
  { 4519, 18, 29, 21, 2, -20 },
  { 4585, 15, 20, 15, 1, -20 },
  { 4623, 16, 20, 17, 0, -20 },
  { 4663, 13, 24, 14, 2, -24 },
  { 4702, 19, 20, 21, 2, -20 },
  { 4750, 18, 20, 18, 2, -20 },
  { 4795, 27, 20, 27, 2, -20 },
  { 4863, 22, 20, 19, -2, -20 },
  { 4918, 23, 29, 18, -3, -20 },
  { 5002, 18, 20, 17, -1, -20 },
  { 5047, 15, 32, 13, 0, -26 },
  { 5107, 4, 35, 20, 8, -27 },
  { 5125, 15, 32, 13, -2, -26 },
  { 5185, 17, 5, 21, 2, -15 },
};

const GFXfont NotoSans_SemiBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMIBOLDITALIC36PT7B_H_
