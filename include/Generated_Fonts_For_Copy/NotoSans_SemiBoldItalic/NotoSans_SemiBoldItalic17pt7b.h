#ifndef _NOTOSANS_SEMIBOLDITALIC17PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCC, 0x63, 0x18, 0x8C, 0x00, 0x39, 0xC0, 0xDF, 0x6D, 0xA6,
  0x06, 0xC1, 0x98, 0x32, 0x3F, 0xF7, 0xFE, 0x32, 0x06, 0x43, 0xFE, 0xFF,
  0xC6, 0x40, 0x98, 0x33, 0x00, 0x02, 0x03, 0x07, 0xE6, 0x93, 0x41, 0xA0,
  0x78, 0x1E, 0x0B, 0x05, 0xBB, 0xDF, 0xC1, 0x00, 0x80, 0x38, 0x73, 0x62,
  0x33, 0x31, 0x9B, 0x0C, 0x90, 0x6D, 0x79, 0xDA, 0x41, 0xB3, 0x09, 0x90,
  0xCD, 0x8C, 0x6C, 0xC3, 0xC0, 0x1F, 0x07, 0x60, 0xCC, 0x19, 0x83, 0xE0,
  0x78, 0x5F, 0x36, 0x66, 0xC7, 0x98, 0xE3, 0xFE, 0x3E, 0xE0, 0xFE, 0x1C,
  0xC3, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x06, 0x00, 0x18,
  0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x8C, 0x61, 0x8C, 0x00, 0x18,
  0x18, 0xD8, 0xFF, 0x3F, 0x78, 0xC8, 0x4C, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x36, 0x6C, 0xF8, 0xFC, 0x01, 0x81, 0x80, 0xC0, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x00, 0x1E, 0x37, 0x63,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xC6, 0xFC, 0x78, 0x1C, 0xFF, 0xB6,
  0x18, 0x63, 0x8C, 0x30, 0xC3, 0x1C, 0x1F, 0x1F, 0xC8, 0x60, 0x30, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0xDF, 0xE0, 0x1F, 0x1D, 0xC0, 0x60,
  0x30, 0x30, 0xF0, 0x7C, 0x06, 0x03, 0x01, 0xBF, 0xDF, 0x80, 0x03, 0x83,
  0xC1, 0xE1, 0xE1, 0xB1, 0x99, 0x8D, 0x8C, 0xFF, 0x83, 0x01, 0x81, 0xC0,
  0x1F, 0x8F, 0xC4, 0x06, 0x03, 0xC1, 0xF8, 0x0C, 0x06, 0x03, 0x01, 0xBF,
  0x9F, 0x80, 0x1F, 0x3D, 0x70, 0x60, 0xEC, 0xFE, 0xE7, 0xC3, 0xC7, 0xC6,
  0xFE, 0x7C, 0x7F, 0xBF, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x30,
  0x38, 0x18, 0x1C, 0x00, 0x3F, 0x33, 0x63, 0x63, 0x36, 0x1C, 0x7E, 0xC6,
  0xC6, 0xC6, 0xEE, 0x7C, 0x3E, 0x77, 0x63, 0xC3, 0xC3, 0xE7, 0x7B, 0x36,
  0x06, 0x0E, 0xFC, 0xF8, 0x33, 0x00, 0x00, 0x0E, 0xE0, 0x18, 0xC0, 0x00,
  0x00, 0x06, 0x63, 0x30, 0x01, 0x03, 0x0F, 0x38, 0xE0, 0xE0, 0x3C, 0x0F,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x07, 0x3C,
  0xF0, 0xC0, 0x7C, 0xDC, 0x18, 0x30, 0xC7, 0x0C, 0x30, 0x00, 0x03, 0x87,
  0x00, 0x07, 0xE0, 0xE3, 0x8C, 0x06, 0xC7, 0xBC, 0xFC, 0xE4, 0x47, 0x62,
  0x73, 0x33, 0xD9, 0xB6, 0x77, 0x30, 0x00, 0xC0, 0x83, 0xF8, 0x03, 0x00,
  0x03, 0x80, 0xE0, 0x78, 0x1E, 0x0C, 0x87, 0x31, 0x8C, 0xFF, 0x3F, 0xDC,
  0x36, 0x0F, 0x83, 0x3F, 0x1F, 0xCC, 0x6C, 0x36, 0x3B, 0xF1, 0xFD, 0xC6,
  0xC3, 0x61, 0xBF, 0xDF, 0x80, 0x0F, 0xCF, 0xE7, 0x01, 0x80, 0x60, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x38, 0x07, 0xF0, 0xFC, 0x3F, 0x0F, 0xE3, 0x1D,
  0xC3, 0x60, 0xD8, 0x36, 0x1F, 0x86, 0xC1, 0xB0, 0xCF, 0xF3, 0xF0, 0x3F,
  0x9F, 0x8C, 0x0E, 0x06, 0x03, 0xF1, 0xF9, 0xC0, 0xC0, 0x60, 0x3F, 0x1F,
  0x80, 0x3F, 0x9F, 0x8C, 0x0E, 0x06, 0x03, 0xF1, 0xF9, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x00, 0x0F, 0xCF, 0xF3, 0x01, 0x80, 0x60, 0x39, 0xFC, 0x7F,
  0x06, 0xC1, 0xB8, 0x67, 0xF8, 0xFE, 0x30, 0x66, 0x18, 0xC3, 0x38, 0x66,
  0x0C, 0xFF, 0x9F, 0xE7, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x61, 0x80, 0x3E,
  0x38, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0xC7, 0xC0, 0x03, 0x03,
  0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0xB8,
  0xF8, 0x30, 0xE6, 0x30, 0xCC, 0x33, 0x06, 0xC0, 0xF8, 0x1F, 0x07, 0x60,
  0xCE, 0x18, 0xC3, 0x1C, 0x61, 0x80, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x38,
  0xC3, 0x0F, 0xFF, 0x38, 0x3C, 0xE0, 0xE2, 0x87, 0x9A, 0x1E, 0x68, 0xD9,
  0xA3, 0x66, 0xDB, 0x33, 0x6C, 0xCF, 0x33, 0x3C, 0xCC, 0xE3, 0x33, 0x18,
  0x38, 0x33, 0x86, 0x38, 0x66, 0xC6, 0x6C, 0x66, 0xCC, 0x66, 0xCC, 0x6C,
  0xC7, 0xCC, 0x3C, 0xC3, 0x8C, 0x38, 0x1F, 0x87, 0xF9, 0xC3, 0xB0, 0x36,
  0x07, 0xC0, 0xF0, 0x3E, 0x06, 0xC0, 0xDC, 0x31, 0xFE, 0x1F, 0x00, 0x3F,
  0x1F, 0xCC, 0x6C, 0x36, 0x1B, 0x1D, 0xFD, 0xF0, 0xC0, 0x60, 0x30, 0x18,
  0x00, 0x1F, 0x87, 0xF9, 0xC3, 0xB0, 0x36, 0x07, 0xC0, 0xF0, 0x3E, 0x06,
  0xC0, 0xDC, 0x31, 0xFE, 0x1F, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x3F, 0x1F,
  0xCC, 0x6E, 0x36, 0x3B, 0xF9, 0xF9, 0xD8, 0xC6, 0x63, 0x31, 0xD8, 0x60,
  0x1F, 0x9F, 0xCC, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x03, 0xBF,
  0x9F, 0x80, 0x7F, 0xFF, 0xC7, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x0E, 0x00, 0x30, 0x66, 0x19, 0xC3, 0x30, 0x66, 0x0C, 0xC3,
  0x98, 0x67, 0x0C, 0xC1, 0x9C, 0x71, 0xFC, 0x1F, 0x00, 0xC1, 0xE1, 0xB0,
  0xD8, 0xCC, 0x66, 0x63, 0x31, 0xB0, 0xD8, 0x78, 0x1C, 0x0C, 0x00, 0xC3,
  0x0F, 0x8E, 0x1B, 0x1C, 0x66, 0x78, 0xCC, 0xF3, 0x1B, 0x66, 0x36, 0x5C,
  0x68, 0xB0, 0xF1, 0x61, 0xE3, 0x83, 0x87, 0x07, 0x0C, 0x00, 0x18, 0x71,
  0xC6, 0x0C, 0xC0, 0xD8, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xF0, 0x1B, 0x83,
  0x18, 0x71, 0x8E, 0x1C, 0xC3, 0xE3, 0xB1, 0x9D, 0x87, 0xC3, 0xC1, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x3F, 0xCF, 0xE0, 0x38, 0x1C, 0x06,
  0x03, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0F, 0xF3, 0xFC, 0x1E, 0x20, 0xC1,
  0x83, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x1E, 0x38, 0x00, 0xCC,
  0xCC, 0x46, 0x66, 0x66, 0x63, 0x1E, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C,
  0x18, 0x30, 0x41, 0x83, 0x1E, 0x3C, 0x00, 0x04, 0x07, 0x07, 0x82, 0x43,
  0x31, 0x09, 0x87, 0x83, 0xFE, 0xE6, 0x30, 0x3D, 0xBB, 0xB8, 0xD8, 0x6C,
  0x36, 0x33, 0x19, 0xFC, 0x76, 0x00, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x79,
  0xDC, 0xC6, 0x63, 0x61, 0xB0, 0xD8, 0xCF, 0xED, 0xE0, 0x3E, 0xE7, 0x86,
  0x0C, 0x18, 0x30, 0x7E, 0x7C, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xF3, 0xBB,
  0x8D, 0x86, 0xC3, 0x63, 0x31, 0x9F, 0xC7, 0x60, 0x3E, 0x77, 0xE3, 0xCE,
  0xFC, 0xC0, 0xC0, 0xFC, 0x7C, 0x03, 0xC1, 0xF0, 0x60, 0x18, 0x1F, 0x83,
  0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x83,
  0xC0, 0xE0, 0x00, 0x1E, 0xCE, 0xE7, 0x19, 0x86, 0x61, 0x98, 0xC6, 0x31,
  0xFC, 0x3B, 0x01, 0xC0, 0x63, 0xF8, 0xFC, 0x00, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x79, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0xD8, 0xCC, 0x6E, 0x30, 0x18,
  0xC4, 0x03, 0x18, 0xC6, 0x63, 0x18, 0xCE, 0x00, 0x06, 0x0C, 0x10, 0x00,
  0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x78, 0xE0, 0x18,
  0x06, 0x01, 0x80, 0xC1, 0x31, 0x8C, 0xC3, 0x60, 0xF0, 0x7C, 0x1F, 0x86,
  0x61, 0x9C, 0xE3, 0x00, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x63, 0x18, 0xCE,
  0x00, 0x37, 0xBC, 0xE7, 0xB3, 0x1C, 0xCC, 0x63, 0x61, 0x8D, 0x8C, 0x36,
  0x31, 0x98, 0xC6, 0xE3, 0x18, 0x37, 0x9C, 0xCC, 0x66, 0x36, 0x1B, 0x1D,
  0x8C, 0xC6, 0xE3, 0x00, 0x3E, 0x77, 0xE3, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE,
  0x7C, 0x1B, 0xC7, 0x71, 0x8C, 0x63, 0x30, 0xCC, 0x33, 0x18, 0xFE, 0x7F,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x3D, 0xBB, 0xB8, 0xD8, 0x6C, 0x36,
  0x33, 0x19, 0xFC, 0x76, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x37, 0x3E, 0x30,
  0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0x3E, 0xE5, 0x83, 0xC3, 0xC1, 0xC3,
  0xFE, 0xF8, 0x30, 0xCF, 0xD8, 0x61, 0x8E, 0x30, 0xC3, 0xCF, 0x00, 0x63,
  0xB1, 0x98, 0xDC, 0x6C, 0x36, 0x3B, 0x19, 0xFC, 0x76, 0x00, 0xC3, 0xC6,
  0xC6, 0xCC, 0xCC, 0x58, 0x58, 0x70, 0x70, 0xC6, 0x3E, 0x71, 0xB3, 0xD9,
  0xB6, 0xCD, 0xBE, 0x69, 0xE3, 0xCF, 0x1C, 0x70, 0xE3, 0x80, 0x39, 0xC6,
  0x61, 0xF0, 0x38, 0x0E, 0x07, 0x83, 0xF1, 0xCC, 0xE3, 0x80, 0x30, 0xCC,
  0x63, 0x18, 0xCC, 0x13, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x83,
  0xC0, 0xE0, 0x00, 0x3F, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xFC, 0xFC,
  0x0E, 0x3C, 0x60, 0xC1, 0x86, 0x3C, 0x70, 0x20, 0x61, 0x83, 0x06, 0x0E,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x38, 0x30, 0x60, 0x83,
  0x03, 0x07, 0x18, 0x20, 0xC1, 0x83, 0x1C, 0x30, 0x00, 0xF9, 0x9F,
};

const GFXglyph NotoSans_SemiBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 5, 0, -12 },
  { 9, 6, 4, 7, 2, -12 },
  { 12, 11, 12, 11, 0, -12 },
  { 29, 9, 14, 9, 0, -13 },
  { 45, 13, 12, 14, 1, -12 },
  { 65, 11, 12, 12, 1, -12 },
  { 82, 2, 4, 4, 2, -12 },
  { 83, 6, 15, 5, 1, -12 },
  { 95, 6, 15, 5, -1, -12 },
  { 107, 8, 8, 9, 2, -13 },
  { 115, 8, 8, 10, 1, -10 },
  { 123, 4, 4, 5, -1, -2 },
  { 125, 5, 1, 5, 0, -5 },
  { 126, 3, 2, 5, 0, -2 },
  { 127, 9, 12, 7, -1, -12 },
  { 141, 8, 12, 9, 1, -12 },
  { 153, 6, 12, 9, 2, -12 },
  { 162, 9, 12, 9, 0, -12 },
  { 176, 9, 12, 9, 0, -12 },
  { 190, 9, 12, 9, 0, -12 },
  { 204, 9, 12, 9, 0, -12 },
  { 218, 8, 12, 9, 1, -12 },
  { 230, 9, 12, 9, 1, -12 },
  { 244, 8, 12, 9, 1, -12 },
  { 256, 8, 12, 9, 1, -12 },
  { 268, 4, 9, 5, 0, -9 },
  { 273, 5, 11, 5, -1, -9 },
  { 280, 8, 9, 10, 1, -11 },
  { 289, 8, 4, 10, 1, -8 },
  { 293, 8, 9, 10, 1, -11 },
  { 302, 7, 12, 8, 1, -12 },
  { 313, 13, 14, 15, 1, -12 },
  { 336, 10, 12, 10, -1, -12 },
  { 351, 9, 12, 10, 1, -12 },
  { 365, 10, 12, 10, 1, -12 },
  { 380, 10, 12, 11, 1, -12 },
  { 395, 9, 12, 9, 1, -12 },
  { 409, 9, 12, 9, 1, -12 },
  { 423, 10, 12, 12, 1, -12 },
  { 438, 11, 12, 12, 1, -12 },
  { 455, 7, 12, 6, 0, -12 },
  { 466, 8, 15, 5, -3, -12 },
  { 481, 11, 12, 10, 1, -12 },
  { 498, 6, 12, 9, 1, -12 },
  { 507, 14, 12, 15, 1, -12 },
  { 528, 12, 12, 13, 1, -12 },
  { 546, 11, 12, 12, 1, -12 },
  { 563, 9, 12, 10, 1, -12 },
  { 577, 11, 15, 12, 1, -12 },
  { 598, 9, 12, 10, 1, -12 },
  { 612, 9, 12, 9, 0, -12 },
  { 626, 9, 12, 9, 1, -12 },
  { 640, 11, 12, 12, 1, -12 },
  { 657, 9, 12, 10, 2, -12 },
  { 671, 15, 12, 15, 2, -12 },
  { 694, 12, 12, 10, -1, -12 },
  { 712, 9, 12, 9, 2, -12 },
  { 726, 10, 12, 9, 0, -12 },
  { 741, 7, 15, 5, 0, -12 },
  { 755, 4, 12, 7, 2, -12 },
  { 761, 7, 15, 5, -1, -12 },
  { 775, 9, 8, 10, 0, -12 },
  { 784, 7, 1, 7, -2, 2 },
  { 785, 4, 3, 5, 2, -13 },
  { 787, 9, 9, 10, 1, -9 },
  { 798, 9, 13, 10, 0, -13 },
  { 813, 7, 9, 8, 1, -9 },
  { 821, 9, 13, 10, 1, -13 },
  { 836, 8, 9, 9, 1, -9 },
  { 845, 10, 17, 6, -2, -13 },
  { 867, 10, 13, 10, 0, -9 },
  { 884, 9, 13, 10, 0, -13 },
  { 899, 5, 13, 5, 0, -13 },
  { 908, 7, 17, 5, -2, -13 },
  { 923, 10, 13, 9, 0, -13 },
  { 940, 5, 13, 5, 0, -13 },
  { 949, 14, 9, 15, 0, -9 },
  { 965, 9, 9, 10, 0, -9 },
  { 976, 8, 9, 10, 1, -9 },
  { 985, 10, 13, 10, -1, -9 },
  { 1002, 9, 13, 10, 1, -9 },
  { 1017, 8, 9, 7, 0, -9 },
  { 1026, 7, 9, 8, 0, -9 },
  { 1034, 6, 11, 6, 1, -11 },
  { 1043, 9, 9, 10, 1, -9 },
  { 1054, 8, 9, 8, 1, -9 },
  { 1063, 13, 9, 13, 1, -9 },
  { 1078, 10, 9, 9, -1, -9 },
  { 1090, 10, 13, 8, -1, -9 },
  { 1107, 8, 9, 8, 0, -9 },
  { 1116, 7, 15, 6, 0, -12 },
  { 1130, 2, 17, 9, 4, -13 },
  { 1135, 7, 15, 6, -1, -12 },
  { 1149, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_SemiBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMIBOLDITALIC17PT7B_H_
