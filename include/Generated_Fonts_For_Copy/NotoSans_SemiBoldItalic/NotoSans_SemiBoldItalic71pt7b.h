#ifndef _NOTOSANS_SEMIBOLDITALIC71PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x1F,
  0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0xF8, 0xFC, 0x03, 0xFF, 0x0F, 0x01, 0xC0,
  0x3F, 0xE1, 0xF0, 0x04, 0x03, 0xFE, 0x1F, 0x00, 0x00, 0x3F, 0xC1, 0xF0,
  0x00, 0x03, 0xFC, 0x1E, 0x00, 0x00, 0x3F, 0xC3, 0xE0, 0x00, 0x03, 0xFE,
  0x3E, 0x00, 0x00, 0x3F, 0xE3, 0xE0, 0x00, 0x03, 0xFF, 0x3E, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x7F,
  0xF0, 0x00, 0x01, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0x0F, 0xF8, 0x00, 0x01,
  0xF0, 0xFF, 0x80, 0x00, 0x1E, 0x0F, 0xF8, 0x00, 0x03, 0xE0, 0xFF, 0x80,
  0x00, 0x3E, 0x0F, 0xF8, 0x80, 0x03, 0xE1, 0xFF, 0x0E, 0x00, 0x3E, 0x1F,
  0xF0, 0xFC, 0x03, 0xC7, 0xFF, 0x0F, 0xFC, 0x7D, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x83,
  0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xFE, 0x3F, 0x81, 0xFE,
  0x3F, 0x87, 0xFF, 0xE7, 0xF0, 0x7F, 0x8F, 0xF1, 0xFF, 0xFE, 0xFF, 0x1F,
  0xF1, 0xFC, 0x7F, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0x1F, 0xFF, 0xFD, 0xFF,
  0xFF, 0x1F, 0xC7, 0xFC, 0x7F, 0xBF, 0xFF, 0xC7, 0xF8, 0xFF, 0x07, 0xF3,
  0xFF, 0xF0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xFC, 0x3F, 0x87, 0xF8, 0x1F,
  0xC3, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0x83, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xF0,
  0x03, 0xFE, 0x07, 0xFF, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xF9, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xF1, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0xFF,
  0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x60, 0x03, 0xF0, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xF0, 0xFC, 0x00,
  0x1F, 0xFE, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0x1F, 0xF0, 0x0F, 0xFF, 0x80, 0x08, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x1F, 0xF8,
  0x7F, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC,
  0x07, 0xF8, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x1F, 0x87, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xF0, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F,
  0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x87, 0xFC, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xBF, 0xCF, 0xFF, 0x3F, 0xE3,
  0xFF, 0x1F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xF8, 0x1C, 0x07, 0xFC,
  0x0C, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC,
  0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xFC,
  0x00, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x3E, 0x00,
  0x3F, 0xF8, 0x01, 0xC0, 0x00, 0xFF, 0xC0, 0x04, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x02, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x84, 0x00, 0x00, 0x1F, 0xF8, 0x38, 0x00,
  0x01, 0xFF, 0xC1, 0xF8, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xBF, 0xFF, 0xC0, 0x02, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x04, 0x00, 0x00,
  0x3F, 0xF0, 0x38, 0x00, 0x07, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x04, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x0C, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xC3, 0xFF, 0xF0, 0x03,
  0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE7, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xE0,
  0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xFC, 0xFF,
  0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC,
  0x7F, 0xC0, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x1F,
  0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFE, 0x3F, 0xC0, 0x07, 0xFF, 0x87, 0xF8,
  0x00, 0x1F, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x60, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x01, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFC, 0x07, 0xFE, 0x0F, 0x00, 0x1F, 0xF8, 0x60, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0xF0, 0x1F, 0xC0, 0x3F, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0x7F, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x3F, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x7F,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7E, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0xFE, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0xFE, 0x03, 0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xFE, 0x1F, 0xF0, 0x7F, 0x01, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x7F,
  0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xF8, 0x3F, 0xFF,
  0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0x80, 0x07,
  0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x60, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x1F,
  0xF8, 0x00, 0x7F, 0xFF, 0xE3, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xC0,
  0x03, 0xFF, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x00, 0x0F,
  0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x38, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC7, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xF7, 0xF0,
  0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE,
  0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F,
  0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xF8,
  0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x3F,
  0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xFC,
  0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xF8,
  0x0F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x80, 0x0F, 0xF0,
  0x1F, 0xC7, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xDF, 0xE0, 0x1F, 0xF0, 0x01,
  0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF8,
  0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xBF, 0xC0, 0x07, 0xF8, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xD0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x87, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0xFE, 0x00, 0x02, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x06, 0x00, 0x00, 0x7F,
  0xF0, 0x3C, 0x00, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0xFF, 0xDF, 0xE0,
  0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x07,
  0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xEF, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC0,
  0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC3,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xE3,
  0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF1, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0x3F, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0xFE,
  0x00, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0xFE, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x7F, 0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0xE0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xEF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x7F, 0x00, 0x3F, 0xFF, 0xE7, 0xF8, 0x01, 0xFF, 0xFE, 0x3F,
  0xC0, 0x07, 0xFF, 0xE1, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0xF8,
  0xFF, 0xFC, 0x00, 0x7F, 0xCF, 0xFF, 0xF0, 0x03, 0xFC, 0xFF, 0xFF, 0x80,
  0x1F, 0xEF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F,
  0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0xCF, 0xFF, 0xFC, 0x01, 0xFC,
  0x3F, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x7C, 0x07, 0xFF, 0x00, 0x18, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x30, 0x3F, 0xF8, 0x03, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0B, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC7,
  0xFC, 0x00, 0x1F, 0xFF, 0xF3, 0xFE, 0x00, 0x1F, 0xFF, 0xFD, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x7F, 0x00, 0x03, 0xFF, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x3F, 0x80,
  0x00, 0x1F, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xDF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F,
  0xFC, 0x7F, 0xC0, 0x1F, 0xFE, 0x7F, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0xFF, 0xE0, 0x01, 0xE0, 0x3F,
  0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x04, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x40, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0x87, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x81, 0xFC, 0x00, 0x3F,
  0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0xFF, 0x9F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xF8, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFD, 0xFE, 0x00, 0x3F, 0xFF,
  0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xF8, 0x00, 0x7F, 0xFF, 0x9F, 0xF0,
  0x00, 0x7F, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x04,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x07, 0xFE,
  0x00, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x0F,
  0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xFF, 0xE0, 0x1F,
  0xE7, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x30, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x01,
  0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE1,
  0xFF, 0xBF, 0x87, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0xFE, 0x00, 0x3F, 0x87, 0xFF, 0xFC, 0x00, 0xFE, 0x3F, 0xFF,
  0xF0, 0x03, 0xF9, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0x80, 0x01,
  0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0x9F, 0xFF, 0xE0, 0x00,
  0x7F, 0xC7, 0xFF, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x1E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xC0, 0x0F,
  0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0xFE, 0x7F,
  0x00, 0xFF, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xDF, 0xE0, 0x0F, 0xFF, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xF8, 0x01,
  0xFF, 0xFE, 0x7F, 0xC0, 0x07, 0xFF, 0xC3, 0xFC, 0x00, 0x0F, 0xFC, 0x1F,
  0xE0, 0x00, 0x1F, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x03, 0xF8, 0x3F, 0xF0, 0x1F, 0xE1, 0xFF, 0x80, 0x7F, 0x8F, 0xFE, 0x01,
  0xFE, 0x7F, 0xF8, 0x07, 0xF3, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x10, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0x00, 0x7C, 0x0F, 0xFC, 0x00, 0x30, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x08, 0x00, 0x07, 0xFC, 0x38, 0x00, 0x3F, 0xF0, 0xFE,
  0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x41, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x80, 0x7F, 0xFB, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFB,
  0xFC, 0x03, 0xFF, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0xF8, 0xFE, 0x00, 0x7F,
  0xFF, 0x87, 0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0x80, 0x07, 0xFF, 0x01, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xF8,
  0x00, 0x07, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xFC,
  0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFE,
  0x7F, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0x87, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0x81, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFE, 0x7F, 0x01, 0xFE,
  0x01, 0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xC7, 0xF0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xF8,
  0x7F, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xE0, 0x07, 0xF8,
  0x7F, 0x07, 0xF0, 0xFF, 0x80, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x00,
  0x7F, 0x8F, 0xF0, 0x7F, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x80, 0x07, 0xF9, 0xFE, 0x07, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x1F,
  0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F, 0xC0, 0x01, 0xFE, 0xFE,
  0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xF8, 0x00, 0x1F,
  0xEF, 0xC0, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x10, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x4F, 0xFF, 0xF0,
  0x00, 0x37, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0xC0, 0x00, 0x7F, 0xFF, 0x20, 0x00, 0x03, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 20, 52, 20, 1, -51 },
  { 131, 25, 19, 31, 7, -51 },
  { 191, 44, 51, 46, 2, -51 },
  { 472, 36, 58, 39, 2, -54 },
  { 733, 51, 52, 59, 5, -51 },
  { 1065, 46, 52, 49, 2, -51 },
  { 1364, 11, 19, 17, 7, -51 },
  { 1391, 25, 62, 23, 3, -51 },
  { 1585, 25, 62, 23, -5, -51 },
  { 1779, 33, 34, 39, 7, -54 },
  { 1920, 34, 34, 41, 4, -42 },
  { 2065, 16, 17, 20, -3, -8 },
  { 2099, 20, 8, 23, 1, -23 },
  { 2119, 11, 11, 20, 1, -10 },
  { 2135, 37, 51, 28, -3, -51 },
  { 2371, 35, 52, 39, 3, -51 },
  { 2599, 25, 51, 39, 8, -51 },
  { 2759, 39, 51, 39, -1, -51 },
  { 3008, 37, 52, 39, 1, -51 },
  { 3249, 38, 51, 39, 0, -51 },
  { 3492, 37, 52, 39, 2, -51 },
  { 3733, 36, 52, 39, 4, -51 },
  { 3967, 37, 51, 39, 4, -51 },
  { 4203, 37, 52, 39, 2, -51 },
  { 4444, 35, 52, 39, 3, -51 },
  { 4672, 17, 40, 20, 1, -39 },
  { 4757, 22, 48, 20, -4, -39 },
  { 4889, 34, 37, 41, 4, -44 },
  { 5047, 34, 20, 41, 4, -35 },
  { 5132, 34, 37, 41, 4, -44 },
  { 5290, 29, 52, 32, 5, -51 },
  { 5479, 56, 57, 61, 3, -51 },
  { 5878, 43, 51, 43, -4, -51 },
  { 6153, 41, 51, 43, 2, -51 },
  { 6415, 41, 52, 43, 5, -51 },
  { 6682, 44, 51, 48, 2, -51 },
  { 6963, 38, 51, 38, 2, -51 },
  { 7206, 38, 51, 36, 2, -51 },
  { 7449, 43, 52, 49, 5, -51 },
  { 7729, 47, 51, 49, 2, -51 },
  { 8029, 32, 51, 26, -2, -51 },
  { 8233, 34, 65, 22, -11, -51 },
  { 8510, 47, 51, 42, 2, -51 },
  { 8810, 29, 51, 36, 2, -51 },
  { 8995, 60, 51, 61, 2, -51 },
  { 9378, 51, 51, 52, 2, -51 },
  { 9704, 44, 52, 52, 5, -51 },
  { 9990, 40, 51, 42, 2, -51 },
  { 10245, 44, 63, 52, 5, -51 },
  { 10592, 40, 51, 43, 2, -51 },
  { 10847, 37, 52, 37, 1, -51 },
  { 11088, 36, 51, 37, 6, -51 },
  { 11318, 44, 52, 49, 5, -51 },
  { 11604, 41, 51, 41, 6, -51 },
  { 11866, 62, 51, 62, 7, -51 },
  { 12262, 51, 51, 41, -4, -51 },
  { 12588, 39, 51, 39, 6, -51 },
  { 12837, 43, 51, 38, -2, -51 },
  { 13112, 29, 62, 22, -1, -51 },
  { 13337, 15, 51, 28, 8, -51 },
  { 13433, 29, 62, 22, -5, -51 },
  { 13658, 36, 33, 40, 2, -51 },
  { 13807, 29, 5, 28, -6, 6 },
  { 13826, 14, 11, 22, 10, -54 },
  { 13846, 37, 40, 41, 3, -39 },
  { 14031, 37, 55, 42, 2, -54 },
  { 14286, 31, 40, 34, 3, -39 },
  { 14441, 41, 55, 42, 3, -54 },
  { 14723, 33, 40, 38, 3, -39 },
  { 14888, 41, 71, 25, -8, -54 },
  { 15252, 39, 56, 42, 1, -39 },
  { 15525, 36, 54, 42, 2, -54 },
  { 15768, 19, 53, 20, 2, -53 },
  { 15894, 31, 70, 20, -9, -53 },
  { 16166, 40, 54, 38, 1, -54 },
  { 16436, 21, 54, 20, 1, -54 },
  { 16578, 58, 39, 63, 2, -39 },
  { 16861, 38, 39, 42, 1, -39 },
  { 17047, 35, 40, 41, 3, -39 },
  { 17222, 41, 56, 42, -2, -39 },
  { 17509, 37, 56, 42, 3, -39 },
  { 17768, 30, 39, 29, 2, -39 },
  { 17915, 30, 40, 33, 1, -39 },
  { 18065, 26, 48, 27, 3, -47 },
  { 18221, 37, 39, 42, 4, -38 },
  { 18402, 36, 38, 35, 3, -38 },
  { 18573, 54, 38, 54, 4, -38 },
  { 18830, 42, 38, 37, -3, -38 },
  { 19030, 45, 55, 35, -6, -38 },
  { 19340, 34, 38, 33, -1, -38 },
  { 19502, 29, 62, 25, 0, -51 },
  { 19727, 6, 70, 39, 17, -54 },
  { 19780, 28, 62, 25, -3, -51 },
  { 19997, 34, 10, 41, 4, -30 },
};

const GFXfont NotoSans_SemiBoldItalic71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMIBOLDITALIC71PT7B_H_
