#ifndef _NOTOSANS_SEMIBOLDITALIC40PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0x80, 0x40, 0x00, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7,
  0x9E, 0x1E, 0x78, 0xF9, 0xE3, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3,
  0x8E, 0x0E, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x38, 0x3C, 0x00,
  0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xF3, 0x8C, 0x1F, 0x1C, 0x00, 0xF8, 0xC0,
  0x07, 0xC6, 0x00, 0x3F, 0x70, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xCF, 0xC0, 0x0E, 0x3E, 0x00, 0x71, 0xF2, 0x03, 0x9F, 0x1C, 0x19,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0xFF, 0x00, 0x1E, 0x0F, 0xFC, 0x01, 0xE0, 0x7F, 0xF0, 0x1F,
  0x07, 0xC7, 0x80, 0xF0, 0x3C, 0x3C, 0x0F, 0x03, 0xE1, 0xE0, 0xF0, 0x1E,
  0x0F, 0x0F, 0x80, 0xF0, 0x78, 0x78, 0x07, 0x87, 0x87, 0x80, 0x3C, 0x3C,
  0x78, 0x01, 0xE1, 0xE3, 0xC3, 0x0F, 0x1F, 0x3C, 0xFE, 0x78, 0xF3, 0xCF,
  0xFB, 0xFF, 0xBC, 0xFF, 0xDF, 0xF9, 0xEF, 0x9F, 0x7F, 0x9E, 0x78, 0x79,
  0xF1, 0xE3, 0xC3, 0xC0, 0x1E, 0x3C, 0x1E, 0x00, 0xF1, 0xE0, 0xF0, 0x0F,
  0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x78, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x1E,
  0x1E, 0x07, 0x80, 0xF1, 0xE0, 0x78, 0x07, 0x9F, 0x07, 0x80, 0x3F, 0xF0,
  0x3C, 0x00, 0xFF, 0x03, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC1,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x7C, 0x3F, 0xF0, 0x1F,
  0x1F, 0xBE, 0x0F, 0x8F, 0xCF, 0xC3, 0xE7, 0xE1, 0xF9, 0xF1, 0xF0, 0x3E,
  0xF8, 0xFC, 0x0F, 0xFE, 0x3E, 0x01, 0xFF, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x0F, 0xC0, 0x7E, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF9, 0xF8, 0x0F, 0xF8, 0x3F, 0x00, 0x7D, 0xF7, 0xDE, 0x79, 0xE7,
  0x9C, 0xF3, 0xCE, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x04, 0x0F, 0x00, 0xC1, 0xE0, 0x3E, 0x38,
  0x07, 0xF7, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xF3,
  0xE0, 0xFF, 0x00, 0x3E, 0xE0, 0x0F, 0x9E, 0x03, 0xE3, 0xC0, 0x38, 0x3C,
  0x03, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0x7F, 0xE0, 0x18, 0xF9, 0xFB, 0xFF, 0xCF, 0x84, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xC7, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F,
  0x81, 0xF0, 0xFC, 0x3F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xFF,
  0xC7, 0xFF, 0xBF, 0xDF, 0x3F, 0x7C, 0x7C, 0xF8, 0x61, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xF9, 0xFC,
  0x07, 0x03, 0xF0, 0x10, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xC7, 0xF0, 0x60, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x04, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC8, 0x00, 0xFC, 0xC0, 0x1F, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7B, 0xC0, 0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF8,
  0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x03, 0xE0,
  0xF8, 0x1E, 0x07, 0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0x83, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x10, 0x01, 0xF8, 0xE0, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xF8, 0x10, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xCF, 0xE0, 0x7D,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xF0, 0xFC, 0xFC, 0x07, 0xCF,
  0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x0F, 0xCF, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7E, 0x1F,
  0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0xCF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0x9F, 0x81, 0xF8, 0x7E, 0x1F, 0x01,
  0xF0, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F,
  0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xFD, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xF8, 0xFC, 0x7E, 0x0F, 0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7E, 0xF8,
  0x1F, 0xDF, 0xC7, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFE, 0xF8, 0x1E,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x80, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1F, 0x07,
  0xE1, 0xF8, 0xFC, 0x1F, 0x01, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x3C, 0x3F,
  0x20, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1F, 0x1E, 0x01, 0xF8,
  0x1E, 0x7C, 0x0F, 0xFE, 0x3C, 0xF0, 0x7F, 0xF8, 0x7B, 0xC1, 0xF8, 0xF0,
  0x77, 0x87, 0xC1, 0xE0, 0xEF, 0x0F, 0x03, 0xC1, 0xFC, 0x3E, 0x0F, 0x03,
  0xF8, 0x78, 0x1E, 0x0F, 0xF0, 0xF0, 0x3C, 0x1F, 0xE1, 0xE0, 0x78, 0x3F,
  0xC3, 0x81, 0xE0, 0xF7, 0x87, 0x03, 0xC1, 0xEF, 0x0F, 0x0F, 0x87, 0x9E,
  0x1F, 0x3F, 0x9F, 0x3C, 0x3F, 0xEF, 0xFC, 0x7C, 0x3F, 0x8F, 0xF0, 0x78,
  0x3E, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0x3C, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x03, 0xE0,
  0x3E, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x1E, 0x7E, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0x03, 0xF0, 0x3E, 0x03, 0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x3E, 0x01, 0xFC, 0x7C, 0x0F,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xCF, 0xC1, 0xFC, 0x01, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x01,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3E, 0x07, 0xF0, 0x1F, 0x00, 0xFC, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x07, 0xE0, 0xF8, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0x7C, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFE, 0x7E, 0x0F, 0xE0, 0x04, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xFE, 0xF8, 0x0F, 0xFC, 0xF8, 0x0F, 0xFC,
  0xF8, 0x0F, 0xFC, 0xF8, 0x1F, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xF0,
  0x7F, 0x01, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00,
  0x7C, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x0F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x8F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x03,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7C,
  0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x00,
  0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE7,
  0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x83, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7B, 0xC0, 0x1F, 0xF8, 0x1E, 0xF0,
  0x07, 0xBC, 0x07, 0xBC, 0x03, 0xFF, 0x03, 0xEF, 0x00, 0xF7, 0xC0, 0xFB,
  0xC0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x03,
  0xCF, 0x03, 0xCF, 0x81, 0xF3, 0xC1, 0xF3, 0xE0, 0x7C, 0xF0, 0x78, 0xF8,
  0x1E, 0x3C, 0x3C, 0x3C, 0x07, 0x87, 0x8F, 0x1F, 0x03, 0xE1, 0xE7, 0x87,
  0xC0, 0xF8, 0x79, 0xE1, 0xF0, 0x3E, 0x1E, 0xF0, 0x7C, 0x0F, 0x07, 0xBC,
  0x1E, 0x03, 0xC1, 0xFE, 0x0F, 0x81, 0xF0, 0x7F, 0x83, 0xE0, 0x7C, 0x1F,
  0xC0, 0xF8, 0x1F, 0x07, 0xF0, 0x3E, 0x07, 0x81, 0xF8, 0x0F, 0x01, 0xE0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x07, 0xC0, 0xFE, 0x00, 0x3C, 0x07, 0xF0, 0x03, 0xE0, 0x7F,
  0x80, 0x1F, 0x03, 0xFE, 0x00, 0xF8, 0x1F, 0xF0, 0x07, 0x80, 0xF7, 0x80,
  0x3C, 0x07, 0xBE, 0x03, 0xE0, 0x7D, 0xF0, 0x1F, 0x03, 0xE7, 0x80, 0xF8,
  0x1F, 0x3E, 0x07, 0x80, 0xF1, 0xF0, 0x7C, 0x07, 0x87, 0xC3, 0xE0, 0x7C,
  0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0xF8, 0x1F, 0x07, 0xC7, 0x80, 0xF0, 0x3E,
  0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x07, 0xDF, 0x03, 0xE0, 0x3E, 0xF8,
  0x1E, 0x01, 0xF7, 0x80, 0xF0, 0x07, 0xFC, 0x0F, 0x80, 0x3F, 0xE0, 0x7C,
  0x01, 0xFF, 0x03, 0xE0, 0x07, 0xF0, 0x1E, 0x00, 0x3F, 0x80, 0xF0, 0x01,
  0xFC, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0xFE, 0x03,
  0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7,
  0xC0, 0x03, 0xF3, 0xF0, 0x03, 0xF1, 0xFC, 0x03, 0xF0, 0x7F, 0x07, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0,
  0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xF3, 0xF0, 0x03,
  0xF1, 0xFC, 0x03, 0xF0, 0x7F, 0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x03, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x3E, 0x3F, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0x83,
  0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF8,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x1F, 0x00, 0x7C, 0xF8,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xF3, 0xE0, 0xFC, 0x02, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x88,
  0x01, 0xF8, 0xE0, 0x3F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x87, 0xE0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00,
  0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xFE,
  0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7,
  0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C,
  0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0,
  0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xFB,
  0xE0, 0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x07, 0xCF, 0x80, 0x7F, 0x00,
  0xF9, 0xF0, 0x0F, 0xE0, 0x3F, 0x3E, 0x03, 0xFC, 0x07, 0xC7, 0xC0, 0x7F,
  0x80, 0xF8, 0xF8, 0x1E, 0xF0, 0x3E, 0x1F, 0x03, 0xDE, 0x07, 0xC3, 0xE0,
  0xFB, 0xC1, 0xF0, 0x7C, 0x1E, 0x78, 0x3E, 0x0F, 0x87, 0xCF, 0x07, 0x81,
  0xF0, 0xF1, 0xE1, 0xF0, 0x3E, 0x1E, 0x3C, 0x3E, 0x07, 0xC7, 0xC7, 0x8F,
  0x80, 0xF8, 0xF0, 0xF1, 0xF0, 0x1F, 0x3E, 0x1E, 0x7C, 0x03, 0xE7, 0x83,
  0xCF, 0x80, 0x3D, 0xF0, 0x79, 0xE0, 0x07, 0xBC, 0x0F, 0x7C, 0x00, 0xF7,
  0x81, 0xEF, 0x00, 0x1F, 0xE0, 0x3D, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x01, 0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0,
  0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD,
  0xF0, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x0F, 0x83,
  0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x3C, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x00, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x78,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x00, 0x78, 0x78, 0x07,
  0x87, 0x80, 0xF0, 0x38, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0xF0, 0x00, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x01, 0xF8,
  0x78, 0x3F, 0xE7, 0x83, 0xFF, 0xBC, 0x3F, 0xFF, 0xE1, 0xF8, 0xFF, 0x1F,
  0x83, 0xF8, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFE, 0xF0, 0x0F, 0xC7, 0x80, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x7C, 0xFF, 0x03, 0xEF,
  0xF8, 0x1E, 0xFF, 0xE0, 0xFE, 0x3F, 0x0F, 0xE0, 0xFC, 0x7E, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E,
  0x07, 0xE3, 0xF8, 0x7E, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0x3F, 0xF0,
  0x78, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1,
  0xF8, 0x31, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x06, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0xF8, 0x0F, 0xF9, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0,
  0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF8,
  0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFE,
  0xF0, 0x03, 0xF1, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0x87, 0xCF, 0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C,
  0x0F, 0xFF, 0x7F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0xC0, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x3C, 0x0F, 0xF9, 0xE0, 0x7F,
  0xF7, 0x83, 0xFF, 0xFE, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE1, 0xF0, 0x1F,
  0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01,
  0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFD, 0xF0,
  0x3F, 0xE7, 0x80, 0x3F, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x08, 0x03, 0xF0, 0x3E, 0x7F, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x7C, 0xFF, 0x03,
  0xEF, 0xFC, 0x1E, 0xFF, 0xE0, 0xFF, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x03,
  0xE3, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x7C, 0x03, 0xE0, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC,
  0x3E, 0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C,
  0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x07,
  0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xC1,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x0F, 0xC0, 0xFC, 0x07, 0x8F, 0xF0, 0xFF,
  0x03, 0xCF, 0xF8, 0xFF, 0xC1, 0xEF, 0xFE, 0xFF, 0xE0, 0xFE, 0x1F, 0xF1,
  0xF8, 0xFE, 0x0F, 0xE0, 0xFC, 0x7E, 0x07, 0xF0, 0x3E, 0x3F, 0x03, 0xF0,
  0x1F, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x8F, 0x80, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x01, 0xF1, 0xF0, 0x1F,
  0x01, 0xF1, 0xF0, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC0, 0x7C, 0x7C, 0x07,
  0xC0, 0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x00,
  0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x03, 0xE0, 0x0F,
  0x0F, 0xC0, 0x78, 0xFF, 0x03, 0xCF, 0xFC, 0x1E, 0xFF, 0xE0, 0xFF, 0x1F,
  0x8F, 0xE0, 0xFC, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF8,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF1,
  0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xF8, 0x7E, 0x7E, 0x07, 0xDF,
  0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8,
  0x0F, 0x9F, 0x83, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F,
  0xE0, 0x00, 0x03, 0xC3, 0xE0, 0x07, 0x9F, 0xF0, 0x0F, 0x7F, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3F, 0x8F, 0xC0, 0xFE, 0x0F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C,
  0x1F, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0xFF, 0x81, 0xF7, 0xFF, 0x03,
  0xEF, 0xFC, 0x07, 0xCF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x78, 0x3F, 0xE7, 0x83, 0xFF, 0xBC, 0x3F, 0xFF, 0xE1, 0xF8, 0x7F, 0x1F,
  0x83, 0xF8, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xDF, 0x03, 0xFC, 0xF0, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x8F,
  0x87, 0x8F, 0xC3, 0xCF, 0xC1, 0xEF, 0xE0, 0xFF, 0xF0, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x03, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x30,
  0x0F, 0x8F, 0xDF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F,
  0x1F, 0x01, 0xF8, 0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0xFD, 0xE0, 0xFF,
  0xCF, 0x07, 0xFE, 0x78, 0x1F, 0xC7, 0x80, 0xF8, 0x03, 0xFF, 0x80, 0x3E,
  0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x0F, 0xC7, 0x80, 0xF8, 0x78, 0x1F,
  0x87, 0x81, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7,
  0xC0, 0x7C, 0xF8, 0x03, 0xCF, 0x80, 0x3D, 0xF0, 0x03, 0xDF, 0x00, 0x3D,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x81, 0xFC,
  0x0F, 0x9E, 0x07, 0xF0, 0x3E, 0x78, 0x1F, 0xC1, 0xF1, 0xE0, 0xFF, 0x07,
  0xC7, 0x83, 0xFC, 0x3F, 0x1E, 0x1E, 0xF0, 0xF8, 0x78, 0x7B, 0xC3, 0xE1,
  0xE3, 0xCF, 0x1F, 0x07, 0x8F, 0x3C, 0x7C, 0x1E, 0x7C, 0xF3, 0xE0, 0x79,
  0xE3, 0xCF, 0x81, 0xE7, 0x8F, 0x3C, 0x07, 0xBC, 0x3D, 0xF0, 0x1E, 0xF0,
  0xF7, 0x80, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xF0,
  0xFC, 0x01, 0xF1, 0xF8, 0x01, 0xF3, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xEF,
  0x80, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x87, 0xC0, 0x3F, 0x03,
  0xE0, 0x7E, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x3C, 0x07, 0xE0, 0x1E,
  0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x7C, 0x00,
  0x0F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0x00, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x7F, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x17, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE8, 0x00,
  0xF8,
};

const GFXglyph NotoSans_SemiBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 30, 11, 1, -29 },
  { 43, 14, 11, 17, 4, -29 },
  { 63, 25, 29, 26, 1, -29 },
  { 154, 21, 32, 22, 1, -30 },
  { 238, 29, 29, 33, 3, -29 },
  { 344, 26, 29, 28, 1, -29 },
  { 439, 6, 11, 10, 4, -29 },
  { 448, 14, 35, 13, 2, -29 },
  { 510, 14, 35, 13, -3, -29 },
  { 572, 19, 19, 22, 4, -31 },
  { 618, 20, 20, 23, 2, -24 },
  { 668, 9, 10, 11, -2, -5 },
  { 680, 11, 4, 13, 1, -13 },
  { 686, 7, 7, 11, 0, -6 },
  { 693, 21, 29, 16, -2, -29 },
  { 770, 20, 29, 22, 2, -29 },
  { 843, 15, 29, 22, 4, -29 },
  { 898, 22, 29, 22, -1, -29 },
  { 978, 20, 29, 22, 1, -29 },
  { 1051, 21, 29, 22, 0, -29 },
  { 1128, 21, 29, 22, 1, -29 },
  { 1205, 20, 29, 22, 2, -29 },
  { 1278, 21, 29, 22, 2, -29 },
  { 1355, 21, 29, 22, 1, -29 },
  { 1432, 19, 29, 22, 2, -29 },
  { 1501, 10, 23, 11, 0, -22 },
  { 1530, 12, 27, 11, -2, -22 },
  { 1571, 20, 21, 23, 2, -25 },
  { 1624, 19, 12, 23, 2, -20 },
  { 1653, 20, 21, 23, 2, -25 },
  { 1706, 16, 30, 18, 3, -29 },
  { 1766, 31, 33, 34, 2, -29 },
  { 1894, 24, 29, 24, -2, -29 },
  { 1981, 23, 29, 24, 1, -29 },
  { 2065, 23, 29, 24, 3, -29 },
  { 2149, 25, 29, 27, 1, -29 },
  { 2240, 22, 29, 21, 1, -29 },
  { 2320, 22, 29, 20, 1, -29 },
  { 2400, 24, 29, 27, 3, -29 },
  { 2487, 27, 29, 28, 1, -29 },
  { 2585, 18, 29, 14, -1, -29 },
  { 2651, 19, 37, 12, -6, -29 },
  { 2739, 26, 29, 24, 1, -29 },
  { 2834, 17, 29, 20, 1, -29 },
  { 2896, 34, 29, 35, 1, -29 },
  { 3020, 29, 29, 30, 1, -29 },
  { 3126, 25, 29, 29, 3, -29 },
  { 3217, 23, 29, 24, 1, -29 },
  { 3301, 25, 36, 29, 3, -29 },
  { 3414, 22, 29, 24, 1, -29 },
  { 3494, 20, 29, 21, 1, -29 },
  { 3567, 21, 29, 21, 3, -29 },
  { 3644, 25, 29, 27, 3, -29 },
  { 3735, 23, 29, 23, 4, -29 },
  { 3819, 35, 29, 35, 4, -29 },
  { 3946, 28, 29, 23, -2, -29 },
  { 4048, 21, 29, 22, 4, -29 },
  { 4125, 24, 29, 21, -1, -29 },
  { 4212, 17, 35, 13, -1, -29 },
  { 4287, 9, 29, 16, 4, -29 },
  { 4320, 16, 35, 13, -3, -29 },
  { 4390, 20, 19, 22, 1, -29 },
  { 4438, 17, 2, 16, -4, 4 },
  { 4443, 8, 7, 12, 6, -31 },
  { 4450, 21, 22, 23, 2, -22 },
  { 4508, 21, 30, 24, 1, -30 },
  { 4587, 17, 22, 19, 2, -22 },
  { 4634, 23, 30, 24, 2, -30 },
  { 4721, 18, 22, 21, 2, -22 },
  { 4771, 23, 41, 14, -4, -31 },
  { 4889, 22, 32, 24, 1, -22 },
  { 4977, 21, 30, 24, 1, -30 },
  { 5056, 11, 30, 11, 1, -30 },
  { 5098, 17, 40, 11, -5, -30 },
  { 5183, 22, 30, 22, 1, -30 },
  { 5266, 11, 30, 11, 1, -30 },
  { 5308, 33, 22, 36, 1, -22 },
  { 5399, 21, 22, 24, 1, -22 },
  { 5457, 19, 22, 23, 2, -22 },
  { 5510, 23, 32, 24, -1, -22 },
  { 5602, 21, 32, 24, 2, -22 },
  { 5686, 17, 22, 17, 1, -22 },
  { 5733, 18, 22, 18, 0, -22 },
  { 5783, 14, 26, 15, 2, -26 },
  { 5829, 21, 22, 24, 2, -22 },
  { 5887, 20, 22, 20, 2, -22 },
  { 5942, 30, 22, 31, 2, -22 },
  { 6025, 24, 22, 21, -2, -22 },
  { 6091, 25, 32, 20, -3, -22 },
  { 6191, 20, 22, 18, -1, -22 },
  { 6246, 16, 35, 14, 0, -29 },
  { 6316, 4, 39, 22, 9, -30 },
  { 6336, 16, 35, 14, -2, -29 },
  { 6406, 20, 6, 23, 2, -17 },
};

const GFXfont NotoSans_SemiBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMIBOLDITALIC40PT7B_H_
