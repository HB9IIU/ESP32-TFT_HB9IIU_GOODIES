#ifndef _NOTOSANS_SEMIBOLDITALIC69PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x3F, 0xC1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF9, 0xF3, 0xF8, 0x07, 0xFE, 0x3E,
  0x07, 0x00, 0xFF, 0x87, 0x80, 0x20, 0x1F, 0xE0, 0xF0, 0x00, 0x03, 0xFC,
  0x3E, 0x00, 0x00, 0xFF, 0x87, 0xC0, 0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x01,
  0xFE, 0x1E, 0x00, 0x00, 0x3F, 0xE3, 0xC0, 0x00, 0x07, 0xFE, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF3, 0xFF,
  0x00, 0x00, 0x3C, 0x7F, 0xE0, 0x00, 0x07, 0x87, 0xFC, 0x00, 0x01, 0xF0,
  0xFF, 0x80, 0x00, 0x3E, 0x1F, 0xF0, 0x00, 0x07, 0x83, 0xFE, 0x00, 0x00,
  0xF0, 0x7F, 0x86, 0x00, 0x3E, 0x1F, 0xF0, 0xF0, 0x07, 0xC7, 0xFE, 0x1F,
  0xE0, 0xFB, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x7F, 0xC0, 0xFE, 0x07, 0xF0, 0xFE, 0x1F,
  0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0x8F, 0xFF, 0xE3, 0xF8, 0x3F, 0x8F, 0xF3,
  0xFF, 0xFC, 0x7F, 0x9F, 0xF1, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xC7, 0xF8, 0x7F, 0x9F, 0xFF, 0xE3,
  0xF8, 0xFE, 0x0F, 0xF1, 0xFF, 0xF0, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xFC,
  0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xE0,
  0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xF9, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xEF, 0xFC,
  0x01, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x7F, 0xC1,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x7F,
  0xE0, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x20,
  0x03, 0xF8, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xF0, 0x7E, 0x00, 0x0F, 0xFE, 0x3E, 0x00, 0x07, 0xFF, 0xDF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0x80, 0x08, 0x0F, 0xF7, 0xE0,
  0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x0F, 0xF8, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x1C, 0x01, 0xFC, 0x00, 0x06, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x0F, 0x07, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xCF, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE3, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFE, 0xFF, 0x1F, 0xFE, 0x7F, 0x87, 0xFC, 0x7F, 0xC3,
  0xFC, 0x3F, 0xE0, 0xF8, 0x1F, 0xE0, 0x78, 0x0F, 0xF0, 0x10, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x02, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFC, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x03, 0x80, 0x03, 0xFF,
  0x00, 0x20, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x80, 0x00, 0x03, 0xFF, 0x0E, 0x00, 0x00, 0x7F, 0xE0,
  0xF8, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x08,
  0x00, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x1F, 0xFC, 0x0F, 0x80, 0x07, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xD0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x0E, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x01, 0x80, 0x00, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0xC7, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0xFC, 0x07, 0xFB,
  0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x80, 0x0F, 0xF8,
  0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F,
  0xE3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xE8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x3F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xF8, 0xFF,
  0xC0, 0x1F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xFC, 0xFF,
  0x01, 0xFF, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x08, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xFE, 0x1F, 0x00, 0x3F, 0xF0,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0x07, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0xFC,
  0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xF8, 0xFC, 0x01, 0xFE, 0x01, 0xF8, 0x07, 0xF3, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xCF, 0xC0,
  0x3F, 0x80, 0x1F, 0x80, 0x3F, 0xBF, 0x80, 0xFE, 0x00, 0x3F, 0x00, 0x7F,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF3, 0xF0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xDF, 0xC0,
  0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0xFE, 0x07, 0xF0, 0x07, 0xF8,
  0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0,
  0x3F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0xFF, 0xC1, 0xFF, 0x07, 0xE0,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0,
  0x1F, 0xC0, 0x7F, 0xFF, 0x3F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFC, 0x3F,
  0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xF8,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0x0E,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x7F,
  0xC0, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x07, 0xF8, 0x00,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x7F, 0xC0, 0x07, 0xFF, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xFF,
  0x8F, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFF,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x8F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0xFE,
  0x7E, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF9, 0xFC, 0x00,
  0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x7F,
  0x9F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x00,
  0x1F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F,
  0xC7, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xC0,
  0x3F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8,
  0x3F, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x80, 0x0F,
  0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE3, 0xF8, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xF9, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFE,
  0x7F, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xBF, 0xC0, 0x3F, 0xC0, 0x07,
  0xF8, 0x07, 0xEF, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xE0, 0x07,
  0xF3, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0xFF, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF3, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xFE, 0x01, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0x1F,
  0xF8, 0x00, 0x18, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x80, 0x00, 0x0F, 0xFC, 0x0F, 0x00,
  0x01, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0x80,
  0x00, 0x07, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x0F,
  0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x03,
  0xFD, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x9F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80,
  0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x0F,
  0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x1F, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x3F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F,
  0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0xE0, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xFC,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00,
  0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFE, 0x1F, 0xF0,
  0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0x00, 0x3F,
  0xFF, 0x87, 0xF0, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xCF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xBF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xFF, 0xBF, 0x80, 0x3F, 0xFF,
  0xF3, 0xF8, 0x01, 0xFF, 0xFE, 0x3F, 0x80, 0x0F, 0xFF, 0x87, 0xF8, 0x00,
  0x7F, 0xF0, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xF0, 0x01, 0xFE, 0x3F, 0xFF, 0x00,
  0x3F, 0xCF, 0xFF, 0xF0, 0x07, 0xFB, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xF1,
  0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFB,
  0xFF, 0xFF, 0xC0, 0xFE, 0x7F, 0xFF, 0xF0, 0x1F, 0xC7, 0xFF, 0xFC, 0x03,
  0xF8, 0x7F, 0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x3C, 0x0F, 0xFE, 0x00, 0x10, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x02, 0x07, 0xFF, 0x00, 0x78, 0x1F, 0xFF, 0x9F,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x7F,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFD, 0xFC, 0x00, 0x3F, 0xFF,
  0xF3, 0xF8, 0x00, 0x3F, 0xFF, 0xC7, 0xF0, 0x00, 0x3F, 0xFF, 0x0F, 0xE0,
  0x00, 0x1F, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x40, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x1F,
  0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x7F,
  0xC0, 0x1F, 0xFC, 0x7F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x7F,
  0xE0, 0x00, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x04, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0xFE, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0xFF,
  0x00, 0x7F, 0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0xBF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF7, 0xF8, 0x00, 0xFF,
  0xFF, 0x9F, 0xE0, 0x01, 0xFF, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0xE3, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x80, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF1, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0xF8, 0x01, 0xFE, 0x3F, 0xFF, 0x80, 0x3F, 0xCF, 0xFF, 0xF8, 0x07, 0xFB,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF,
  0x07, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0xE0, 0x03, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF8,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF,
  0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00,
  0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x03, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xDF, 0x83, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0xF8, 0x00, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xE3, 0xFF, 0xFE, 0x00, 0xFE,
  0x7F, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xFC, 0x01,
  0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xF0,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7,
  0xF8, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x1F, 0xF0,
  0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x83, 0xFF, 0xC0, 0x00, 0x7F, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x3F, 0xFF,
  0xC0, 0x01, 0xFC, 0xFF, 0xFF, 0x80, 0x07, 0xFB, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xCF, 0xFF, 0xFC, 0x00, 0x7F, 0x8F, 0xFF, 0xF0,
  0x00, 0xFF, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x03, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0x87, 0xF0,
  0x07, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xFE,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xE7, 0xF8, 0x01,
  0xFF, 0xFC, 0xFF, 0x80, 0x0F, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x00, 0x70, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x0F, 0xFC, 0x03, 0xF8, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF,
  0x01, 0xFE, 0xFF, 0xF8, 0x0F, 0xF7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x20, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE,
  0x7F, 0xC1, 0xFF, 0x80, 0x3C, 0x0F, 0xF8, 0x00, 0x60, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x40, 0x00, 0x7F,
  0xE3, 0x80, 0x03, 0xFE, 0x1F, 0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xE3, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x00,
  0x1F, 0xFC, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xE7, 0xFB, 0xF8, 0x0F, 0xFF, 0xFF, 0x7F,
  0x80, 0x7F, 0xFF, 0xE7, 0xF8, 0x07, 0xFF, 0xFE, 0x7F, 0x00, 0x3F, 0xFF,
  0x87, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0x00, 0x0F, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xF0, 0x00, 0x0F,
  0xF9, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xF8, 0x1F, 0xF0, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00,
  0x3F, 0xC7, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFC,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xF8, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xF0, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x0F, 0xEF,
  0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFE, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x0F,
  0xCF, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xFC, 0x07, 0xF0,
  0x1F, 0xCF, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xF8, 0x07,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xF0,
  0x07, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0xFE, 0x1F,
  0xE0, 0x07, 0xF8, 0xFE, 0x0F, 0xE3, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0xFE,
  0x3F, 0xC0, 0x07, 0xF9, 0xFC, 0x0F, 0xE7, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0xFE, 0x7F, 0x80, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0xFE, 0xFF, 0x00, 0x07, 0xF3, 0xF0, 0x0F, 0xEF, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0x7E, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00,
  0x1F, 0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3B, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x87, 0xFF, 0x00, 0x00, 0x4F, 0xFF,
  0xF0, 0x00, 0x6F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x60, 0x00, 0x3F, 0xFE, 0x20, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiBoldItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 20, 50, 19, 1, -49 },
  { 126, 24, 18, 30, 7, -49 },
  { 180, 43, 49, 45, 2, -49 },
  { 444, 35, 56, 38, 2, -52 },
  { 689, 51, 51, 58, 4, -50 },
  { 1015, 45, 51, 48, 2, -50 },
  { 1302, 11, 18, 17, 7, -49 },
  { 1327, 24, 60, 22, 3, -49 },
  { 1507, 25, 61, 22, -5, -50 },
  { 1698, 33, 33, 38, 6, -53 },
  { 1835, 33, 33, 39, 4, -41 },
  { 1972, 15, 17, 19, -3, -8 },
  { 2004, 19, 7, 22, 1, -22 },
  { 2021, 11, 11, 19, 1, -10 },
  { 2037, 36, 50, 27, -3, -50 },
  { 2262, 34, 51, 38, 3, -50 },
  { 2479, 25, 49, 38, 8, -49 },
  { 2633, 38, 50, 38, -1, -50 },
  { 2871, 36, 51, 38, 1, -50 },
  { 3101, 37, 49, 38, 0, -49 },
  { 3328, 36, 50, 38, 2, -49 },
  { 3553, 34, 51, 38, 4, -50 },
  { 3770, 36, 49, 38, 4, -49 },
  { 3991, 36, 51, 38, 2, -50 },
  { 4221, 34, 51, 38, 3, -50 },
  { 4438, 17, 39, 19, 1, -38 },
  { 4521, 22, 47, 19, -4, -38 },
  { 4651, 33, 36, 39, 4, -43 },
  { 4800, 33, 20, 39, 4, -34 },
  { 4883, 33, 36, 39, 4, -43 },
  { 5032, 28, 51, 31, 5, -50 },
  { 5211, 55, 55, 59, 3, -49 },
  { 5590, 42, 49, 42, -4, -49 },
  { 5848, 40, 49, 42, 2, -49 },
  { 6093, 41, 51, 42, 4, -50 },
  { 6355, 42, 49, 46, 2, -49 },
  { 6613, 37, 49, 37, 2, -49 },
  { 6840, 37, 49, 35, 2, -49 },
  { 7067, 42, 51, 47, 4, -50 },
  { 7335, 46, 49, 48, 2, -49 },
  { 7617, 31, 49, 25, -2, -49 },
  { 7807, 33, 63, 21, -11, -49 },
  { 8067, 45, 49, 41, 2, -49 },
  { 8343, 28, 49, 35, 2, -49 },
  { 8515, 58, 49, 60, 2, -49 },
  { 8871, 49, 49, 51, 2, -49 },
  { 9172, 44, 51, 50, 4, -50 },
  { 9453, 39, 49, 41, 2, -49 },
  { 9692, 44, 62, 50, 4, -50 },
  { 10033, 38, 49, 42, 2, -49 },
  { 10266, 36, 51, 36, 1, -50 },
  { 10496, 35, 49, 36, 6, -49 },
  { 10711, 43, 50, 47, 5, -49 },
  { 10980, 40, 49, 40, 6, -49 },
  { 11225, 60, 49, 61, 7, -49 },
  { 11593, 49, 49, 40, -4, -49 },
  { 11894, 38, 49, 37, 6, -49 },
  { 12127, 42, 49, 37, -2, -49 },
  { 12385, 28, 60, 22, -1, -49 },
  { 12595, 16, 50, 27, 7, -50 },
  { 12695, 28, 60, 22, -5, -49 },
  { 12905, 35, 32, 39, 2, -50 },
  { 13045, 28, 5, 27, -6, 6 },
  { 13063, 13, 11, 21, 10, -53 },
  { 13081, 36, 39, 40, 3, -38 },
  { 13257, 35, 53, 41, 2, -52 },
  { 13489, 30, 39, 33, 3, -38 },
  { 13636, 39, 53, 41, 3, -52 },
  { 13895, 32, 39, 37, 3, -38 },
  { 14051, 39, 70, 24, -7, -53 },
  { 14393, 38, 55, 41, 1, -38 },
  { 14655, 35, 52, 41, 2, -52 },
  { 14883, 19, 52, 20, 2, -52 },
  { 15007, 30, 69, 20, -9, -52 },
  { 15266, 39, 52, 37, 1, -52 },
  { 15520, 20, 52, 20, 1, -52 },
  { 15650, 56, 38, 62, 2, -38 },
  { 15916, 36, 38, 41, 1, -38 },
  { 16087, 34, 39, 40, 3, -38 },
  { 16253, 39, 55, 41, -2, -38 },
  { 16522, 36, 55, 41, 3, -38 },
  { 16770, 29, 38, 29, 2, -38 },
  { 16908, 29, 39, 32, 1, -38 },
  { 17050, 25, 47, 26, 3, -46 },
  { 17197, 36, 38, 41, 4, -37 },
  { 17368, 35, 37, 34, 3, -37 },
  { 17530, 52, 37, 53, 4, -37 },
  { 17771, 41, 37, 36, -3, -37 },
  { 17961, 43, 54, 34, -5, -37 },
  { 18252, 33, 37, 32, -1, -37 },
  { 18405, 28, 60, 24, 0, -49 },
  { 18615, 7, 68, 38, 16, -52 },
  { 18675, 27, 60, 24, -3, -49 },
  { 18878, 33, 11, 39, 4, -30 },
};

const GFXfont NotoSans_SemiBoldItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMIBOLDITALIC69PT7B_H_
