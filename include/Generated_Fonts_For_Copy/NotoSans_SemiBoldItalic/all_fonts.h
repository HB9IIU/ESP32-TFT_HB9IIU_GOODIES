#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_SemiBoldItalic
// Headers: 67

#include "NotoSans_SemiBoldItalic6pt7b.h"
#include "NotoSans_SemiBoldItalic7pt7b.h"
#include "NotoSans_SemiBoldItalic8pt7b.h"
#include "NotoSans_SemiBoldItalic9pt7b.h"
#include "NotoSans_SemiBoldItalic10pt7b.h"
#include "NotoSans_SemiBoldItalic11pt7b.h"
#include "NotoSans_SemiBoldItalic12pt7b.h"
#include "NotoSans_SemiBoldItalic13pt7b.h"
#include "NotoSans_SemiBoldItalic14pt7b.h"
#include "NotoSans_SemiBoldItalic15pt7b.h"
#include "NotoSans_SemiBoldItalic16pt7b.h"
#include "NotoSans_SemiBoldItalic17pt7b.h"
#include "NotoSans_SemiBoldItalic18pt7b.h"
#include "NotoSans_SemiBoldItalic19pt7b.h"
#include "NotoSans_SemiBoldItalic20pt7b.h"
#include "NotoSans_SemiBoldItalic21pt7b.h"
#include "NotoSans_SemiBoldItalic22pt7b.h"
#include "NotoSans_SemiBoldItalic23pt7b.h"
#include "NotoSans_SemiBoldItalic24pt7b.h"
#include "NotoSans_SemiBoldItalic25pt7b.h"
#include "NotoSans_SemiBoldItalic26pt7b.h"
#include "NotoSans_SemiBoldItalic27pt7b.h"
#include "NotoSans_SemiBoldItalic28pt7b.h"
#include "NotoSans_SemiBoldItalic29pt7b.h"
#include "NotoSans_SemiBoldItalic30pt7b.h"
#include "NotoSans_SemiBoldItalic31pt7b.h"
#include "NotoSans_SemiBoldItalic32pt7b.h"
#include "NotoSans_SemiBoldItalic33pt7b.h"
#include "NotoSans_SemiBoldItalic34pt7b.h"
#include "NotoSans_SemiBoldItalic35pt7b.h"
#include "NotoSans_SemiBoldItalic36pt7b.h"
#include "NotoSans_SemiBoldItalic37pt7b.h"
#include "NotoSans_SemiBoldItalic38pt7b.h"
#include "NotoSans_SemiBoldItalic39pt7b.h"
#include "NotoSans_SemiBoldItalic40pt7b.h"
#include "NotoSans_SemiBoldItalic41pt7b.h"
#include "NotoSans_SemiBoldItalic42pt7b.h"
#include "NotoSans_SemiBoldItalic43pt7b.h"
#include "NotoSans_SemiBoldItalic44pt7b.h"
#include "NotoSans_SemiBoldItalic45pt7b.h"
#include "NotoSans_SemiBoldItalic46pt7b.h"
#include "NotoSans_SemiBoldItalic47pt7b.h"
#include "NotoSans_SemiBoldItalic48pt7b.h"
#include "NotoSans_SemiBoldItalic49pt7b.h"
#include "NotoSans_SemiBoldItalic50pt7b.h"
#include "NotoSans_SemiBoldItalic51pt7b.h"
#include "NotoSans_SemiBoldItalic52pt7b.h"
#include "NotoSans_SemiBoldItalic53pt7b.h"
#include "NotoSans_SemiBoldItalic54pt7b.h"
#include "NotoSans_SemiBoldItalic55pt7b.h"
#include "NotoSans_SemiBoldItalic56pt7b.h"
#include "NotoSans_SemiBoldItalic57pt7b.h"
#include "NotoSans_SemiBoldItalic58pt7b.h"
#include "NotoSans_SemiBoldItalic59pt7b.h"
#include "NotoSans_SemiBoldItalic60pt7b.h"
#include "NotoSans_SemiBoldItalic61pt7b.h"
#include "NotoSans_SemiBoldItalic62pt7b.h"
#include "NotoSans_SemiBoldItalic63pt7b.h"
#include "NotoSans_SemiBoldItalic64pt7b.h"
#include "NotoSans_SemiBoldItalic65pt7b.h"
#include "NotoSans_SemiBoldItalic66pt7b.h"
#include "NotoSans_SemiBoldItalic67pt7b.h"
#include "NotoSans_SemiBoldItalic68pt7b.h"
#include "NotoSans_SemiBoldItalic69pt7b.h"
#include "NotoSans_SemiBoldItalic70pt7b.h"
#include "NotoSans_SemiBoldItalic71pt7b.h"
#include "NotoSans_SemiBoldItalic72pt7b.h"
