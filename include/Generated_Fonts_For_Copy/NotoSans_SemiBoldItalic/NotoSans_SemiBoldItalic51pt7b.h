#ifndef _NOTOSANS_SEMIBOLDITALIC51PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x00, 0x30, 0x00, 0x3F, 0x1F, 0xCF, 0xC7, 0xE3, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF0, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x78, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0x3C, 0x38,
  0x1F, 0x8F, 0x00, 0x07, 0xE3, 0xC0, 0x01, 0xF8, 0xE0, 0x00, 0x7E, 0x38,
  0x00, 0x1F, 0x9E, 0x00, 0x07, 0xF7, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0E, 0xFF, 0x00, 0x07, 0x9F,
  0xC0, 0x01, 0xE3, 0xF0, 0x00, 0x70, 0xFC, 0x00, 0x1C, 0x3F, 0x20, 0x0F,
  0x1F, 0xCF, 0x03, 0xCF, 0xE3, 0xFC, 0xEF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x20, 0x0F, 0xF8,
  0x00, 0x1F, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xE0,
  0x1F, 0xFF, 0x80, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0xF8,
  0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0xF8, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xE0,
  0xF8, 0x00, 0xFC, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0x7C, 0x3E, 0x00, 0x0F,
  0xC1, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC7, 0xC7, 0xF8, 0xFC, 0x3E, 0x3E,
  0x3F, 0xF3, 0xF1, 0xF9, 0xF3, 0xFF, 0xE7, 0xFF, 0xC7, 0xCF, 0xFF, 0x9F,
  0xFF, 0x3E, 0x7E, 0x3E, 0x3F, 0xF9, 0xF1, 0xF0, 0xF8, 0x7F, 0xCF, 0x8F,
  0xC3, 0xF0, 0xFC, 0x3E, 0x3E, 0x0F, 0xC0, 0x01, 0xF1, 0xF8, 0x3E, 0x00,
  0x0F, 0x87, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC1, 0xF8, 0x03,
  0xF0, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0xFC, 0x03, 0xE0, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x7C,
  0x00, 0x3F, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF, 0xF0, 0x07, 0xE1,
  0xFF, 0xFC, 0x07, 0xF1, 0xFE, 0x7F, 0x03, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8,
  0xFE, 0x0F, 0xE1, 0xF8, 0xFE, 0x03, 0xF9, 0xF8, 0x7F, 0x00, 0xFF, 0xFC,
  0x3F, 0x00, 0x7F, 0xFC, 0x1F, 0x80, 0x1F, 0xFC, 0x0F, 0xC0, 0x07, 0xFC,
  0x07, 0xF0, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFD,
  0xFC, 0x03, 0xFF, 0xF8, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0xF8, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x40, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x7C, 0x3E, 0x00,
  0xFF, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0x07, 0xFE, 0x00,
  0x0F, 0xDF, 0x00, 0x1F, 0x9F, 0x00, 0x3F, 0x8F, 0x80, 0x7F, 0x0F, 0x80,
  0x1E, 0x0F, 0xC0, 0x0C, 0x07, 0xC0, 0x04, 0x07, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x80, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF,
  0xFE, 0xFF, 0xF8, 0x3E, 0x7E, 0xFF, 0xFF, 0xFE, 0xFE, 0xFC, 0x30, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE7, 0xF0,
  0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFE,
  0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFD,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F,
  0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F,
  0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0x3F, 0x1F, 0x8F, 0xC7, 0x87, 0xF0,
  0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0xF0, 0x0F, 0x00, 0x7F,
  0x00, 0x40, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0x3F, 0xF0, 0x1C, 0x01, 0xFC, 0x06, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x88, 0x00, 0x1F, 0xE3, 0xC0,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0x7E, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xDE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE1, 0x80, 0x03, 0xFC, 0x3C, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFE, 0x18,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0xFC, 0xFF, 0xE0, 0x7E, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF0,
  0x07, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFE,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xFC,
  0x07, 0xF0, 0x7F, 0xEF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xC7, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0x7F, 0x1F,
  0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F,
  0x3F, 0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0xCF, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFB, 0xF0, 0x7F, 0xFB, 0xF8, 0x1F, 0xF9, 0xF8, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0x00,
  0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0x30, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xF1, 0xFF, 0x38, 0x07, 0xF2, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x03, 0xE0, 0x01, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0xFF, 0x07, 0xC3, 0xF0,
  0x1F, 0xFF, 0xC3, 0xE1, 0xF0, 0x1F, 0xFF, 0xC0, 0xF9, 0xF0, 0x1F, 0xEF,
  0xE0, 0x7C, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x7C, 0x1F, 0x80, 0xF8, 0x1F,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0xBE, 0x0F, 0xC0, 0x7C, 0x07, 0xDF, 0x07,
  0xC0, 0x3E, 0x03, 0xCF, 0x83, 0xE0, 0x1F, 0x03, 0xE7, 0x83, 0xE0, 0x1F,
  0x01, 0xF7, 0xC1, 0xF0, 0x0F, 0x80, 0xFB, 0xE0, 0xF8, 0x07, 0xC0, 0xF9,
  0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0xF8, 0x3E, 0x07, 0xF0, 0x7C, 0x3C, 0x1F,
  0x83, 0xF8, 0x7E, 0x1F, 0x07, 0xE7, 0xFE, 0x7E, 0x0F, 0x83, 0xFF, 0xDF,
  0xFE, 0x07, 0xC0, 0xFF, 0xCF, 0xFE, 0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x00,
  0xF8, 0x07, 0x80, 0x78, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFE, 0x1F, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xFC, 0x3F, 0x00, 0x3F, 0xC1, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0x04, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x20,
  0x0F, 0xFC, 0x07, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0x03, 0xFF, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01,
  0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF8, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x0E, 0x03, 0xFE, 0x00, 0x04, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF,
  0xF9, 0xF8, 0x03, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF,
  0x9F, 0xC0, 0x3F, 0xFF, 0x3F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xF0, 0x01, 0xFC, 0x0F,
  0xF0, 0x03, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x83, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0x80,
  0x7F, 0x80, 0x0F, 0xC0, 0x7F, 0x80, 0x07, 0xE0, 0x7F, 0x80, 0x07, 0xF0,
  0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xF8, 0x7F, 0x80, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0,
  0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x0F, 0xBE, 0x00, 0x1F, 0x7E, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x81,
  0xFB, 0xE0, 0x03, 0xEF, 0xC0, 0x7E, 0xF8, 0x01, 0xFB, 0xF0, 0x1F, 0xBE,
  0x00, 0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x3F, 0x3F, 0x03, 0xF3, 0xE0, 0x0F,
  0x9F, 0x80, 0xFC, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x01, 0xF1, 0xF8,
  0x0F, 0xCF, 0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x81, 0xF8,
  0xFC, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xC3,
  0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x7E, 0x1F,
  0xC0, 0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0x3F, 0x07, 0xCF, 0xC1, 0xF8, 0x0F,
  0xC1, 0xF3, 0xE0, 0x7E, 0x03, 0xE0, 0x7D, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x7C, 0x0F, 0xE0, 0x7E, 0x07, 0xFF, 0x03, 0xF0, 0x1F, 0x81, 0xFF, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x3F,
  0xF0, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x3F, 0xF8, 0x00, 0x7E,
  0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0xF8, 0x00, 0xFC, 0x07, 0xEF, 0xC0,
  0x0F, 0xC0, 0x7E, 0xFC, 0x00, 0xFC, 0x07, 0xEF, 0xC0, 0x0F, 0xC0, 0x7C,
  0x7E, 0x01, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8,
  0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0x07, 0xE7, 0xE0, 0x3F, 0x00, 0x7E,
  0x7E, 0x03, 0xF0, 0x07, 0xF7, 0xC0, 0x3F, 0x00, 0x3F, 0x7C, 0x07, 0xE0,
  0x03, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0xFC, 0x07, 0xE0, 0x01, 0xFF, 0xC0,
  0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x81,
  0xFF, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0,
  0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFC, 0x01, 0xFE,
  0x0F, 0xC0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x5F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E,
  0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x03,
  0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x80,
  0x70, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x0C, 0x00, 0x3F, 0xC3, 0xE0, 0x3F, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x1F, 0xC0,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xCF, 0xC0, 0x07,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xFE,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0x87, 0xE0, 0x0F, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFF, 0xE0, 0x1F,
  0xC1, 0xF8, 0x07, 0xDF, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x1F,
  0x81, 0xF9, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0x03, 0xE0,
  0xFC, 0x7E, 0x1F, 0xC0, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0xF8, 0x7E,
  0x0F, 0x8F, 0xE0, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x03,
  0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0xF9,
  0xF8, 0x00, 0x7C, 0xF8, 0x07, 0xDF, 0x80, 0x03, 0xE7, 0xC0, 0x3E, 0xFC,
  0x00, 0x1F, 0x7E, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0,
  0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC7,
  0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x0F, 0x00, 0x3F, 0x83, 0xE0, 0x1F, 0xF8, 0xFC, 0x07, 0xFF, 0x9F,
  0x01, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x87, 0xF8,
  0x1F, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F,
  0xE1, 0xFC, 0x07, 0xF8, 0x1F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xDF, 0x80, 0x7F, 0xF3, 0xE0, 0x07, 0xF8, 0x7C,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x3F, 0xF0,
  0x07, 0xEF, 0xFF, 0x01, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF,
  0xFF, 0xF8, 0x3E, 0xFF, 0xFE, 0x07, 0xDF, 0xFF, 0x81, 0xF9, 0xFF, 0xE0,
  0x3E, 0x0F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0x07,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x04, 0x1F, 0xE0,
  0x38, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xFC, 0xFE, 0x00, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0x03, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFC,
  0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7E, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xC0, 0x0F, 0xFE, 0x7C,
  0x00, 0x3F, 0xC3, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F,
  0xF0, 0x7F, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x3F,
  0x00, 0x7F, 0x3F, 0x00, 0xFE, 0x7F, 0x03, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x08, 0x7F, 0x80, 0x30, 0x7F, 0xF7, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x40, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x87, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x02,
  0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC1, 0xF0, 0x07, 0xFE, 0x3F, 0x00, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF,
  0xBE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0x7E, 0x01, 0xFF, 0xEF, 0xE0, 0x0F, 0xFC, 0xFC, 0x00, 0x7F, 0x8F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x08, 0x00, 0x7F, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x3F, 0x3F, 0xF0, 0x07, 0xEF, 0xFF, 0x01, 0xFB, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFE, 0x1F, 0xC0, 0xFF, 0x81, 0xFC, 0x3F, 0xE0, 0x3F, 0x87,
  0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x08, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x00,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0xFC, 0x0F, 0xF0,
  0x07, 0xE0, 0xFF, 0x00, 0x3F, 0x0F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x7F,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3E, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xBF, 0xFE, 0x3F, 0xFE, 0x07,
  0xFF, 0xFF, 0xDF, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x8F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x81, 0xFC, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x87, 0xF0,
  0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC3,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0xFE, 0x00, 0x7C, 0x7F, 0xF0,
  0x1F, 0x9F, 0xFE, 0x03, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC,
  0x3F, 0xC1, 0xFF, 0x03, 0xF8, 0x7F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0,
  0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8,
  0x7F, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0x87, 0xF8, 0x7F,
  0x80, 0xFC, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F, 0xDF,
  0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F,
  0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF8, 0x0F,
  0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x07, 0xC7, 0xFE, 0x00, 0x3E, 0x7F, 0xF8, 0x03, 0xF7, 0xFF, 0xC0, 0x1F,
  0x7F, 0xFF, 0x00, 0xFF, 0xC7, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80,
  0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFD, 0xFF, 0xF0, 0x0F, 0xE7, 0xFF, 0x00, 0x7E, 0x1F,
  0xE0, 0x03, 0xF0, 0x10, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x83,
  0xE0, 0x1F, 0xF8, 0x7C, 0x07, 0xFF, 0x9F, 0x01, 0xFF, 0xFB, 0xE0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE0, 0xFC, 0x07, 0xF8, 0x1F,
  0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFC, 0x07, 0xFF, 0xBF,
  0x80, 0x7F, 0xE7, 0xE0, 0x07, 0xF8, 0xFC, 0x00, 0x10, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xE0, 0xFC, 0x0F, 0x8F, 0xF0, 0x3E, 0x7F, 0x81, 0xFB, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0x80, 0xE0, 0xFC, 0x00,
  0x87, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF2, 0x00, 0x1F, 0xCE, 0x00, 0xFE, 0x3F, 0x9F, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x7E,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F,
  0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xFC, 0x3F, 0x01, 0xFF,
  0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0xFB, 0xE0, 0xFF, 0xFC, 0xF8, 0x1F, 0xFF,
  0x3E, 0x03, 0xFF, 0x8F, 0x80, 0x7F, 0x87, 0xC0, 0x03, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8,
  0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x80,
  0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xCF, 0xE0, 0x01, 0xF3,
  0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xBF, 0x00, 0xFF,
  0x00, 0xFE, 0xFC, 0x03, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xF0, 0x1F, 0xCF,
  0xC0, 0x7B, 0xC0, 0x7E, 0x3F, 0x03, 0xEF, 0x81, 0xF8, 0xFC, 0x0F, 0xBE,
  0x0F, 0xE3, 0xF0, 0x7C, 0xF8, 0x3F, 0x0F, 0xC1, 0xF3, 0xE1, 0xFC, 0x1F,
  0x0F, 0xCF, 0x87, 0xE0, 0x7C, 0x3E, 0x3E, 0x3F, 0x81, 0xF0, 0xF8, 0xF8,
  0xFC, 0x07, 0xC7, 0xC3, 0xE7, 0xF0, 0x1F, 0x1F, 0x0F, 0x9F, 0x80, 0x7C,
  0xF8, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0xFB, 0xF0, 0x07, 0xDF, 0x83, 0xEF,
  0xC0, 0x1F, 0x7C, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x00,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8,
  0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0x3F, 0xF8,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_SemiBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 37, 14, 1, -36 },
  { 66, 18, 13, 22, 5, -36 },
  { 96, 32, 36, 33, 1, -36 },
  { 240, 26, 42, 28, 1, -39 },
  { 377, 38, 37, 43, 3, -37 },
  { 553, 33, 38, 35, 2, -37 },
  { 710, 8, 13, 12, 5, -36 },
  { 723, 18, 44, 16, 2, -36 },
  { 822, 18, 45, 16, -4, -37 },
  { 924, 24, 24, 28, 5, -39 },
  { 996, 24, 24, 29, 3, -30 },
  { 1068, 11, 13, 14, -2, -6 },
  { 1086, 14, 5, 16, 1, -16 },
  { 1095, 8, 8, 14, 1, -7 },
  { 1103, 26, 37, 20, -2, -37 },
  { 1224, 25, 38, 28, 2, -37 },
  { 1343, 18, 36, 28, 6, -36 },
  { 1424, 28, 37, 28, -1, -37 },
  { 1554, 26, 38, 28, 1, -37 },
  { 1678, 27, 36, 28, 0, -36 },
  { 1800, 27, 37, 28, 1, -36 },
  { 1925, 25, 38, 28, 3, -37 },
  { 2044, 27, 36, 28, 3, -36 },
  { 2166, 26, 38, 28, 2, -37 },
  { 2290, 25, 38, 28, 2, -37 },
  { 2409, 12, 29, 14, 1, -28 },
  { 2453, 16, 35, 14, -3, -28 },
  { 2523, 24, 27, 29, 3, -32 },
  { 2604, 24, 14, 29, 3, -25 },
  { 2646, 24, 27, 29, 3, -32 },
  { 2727, 20, 38, 23, 4, -37 },
  { 2822, 41, 41, 44, 2, -36 },
  { 3033, 31, 36, 31, -3, -36 },
  { 3173, 29, 36, 31, 2, -36 },
  { 3304, 30, 38, 31, 3, -37 },
  { 3447, 31, 36, 34, 2, -36 },
  { 3587, 27, 36, 27, 2, -36 },
  { 3709, 27, 36, 26, 2, -36 },
  { 3831, 31, 38, 35, 3, -37 },
  { 3979, 34, 36, 35, 2, -36 },
  { 4132, 22, 36, 18, -1, -36 },
  { 4231, 24, 46, 16, -8, -36 },
  { 4369, 33, 36, 30, 2, -36 },
  { 4518, 20, 36, 26, 2, -36 },
  { 4608, 42, 36, 44, 2, -36 },
  { 4797, 36, 36, 38, 2, -36 },
  { 4959, 33, 38, 37, 3, -37 },
  { 5116, 28, 36, 30, 2, -36 },
  { 5242, 33, 46, 37, 3, -37 },
  { 5432, 28, 36, 31, 2, -36 },
  { 5558, 26, 38, 27, 1, -37 },
  { 5682, 27, 36, 27, 4, -36 },
  { 5804, 32, 37, 35, 4, -36 },
  { 5952, 29, 36, 29, 5, -36 },
  { 6083, 45, 36, 45, 5, -36 },
  { 6286, 37, 36, 30, -3, -36 },
  { 6453, 27, 36, 28, 5, -36 },
  { 6575, 31, 36, 27, -1, -36 },
  { 6715, 21, 44, 16, -1, -36 },
  { 6831, 11, 37, 20, 6, -37 },
  { 6882, 21, 44, 16, -4, -36 },
  { 6998, 26, 24, 29, 1, -37 },
  { 7076, 21, 3, 20, -5, 5 },
  { 7084, 10, 8, 16, 7, -39 },
  { 7094, 27, 29, 30, 2, -28 },
  { 7192, 27, 40, 30, 1, -39 },
  { 7327, 23, 29, 24, 2, -28 },
  { 7411, 29, 40, 30, 2, -39 },
  { 7556, 24, 29, 27, 2, -28 },
  { 7643, 30, 51, 18, -6, -39 },
  { 7835, 28, 40, 30, 1, -28 },
  { 7975, 27, 39, 30, 1, -39 },
  { 8107, 14, 38, 14, 1, -38 },
  { 8174, 21, 50, 14, -6, -38 },
  { 8306, 29, 39, 28, 1, -39 },
  { 8448, 15, 39, 14, 1, -39 },
  { 8522, 42, 28, 46, 1, -28 },
  { 8669, 27, 28, 30, 1, -28 },
  { 8764, 25, 28, 29, 2, -28 },
  { 8852, 29, 40, 30, -1, -28 },
  { 8997, 27, 40, 30, 2, -28 },
  { 9132, 22, 28, 21, 1, -28 },
  { 9209, 22, 29, 23, 0, -28 },
  { 9289, 19, 35, 19, 2, -34 },
  { 9373, 26, 29, 30, 3, -28 },
  { 9468, 26, 28, 25, 2, -28 },
  { 9559, 38, 28, 39, 3, -28 },
  { 9692, 30, 28, 26, -2, -28 },
  { 9797, 32, 40, 25, -4, -28 },
  { 9957, 25, 28, 23, -1, -28 },
  { 10045, 21, 44, 18, 0, -36 },
  { 10161, 5, 51, 28, 12, -39 },
  { 10193, 20, 44, 18, -2, -36 },
  { 10303, 24, 8, 29, 3, -22 },
};

const GFXfont NotoSans_SemiBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMIBOLDITALIC51PT7B_H_
