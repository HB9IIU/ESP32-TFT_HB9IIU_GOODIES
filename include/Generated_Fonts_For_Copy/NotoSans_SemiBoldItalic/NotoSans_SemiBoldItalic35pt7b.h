#ifndef _NOTOSANS_SEMIBOLDITALIC35PT7B_H_
#define _NOTOSANS_SEMIBOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-SemiBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x10, 0x00,
  0x00, 0x00, 0x70, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x79, 0xF7, 0x9E,
  0xF1, 0xEF, 0x1E, 0xF1, 0xCE, 0x1C, 0xE3, 0xCE, 0x38, 0xE3, 0x80, 0x00,
  0x70, 0xF0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE1,
  0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E,
  0x3C, 0x00, 0x70, 0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC0, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x78, 0x00, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7C, 0xC6, 0x1E, 0x70, 0x07, 0x9C, 0x01, 0xE6, 0x00, 0x7D, 0x80, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x37,
  0xC0, 0x1C, 0xF0, 0x06, 0x3C, 0x81, 0x9F, 0x38, 0x6F, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x07, 0xF8, 0x07, 0x83, 0xFF, 0x01, 0xC0,
  0xF3, 0xC0, 0xF0, 0x78, 0xF0, 0x78, 0x1E, 0x3C, 0x3C, 0x07, 0x0F, 0x0E,
  0x03, 0xC3, 0xC7, 0x80, 0xF0, 0xE3, 0xC0, 0x3C, 0x79, 0xE0, 0x0F, 0x1E,
  0x73, 0xF3, 0xCF, 0x3D, 0xFE, 0x7F, 0xDE, 0xFF, 0x9F, 0xEF, 0x3C, 0xF3,
  0xF3, 0x9E, 0x3C, 0x01, 0xE7, 0x8F, 0x00, 0xF1, 0xC3, 0xC0, 0x38, 0xF0,
  0xF0, 0x1C, 0x3C, 0x38, 0x0F, 0x0F, 0x1E, 0x07, 0x83, 0xC7, 0x81, 0xC0,
  0xF3, 0xC0, 0xE0, 0x1F, 0xF0, 0x78, 0x07, 0xF8, 0x3C, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3E, 0x3E, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x07,
  0x8F, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x03, 0xE3, 0xFF, 0x07, 0x8F, 0x9E, 0x1F, 0x3E, 0x3E, 0x3C, 0x78, 0x3E,
  0xF9, 0xF0, 0x3F, 0xE3, 0xE0, 0x7F, 0x87, 0xC0, 0x7E, 0x0F, 0x80, 0xFC,
  0x0F, 0xCF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFE, 0xF8, 0x1F, 0xF0, 0xF8,
  0x7B, 0xFD, 0xEF, 0x73, 0x9C, 0xE0, 0x00, 0xF8, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x06, 0x0E, 0x03, 0xC7,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xF8, 0x23,
  0xDC, 0x03, 0xEF, 0x03, 0xE3, 0x80, 0x61, 0xE0, 0x10, 0xF0, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x0F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x39, 0xFF, 0xFF, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0x3E, 0x1F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xE0, 0x1F, 0x78,
  0x07, 0xDE, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03,
  0xCF, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x3E, 0x1F, 0xBF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xF1, 0xFF, 0x3F,
  0xFF, 0xFE, 0xF9, 0xE7, 0x1E, 0x43, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xFF, 0x07, 0xF7, 0xE0, 0x70, 0x3E, 0x08, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xC7, 0xE0, 0x20, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC8, 0x01, 0xF1, 0xF0, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x1F, 0xE0,
  0x07, 0xBC, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0xC7, 0x80,
  0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0xB0, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x80, 0x3E, 0x3E, 0x7F, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F,
  0x82, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x3E, 0x07, 0xBF, 0xC3, 0xFF, 0xF8, 0xFF, 0x7E, 0x3F, 0x07, 0xCF,
  0x81, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0,
  0x78, 0xF8, 0x3E, 0x1F, 0x3F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3E, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF1,
  0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xE7, 0xE0, 0x7F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xE3, 0xE1, 0xF0, 0x7C, 0x78, 0x0F,
  0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x1F, 0x0F, 0xC7,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x07,
  0xFF, 0x87, 0xE7, 0xE3, 0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xBE, 0x07, 0xCF, 0x07, 0xE7, 0xEF, 0xF3, 0xFF,
  0x78, 0xFF, 0x7C, 0x1F, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x0F, 0x86, 0x3F, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x0F, 0x87, 0xC7, 0xE3, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xF8, 0xFC, 0x7E, 0x1E, 0x00, 0x03,
  0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1E, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0xE3, 0xFF, 0xC7, 0xFF, 0x9E, 0x3E, 0x40, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0x79, 0xE0, 0x7F, 0xCF, 0x78,
  0x3F, 0xF0, 0xEF, 0x0F, 0xFE, 0x1D, 0xC3, 0xC3, 0xC3, 0xF8, 0xF0, 0x78,
  0x7E, 0x1E, 0x0E, 0x0F, 0xC3, 0x81, 0xC1, 0xF8, 0xF0, 0x78, 0x7F, 0x1E,
  0x0F, 0x0E, 0xE3, 0xC3, 0xC3, 0xDC, 0x78, 0x78, 0x7B, 0x87, 0xBF, 0xBE,
  0x70, 0xFF, 0x7F, 0x8F, 0x0F, 0xCF, 0xE0, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x60, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x3C,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00,
  0x78, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1,
  0xF0, 0x3E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3E, 0x07, 0xC3, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03,
  0xC7, 0xC0, 0x7C, 0x78, 0x0F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xF7, 0xE0, 0xFC, 0x02, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x10, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xF8, 0x3F, 0x07,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF8, 0x03,
  0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0xF8,
  0xF8, 0x0F, 0xC7, 0xC1, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x0F, 0xC0, 0x10, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x07,
  0xFC, 0xF8, 0x1F, 0xF3, 0xE0, 0x7F, 0xCF, 0x81, 0xFF, 0x3E, 0x00, 0x78,
  0xF8, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x7E,
  0x03, 0xC0, 0xFF, 0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x01,
  0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x3E,
  0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C,
  0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0xC0,
  0x1E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x03,
  0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x7F, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x07,
  0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x3C, 0x0F, 0x80, 0xF8,
  0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x0F, 0x3E,
  0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x7C, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3B, 0xC1, 0xFE, 0x03, 0xDE,
  0x0F, 0x70, 0x1C, 0xF0, 0xF3, 0x81, 0xEF, 0x07, 0x9C, 0x0E, 0x78, 0x3C,
  0xE0, 0xF3, 0xC1, 0xE7, 0x07, 0x1E, 0x0F, 0x38, 0x79, 0xF0, 0xF1, 0xE3,
  0x8F, 0x07, 0x8F, 0x3C, 0x78, 0x3C, 0x79, 0xC3, 0xC1, 0xE3, 0xDE, 0x1E,
  0x1E, 0x1F, 0xE1, 0xF0, 0xF0, 0xFF, 0x0F, 0x07, 0x83, 0xF0, 0x78, 0x3C,
  0x1F, 0x83, 0xC1, 0xE0, 0xF8, 0x1E, 0x1E, 0x07, 0xC1, 0xF0, 0xF0, 0x3C,
  0x0F, 0x00, 0x07, 0xE0, 0x07, 0x83, 0xF0, 0x03, 0xC1, 0xF8, 0x03, 0xE0,
  0xFE, 0x01, 0xE0, 0xFF, 0x00, 0xF0, 0x7F, 0x80, 0x78, 0x3F, 0xE0, 0x3C,
  0x1E, 0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x0F, 0x3E, 0x0F, 0x07, 0x8F, 0x07,
  0x83, 0xC7, 0x87, 0xC1, 0xE3, 0xE3, 0xC0, 0xF0, 0xF1, 0xE0, 0xF0, 0x78,
  0xF0, 0x78, 0x3E, 0x78, 0x3C, 0x0F, 0x7C, 0x1E, 0x07, 0xBC, 0x1F, 0x03,
  0xFE, 0x0F, 0x00, 0xFF, 0x07, 0x80, 0x7F, 0x83, 0xC0, 0x1F, 0xC1, 0xE0,
  0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x80, 0xF8, 0x7C,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x3D, 0xF0, 0x00,
  0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0x80,
  0x1F, 0x1F, 0x00, 0xFC, 0x7E, 0x07, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0,
  0xF0, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xE0, 0x7E,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x7C,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x3D, 0xF0, 0x00,
  0xF7, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0x80,
  0x1F, 0x1F, 0x00, 0xFC, 0x7E, 0x07, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xF8, 0x3E, 0x1F,
  0x03, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x7C, 0x7C,
  0x1F, 0x8F, 0x1F, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xF1,
  0xE0, 0x3C, 0x3E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0xC0,
  0xF0, 0xF0, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x3C, 0xF8, 0x07, 0xC0, 0x01,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xBE, 0x1F, 0x01, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x80, 0x7C, 0x3E, 0x7F,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7,
  0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0,
  0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x81, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x07, 0xC7,
  0x80, 0x78, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0,
  0x78, 0x3E, 0x07, 0x83, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0x3C, 0xF8,
  0x03, 0xCF, 0x00, 0x3D, 0xF0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7B, 0xE0, 0x3F,
  0x01, 0xF7, 0xC0, 0x7E, 0x03, 0xC7, 0x80, 0xFC, 0x07, 0x8F, 0x03, 0xF8,
  0x1F, 0x1E, 0x07, 0xF0, 0x3C, 0x3C, 0x1F, 0xE0, 0xF8, 0x78, 0x3B, 0xC1,
  0xE0, 0xF0, 0xF7, 0x87, 0xC1, 0xE1, 0xEF, 0x0F, 0x03, 0xC7, 0x9E, 0x1E,
  0x07, 0x8F, 0x3C, 0x78, 0x0F, 0x3C, 0x38, 0xF0, 0x1E, 0x78, 0x73, 0xE0,
  0x3C, 0xE0, 0xE7, 0x80, 0x7B, 0xC1, 0xCF, 0x00, 0xF7, 0x83, 0xBC, 0x01,
  0xFE, 0x07, 0x78, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x78, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xE7,
  0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF3, 0xE0, 0x01,
  0xF1, 0xF0, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x03,
  0xEF, 0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0x78, 0x3C,
  0x0F, 0x0F, 0x81, 0xE3, 0xE0, 0x3E, 0x78, 0x03, 0xDF, 0x00, 0x7B, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1E, 0x3C, 0x78, 0xF1,
  0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xF1, 0xE3, 0xC7, 0x8F,
  0x0E, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xEF, 0x00, 0x79, 0xC0,
  0x1C, 0x70, 0x0F, 0x1E, 0x03, 0x83, 0x81, 0xE0, 0xE0, 0xF0, 0x3C, 0x38,
  0x07, 0x1E, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0xF1, 0xE1, 0xE1, 0xC1, 0xC0, 0x07, 0xE3, 0xC3, 0xFC,
  0xF1, 0xFF, 0xF8, 0xFC, 0xFE, 0x3E, 0x1F, 0x9F, 0x03, 0xE7, 0x80, 0xF3,
  0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0,
  0x3E, 0x3C, 0x0F, 0x8F, 0x07, 0xE3, 0xE3, 0xF8, 0xFF, 0xDC, 0x1F, 0xEF,
  0x03, 0xF3, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x3F, 0x07,
  0xDF, 0xE1, 0xEF, 0xF8, 0x7F, 0x3F, 0x1F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0,
  0x3C, 0xF8, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x7D, 0xF0, 0x1E,
  0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF3, 0xF8, 0xF8, 0xFF, 0xFE, 0x3D,
  0xFF, 0x0E, 0x3F, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xF8, 0xE7,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x02, 0x7E, 0x38, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x07,
  0xE7, 0xC1, 0xFE, 0xF8, 0x7F, 0xFE, 0x1F, 0x9F, 0xC3, 0xE0, 0xF8, 0xF8,
  0x1F, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x3C, 0x1F, 0x87, 0xC7,
  0xF0, 0xFF, 0xDC, 0x0F, 0xF3, 0x80, 0xFC, 0xF0, 0x00, 0x03, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x3F, 0x1F, 0x3C, 0x0F, 0x7C, 0x1F, 0x78, 0x1E, 0xF8,
  0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x18, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x09, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF1, 0xE0, 0xFF, 0x3C, 0x3F, 0xFF, 0x0F, 0xCF,
  0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3E,
  0x1E, 0x0F, 0xC3, 0xE7, 0xF8, 0x7F, 0xFE, 0x07, 0xFB, 0xC0, 0x7E, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x20, 0x1F, 0x06, 0x07, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x3F, 0x07, 0xDF, 0xE1, 0xEF, 0xFC, 0x7F, 0x1F, 0x1F,
  0x87, 0xC7, 0xC0, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF3,
  0xE0, 0x3C, 0xF8, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xE0, 0x07, 0x81, 0xF0,
  0x78, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x27, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x3E,
  0x0F, 0x0F, 0x81, 0xE3, 0xE0, 0x3C, 0xF8, 0x0F, 0xBE, 0x01, 0xEF, 0x80,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x78, 0x07, 0xCF, 0x80,
  0xF0, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x1E, 0x07, 0xC3,
  0xC0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8,
  0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C,
  0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x00, 0x0E, 0x3F, 0x07, 0xE1, 0xE7, 0xF9, 0xFF, 0x1E, 0xFF, 0xBF, 0xF1,
  0xFC, 0xFB, 0x9F, 0x1F, 0x87, 0xF0, 0xF1, 0xF0, 0x7E, 0x0F, 0x3E, 0x07,
  0xC0, 0xF3, 0xE0, 0x7C, 0x0F, 0x3E, 0x07, 0x80, 0xF3, 0xC0, 0x78, 0x1F,
  0x3C, 0x0F, 0x81, 0xF7, 0xC0, 0xF8, 0x1E, 0x7C, 0x0F, 0x01, 0xE7, 0x80,
  0xF0, 0x3E, 0x78, 0x1F, 0x03, 0xEF, 0x81, 0xF0, 0x3C, 0xF8, 0x1E, 0x03,
  0xCF, 0x01, 0xE0, 0x3C, 0xF0, 0x1E, 0x07, 0xC0, 0x0E, 0x3F, 0x07, 0x9F,
  0xE1, 0xEF, 0xFC, 0x7F, 0x1F, 0x1F, 0x87, 0xC7, 0xC0, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x79, 0xF0, 0x3E, 0x7C,
  0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x3C, 0x07,
  0xCF, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xE7, 0xE7,
  0xC0, 0xF3, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xF7, 0x80, 0xF3, 0xE0, 0xF9, 0xF9,
  0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0x8F, 0xC0, 0x7B,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F,
  0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1,
  0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xC3, 0xF8, 0xF8,
  0x3D, 0xFF, 0x83, 0xDF, 0xF0, 0x3C, 0xFC, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE3, 0xC3, 0xFE, 0xF1, 0xFF, 0xB8, 0xFC,
  0xFE, 0x3E, 0x1F, 0x9F, 0x03, 0xE7, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F,
  0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F,
  0x07, 0xE3, 0xE3, 0xF8, 0xFF, 0xFC, 0x1F, 0xEF, 0x03, 0xF3, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0E, 0x3E, 0x3C, 0xF8, 0x7B, 0xF0, 0xFF,
  0xE1, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0xF8,
  0x63, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xA0, 0x1F, 0x70, 0x7C, 0xFF,
  0xF9, 0xFF, 0xE1, 0xFF, 0x00, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x88, 0xFF,
  0x87, 0xF8, 0x7F, 0x80, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xC0, 0x7C, 0xF0,
  0x1E, 0x3C, 0x07, 0x9F, 0x01, 0xE7, 0xC0, 0xF9, 0xE0, 0x3C, 0x78, 0x0F,
  0x1E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F,
  0x07, 0xE3, 0xE3, 0xF8, 0xFF, 0xDE, 0x1F, 0xE7, 0x03, 0xF1, 0xC0, 0xF0,
  0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3,
  0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C,
  0x07, 0xBC, 0x03, 0xDE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x03, 0xFC, 0x0F, 0x81, 0xFF, 0x03,
  0xE0, 0x7B, 0xC1, 0xF8, 0x3E, 0xF0, 0x7E, 0x0F, 0x3C, 0x3F, 0xC7, 0xCF,
  0x0E, 0xF1, 0xE3, 0xC7, 0xBC, 0x78, 0xF1, 0xCF, 0x3C, 0x3C, 0xF3, 0xCF,
  0x07, 0x3C, 0xF7, 0x81, 0xCE, 0x3D, 0xE0, 0x77, 0x8F, 0xF0, 0x1D, 0xC3,
  0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F,
  0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x80,
  0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00, 0x3E, 0x7C, 0x03, 0xE1, 0xE0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x3F, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x1E,
  0x01, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0xC1, 0xF0, 0x0F, 0x07,
  0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00,
  0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x01, 0xDF, 0x00, 0x07, 0x78, 0x00, 0x1D,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x81, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xFE, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x01, 0xFC,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x01, 0xFC, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x0C, 0x00, 0x00,
  0x3F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0xF8, 0x07, 0xF0,
};

const GFXglyph NotoSans_SemiBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 25, 10, 1, -25 },
  { 33, 12, 9, 15, 4, -25 },
  { 47, 22, 25, 23, 1, -25 },
  { 116, 18, 29, 19, 1, -27 },
  { 182, 26, 25, 29, 2, -25 },
  { 264, 23, 25, 24, 1, -25 },
  { 336, 5, 9, 8, 4, -25 },
  { 342, 13, 31, 11, 1, -25 },
  { 393, 13, 31, 11, -3, -25 },
  { 444, 17, 17, 19, 3, -27 },
  { 481, 17, 17, 20, 2, -21 },
  { 518, 8, 9, 10, -2, -4 },
  { 527, 9, 4, 11, 1, -11 },
  { 532, 6, 5, 10, 0, -5 },
  { 536, 19, 25, 14, -2, -25 },
  { 596, 18, 25, 19, 1, -25 },
  { 653, 12, 25, 19, 4, -25 },
  { 691, 19, 25, 19, 0, -25 },
  { 751, 19, 25, 19, 0, -25 },
  { 811, 19, 25, 19, 0, -25 },
  { 871, 18, 25, 19, 1, -25 },
  { 928, 18, 25, 19, 2, -25 },
  { 985, 18, 25, 19, 2, -25 },
  { 1042, 18, 25, 19, 1, -25 },
  { 1099, 17, 25, 19, 2, -25 },
  { 1153, 9, 19, 10, 0, -19 },
  { 1175, 11, 24, 10, -2, -19 },
  { 1208, 17, 18, 20, 2, -22 },
  { 1247, 17, 10, 20, 2, -17 },
  { 1269, 17, 18, 20, 2, -22 },
  { 1308, 14, 25, 16, 3, -25 },
  { 1352, 27, 28, 30, 2, -25 },
  { 1447, 21, 25, 21, -2, -25 },
  { 1513, 20, 25, 21, 1, -25 },
  { 1576, 21, 25, 21, 2, -25 },
  { 1642, 21, 25, 24, 1, -25 },
  { 1708, 19, 25, 19, 1, -25 },
  { 1768, 19, 25, 18, 1, -25 },
  { 1828, 22, 25, 24, 2, -25 },
  { 1897, 23, 25, 24, 1, -25 },
  { 1969, 16, 25, 13, -1, -25 },
  { 2019, 17, 32, 11, -6, -25 },
  { 2087, 23, 25, 21, 1, -25 },
  { 2159, 14, 25, 18, 1, -25 },
  { 2203, 29, 25, 30, 1, -25 },
  { 2294, 25, 25, 26, 1, -25 },
  { 2373, 22, 25, 25, 2, -25 },
  { 2442, 20, 25, 21, 1, -25 },
  { 2505, 22, 31, 25, 2, -25 },
  { 2591, 19, 25, 21, 1, -25 },
  { 2651, 18, 25, 18, 1, -25 },
  { 2708, 18, 25, 18, 3, -25 },
  { 2765, 21, 25, 24, 3, -25 },
  { 2831, 20, 25, 20, 3, -25 },
  { 2894, 31, 25, 31, 3, -25 },
  { 2991, 25, 25, 20, -2, -25 },
  { 3070, 19, 25, 19, 3, -25 },
  { 3130, 21, 25, 19, -1, -25 },
  { 3196, 15, 31, 11, -1, -25 },
  { 3255, 7, 25, 14, 4, -25 },
  { 3277, 14, 31, 11, -2, -25 },
  { 3332, 18, 16, 20, 1, -25 },
  { 3368, 14, 3, 14, -3, 3 },
  { 3374, 7, 6, 11, 5, -27 },
  { 3380, 18, 19, 20, 2, -19 },
  { 3423, 18, 27, 21, 1, -27 },
  { 3484, 15, 19, 17, 2, -19 },
  { 3520, 19, 27, 21, 2, -27 },
  { 3585, 16, 19, 19, 2, -19 },
  { 3623, 20, 35, 12, -4, -27 },
  { 3711, 19, 27, 21, 1, -19 },
  { 3776, 18, 27, 21, 1, -27 },
  { 3837, 10, 26, 10, 1, -26 },
  { 3870, 15, 34, 10, -4, -26 },
  { 3934, 19, 27, 19, 1, -27 },
  { 3999, 10, 27, 10, 1, -27 },
  { 4033, 28, 19, 31, 1, -19 },
  { 4100, 18, 19, 21, 1, -19 },
  { 4143, 17, 19, 20, 2, -19 },
  { 4184, 20, 27, 21, -1, -19 },
  { 4252, 18, 27, 21, 2, -19 },
  { 4313, 15, 19, 14, 1, -19 },
  { 4349, 15, 19, 16, 0, -19 },
  { 4385, 12, 23, 13, 2, -23 },
  { 4420, 18, 19, 21, 2, -19 },
  { 4463, 17, 19, 17, 2, -19 },
  { 4504, 26, 19, 27, 2, -19 },
  { 4566, 21, 19, 18, -2, -19 },
  { 4616, 22, 27, 17, -3, -19 },
  { 4691, 17, 19, 16, -1, -19 },
  { 4732, 14, 31, 12, 0, -25 },
  { 4787, 4, 35, 19, 8, -27 },
  { 4805, 14, 31, 12, -2, -25 },
  { 4860, 17, 5, 20, 2, -15 },
};

const GFXfont NotoSans_SemiBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiBoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMIBOLDITALIC35PT7B_H_
