#ifndef _ROBOTOCONDENSED_BLACKITALIC41PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x3C, 0x00, 0x7C, 0xFB, 0xE7,
  0xDF, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xFB, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7,
  0x8F, 0x38, 0x70, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00,
  0xF3, 0x80, 0x07, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1C, 0xF0,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3C,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9C, 0x03,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0x3C,
  0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x03, 0xFE, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xF9, 0xFC, 0x7F, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE7, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF8, 0xFE,
  0x3F, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x8F, 0x1E, 0x3D,
  0xE3, 0xC7, 0xBC, 0x79, 0xE7, 0x9F, 0x78, 0xF3, 0xCF, 0x1E, 0x7B, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xF7, 0x80, 0x7D, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFC, 0xF1,
  0xEF, 0x1E, 0x79, 0xE3, 0xCF, 0x3C, 0x7B, 0xC7, 0x8F, 0xF0, 0xF3, 0xCE,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3F,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x8F, 0x87, 0xFE, 0x3E, 0x3F, 0xFC, 0xF8, 0xFF, 0xF7, 0xE7, 0xFF,
  0xFF, 0x9F, 0x9F, 0xFC, 0xFE, 0x7F, 0xF3, 0xF8, 0xFF, 0x8F, 0xE1, 0xFE,
  0x1F, 0xCF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x07, 0xE3, 0xF8, 0x3C, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0xFB,
  0xEF, 0x3C, 0x00, 0x10, 0x03, 0x80, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0x80, 0x04, 0x00, 0x01, 0x00, 0x1C,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x0E, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x1C, 0x38, 0x67, 0xCE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xC1, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0x70, 0x0F, 0x9E, 0x07,
  0xE7, 0xC1, 0xF0, 0xF0, 0x38, 0x38, 0x00, 0x04, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x8F, 0xC7, 0xE3,
  0xE1, 0xF0, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x03, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xFC, 0x39, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0x8F, 0xE7, 0xE3, 0xF0, 0xF8, 0xFC, 0x3F, 0x7E, 0x0F, 0xDF, 0x87, 0xF7,
  0xE1, 0xFD, 0xF8, 0x7F, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xE1, 0xFB, 0xF0,
  0x7E, 0xFC, 0x3F, 0xBF, 0x0F, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F,
  0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE,
  0x3F, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0xCF, 0xFE, 0x73, 0xF4, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x7F, 0x1F, 0xC7,
  0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xFE, 0x0F,
  0xCF, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xF3, 0xF8, 0x7F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0x7E, 0x03,
  0xFF, 0xC0, 0xFB, 0xF8, 0x3F, 0x7E, 0x07, 0xCF, 0xC1, 0xF1, 0xF8, 0x7E,
  0x7F, 0x0F, 0x8F, 0xE3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFD, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x71, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F, 0x0F,
  0xC7, 0xF3, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF3, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFC, 0xFF, 0x7E, 0x1F, 0xDF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xDF, 0x87, 0xE7, 0xE3, 0xF9, 0xF9, 0xFE, 0x7F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x9F,
  0xC7, 0xF3, 0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F,
  0x0F, 0xCF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xE7, 0xE1, 0xF8, 0x7E, 0x7F, 0x0F, 0xCF, 0xE3, 0xF9,
  0xF8, 0x7F, 0x3F, 0x8F, 0xE7, 0xF3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0xFD, 0xFC, 0x7E,
  0xFC, 0x3F, 0x7E, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xF7, 0xE1,
  0xFB, 0xF9, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x07, 0xE1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1F, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x87, 0x80, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x7C, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFF, 0x0F, 0xFE, 0x3F, 0xFE, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07,
  0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8,
  0xFD, 0xFC, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0x3F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80,
  0x03, 0xC0, 0xF8, 0x00, 0x0E, 0x07, 0x81, 0xF0, 0x78, 0x7C, 0x3F, 0xE3,
  0xC3, 0xC3, 0xFF, 0x9E, 0x3C, 0x3F, 0xFC, 0xF1, 0xE3, 0xE3, 0xC7, 0x9F,
  0x1F, 0x1E, 0x3C, 0xF1, 0xF1, 0xF1, 0xE7, 0x8F, 0x8F, 0x8F, 0x78, 0xF8,
  0x78, 0x7B, 0xC7, 0xC3, 0xC3, 0xDE, 0x3E, 0x3E, 0x1E, 0xF1, 0xF1, 0xF0,
  0xE7, 0x8F, 0x0F, 0x0F, 0x7C, 0x78, 0x78, 0x7B, 0xC3, 0xC7, 0xC7, 0x9E,
  0x1E, 0x3E, 0x3C, 0xF0, 0xFF, 0xFB, 0xC7, 0x87, 0xFF, 0xFC, 0x1E, 0x1F,
  0x9F, 0xC0, 0xF0, 0x78, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7E, 0x7F, 0x00, 0x7E,
  0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x8F, 0xF0, 0xFC,
  0x1F, 0xC3, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F,
  0xC7, 0xF0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC0,
  0xFC, 0x7F, 0x03, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x87, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xE1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F,
  0x3F, 0x80, 0xFC, 0xFE, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0xFE, 0x07, 0xF1,
  0xF8, 0x1F, 0xC7, 0xE0, 0xFE, 0x1F, 0xEF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xBF, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x1F, 0xC1, 0xFC, 0x7F,
  0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF0, 0x3F, 0x9F, 0xC0, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0,
  0xFE, 0x1F, 0x8F, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xCF, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x3F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0xE7, 0xF1, 0xFF,
  0x9F, 0xC7, 0xFE, 0x7F, 0x1F, 0xF9, 0xF8, 0x7F, 0xE7, 0xE0, 0x3F, 0x9F,
  0x80, 0xFE, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xF7,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x03, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xEF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x7F, 0x81, 0xF8, 0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x87, 0xF8,
  0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x80, 0x3F, 0x3F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0x7F, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1,
  0xFC, 0x01, 0xF8, 0x7F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0xC7, 0xFF, 0x83, 0xF7, 0x8F, 0xBF, 0x0F, 0xEF, 0x1F, 0xFE, 0x1F, 0xDE,
  0x7D, 0xFC, 0x3F, 0x3C, 0xFB, 0xF0, 0x7E, 0x7B, 0xE7, 0xE0, 0xFC, 0xF7,
  0xDF, 0xC3, 0xF9, 0xEF, 0x3F, 0x87, 0xF3, 0xFE, 0x7F, 0x0F, 0xE7, 0xFC,
  0xFC, 0x1F, 0xCF, 0xF1, 0xF8, 0x3F, 0x1F, 0xE7, 0xF0, 0x7E, 0x3F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x1F, 0xC3, 0xF8, 0x7C, 0x3F, 0x87, 0xF0, 0xF8, 0x7E,
  0x0F, 0xE1, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC3,
  0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF0, 0x7F, 0xC1, 0xF8,
  0x3F, 0xE1, 0xFC, 0x1F, 0xF0, 0xFE, 0x1F, 0xF8, 0x7F, 0x0F, 0xFC, 0x3F,
  0x87, 0xFF, 0x1F, 0x83, 0xFF, 0x8F, 0xC1, 0xFB, 0xCF, 0xE0, 0xFD, 0xE7,
  0xF0, 0xFE, 0x7B, 0xF8, 0x7F, 0x3D, 0xFC, 0x3F, 0x9E, 0xFC, 0x1F, 0xCF,
  0x7E, 0x0F, 0xC7, 0xFF, 0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0xFF, 0xC3, 0xF8,
  0x7F, 0xE1, 0xFC, 0x3F, 0xE0, 0xFC, 0x0F, 0xF0, 0x7E, 0x07, 0xF8, 0x7F,
  0x03, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F,
  0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xF0,
  0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7E, 0x01,
  0xFC, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xEF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8,
  0x1F, 0xC3, 0xF0, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0x7E, 0x3F,
  0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xF0,
  0x0F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01,
  0xFC, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xEF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x04, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x8F, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x1F, 0xC0, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F,
  0x83, 0xF8, 0x7E, 0x1F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC1,
  0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xF3, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF9,
  0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0x1F, 0xE7,
  0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x1F,
  0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF8,
  0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03,
  0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F,
  0x83, 0xF8, 0x3F, 0xDF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x8F, 0xC0,
  0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF0,
  0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x83, 0xF7,
  0xF0, 0xFC, 0x3F, 0xBF, 0x87, 0xE1, 0xFD, 0xFC, 0x7F, 0x0F, 0xEF, 0xE3,
  0xF8, 0x7E, 0x7F, 0x1F, 0xC7, 0xF3, 0xF9, 0xFE, 0x3F, 0x9F, 0xCF, 0xF1,
  0xF8, 0xFE, 0x7F, 0x9F, 0xC7, 0xF7, 0xFC, 0xFE, 0x3F, 0xBF, 0xE7, 0xE1,
  0xFD, 0xFF, 0x7F, 0x0F, 0xFF, 0xFB, 0xF8, 0x7F, 0xFF, 0xDF, 0x83, 0xFF,
  0xFE, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x7F,
  0xF0, 0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xF8, 0x07, 0xFC, 0xFF, 0xC0,
  0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F,
  0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x07,
  0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0x87, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF8, 0xFC, 0x00,
  0x7F, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xFD, 0xF8,
  0x0F, 0xE7, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x83, 0xF1, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x01,
  0xF3, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x83,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF8, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFE, 0x07, 0xBC, 0x1F, 0x7C, 0x3E, 0x78, 0xF8, 0xF1,
  0xF1, 0xE7, 0xC3, 0xCF, 0x87, 0xBE, 0x0F, 0x80, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F,
  0xFF, 0x8F, 0xE7, 0xE3, 0xF9, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0xFF,
  0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x8F, 0xCF, 0xE3, 0xF3,
  0xF8, 0xFC, 0xFC, 0x7F, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0x9F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xFB, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xE1, 0xFC, 0xFC,
  0x3F, 0x9F, 0x87, 0xE7, 0xF0, 0xFC, 0xFE, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0,
  0x7E, 0x7E, 0x1F, 0xCF, 0xE7, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xFB, 0xFC, 0x3F, 0x3E, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE7, 0xE3, 0xF0, 0xF9, 0xFC, 0x3F,
  0x7F, 0x0F, 0xDF, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x7C, 0xFE, 0x1F, 0xEF, 0xC1,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x3F, 0xC7, 0xE1, 0xFC,
  0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F,
  0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x1F,
  0x7E, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF,
  0xFB, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x10,
  0xFF, 0x3C, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0x80, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x00,
  0x03, 0xF3, 0xF0, 0x7F, 0xBF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE3, 0xF8, 0xFE, 0x3F, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0,
  0xFE, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0x7E,
  0x1F, 0xC7, 0xE1, 0xFC, 0x7F, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFB, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x30, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF0,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFD, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xF3, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x0F, 0xE7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xE0, 0x01, 0x00, 0xF8, 0x1F, 0x87, 0xF0, 0xFE,
  0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x00,
  0x00, 0x0C, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0xC7, 0xF3, 0xFC, 0x3F,
  0x3F, 0xC1, 0xF9, 0xFC, 0x0F, 0xDF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7F, 0x03,
  0xF3, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7E, 0x1F,
  0xC3, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0x9F, 0x0F, 0x81, 0xFB, 0xF9, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xF9, 0xFE, 0x7F,
  0x3F, 0x8F, 0xC7, 0xF3, 0xF8, 0xFC, 0x7F, 0x3F, 0x0F, 0xC7, 0xF3, 0xF1,
  0xFC, 0x7F, 0x3F, 0x1F, 0xC7, 0xE7, 0xF1, 0xFC, 0x7E, 0x7F, 0x1F, 0x87,
  0xE7, 0xF1, 0xF8, 0xFE, 0x7E, 0x1F, 0x8F, 0xE7, 0xE3, 0xF8, 0xFE, 0x7E,
  0x3F, 0x8F, 0xCF, 0xE3, 0xF8, 0xFC, 0xFE, 0x3F, 0x0F, 0xCF, 0xE3, 0xF1,
  0xFC, 0xFC, 0x3F, 0x1F, 0xCF, 0xC7, 0xF1, 0xFC, 0x0F, 0xCF, 0x81, 0xFF,
  0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xF1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7,
  0xF3, 0xF8, 0xFE, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x7F, 0x1F,
  0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x9F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xFB, 0xF0,
  0xFC, 0xFE, 0x7F, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8,
  0x03, 0xF8, 0x00, 0x07, 0xE7, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC,
  0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0xCF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF7, 0xF8, 0x1F, 0x9F,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC7,
  0xE3, 0xFD, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFE, 0x3F,
  0x9F, 0x87, 0xF7, 0xF0, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFE,
  0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF8,
  0xFC, 0x7F, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x9E,
  0x3F, 0x7C, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xF9, 0x1F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF3, 0xF0, 0xFC, 0xFC, 0x7F, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0xC7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0x83, 0xF8,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xF8, 0x1F, 0x80, 0x3F,
  0x8F, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE7, 0xF0, 0xFC, 0xFE,
  0x3F, 0x9F, 0xC7, 0xF3, 0xF0, 0xFE, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF8,
  0x7E, 0x7F, 0x1F, 0xCF, 0xE3, 0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF8, 0xFE, 0x7F, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0x3E, 0xFC, 0x00, 0xFE, 0x3F, 0xBF, 0x8F, 0xEF, 0xE3, 0xFB, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x87, 0xE7, 0xE1, 0xFB, 0xF8, 0x7E, 0xFC,
  0x1F, 0xBF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x3C, 0x3F, 0xFC, 0x7C, 0x7E,
  0xFC, 0x7C, 0x7E, 0xFC, 0xFC, 0x7E, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFD, 0xFC, 0xFC, 0xFD, 0xFC, 0xF8, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xF0, 0xFF, 0xDF, 0xF0, 0xFF, 0x9F, 0xE0,
  0xFF, 0x9F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0,
  0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x00,
  0x0F, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E,
  0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x0F,
  0xE7, 0xE0, 0x7F, 0x3F, 0x07, 0xF1, 0xFC, 0x3F, 0x87, 0xE0, 0x1F, 0xC3,
  0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0xFE, 0x0F,
  0xE7, 0xF0, 0x3F, 0x7F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x00, 0x20,
  0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x0F,
  0xE0, 0xFE, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x04, 0x00, 0x07, 0x83, 0x81,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x00,
  0x02, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x03, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0xC0, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x3C, 0xFF, 0x8F, 0xBF, 0xF9, 0xF7, 0xFF, 0xFE, 0xF9,
  0xFF, 0xBE, 0x1F, 0xF7, 0xC1, 0xFC, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 29, 11, 0, -29 },
  { 45, 13, 11, 13, 2, -31 },
  { 63, 21, 29, 20, 0, -29 },
  { 140, 19, 37, 20, 1, -33 },
  { 228, 19, 29, 26, 4, -29 },
  { 297, 22, 29, 24, 0, -29 },
  { 377, 6, 12, 6, 2, -31 },
  { 386, 13, 41, 13, 2, -32 },
  { 453, 13, 41, 13, -2, -32 },
  { 520, 18, 18, 19, 2, -29 },
  { 561, 17, 22, 18, 1, -25 },
  { 608, 9, 13, 11, -2, -5 },
  { 623, 11, 5, 17, 3, -15 },
  { 630, 7, 7, 12, 1, -7 },
  { 637, 18, 32, 12, -3, -29 },
  { 709, 18, 29, 20, 2, -29 },
  { 775, 13, 29, 20, 4, -29 },
  { 823, 20, 29, 20, 0, -29 },
  { 896, 20, 29, 20, 0, -29 },
  { 969, 19, 29, 20, 1, -29 },
  { 1038, 19, 29, 20, 1, -29 },
  { 1107, 18, 29, 20, 1, -29 },
  { 1173, 20, 29, 20, 1, -29 },
  { 1246, 19, 29, 20, 1, -29 },
  { 1315, 17, 29, 20, 3, -29 },
  { 1377, 10, 23, 12, 1, -23 },
  { 1406, 13, 31, 11, -2, -23 },
  { 1457, 16, 20, 18, 1, -22 },
  { 1497, 18, 13, 21, 1, -19 },
  { 1527, 17, 20, 18, 0, -22 },
  { 1570, 17, 29, 18, 2, -29 },
  { 1632, 29, 37, 30, 0, -28 },
  { 1767, 24, 29, 24, -2, -29 },
  { 1854, 22, 29, 23, 0, -29 },
  { 1934, 22, 29, 23, 1, -29 },
  { 2014, 22, 29, 22, 0, -29 },
  { 2094, 22, 29, 19, 0, -29 },
  { 2174, 21, 29, 19, 0, -29 },
  { 2251, 22, 29, 24, 1, -29 },
  { 2331, 25, 29, 24, 0, -29 },
  { 2422, 12, 29, 11, 0, -29 },
  { 2466, 21, 29, 20, 0, -29 },
  { 2543, 26, 29, 22, 0, -29 },
  { 2638, 17, 29, 19, 0, -29 },
  { 2700, 31, 29, 30, 0, -29 },
  { 2813, 25, 29, 24, 0, -29 },
  { 2904, 23, 29, 24, 1, -29 },
  { 2988, 23, 29, 23, 0, -29 },
  { 3072, 23, 34, 24, 1, -29 },
  { 3170, 22, 29, 23, 0, -29 },
  { 3250, 21, 29, 22, 1, -29 },
  { 3327, 21, 29, 22, 3, -29 },
  { 3404, 23, 29, 23, 1, -29 },
  { 3488, 23, 29, 23, 3, -29 },
  { 3572, 29, 29, 30, 3, -29 },
  { 3678, 27, 29, 22, -2, -29 },
  { 3776, 22, 29, 22, 3, -29 },
  { 3856, 24, 29, 21, -1, -29 },
  { 3943, 14, 41, 11, -1, -34 },
  { 4015, 11, 32, 15, 3, -29 },
  { 4059, 14, 41, 11, -2, -34 },
  { 4131, 15, 15, 16, 1, -29 },
  { 4160, 16, 5, 16, -3, 0 },
  { 4170, 10, 6, 14, 4, -30 },
  { 4178, 18, 22, 19, 0, -22 },
  { 4228, 19, 31, 20, 0, -31 },
  { 4302, 18, 22, 18, 0, -22 },
  { 4352, 20, 31, 20, 1, -31 },
  { 4430, 17, 22, 19, 1, -22 },
  { 4477, 15, 31, 13, 1, -31 },
  { 4536, 20, 30, 20, 0, -22 },
  { 4611, 19, 31, 20, -1, -31 },
  { 4685, 11, 31, 10, 0, -31 },
  { 4728, 16, 39, 10, -5, -31 },
  { 4806, 21, 31, 20, 0, -31 },
  { 4888, 12, 31, 10, 0, -31 },
  { 4935, 28, 22, 29, 0, -22 },
  { 5012, 19, 22, 20, -1, -22 },
  { 5065, 18, 22, 20, 1, -22 },
  { 5115, 21, 30, 20, -2, -22 },
  { 5194, 19, 30, 20, 1, -22 },
  { 5266, 15, 22, 14, 0, -22 },
  { 5308, 18, 22, 18, 0, -22 },
  { 5358, 12, 27, 12, 1, -27 },
  { 5399, 19, 22, 20, 1, -22 },
  { 5452, 18, 22, 18, 2, -22 },
  { 5502, 24, 22, 25, 2, -22 },
  { 5568, 21, 22, 18, -2, -22 },
  { 5626, 21, 30, 18, -1, -22 },
  { 5705, 19, 22, 18, -1, -22 },
  { 5758, 12, 39, 12, 1, -32 },
  { 5817, 9, 34, 10, 1, -29 },
  { 5856, 12, 39, 12, -1, -32 },
  { 5915, 19, 9, 22, 1, -16 },
};

const GFXfont RobotoCondensed_BlackItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_BLACKITALIC41PT7B_H_
