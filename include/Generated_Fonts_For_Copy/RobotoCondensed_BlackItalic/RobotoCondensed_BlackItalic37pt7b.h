#ifndef _ROBOTOCONDENSED_BLACKITALIC37PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x3F, 0x87, 0xF0, 0x7C, 0x07,
  0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x78, 0xE7, 0x9E, 0x79, 0xE7,
  0x1E, 0x71, 0xC7, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0xDE, 0x00,
  0x73, 0xC0, 0x0E, 0x70, 0x03, 0xDE, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xCE, 0x00, 0x7B, 0xC0, 0x0E,
  0x70, 0x03, 0xCE, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x7B,
  0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x01, 0xCE,
  0x00, 0x79, 0xC0, 0x0F, 0x78, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xCF, 0xC7, 0xC7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE7, 0xE1, 0xF3, 0xF0, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F,
  0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x01, 0xEF, 0x0C, 0xF1, 0xC7, 0xBC, 0x71, 0xCF, 0x3C, 0xF3, 0xCF,
  0x78, 0xF3, 0xFC, 0x1F, 0xEE, 0x07, 0xFF, 0x80, 0x7B, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3D, 0xE0, 0x1F, 0xFE, 0x07, 0x7F, 0x83, 0xFC, 0xF1,
  0xEF, 0x3C, 0xF3, 0x8F, 0x3C, 0xE3, 0xDE, 0x38, 0xE7, 0x0F, 0x78, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0x1E, 0x3F, 0xE7, 0xCF, 0xFC, 0xF9, 0xFF, 0xDF, 0x7F, 0xFF, 0xEF, 0xDF,
  0xFB, 0xF1, 0xFF, 0x7E, 0x3F, 0xCF, 0xC3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xF9, 0xFC, 0x7D, 0xE7, 0x9E, 0x7B,
  0xEF, 0x3C, 0xF3, 0xC0, 0x00, 0x40, 0x1C, 0x07, 0x81, 0xF0, 0x7C, 0x1F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x80, 0x02, 0x00, 0x38, 0x03, 0x80,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07,
  0x00, 0x40, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x61,
  0xC2, 0x79, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0x1F,
  0xE0, 0x3E, 0xE0, 0x7C, 0xF0, 0xF8, 0x78, 0x30, 0x70, 0x10, 0x60, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0xF8, 0xF8, 0x30, 0xFF,
  0xFF, 0xEF, 0xFB, 0xFE, 0xFF, 0x80, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0xF8,
  0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3,
  0xE7, 0xE1, 0xF3, 0xF1, 0xF9, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E,
  0x1F, 0x3F, 0x0F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0,
  0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x30, 0x1E, 0x0F, 0xE3,
  0xFE, 0x7F, 0xEF, 0xFE, 0xFF, 0xEE, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xFC,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xCF, 0xC1, 0xF3, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xC7, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x07, 0xBE, 0x07, 0xFF, 0x03, 0xDF, 0x83, 0xEF, 0xC3, 0xE7, 0xE1,
  0xF3, 0xF1, 0xF1, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF8, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x78, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xF3, 0xF0, 0x10, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7,
  0xE7, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x78, 0x7F, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0x9F,
  0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFC,
  0xFC, 0xFC, 0x3E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3E, 0x7E,
  0x3E, 0x7E, 0x3F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0x7C,
  0x7E, 0x7E, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F,
  0x00, 0x78, 0x00, 0x1F, 0x0F, 0x8F, 0xE7, 0xF1, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x0F, 0x00, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x02, 0x00, 0x38, 0x01,
  0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0xFE, 0x01,
  0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x20, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x00, 0x7C, 0x00, 0x70, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF1, 0xFF, 0xE7, 0xFF, 0xEF, 0xCF, 0xFF, 0x1F, 0xFE, 0x3F, 0x00, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x0F, 0x07,
  0xC1, 0xC7, 0x87, 0xFC, 0x71, 0xE3, 0xFF, 0x1C, 0xF0, 0xFB, 0xC7, 0x3C,
  0x78, 0xF1, 0xDE, 0x3E, 0x3C, 0x77, 0x8F, 0x0E, 0x1D, 0xE3, 0xC7, 0x87,
  0x79, 0xF1, 0xE3, 0xDC, 0x78, 0x78, 0xEF, 0x1E, 0x3C, 0x3B, 0xC7, 0x8F,
  0x1E, 0xF1, 0xE3, 0xC7, 0x3C, 0x7D, 0xF3, 0xCF, 0x1F, 0xFF, 0xE3, 0xC3,
  0xF7, 0xF0, 0x70, 0x78, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x01, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F,
  0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x9F,
  0xC0, 0x7E, 0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF1, 0xF8, 0x7F, 0x1F,
  0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xF0, 0xFC,
  0x3F, 0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F,
  0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF7,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC1, 0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x3E, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x87, 0xF3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F,
  0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0x7E, 0x3F, 0x87, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x3F, 0x83, 0xF3,
  0xF0, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x3F, 0xE7, 0xE3, 0xFE, 0x7E, 0x3F, 0xEF, 0xE3, 0xFE, 0xFC, 0x0F,
  0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x0F,
  0xE0, 0x7E, 0x3F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xFC, 0x07, 0xE7, 0xF0,
  0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xF7,
  0x8F, 0xFC, 0x3F, 0x79, 0xFF, 0xC3, 0xF7, 0x9E, 0xFC, 0x3F, 0x7B, 0xEF,
  0xC3, 0xF7, 0xBC, 0xF8, 0x3E, 0x7B, 0xDF, 0x87, 0xE7, 0xFD, 0xF8, 0x7E,
  0x7F, 0x9F, 0x87, 0xE7, 0xF9, 0xF8, 0x7E, 0x7F, 0x1F, 0x87, 0xE7, 0xF3,
  0xF0, 0xFE, 0x3E, 0x3F, 0x0F, 0xC3, 0xE3, 0xF0, 0xFC, 0x3E, 0x3F, 0x0F,
  0xC3, 0xC3, 0xF0, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0,
  0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC3, 0xFE, 0x1F, 0x87, 0xFC, 0x3F, 0x0F,
  0xF8, 0xFC, 0x1F, 0xF1, 0xF8, 0x3F, 0xE3, 0xF0, 0x7F, 0xE7, 0xE1, 0xFB,
  0xCF, 0xC3, 0xF7, 0x9F, 0x87, 0xE7, 0x7E, 0x0F, 0xCE, 0xFC, 0x1F, 0x9F,
  0xF8, 0x3F, 0x3F, 0xF0, 0xFC, 0x3F, 0xE1, 0xF8, 0x7F, 0xC3, 0xF0, 0xFF,
  0x07, 0xE1, 0xFE, 0x0F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xF0,
  0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x3F, 0x83, 0xF3,
  0xF0, 0x3F, 0x3F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F,
  0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x0F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0x3F,
  0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xFF, 0xE0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F,
  0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00,
  0x04, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83,
  0xF1, 0xF8, 0x3F, 0x1F, 0x87, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xE7, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF8, 0xFE, 0x1F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0xCF, 0xE1, 0xF9,
  0xF8, 0x3F, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x0F, 0xE3, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0xFE,
  0x1F, 0xCF, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F, 0x07,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0xFC, 0x3E, 0x1F, 0xBF, 0x0F, 0x87, 0xEF, 0xC7, 0xE1, 0xFB, 0xF1,
  0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x3F, 0x8F, 0xCF, 0xCF, 0xE3, 0xE3,
  0xF3, 0xF9, 0xF8, 0xFD, 0xFE, 0x7E, 0x3F, 0x7F, 0x9F, 0x0F, 0xDF, 0xEF,
  0xC3, 0xFF, 0xFB, 0xF0, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFD,
  0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0xFF, 0xDF, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F,
  0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8,
  0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03,
  0xF0, 0xFC, 0x03, 0xF1, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x01,
  0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F,
  0xEF, 0xC0, 0x0F, 0xCF, 0xE0, 0x1F, 0xC7, 0xE0, 0x1F, 0x87, 0xE0, 0x3F,
  0x87, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xFF, 0x81,
  0xFD, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC1, 0xF3, 0xF0, 0x3E, 0x7E, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x03, 0xF8,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x00, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0x03, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x7B, 0xC3, 0xDE, 0x3E, 0x71, 0xE3,
  0x9F, 0x1E, 0xF0, 0xFF, 0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x03, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x3F, 0x3F, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0x7E, 0xFC, 0x7E, 0xFC,
  0x7E, 0xFC, 0x7C, 0xFD, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x1E,
  0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xC3, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E,
  0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xE7, 0xE1, 0xF3, 0xF1, 0xF9,
  0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3E, 0xFF, 0x1F, 0x3E,
  0x00, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x3E,
  0x3F, 0x7E, 0x1F, 0x7E, 0x3F, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x7E, 0x7C, 0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xCF, 0xC1, 0xFD, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7E, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1,
  0xF0, 0xFC, 0x3E, 0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x1F, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xBE, 0x00,
  0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3E,
  0x7C, 0x3E, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x10, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0xF3, 0xFF, 0xBF, 0xF9, 0xFF, 0xC3,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x00, 0x03, 0xE7, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F,
  0xFF, 0x8F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87,
  0xE7, 0xE1, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0xC7, 0xE3, 0xF1,
  0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x3D, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC1, 0xEF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xDE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xE7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0x07, 0x83, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x78, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x8F, 0xE3, 0xF3, 0xF8, 0x7C, 0xFE,
  0x0F, 0x9F, 0x83, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFD, 0xF8, 0x1F, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x80, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x1F, 0x3E, 0x3E, 0x0F,
  0xBF, 0xBF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xF8, 0xFC, 0xFC, 0xFC, 0x7C, 0x7E, 0x7E, 0x7E, 0x3F, 0x3E, 0x3F, 0x1F,
  0xBF, 0x1F, 0x8F, 0xDF, 0x8F, 0xC7, 0xEF, 0xC7, 0xE3, 0xE7, 0xE3, 0xF3,
  0xF3, 0xF1, 0xF1, 0xF9, 0xF1, 0xF8, 0xFD, 0xF8, 0xFC, 0x7E, 0xFC, 0x7E,
  0x3F, 0x7E, 0x3F, 0x1F, 0x3F, 0x1F, 0x9F, 0x9F, 0x8F, 0x8F, 0xC0, 0x1F,
  0x3C, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0xFC,
  0xFC, 0x7E, 0x7C, 0x3F, 0x7E, 0x1F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7,
  0xE7, 0xE3, 0xF3, 0xE1, 0xFB, 0xF0, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E,
  0x3F, 0x3F, 0x1F, 0x9F, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xF8, 0xF9, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E,
  0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF9,
  0xF0, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xE3,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xBE,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0xC3, 0xFB,
  0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xC7, 0xE7, 0xE1, 0xF9,
  0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0xFC,
  0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7D, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x1F,
  0x38, 0xFF, 0xC7, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFC, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x3F, 0x3E, 0x3F, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0xF8, 0x7C, 0xFC, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC7, 0xFE, 0xFF, 0xDF, 0xFF, 0xFE, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x83, 0xF0, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0xF8, 0x3F, 0x1F, 0x9F,
  0x0F, 0xCF, 0x87, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC,
  0xF8, 0x7E, 0x7C, 0x3E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7,
  0xE7, 0xE3, 0xF3, 0xF1, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F,
  0xFF, 0x07, 0xDF, 0x80, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xF8, 0xFD, 0xF8, 0xFD, 0xF8, 0x7D, 0xF0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0xF8, 0xFF, 0xC7,
  0xCF, 0xFE, 0x3E, 0x7F, 0xF3, 0xF3, 0xEF, 0x9F, 0x9F, 0x7C, 0xFD, 0xFB,
  0xEF, 0xEF, 0x9F, 0x7F, 0x7C, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xF9, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFC, 0x7F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C,
  0x00, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x3E, 0x7E, 0x07, 0xCF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xDF,
  0x01, 0xFB, 0xE0, 0x3F, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7E, 0x1F,
  0x00, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xE1, 0xF9,
  0xF8, 0x3F, 0x3F, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x40, 0x38, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x70, 0x04, 0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x06, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x0F, 0x87, 0xF0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x1F,
  0x03, 0xC0, 0x20, 0x00, 0x1F, 0x00, 0x1F, 0xC3, 0xDF, 0xF1, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF7, 0xCF, 0xFB, 0xC3, 0xF8, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_BlackItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 26, 10, 0, -26 },
  { 37, 12, 10, 11, 1, -28 },
  { 52, 19, 26, 18, 0, -26 },
  { 114, 17, 34, 18, 1, -30 },
  { 187, 18, 26, 23, 3, -26 },
  { 246, 19, 26, 21, 0, -26 },
  { 308, 6, 10, 6, 2, -28 },
  { 316, 11, 37, 12, 2, -29 },
  { 367, 12, 37, 12, -2, -29 },
  { 423, 16, 16, 17, 2, -26 },
  { 455, 15, 19, 17, 1, -22 },
  { 491, 8, 12, 10, -2, -5 },
  { 503, 10, 5, 15, 3, -14 },
  { 510, 6, 6, 11, 1, -6 },
  { 515, 17, 28, 11, -3, -26 },
  { 575, 17, 26, 18, 1, -26 },
  { 631, 12, 26, 18, 4, -26 },
  { 670, 18, 26, 18, 0, -26 },
  { 729, 18, 26, 18, 0, -26 },
  { 788, 17, 26, 18, 1, -26 },
  { 844, 17, 26, 18, 1, -26 },
  { 900, 16, 26, 18, 1, -26 },
  { 952, 18, 26, 18, 1, -26 },
  { 1011, 17, 26, 18, 1, -26 },
  { 1067, 16, 26, 18, 2, -26 },
  { 1119, 9, 20, 11, 1, -20 },
  { 1142, 12, 27, 10, -2, -20 },
  { 1183, 15, 18, 16, 1, -20 },
  { 1217, 16, 13, 19, 1, -18 },
  { 1243, 16, 18, 16, 0, -20 },
  { 1279, 15, 26, 17, 2, -26 },
  { 1328, 26, 33, 28, 0, -25 },
  { 1436, 22, 26, 22, -2, -26 },
  { 1508, 20, 26, 20, 0, -26 },
  { 1573, 20, 26, 21, 1, -26 },
  { 1638, 20, 26, 20, 0, -26 },
  { 1703, 20, 26, 18, 0, -26 },
  { 1768, 19, 26, 17, 0, -26 },
  { 1830, 20, 26, 21, 1, -26 },
  { 1895, 23, 26, 22, 0, -26 },
  { 1970, 11, 26, 10, 0, -26 },
  { 2006, 19, 26, 18, 0, -26 },
  { 2068, 23, 26, 20, 0, -26 },
  { 2143, 15, 26, 17, 0, -26 },
  { 2192, 28, 26, 27, 0, -26 },
  { 2283, 23, 26, 22, 0, -26 },
  { 2358, 20, 26, 22, 1, -26 },
  { 2423, 21, 26, 21, 0, -26 },
  { 2492, 20, 31, 22, 1, -26 },
  { 2570, 20, 26, 20, 0, -26 },
  { 2635, 19, 26, 20, 1, -26 },
  { 2697, 19, 26, 20, 3, -26 },
  { 2759, 21, 26, 21, 1, -26 },
  { 2828, 20, 26, 21, 3, -26 },
  { 2893, 26, 26, 27, 3, -26 },
  { 2978, 24, 26, 20, -2, -26 },
  { 3056, 19, 26, 20, 3, -26 },
  { 3118, 22, 26, 19, -1, -26 },
  { 3190, 13, 37, 10, -1, -31 },
  { 3251, 9, 28, 14, 3, -26 },
  { 3283, 13, 37, 10, -2, -31 },
  { 3344, 13, 13, 14, 1, -26 },
  { 3366, 14, 5, 14, -2, 0 },
  { 3375, 8, 6, 12, 4, -28 },
  { 3381, 16, 20, 17, 0, -20 },
  { 3421, 17, 28, 18, 0, -28 },
  { 3481, 16, 20, 16, 0, -20 },
  { 3521, 19, 28, 18, 0, -28 },
  { 3588, 16, 20, 17, 1, -20 },
  { 3628, 13, 28, 12, 1, -28 },
  { 3674, 18, 28, 18, 0, -20 },
  { 3737, 18, 28, 18, -1, -28 },
  { 3800, 10, 28, 9, 0, -28 },
  { 3835, 14, 36, 9, -4, -28 },
  { 3898, 19, 28, 18, 0, -28 },
  { 3965, 11, 28, 9, 0, -28 },
  { 4004, 25, 20, 26, 0, -20 },
  { 4067, 17, 20, 18, 0, -20 },
  { 4110, 17, 20, 18, 0, -20 },
  { 4153, 19, 28, 18, -2, -20 },
  { 4220, 18, 28, 18, 0, -20 },
  { 4283, 13, 20, 12, 0, -20 },
  { 4316, 16, 20, 16, 0, -20 },
  { 4356, 11, 24, 11, 1, -24 },
  { 4389, 17, 20, 18, 1, -20 },
  { 4432, 16, 20, 17, 2, -20 },
  { 4472, 21, 20, 22, 2, -20 },
  { 4525, 19, 20, 16, -1, -20 },
  { 4573, 19, 28, 17, -1, -20 },
  { 4640, 18, 20, 16, -1, -20 },
  { 4685, 11, 36, 11, 1, -29 },
  { 4735, 8, 31, 9, 1, -26 },
  { 4766, 11, 36, 11, -1, -29 },
  { 4816, 17, 8, 19, 1, -15 },
};

const GFXfont RobotoCondensed_BlackItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_BLACKITALIC37PT7B_H_
