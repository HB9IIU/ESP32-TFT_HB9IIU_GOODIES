#ifndef _ROBOTOCONDENSED_BLACKITALIC66PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x70,
  0x00, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFE, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE3, 0xF0, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01,
  0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x08, 0x1F, 0xC7, 0xE0, 0x38, 0x7F, 0x0F, 0xC0, 0x7C, 0xFE,
  0x1F, 0xC1, 0xFD, 0xFC, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x0F, 0xC7, 0xE0,
  0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x0F,
  0xE7, 0xF0, 0x7F, 0x1F, 0xDF, 0xC0, 0xFF, 0xFF, 0x3F, 0x00, 0xFF, 0xFE,
  0xFE, 0x01, 0xFF, 0xFB, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x9F,
  0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xFF, 0x00, 0x0F, 0xDF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xFC,
  0x07, 0xF7, 0xF1, 0xFC, 0x1F, 0xDF, 0xC3, 0xF8, 0x3F, 0x3F, 0x87, 0xF0,
  0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE1, 0xFC, 0x3F, 0x9F,
  0xC3, 0xF8, 0x7F, 0x7F, 0x07, 0xF0, 0xFC, 0xFC, 0x0F, 0xE3, 0xF8, 0xF8,
  0x1F, 0xC7, 0xF0, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0x87, 0xFC, 0x7F, 0xFF, 0xE1,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xE7, 0xFE, 0xFF,
  0xEF, 0xF9, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0x07, 0xFF, 0xF8, 0xFF,
  0xC1, 0xFF, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF,
  0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x02, 0x00, 0xFC, 0x00, 0x1C, 0x07, 0xE0, 0x71,
  0xF8, 0x3E, 0x1F, 0x8F, 0xF1, 0xF3, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x7F,
  0x87, 0xF0, 0x07, 0xFC, 0x1F, 0x80, 0x7F, 0xC0, 0xFE, 0x00, 0xFC, 0x07,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x00,
  0xF0, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x1F, 0x83,
  0xFC, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xE3,
  0xFC, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC,
  0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x3F,
  0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC,
  0x07, 0xFE, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x03,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF,
  0xC7, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xE3,
  0xFF, 0x01, 0xFF, 0x87, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x3F,
  0xF3, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF,
  0x0F, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFD, 0xFF, 0xC0, 0x0F, 0xFB,
  0xFF, 0x80, 0x1F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x1F,
  0xF8, 0x03, 0xFC, 0x7F, 0xF0, 0x0F, 0xF8, 0xFF, 0xE0, 0x1F, 0xE1, 0xFF,
  0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0xF8, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xF0, 0x7F, 0xF0, 0x00, 0x60, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0xFC,
  0x00, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF, 0x83, 0xFF, 0x9F, 0xF8, 0x0F,
  0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x7F, 0xF0, 0x1F, 0xFB,
  0xFF, 0x80, 0xFF, 0xDF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE,
  0x01, 0xFF, 0xBF, 0xF0, 0x1F, 0xFC, 0xFF, 0x80, 0xFF, 0xE7, 0xFC, 0x07,
  0xFE, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x83,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F,
  0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x3F, 0xF0,
  0x7F, 0xE3, 0xFF, 0x03, 0xFE, 0x7F, 0xF0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE,
  0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F,
  0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0xFF, 0xE7, 0xFE, 0x0F, 0xFE, 0x7F,
  0xF1, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F,
  0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0xF0, 0x1F,
  0x81, 0xFE, 0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xF0, 0x1F, 0xFF, 0xE0, 0xFC,
  0x3F, 0xC0, 0xFF, 0xFF, 0xC3, 0xF0, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xC3,
  0xF8, 0x3F, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xFF, 0x0F, 0xE0, 0xFC, 0x7F,
  0x07, 0xF8, 0x3F, 0x83, 0xF3, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xCF, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFD, 0xFC, 0x1F,
  0xE0, 0x7F, 0x03, 0xF7, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xDF, 0xC3, 0xFC,
  0x0F, 0xE0, 0x7F, 0x7E, 0x0F, 0xF0, 0x3F, 0x81, 0xFB, 0xF8, 0x3F, 0xC0,
  0xFE, 0x07, 0xEF, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0xBF, 0x83, 0xF8, 0x1F,
  0xC0, 0x7E, 0xFE, 0x1F, 0xE0, 0x7F, 0x03, 0xF3, 0xF8, 0x7F, 0x81, 0xFC,
  0x0F, 0xCF, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F, 0x3F, 0x07, 0xF8, 0x3F, 0x81,
  0xF8, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xE3, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0x0F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFC, 0x3F, 0x03, 0xFC, 0xFF, 0x87, 0xE0,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xC0, 0x7F, 0xF7, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0x8F, 0xFF, 0x00, 0xFE,
  0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xF8, 0x01, 0xC0, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x87, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xF0,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x0F, 0xFE,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8,
  0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xFC, 0x7F, 0xF0,
  0x3F, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xFC, 0x7F, 0xF0, 0x7F, 0xFF, 0xC7,
  0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0x07, 0xFF,
  0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x00, 0x1F, 0xF8,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xC7, 0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFD, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFE,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xF7, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFD, 0xFE, 0x0F, 0xF7, 0xFE, 0x03,
  0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xE1, 0xFE, 0xFF, 0xC0,
  0x3F, 0xF7, 0xF8, 0x7F, 0xBF, 0xF0, 0x0F, 0xFC, 0xFE, 0x3F, 0xCF, 0xFC,
  0x07, 0xFF, 0x3F, 0x8F, 0xF3, 0xFF, 0x01, 0xFF, 0xCF, 0xE3, 0xFD, 0xFF,
  0xC0, 0x7F, 0xE3, 0xF9, 0xFE, 0x7F, 0xE0, 0x1F, 0xF8, 0xFE, 0x7F, 0x9F,
  0xF8, 0x07, 0xFE, 0x3F, 0xBF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xEF, 0xF3,
  0xFF, 0x80, 0xFF, 0xE3, 0xFB, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xFE,
  0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xF8, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x07, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F,
  0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xBF, 0x07, 0xFE, 0x01, 0xFF, 0xDF, 0xC3, 0xFF,
  0x00, 0xFF, 0xEF, 0xE3, 0xFF, 0x80, 0x7F, 0xF3, 0xF1, 0xFF, 0xC0, 0x3F,
  0xF9, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F,
  0x3F, 0xF0, 0x0F, 0xFE, 0x3F, 0x9F, 0xF8, 0x07, 0xFF, 0x0F, 0xDF, 0xFC,
  0x03, 0xFF, 0x87, 0xEF, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0xFF,
  0xE1, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC,
  0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x8F,
  0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x3F,
  0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F,
  0xF3, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF,
  0xCF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8,
  0x7F, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8,
  0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x07,
  0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x80,
  0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xBF,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF3, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x3F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xE3, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0x0F, 0xFE, 0x3F, 0xFF, 0x1F, 0xF8, 0x3F, 0xF9, 0xFF, 0xFC,
  0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F, 0xFB, 0xFF, 0xFD, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF9, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF1,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0xFF, 0xF3,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x87, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF9, 0xFF,
  0xC0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF8,
  0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x0F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xCF, 0xC0,
  0x7F, 0x9F, 0x80, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x1F,
  0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFC, 0x0F, 0xF7, 0xF8,
  0x1F, 0xEF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF,
  0xC1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC3, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xCF, 0xFE, 0x0F, 0xFC, 0xFF, 0xE1, 0xFF, 0xCF, 0xFE, 0x1F, 0xFC, 0xFF,
  0xC1, 0xFF, 0xCF, 0xFC, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xDF, 0xF8, 0x1F, 0xFD, 0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE3, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF,
  0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8,
  0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80,
  0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x0F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF7, 0xFF, 0xE0, 0x7F, 0xC7, 0xFF, 0x80,
  0xFF, 0x87, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE7, 0xFF, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0x9F, 0xF8, 0x1F,
  0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xDF, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x9F, 0xF8, 0x3F, 0xF3,
  0xFF, 0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x78, 0x3F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x03,
  0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xFE, 0x07, 0xFC,
  0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xF9, 0xFF,
  0xC0, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0x00, 0xFF, 0xE0,
  0x3C, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xC0,
  0x1F, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xC7, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x18, 0x03, 0xFF, 0x80,
  0x1F, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE3, 0xE0,
  0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x81,
  0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE1,
  0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x87, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0x8F,
  0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF,
  0xDF, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF0,
  0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xF3, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0xBF, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xE3, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x7F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF,
  0x07, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8,
  0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC7, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8,
  0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87,
  0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF,
  0x81, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xFE, 0x07, 0xFC, 0x7F,
  0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80,
  0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0x7F, 0xE0, 0x3F, 0xFB, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0x7F,
  0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0,
  0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF,
  0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFD, 0xFF, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFF,
  0x3F, 0xF0, 0x03, 0xFF, 0x87, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x81, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x8F,
  0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xC7, 0xFF,
  0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xFF,
  0x9F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFB, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x1F,
  0xF8, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x0F,
  0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x87,
  0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0x03, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xEF, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0, 0xFF, 0xE7, 0xFE,
  0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x3F, 0xF8, 0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F,
  0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE, 0xFF,
  0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xEF, 0xF8, 0x3F, 0xC1, 0xFF, 0xBF, 0xE0,
  0xFF, 0x07, 0xFE, 0xFF, 0x87, 0xFC, 0x1F, 0xF3, 0xFE, 0x1F, 0xF0, 0xFF,
  0xCF, 0xF8, 0x7F, 0xC3, 0xFF, 0x3F, 0xE3, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFE, 0x7F, 0xF1, 0xFF, 0x8F, 0xF9, 0xFF, 0xC7, 0xFC,
  0x3F, 0xE7, 0xFF, 0xBF, 0xF0, 0xFF, 0xBF, 0xFE, 0xFF, 0x83, 0xFE, 0xFF,
  0xFB, 0xFE, 0x0F, 0xF7, 0xFF, 0xEF, 0xF8, 0x3F, 0xDF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xBF, 0xFF, 0x80, 0xFF, 0xFC, 0xFF, 0xFE, 0x03,
  0xFF, 0xF3, 0xFF, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F,
  0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xE0, 0x03, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x3F,
  0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xCF,
  0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x0F, 0xFB,
  0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x3F, 0xFC,
  0x07, 0xF0, 0xFF, 0xFC, 0x0F, 0xE1, 0xFF, 0xF8, 0x1F, 0xC7, 0xFF, 0xF8,
  0x7F, 0x8F, 0xFF, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xDF, 0xFF,
  0xF8, 0xFF, 0x0F, 0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0xC7, 0xF8, 0x1F, 0xFF,
  0x0F, 0xF0, 0x1F, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00,
};

const GFXglyph RobotoCondensed_BlackItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 18, 48, 17, 1, -47 },
  { 109, 21, 18, 20, 3, -50 },
  { 157, 33, 47, 33, 0, -47 },
  { 351, 31, 62, 33, 2, -55 },
  { 592, 31, 49, 41, 6, -48 },
  { 782, 34, 49, 38, 1, -48 },
  { 991, 11, 19, 10, 3, -50 },
  { 1018, 20, 66, 21, 3, -52 },
  { 1183, 21, 67, 21, -3, -52 },
  { 1359, 29, 29, 30, 3, -47 },
  { 1465, 28, 34, 30, 1, -38 },
  { 1584, 15, 21, 17, -4, -8 },
  { 1624, 18, 8, 27, 4, -24 },
  { 1642, 12, 11, 19, 1, -10 },
  { 1659, 29, 51, 20, -5, -47 },
  { 1844, 30, 49, 33, 2, -48 },
  { 2028, 21, 47, 33, 7, -47 },
  { 2152, 32, 48, 33, 0, -48 },
  { 2344, 32, 49, 33, 0, -48 },
  { 2540, 31, 47, 33, 1, -47 },
  { 2723, 32, 48, 33, 1, -47 },
  { 2915, 29, 48, 33, 2, -47 },
  { 3089, 32, 47, 33, 2, -47 },
  { 3277, 31, 49, 33, 1, -48 },
  { 3467, 28, 48, 33, 4, -48 },
  { 3635, 16, 37, 19, 1, -36 },
  { 3709, 20, 49, 18, -3, -36 },
  { 3832, 27, 32, 29, 1, -36 },
  { 3940, 29, 21, 33, 2, -31 },
  { 4017, 27, 31, 29, 1, -35 },
  { 4122, 26, 49, 29, 4, -48 },
  { 4282, 46, 60, 49, 1, -45 },
  { 4627, 38, 47, 39, -3, -47 },
  { 4851, 36, 47, 36, 0, -47 },
  { 5063, 35, 49, 37, 2, -48 },
  { 5278, 35, 47, 36, 0, -47 },
  { 5484, 35, 47, 31, 0, -47 },
  { 5690, 34, 47, 30, 0, -47 },
  { 5890, 36, 49, 38, 2, -48 },
  { 6111, 41, 47, 39, 0, -47 },
  { 6352, 19, 47, 18, 0, -47 },
  { 6464, 33, 48, 32, 0, -47 },
  { 6662, 42, 47, 36, 0, -47 },
  { 6909, 27, 47, 31, 0, -47 },
  { 7068, 50, 47, 49, 0, -47 },
  { 7362, 41, 47, 39, 0, -47 },
  { 7603, 36, 49, 39, 2, -48 },
  { 7824, 37, 47, 37, 0, -47 },
  { 8042, 36, 57, 39, 2, -48 },
  { 8299, 36, 47, 36, 0, -47 },
  { 8511, 35, 49, 35, 1, -48 },
  { 8726, 34, 47, 36, 5, -47 },
  { 8926, 37, 48, 37, 2, -47 },
  { 9148, 37, 47, 37, 5, -47 },
  { 9366, 46, 47, 48, 5, -47 },
  { 9637, 43, 47, 36, -3, -47 },
  { 9890, 35, 47, 35, 5, -47 },
  { 10096, 38, 47, 34, -1, -47 },
  { 10320, 24, 66, 17, -2, -55 },
  { 10518, 17, 51, 25, 5, -47 },
  { 10627, 24, 66, 17, -4, -55 },
  { 10825, 23, 23, 26, 2, -47 },
  { 10892, 25, 8, 25, -4, 0 },
  { 10917, 15, 10, 22, 7, -49 },
  { 10936, 28, 37, 30, 0, -36 },
  { 11066, 31, 51, 32, -1, -50 },
  { 11264, 27, 37, 29, 1, -36 },
  { 11389, 33, 51, 32, 1, -50 },
  { 11600, 29, 37, 31, 1, -36 },
  { 11735, 25, 51, 21, 1, -51 },
  { 11895, 33, 49, 32, -1, -36 },
  { 12098, 31, 50, 32, -1, -50 },
  { 12292, 18, 50, 17, 0, -50 },
  { 12405, 26, 63, 16, -8, -50 },
  { 12610, 35, 50, 31, -1, -50 },
  { 12829, 19, 50, 17, 0, -50 },
  { 12948, 45, 36, 47, 0, -36 },
  { 13151, 31, 36, 32, -1, -36 },
  { 13291, 29, 37, 32, 1, -36 },
  { 13426, 33, 49, 32, -3, -36 },
  { 13629, 31, 49, 32, 1, -36 },
  { 13819, 25, 36, 22, -1, -36 },
  { 13932, 28, 37, 29, 0, -36 },
  { 14062, 19, 45, 20, 2, -44 },
  { 14169, 31, 36, 32, 1, -35 },
  { 14309, 28, 35, 29, 3, -35 },
  { 14432, 38, 35, 40, 4, -35 },
  { 14599, 34, 35, 29, -3, -35 },
  { 14748, 33, 48, 30, -1, -35 },
  { 14946, 30, 35, 29, -1, -35 },
  { 15078, 20, 64, 19, 1, -52 },
  { 15238, 14, 56, 16, 1, -47 },
  { 15336, 20, 63, 19, -2, -51 },
  { 15494, 31, 15, 35, 2, -27 },
};

const GFXfont RobotoCondensed_BlackItalic66pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic66pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic66pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOCONDENSED_BLACKITALIC66PT7B_H_
