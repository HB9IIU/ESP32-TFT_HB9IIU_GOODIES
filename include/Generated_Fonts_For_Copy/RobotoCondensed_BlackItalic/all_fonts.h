#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoCondensed_BlackItalic
// Headers: 67

#include "RobotoCondensed_BlackItalic6pt7b.h"
#include "RobotoCondensed_BlackItalic7pt7b.h"
#include "RobotoCondensed_BlackItalic8pt7b.h"
#include "RobotoCondensed_BlackItalic9pt7b.h"
#include "RobotoCondensed_BlackItalic10pt7b.h"
#include "RobotoCondensed_BlackItalic11pt7b.h"
#include "RobotoCondensed_BlackItalic12pt7b.h"
#include "RobotoCondensed_BlackItalic13pt7b.h"
#include "RobotoCondensed_BlackItalic14pt7b.h"
#include "RobotoCondensed_BlackItalic15pt7b.h"
#include "RobotoCondensed_BlackItalic16pt7b.h"
#include "RobotoCondensed_BlackItalic17pt7b.h"
#include "RobotoCondensed_BlackItalic18pt7b.h"
#include "RobotoCondensed_BlackItalic19pt7b.h"
#include "RobotoCondensed_BlackItalic20pt7b.h"
#include "RobotoCondensed_BlackItalic21pt7b.h"
#include "RobotoCondensed_BlackItalic22pt7b.h"
#include "RobotoCondensed_BlackItalic23pt7b.h"
#include "RobotoCondensed_BlackItalic24pt7b.h"
#include "RobotoCondensed_BlackItalic25pt7b.h"
#include "RobotoCondensed_BlackItalic26pt7b.h"
#include "RobotoCondensed_BlackItalic27pt7b.h"
#include "RobotoCondensed_BlackItalic28pt7b.h"
#include "RobotoCondensed_BlackItalic29pt7b.h"
#include "RobotoCondensed_BlackItalic30pt7b.h"
#include "RobotoCondensed_BlackItalic31pt7b.h"
#include "RobotoCondensed_BlackItalic32pt7b.h"
#include "RobotoCondensed_BlackItalic33pt7b.h"
#include "RobotoCondensed_BlackItalic34pt7b.h"
#include "RobotoCondensed_BlackItalic35pt7b.h"
#include "RobotoCondensed_BlackItalic36pt7b.h"
#include "RobotoCondensed_BlackItalic37pt7b.h"
#include "RobotoCondensed_BlackItalic38pt7b.h"
#include "RobotoCondensed_BlackItalic39pt7b.h"
#include "RobotoCondensed_BlackItalic40pt7b.h"
#include "RobotoCondensed_BlackItalic41pt7b.h"
#include "RobotoCondensed_BlackItalic42pt7b.h"
#include "RobotoCondensed_BlackItalic43pt7b.h"
#include "RobotoCondensed_BlackItalic44pt7b.h"
#include "RobotoCondensed_BlackItalic45pt7b.h"
#include "RobotoCondensed_BlackItalic46pt7b.h"
#include "RobotoCondensed_BlackItalic47pt7b.h"
#include "RobotoCondensed_BlackItalic48pt7b.h"
#include "RobotoCondensed_BlackItalic49pt7b.h"
#include "RobotoCondensed_BlackItalic50pt7b.h"
#include "RobotoCondensed_BlackItalic51pt7b.h"
#include "RobotoCondensed_BlackItalic52pt7b.h"
#include "RobotoCondensed_BlackItalic53pt7b.h"
#include "RobotoCondensed_BlackItalic54pt7b.h"
#include "RobotoCondensed_BlackItalic55pt7b.h"
#include "RobotoCondensed_BlackItalic56pt7b.h"
#include "RobotoCondensed_BlackItalic57pt7b.h"
#include "RobotoCondensed_BlackItalic58pt7b.h"
#include "RobotoCondensed_BlackItalic59pt7b.h"
#include "RobotoCondensed_BlackItalic60pt7b.h"
#include "RobotoCondensed_BlackItalic61pt7b.h"
#include "RobotoCondensed_BlackItalic62pt7b.h"
#include "RobotoCondensed_BlackItalic63pt7b.h"
#include "RobotoCondensed_BlackItalic64pt7b.h"
#include "RobotoCondensed_BlackItalic65pt7b.h"
#include "RobotoCondensed_BlackItalic66pt7b.h"
#include "RobotoCondensed_BlackItalic67pt7b.h"
#include "RobotoCondensed_BlackItalic68pt7b.h"
#include "RobotoCondensed_BlackItalic69pt7b.h"
#include "RobotoCondensed_BlackItalic70pt7b.h"
#include "RobotoCondensed_BlackItalic71pt7b.h"
#include "RobotoCondensed_BlackItalic72pt7b.h"
