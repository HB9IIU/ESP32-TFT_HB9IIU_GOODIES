#ifndef _ROBOTOCONDENSED_BLACKITALIC8PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0x74, 0x35, 0x76, 0x6C, 0x22, 0x54, 0x2A, 0x64, 0xDF,
  0x3E, 0xC0, 0x25, 0x67, 0xBF, 0x60, 0x29, 0x49, 0x22, 0x55, 0x58, 0x23,
  0x62, 0x26, 0xE4, 0xC0, 0xC0, 0xC0, 0x12, 0x22, 0x44, 0x25, 0x5F, 0xA6,
  0x35, 0xF0, 0x65, 0x32, 0x4E, 0x65, 0x36, 0xBE, 0x33, 0x6E, 0xF2, 0x74,
  0x63, 0xAE, 0x24, 0x6F, 0xB6, 0x71, 0x22, 0x44, 0x25, 0x76, 0xAE, 0x25,
  0x57, 0x24, 0x43, 0x42, 0x80, 0x39, 0x80, 0x70, 0xE0, 0x47, 0x00, 0x67,
  0x24, 0x04, 0x11, 0xA7, 0x6D, 0xD6, 0xE8, 0x18, 0x33, 0x55, 0xF9, 0x75,
  0x5F, 0xDE, 0x32, 0xB1, 0x8D, 0x38, 0x65, 0x5D, 0xFE, 0x74, 0x4E, 0xCE,
  0x74, 0x4E, 0xC8, 0x32, 0x91, 0xED, 0x38, 0x4A, 0xD7, 0xED, 0x48, 0x57,
  0xE0, 0x11, 0x32, 0xAE, 0x5A, 0x99, 0xCF, 0x58, 0x49, 0x6D, 0xC0, 0x6D,
  0xB6, 0xFF, 0xFA, 0xA0, 0x4A, 0xDF, 0xEF, 0x48, 0x32, 0xB7, 0xAD, 0x38,
  0x75, 0x5F, 0xC8, 0x32, 0xB7, 0xAD, 0x38, 0x40, 0x75, 0x5F, 0xEB, 0x35,
  0x43, 0x96, 0xF4, 0x44, 0xC8, 0x5A, 0x95, 0xAD, 0x30, 0xBB, 0xAE, 0xCC,
  0xAF, 0x7D, 0xEF, 0x58, 0x5A, 0x9C, 0xC6, 0x58, 0xBA, 0xEC, 0xC8, 0x70,
  0x88, 0xC4, 0x78, 0x69, 0x2D, 0xA6, 0xAA, 0xB0, 0x55, 0xFA, 0x2D, 0x80,
  0x60, 0x80, 0x6E, 0xF0, 0x44, 0x7F, 0xBE, 0x72, 0xF0, 0x11, 0x7B, 0xAE,
  0x6F, 0x8E, 0x6B, 0xAD, 0x80, 0x7B, 0xAE, 0xAC, 0x44, 0x7F, 0xAA, 0x47,
  0xA0, 0x20, 0xB6, 0x94, 0x44, 0x7E, 0xEA, 0x57, 0xA0, 0x7F, 0x6B, 0x50,
  0xFF, 0xAA, 0x6B, 0xAE, 0x7F, 0xAE, 0x88, 0x7B, 0xAE, 0x22, 0x7A, 0x40,
  0x78, 0xF0, 0x59, 0x6C, 0x7F, 0xAE, 0xF6, 0x64, 0xEF, 0xBD, 0xE0, 0x66,
  0x6A, 0xF6, 0x64, 0x48, 0x66, 0x4E, 0x49, 0x4D, 0x20, 0x55, 0xA8, 0x55,
  0xE8, 0xF2,
};

const GFXglyph RobotoCondensed_BlackItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 2, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 3, 6, 5, 1, -6 },
  { 14, 4, 6, 5, 0, -6 },
  { 17, 2, 2, 1, 0, -6 },
  { 18, 3, 8, 3, 0, -6 },
  { 21, 2, 8, 3, 0, -6 },
  { 23, 4, 4, 4, 0, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 1, 3, 2, 0, -1 },
  { 28, 2, 1, 3, 1, -3 },
  { 29, 2, 1, 2, 0, -1 },
  { 30, 4, 6, 2, -1, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 6, 2, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 4, 3, 4, 0, -4 },
  { 69, 3, 4, 4, 0, -4 },
  { 71, 4, 6, 4, 0, -6 },
  { 74, 6, 8, 6, 0, -6 },
  { 80, 4, 6, 5, 0, -6 },
  { 83, 4, 6, 4, 0, -6 },
  { 86, 5, 6, 4, 0, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 4, 6, 4, 0, -6 },
  { 96, 4, 6, 4, 0, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 5, 6, 5, 0, -6 },
  { 107, 2, 6, 2, 0, -6 },
  { 109, 4, 6, 4, 0, -6 },
  { 112, 5, 6, 4, 0, -6 },
  { 116, 3, 6, 4, 0, -6 },
  { 119, 6, 6, 6, 0, -6 },
  { 124, 5, 6, 5, 0, -6 },
  { 128, 5, 6, 5, 0, -6 },
  { 132, 4, 6, 4, 0, -6 },
  { 135, 5, 7, 5, 0, -6 },
  { 140, 4, 6, 4, 0, -6 },
  { 143, 4, 6, 4, 0, -6 },
  { 146, 4, 6, 4, 1, -6 },
  { 149, 5, 6, 4, 0, -6 },
  { 153, 4, 6, 5, 1, -6 },
  { 156, 5, 6, 6, 1, -6 },
  { 160, 5, 6, 4, 0, -6 },
  { 164, 4, 6, 4, 1, -6 },
  { 167, 5, 6, 4, 0, -6 },
  { 171, 3, 8, 2, 0, -7 },
  { 174, 2, 6, 3, 1, -6 },
  { 176, 2, 8, 2, 0, -7 },
  { 178, 3, 3, 3, 0, -6 },
  { 180, 4, 1, 3, -1, 0 },
  { 181, 2, 1, 3, 1, -6 },
  { 182, 3, 4, 4, 0, -4 },
  { 184, 4, 6, 4, 0, -6 },
  { 187, 3, 4, 4, 0, -4 },
  { 189, 4, 6, 4, 0, -6 },
  { 192, 4, 4, 4, 0, -4 },
  { 194, 3, 6, 3, 0, -6 },
  { 197, 4, 6, 4, 0, -4 },
  { 200, 4, 6, 4, 0, -6 },
  { 203, 2, 6, 2, 0, -6 },
  { 205, 3, 8, 2, -1, -6 },
  { 208, 4, 6, 4, 0, -6 },
  { 211, 2, 6, 2, 0, -6 },
  { 213, 5, 4, 6, 0, -4 },
  { 216, 4, 4, 4, 0, -4 },
  { 218, 4, 4, 4, 0, -4 },
  { 220, 4, 6, 4, 0, -4 },
  { 223, 4, 6, 4, 0, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 3, 4, 4, 0, -4 },
  { 230, 3, 5, 2, 0, -5 },
  { 232, 4, 4, 4, 0, -4 },
  { 234, 4, 4, 4, 0, -4 },
  { 236, 5, 4, 5, 0, -4 },
  { 239, 4, 4, 4, 0, -4 },
  { 241, 4, 6, 4, 0, -4 },
  { 244, 4, 4, 4, 0, -4 },
  { 246, 3, 7, 2, 0, -6 },
  { 249, 2, 7, 2, 0, -6 },
  { 251, 2, 7, 2, 0, -6 },
  { 253, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_BlackItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_BLACKITALIC8PT7B_H_
