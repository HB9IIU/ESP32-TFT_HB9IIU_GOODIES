#ifndef _ROBOTOCONDENSED_BLACKITALIC26PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0x70, 0x77, 0x77, 0x77, 0x67,
  0xE6, 0xE6, 0xEE, 0x03, 0xB0, 0x1B, 0x80, 0xDC, 0x0E, 0xC0, 0x66, 0x03,
  0x70, 0xFF, 0xE7, 0xFF, 0x0D, 0xC0, 0xEE, 0x07, 0x61, 0xFF, 0xCF, 0xFE,
  0x1D, 0x80, 0xCC, 0x06, 0xE0, 0x76, 0x03, 0xB0, 0x1B, 0x80, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x78, 0x1F, 0xC3, 0xFE, 0x3D, 0xE3, 0xCF, 0x7C, 0xF3,
  0xC0, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0xFC, 0x7F, 0x83, 0xE0, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x3C, 0x03, 0xF0, 0x1F, 0x89, 0xCC, 0xEE, 0x66, 0x77, 0x63, 0xBF, 0x0F,
  0xF0, 0x3B, 0x00, 0x38, 0x03, 0xF8, 0x1F, 0xE1, 0xFB, 0x1D, 0x9C, 0xCC,
  0xCE, 0xE6, 0x63, 0x70, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x3F, 0x80, 0xFE,
  0x07, 0xBC, 0x1E, 0xF0, 0x73, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x7C,
  0xF3, 0xFB, 0x9F, 0xEE, 0x7F, 0xFB, 0xEF, 0xEF, 0x1F, 0x3E, 0x78, 0x7F,
  0xF1, 0xFF, 0xC1, 0xE7, 0x80, 0x77, 0x77, 0x6E, 0xE0, 0x01, 0x07, 0x0F,
  0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x10, 0x08,
  0x0C, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0xE0,
  0x80, 0x03, 0x00, 0x70, 0x07, 0x06, 0x66, 0xFF, 0xE3, 0xFE, 0x0E, 0x01,
  0xF0, 0x3B, 0x87, 0x18, 0x21, 0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE1, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xC3, 0xC0, 0x70, 0x1E, 0x03, 0xC0,
  0x78, 0x00, 0x39, 0xCE, 0xF7, 0x7B, 0x88, 0xFF, 0xFF, 0xF0, 0x7F, 0xDE,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x81, 0xFC,
  0x3F, 0xE3, 0xDE, 0x78, 0xE7, 0x8E, 0x79, 0xE7, 0x9E, 0xF9, 0xEF, 0x1E,
  0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x7C, 0x7F, 0x87, 0xF0,
  0x3E, 0x00, 0x03, 0x0F, 0x7F, 0xFE, 0xFE, 0xDE, 0x1E, 0x1E, 0x1E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x07, 0xC0, 0x7F,
  0x07, 0xFC, 0x7D, 0xE3, 0xCF, 0x1E, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xFF,
  0xE7, 0xFF, 0x3F, 0xF8, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7D, 0xE3, 0xCF,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x3E, 0x03, 0xF8, 0x03, 0xC0,
  0x0E, 0x00, 0xFB, 0xC7, 0x9F, 0x7C, 0x7F, 0xC3, 0xFE, 0x07, 0xC0, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x1D, 0xE1, 0xEF, 0x0E, 0x78, 0xF3, 0xC7, 0xFF, 0x3F, 0xFB, 0xFF, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0xCF, 0x00, 0x3C,
  0x03, 0xE0, 0x1F, 0x7C, 0xF1, 0xE7, 0x8F, 0x7C, 0x7F, 0xC1, 0xFC, 0x07,
  0xC0, 0x01, 0xC0, 0xF8, 0x3F, 0x0F, 0xC3, 0xE0, 0x78, 0x1F, 0xE3, 0xFE,
  0xFF, 0xFF, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0xF7, 0xDE, 0x7F,
  0x8F, 0xF0, 0x78, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0x07,
  0x81, 0xFC, 0x3F, 0xE3, 0xDE, 0x3D, 0xF7, 0x9F, 0x39, 0xE3, 0xDE, 0x3F,
  0xC3, 0xF8, 0x7F, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x7C, 0xFF,
  0x87, 0xF8, 0x3E, 0x00, 0x0F, 0x0F, 0xE7, 0xFD, 0xEF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3F, 0x81, 0xE0, 0xF0, 0xFC,
  0xFE, 0x3F, 0x0F, 0x00, 0x39, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x3C, 0xF3, 0x80, 0x0E, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0xF0, 0x60, 0x00, 0x20,
  0x1C, 0x1F, 0x8F, 0xE7, 0xF8, 0xF8, 0x1E, 0x07, 0xF8, 0x3F, 0xC1, 0xF0,
  0x0E, 0x00, 0x40, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xBF,
  0xF7, 0xFE, 0x20, 0x07, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xC0, 0xF8,
  0x7E, 0x3F, 0xCF, 0xE1, 0xF0, 0x30, 0x08, 0x00, 0x1E, 0x1F, 0xEF, 0xFB,
  0xDF, 0xF3, 0xC1, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x83, 0xC0, 0xE0, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x3F,
  0xE0, 0x1F, 0x1E, 0x07, 0x80, 0xC0, 0xE0, 0x1C, 0x38, 0xF1, 0x8E, 0x3F,
  0x31, 0xCF, 0xE6, 0x73, 0x9C, 0xCE, 0x73, 0x99, 0xDC, 0x73, 0x33, 0x8C,
  0x6E, 0x73, 0x8D, 0xCE, 0x73, 0xB9, 0xCE, 0x67, 0x3B, 0xDC, 0xE7, 0xFF,
  0x1C, 0x73, 0xC1, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x7D, 0xC0,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xEE, 0x03, 0xDC, 0x07, 0x38, 0x1E, 0x78,
  0x3C, 0xF0, 0xF1, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x3E, 0x1E, 0x78,
  0x3D, 0xF0, 0x7F, 0xE0, 0xF8, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xCF, 0x9F,
  0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3F, 0xF9, 0xFF, 0x87, 0xFF,
  0x1E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x8F, 0xBE, 0x7C, 0xFF, 0xF3, 0xFF,
  0x8F, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xBE, 0x7C, 0x79,
  0xE1, 0xF7, 0x87, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3E, 0xF8, 0x7F, 0xE0, 0xFF, 0x01, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0x8F, 0xBE, 0x3E, 0x78, 0xF0, 0xF3,
  0xC3, 0xCF, 0x1F, 0x3C, 0x7D, 0xF1, 0xF7, 0xC7, 0x9E, 0x1E, 0x78, 0x79,
  0xE3, 0xE7, 0x8F, 0x3E, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xBE, 0x7C,
  0x3D, 0xE0, 0xF7, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE7, 0xEF, 0x1F, 0xBC,
  0xFE, 0xF0, 0xFB, 0xC3, 0xEF, 0x0F, 0x3F, 0x7C, 0x7F, 0xF0, 0xFF, 0x81,
  0xF8, 0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x3E, 0x1E, 0x3E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0xF8, 0x78, 0xF8, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x78, 0xF3, 0xCF, 0x9F,
  0x78, 0x7F, 0xC3, 0xFC, 0x07, 0x80, 0x1E, 0x1F, 0x1E, 0x3E, 0x1E, 0x7C,
  0x3E, 0x7C, 0x3E, 0xF8, 0x3C, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7D, 0xE0, 0x7D, 0xE0, 0x79, 0xF0,
  0xF9, 0xF0, 0xF9, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0x1F,
  0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x87, 0xE3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFE, 0x3F, 0x9F, 0xC7, 0xF9, 0xFC,
  0x7B, 0xBB, 0xC7, 0xBB, 0xBC, 0x7B, 0xF3, 0xC7, 0xBF, 0x7C, 0x79, 0xF7,
  0x8F, 0x9E, 0x78, 0xF9, 0xE7, 0x8F, 0x1C, 0x78, 0xF1, 0xCF, 0x80, 0x1E,
  0x0F, 0x1F, 0x0F, 0x1F, 0x1F, 0x3F, 0x1E, 0x3F, 0x1E, 0x3F, 0x1E, 0x3F,
  0x9E, 0x3F, 0x9E, 0x3F, 0xBE, 0x7D, 0xBC, 0x7D, 0xBC, 0x79, 0xFC, 0x79,
  0xFC, 0x78, 0xFC, 0x78, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF8, 0xF0,
  0x78, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xBE, 0x7C, 0x7D, 0xE0, 0xF7,
  0x83, 0xDE, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B,
  0xC3, 0xEF, 0x0F, 0x3F, 0xFC, 0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0xE1, 0xFF, 0x8F, 0x9F, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x0F, 0x3C, 0x7D, 0xF3, 0xF7, 0xFF, 0x9F, 0xFC, 0x7F, 0xC1, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0xC1, 0xFF, 0x8F, 0xBE, 0x3C, 0x7D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xEF, 0x0F, 0x3F,
  0xFC, 0x7F, 0xE0, 0xFF, 0x01, 0xFE, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x00,
  0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xCF, 0x9F, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x1F, 0x3C, 0xF9, 0xFF, 0xE7, 0xFE, 0x1F, 0xF8, 0x79, 0xE1, 0xE7,
  0x87, 0x9E, 0x3E, 0x7C, 0xF9, 0xF3, 0xC3, 0xCF, 0x0F, 0x00, 0x03, 0xE0,
  0x3F, 0xC1, 0xFF, 0x87, 0xDF, 0x3E, 0x3C, 0xF8, 0xF3, 0xE0, 0x07, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xF3, 0xE3, 0xE7, 0x8F,
  0x1F, 0x7C, 0x7F, 0xF0, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xDF, 0x1F, 0x7C, 0x7D,
  0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x7B, 0xE3, 0xEF, 0x8F, 0xBC, 0x3C,
  0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0x3E, 0xF8, 0x7F, 0xE1, 0xFF, 0x01, 0xF0,
  0x00, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xC7,
  0x9F, 0x1E, 0x78, 0x79, 0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7F, 0x81,
  0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF1,
  0xE3, 0xFC, 0x79, 0xFF, 0x3E, 0x7B, 0xCF, 0x9E, 0xF3, 0xEF, 0xBD, 0xFB,
  0xCF, 0x7E, 0xF3, 0xDF, 0xBC, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xEF, 0xE3,
  0xFB, 0xF0, 0xFE, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x00, 0x1F, 0x1F, 0x0F, 0x8F, 0x83, 0xC7,
  0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7B, 0xC0, 0x7D, 0xF0, 0x7C, 0x78, 0x3E, 0x3C, 0x3E, 0x1F, 0x00, 0xF8,
  0x7F, 0xE3, 0xE7, 0x8F, 0x1E, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0xBC, 0x0E,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0xFE, 0x7F,
  0xF8, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0x83, 0xE0,
  0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xF0, 0x7C, 0x3F, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xF1,
  0xE0, 0x0F, 0x8F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87,
  0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x0E, 0x07, 0x87, 0xC3, 0xE3,
  0xB1, 0x99, 0xCD, 0xE7, 0xE3, 0x80, 0x7F, 0xDF, 0xFF, 0xFC, 0xF1, 0xC7,
  0x8E, 0x0F, 0x83, 0xF8, 0xFF, 0xBE, 0xF0, 0x1E, 0x3F, 0xDF, 0xFB, 0xDF,
  0xF3, 0xDE, 0x7B, 0xCF, 0x7F, 0xE7, 0xFC, 0x77, 0x80, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F, 0xF3, 0xDF,
  0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x79, 0xE7, 0x9E, 0xF9, 0xEF, 0xFE,
  0xFF, 0xCF, 0x78, 0x0F, 0x83, 0xF8, 0xFF, 0xBE, 0xF7, 0x9E, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x79, 0xEF, 0x3F, 0xE7, 0xF8, 0x3E, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x7B, 0xC7, 0xFE,
  0x3F, 0xF3, 0xEF, 0x9E, 0x3C, 0xF3, 0xE7, 0x9E, 0x7C, 0xF3, 0xC7, 0x9E,
  0x3C, 0xFB, 0xE3, 0xFF, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0x81, 0xFE, 0x3F,
  0xE3, 0xCE, 0x78, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE, 0xF8, 0x07, 0x80, 0x79,
  0x87, 0xFC, 0x3F, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0xFC, 0x7C, 0x1E, 0x07,
  0x87, 0xF9, 0xFE, 0x7F, 0x8F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x0F, 0x79, 0xFF, 0xCF, 0xFC, 0xF9,
  0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xDF, 0x3E, 0xF1, 0xE7, 0x8F, 0x1E, 0x78,
  0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x0F, 0x08, 0xF8, 0xFF, 0x87, 0xFC, 0x1F,
  0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3D, 0xC3,
  0xFE, 0x3F, 0xE7, 0xDF, 0x78, 0xF7, 0x9F, 0x79, 0xE7, 0x9E, 0x79, 0xEF,
  0x9E, 0xF1, 0xEF, 0x3E, 0xF3, 0xCF, 0x3C, 0x1E, 0x3C, 0x78, 0xE0, 0x07,
  0x8F, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE3, 0xC0,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3E, 0x3F, 0x0F, 0xC3, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xCF, 0x8F, 0x7C, 0x3D, 0xE0, 0xFF, 0x87,
  0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1E, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3E, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x80, 0x3D,
  0xC7, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xF7, 0xDF, 0x7D, 0xF3, 0xDE, 0x79,
  0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0x3E, 0x7B,
  0xCF, 0x3E, 0xF3, 0xCF, 0x3C, 0xF3, 0xC0, 0x3D, 0xC3, 0xFE, 0x3F, 0xF7,
  0xDF, 0x78, 0xF7, 0x9F, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0x9E, 0xF1, 0xEF,
  0x3E, 0xF3, 0xCF, 0x3C, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0xDE, 0x78, 0xF7,
  0x8F, 0x78, 0xFF, 0x9F, 0xF1, 0xEF, 0x1E, 0x7B, 0xE7, 0xFC, 0x3F, 0x81,
  0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x3D, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE7, 0x8F, 0x3C, 0xF1, 0xE7, 0x9F, 0x3C, 0xFF, 0xC7, 0xFE, 0x3D, 0xE1,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x73, 0xFF, 0x3F,
  0xF7, 0xDF, 0x78, 0xF7, 0x9E, 0x79, 0xEF, 0x9E, 0xF1, 0xEF, 0x1E, 0xFB,
  0xE7, 0xFC, 0x7F, 0xC3, 0xFC, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x3D, 0x9F, 0xCF, 0xE7, 0xF7, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x0F, 0x87, 0xF8, 0xFF, 0xBC, 0xF7, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xDE, 0x7B, 0xCF, 0x7F, 0xE7, 0xF8, 0x7C,
  0x00, 0x3C, 0x78, 0xF7, 0xFF, 0xFF, 0xDE, 0x3C, 0x78, 0xF3, 0xC7, 0x8F,
  0x1E, 0x3F, 0x7C, 0x78, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9, 0xE7, 0x8F,
  0x3C, 0x79, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0xF8, 0xFF, 0xC7,
  0xFC, 0x1F, 0xE0, 0xF1, 0xFE, 0x3F, 0xCF, 0x39, 0xE7, 0x3C, 0xEF, 0x1D,
  0xE3, 0xB8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xC0, 0x78, 0x00, 0xF3,
  0x9F, 0xE7, 0x3F, 0xCE, 0x7F, 0xBC, 0xE7, 0x7B, 0xCF, 0xF7, 0x9F, 0xFE,
  0x3F, 0xFC, 0x7D, 0xF8, 0xFB, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x0E,
  0x3C, 0x00, 0x1E, 0x78, 0xF7, 0xC7, 0xBC, 0x3F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFB, 0xC7, 0x9E, 0x7C,
  0xF0, 0x78, 0xF3, 0xC7, 0x9F, 0x7C, 0x7B, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x38, 0x00, 0x3F, 0xF3, 0xFE, 0x3F,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78,
  0x0F, 0xFC, 0xFF, 0xCF, 0xF8, 0x01, 0x07, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x3C, 0x78, 0x70, 0xF0, 0x78, 0x38, 0x78, 0x78, 0x78,
  0x78, 0x70, 0x70, 0x38, 0x38, 0x10, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x86,
  0x38, 0xE3, 0x0C, 0x30, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0x63, 0x80, 0x08,
  0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E, 0x0F, 0x07,
  0x1F, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xE0, 0x40,
  0x38, 0x77, 0xC7, 0x7E, 0xEE, 0xFE, 0xE7, 0xEE, 0x3C,
};

const GFXglyph RobotoCondensed_BlackItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 19, 7, 0, -19 },
  { 20, 8, 7, 8, 1, -20 },
  { 27, 13, 19, 13, 0, -19 },
  { 58, 12, 25, 13, 1, -22 },
  { 96, 13, 19, 16, 2, -19 },
  { 127, 14, 19, 15, 0, -19 },
  { 161, 4, 7, 4, 1, -20 },
  { 165, 8, 26, 8, 1, -20 },
  { 191, 8, 26, 8, -1, -20 },
  { 217, 12, 11, 12, 1, -19 },
  { 234, 11, 14, 12, 1, -16 },
  { 254, 5, 8, 7, -1, -3 },
  { 259, 7, 3, 11, 2, -9 },
  { 262, 5, 4, 8, 0, -4 },
  { 265, 12, 21, 8, -2, -19 },
  { 297, 12, 19, 13, 1, -19 },
  { 326, 8, 19, 13, 3, -19 },
  { 345, 13, 19, 13, 0, -19 },
  { 376, 13, 19, 13, 0, -19 },
  { 407, 13, 19, 13, 0, -19 },
  { 438, 13, 19, 13, 0, -19 },
  { 469, 11, 19, 13, 1, -19 },
  { 496, 13, 19, 13, 1, -19 },
  { 527, 12, 19, 13, 1, -19 },
  { 556, 10, 19, 13, 2, -19 },
  { 580, 6, 14, 7, 1, -14 },
  { 591, 8, 19, 7, -1, -14 },
  { 610, 11, 12, 11, 0, -14 },
  { 627, 11, 8, 13, 1, -12 },
  { 638, 11, 13, 11, 0, -14 },
  { 656, 10, 19, 12, 2, -19 },
  { 680, 19, 24, 19, 0, -18 },
  { 737, 15, 19, 15, -1, -19 },
  { 773, 14, 19, 14, 0, -19 },
  { 807, 14, 19, 14, 1, -19 },
  { 841, 14, 19, 14, 0, -19 },
  { 875, 14, 19, 12, 0, -19 },
  { 909, 13, 19, 12, 0, -19 },
  { 940, 14, 19, 15, 1, -19 },
  { 974, 16, 19, 15, 0, -19 },
  { 1012, 8, 19, 7, 0, -19 },
  { 1031, 13, 19, 12, 0, -19 },
  { 1062, 16, 19, 14, 0, -19 },
  { 1100, 11, 19, 12, 0, -19 },
  { 1127, 20, 19, 19, 0, -19 },
  { 1175, 16, 19, 15, 0, -19 },
  { 1213, 14, 19, 15, 1, -19 },
  { 1247, 14, 19, 15, 0, -19 },
  { 1281, 14, 22, 15, 1, -19 },
  { 1320, 14, 19, 14, 0, -19 },
  { 1354, 14, 19, 14, 0, -19 },
  { 1388, 13, 19, 14, 2, -19 },
  { 1419, 14, 19, 15, 1, -19 },
  { 1453, 14, 19, 15, 2, -19 },
  { 1487, 18, 19, 19, 2, -19 },
  { 1530, 17, 19, 14, -1, -19 },
  { 1571, 14, 19, 14, 2, -19 },
  { 1605, 15, 19, 13, 0, -19 },
  { 1641, 10, 26, 7, -1, -22 },
  { 1674, 7, 21, 10, 2, -19 },
  { 1693, 9, 26, 7, -1, -22 },
  { 1723, 9, 9, 10, 1, -19 },
  { 1734, 10, 3, 10, -2, 0 },
  { 1738, 6, 4, 9, 3, -20 },
  { 1741, 11, 14, 12, 0, -14 },
  { 1761, 12, 20, 12, 0, -20 },
  { 1791, 11, 14, 12, 0, -14 },
  { 1811, 13, 20, 12, 0, -20 },
  { 1844, 12, 14, 12, 0, -14 },
  { 1865, 10, 20, 8, 0, -20 },
  { 1890, 13, 19, 13, 0, -14 },
  { 1921, 12, 20, 13, 0, -20 },
  { 1951, 7, 19, 7, 0, -19 },
  { 1968, 10, 24, 6, -3, -19 },
  { 1998, 14, 20, 12, 0, -20 },
  { 2033, 7, 20, 7, 0, -20 },
  { 2051, 18, 14, 19, 0, -14 },
  { 2083, 12, 14, 13, 0, -14 },
  { 2104, 12, 14, 12, 0, -14 },
  { 2125, 13, 19, 12, -1, -14 },
  { 2156, 12, 19, 12, 0, -14 },
  { 2185, 9, 14, 9, 0, -14 },
  { 2201, 11, 14, 11, 0, -14 },
  { 2221, 7, 17, 8, 1, -17 },
  { 2236, 13, 14, 13, 0, -14 },
  { 2259, 11, 14, 12, 1, -14 },
  { 2279, 15, 14, 16, 1, -14 },
  { 2306, 13, 14, 12, -1, -14 },
  { 2329, 13, 19, 12, 0, -14 },
  { 2360, 12, 14, 12, 0, -14 },
  { 2381, 8, 25, 7, 0, -20 },
  { 2406, 6, 22, 6, 0, -19 },
  { 2423, 8, 25, 7, -1, -20 },
  { 2448, 12, 6, 14, 1, -11 },
};

const GFXfont RobotoCondensed_BlackItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_BLACKITALIC26PT7B_H_
