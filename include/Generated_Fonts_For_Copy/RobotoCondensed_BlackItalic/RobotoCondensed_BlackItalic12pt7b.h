#ifndef _ROBOTOCONDENSED_BLACKITALIC12PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0x86, 0xC0, 0x55, 0x50, 0x1C, 0xE2, 0x9F, 0x33, 0xE5,
  0x1C, 0xE0, 0x08, 0xE7, 0xDB, 0x60, 0xE1, 0xB6, 0x79, 0xC2, 0x00, 0x62,
  0xAA, 0xBC, 0x20, 0xE5, 0x7F, 0x18, 0x38, 0xE6, 0x9E, 0x73, 0xDD, 0xFE,
  0x7C, 0xE0, 0x2D, 0x69, 0x24, 0x92, 0x20, 0x23, 0x11, 0x11, 0x13, 0x32,
  0x64, 0x25, 0x7C, 0xC9, 0x00, 0x31, 0xBF, 0xF2, 0x30, 0x6D, 0x60, 0xFC,
  0xF0, 0x08, 0xC4, 0x23, 0x10, 0x88, 0x46, 0x00, 0x39, 0xF6, 0xDB, 0x4F,
  0x2D, 0x9E, 0x70, 0x17, 0xF3, 0x26, 0x66, 0x60, 0x39, 0xF6, 0xC3, 0x18,
  0xC6, 0x3E, 0xF8, 0x39, 0xF0, 0xC6, 0x38, 0x6D, 0xBE, 0x70, 0x0C, 0x73,
  0x8E, 0x7B, 0xEF, 0x86, 0x10, 0x3D, 0xF6, 0x1E, 0x58, 0x6D, 0xBE, 0x70,
  0x18, 0xE6, 0x1E, 0x7B, 0x3C, 0x9E, 0x70, 0x7D, 0xF0, 0x86, 0x18, 0xC3,
  0x18, 0x60, 0x39, 0xF6, 0xDE, 0x79, 0x6D, 0xBE, 0x70, 0x77, 0xB7, 0xBF,
  0xF8, 0xDC, 0xC0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x00, 0x26, 0x64, 0x09,
  0xF9, 0xC7, 0x08, 0x7D, 0xE0, 0x1E, 0xF8, 0x43, 0x87, 0xE8, 0x00, 0x7F,
  0x33, 0x64, 0x0C, 0xC0, 0x1E, 0x18, 0x9B, 0x4A, 0xBD, 0x5D, 0xAA, 0xF5,
  0x3C, 0x80, 0x20, 0x0E, 0x00, 0x0C, 0x18, 0x78, 0xF3, 0x67, 0xCF, 0xB3,
  0x66, 0x7C, 0xF9, 0x93, 0x67, 0x89, 0xB3, 0x7E, 0xF8, 0x3C, 0xFD, 0x9B,
  0x06, 0x18, 0x33, 0x3E, 0x78, 0x79, 0xF6, 0xDB, 0x6D, 0x3C, 0xFE, 0xF0,
  0x7D, 0xF6, 0x1E, 0x79, 0x0C, 0x3E, 0xF8, 0x7D, 0xF6, 0x1E, 0x79, 0x0C,
  0x30, 0xC0, 0x3C, 0xFD, 0x9B, 0x06, 0x1B, 0xB3, 0x3E, 0x78, 0x66, 0xCD,
  0x9B, 0xF7, 0xE8, 0xF3, 0x66, 0xCC, 0x6D, 0xB6, 0xF6, 0xC0, 0x0C, 0x30,
  0xC2, 0x18, 0x6D, 0xBE, 0x70, 0x66, 0x6C, 0x6C, 0x78, 0x78, 0x78, 0xD8,
  0xDC, 0xCC, 0x63, 0x18, 0xC6, 0x23, 0x1F, 0xF8, 0x73, 0xB9, 0xDC, 0xEE,
  0xF7, 0x52, 0xFB, 0x7D, 0xB6, 0xDB, 0x00, 0x66, 0xED, 0xDB, 0xB7, 0x6A,
  0xB3, 0x66, 0xCC, 0x3C, 0xFD, 0x9B, 0x36, 0x78, 0xF3, 0x3E, 0x78, 0x7C,
  0xF9, 0x9B, 0x37, 0xCF, 0x30, 0x60, 0xC0, 0x3C, 0x7D, 0x9B, 0x36, 0x78,
  0xF3, 0x3E, 0x38, 0x18, 0x20, 0x7C, 0xF9, 0x9B, 0x67, 0xCF, 0x36, 0x6C,
  0xCC, 0x3D, 0xF6, 0x5C, 0x38, 0x7C, 0xFF, 0x78, 0xFF, 0xF3, 0x08, 0x61,
  0x86, 0x18, 0x60, 0x66, 0xCD, 0x9B, 0x26, 0xCD, 0xB3, 0x3E, 0x78, 0xCD,
  0x9B, 0x36, 0xCD, 0x9A, 0x1C, 0x38, 0x60, 0xDB, 0xDB, 0xFB, 0xFE, 0xFE,
  0xFE, 0xFC, 0xFC, 0xDC, 0x33, 0x36, 0x16, 0x1C, 0x1C, 0x3C, 0x3C, 0x7C,
  0x66, 0xCF, 0x6D, 0x94, 0x71, 0x86, 0x18, 0x60, 0x7E, 0xF8, 0x30, 0xC3,
  0x06, 0x18, 0x7E, 0xF8, 0x76, 0x66, 0x66, 0x4C, 0xCC, 0xCC, 0xDB, 0x6C,
  0x9B, 0x6C, 0x31, 0x8C, 0x63, 0x18, 0xC4, 0x63, 0x19, 0xC0, 0x31, 0x9C,
  0xA0, 0xF8, 0x4C, 0x7B, 0xC6, 0xFD, 0xFF, 0xE0, 0x63, 0x1E, 0xF6, 0xA7,
  0x7F, 0xF0, 0x33, 0xF7, 0x8C, 0x7D, 0xC0, 0x0C, 0x37, 0xDF, 0xCB, 0x6D,
  0xBE, 0x78, 0x3B, 0xF3, 0xFC, 0x79, 0xC0, 0x39, 0xDC, 0xC6, 0x31, 0x98,
  0xC0, 0x7D, 0xFC, 0xB6, 0xDB, 0xE7, 0xAE, 0xF0, 0x63, 0x1E, 0xF7, 0xEF,
  0x7B, 0xD8, 0x6C, 0x36, 0xD6, 0xD8, 0x33, 0x03, 0x33, 0x26, 0x66, 0xEC,
  0x61, 0x86, 0xDE, 0x71, 0xCF, 0x36, 0xD8, 0x6D, 0xB6, 0xB6, 0xC0, 0x7F,
  0x7F, 0x5B, 0xDB, 0xDB, 0xDB, 0xDB, 0x7B, 0xD7, 0xBD, 0xEF, 0x60, 0x3B,
  0xF3, 0xBD, 0xFD, 0xC0, 0x3C, 0xF2, 0x59, 0x6D, 0xF7, 0x98, 0x40, 0x7D,
  0xED, 0xB6, 0xDB, 0xE7, 0x84, 0x30, 0x77, 0x4C, 0xCC, 0xC0, 0x73, 0xD0,
  0xE1, 0xED, 0xC0, 0x67, 0x66, 0x64, 0xE6, 0x6D, 0xB4, 0xB6, 0xDB, 0xE7,
  0x80, 0x9F, 0xBD, 0xCE, 0x73, 0x00, 0xB5, 0x7A, 0xF7, 0xCD, 0x9B, 0x36,
  0x00, 0x79, 0xE7, 0x1C, 0x73, 0x4D, 0x80, 0x6D, 0xE7, 0x9C, 0x71, 0x86,
  0x38, 0xC0, 0x7B, 0xCC, 0x66, 0x7F, 0xC0, 0x12, 0x66, 0x6C, 0x44, 0x44,
  0x40, 0x25, 0x24, 0x92, 0x52, 0x00, 0x4D, 0xB6, 0xD6, 0xDA, 0x00, 0x65,
  0xFD, 0x80,
};

const GFXglyph RobotoCondensed_BlackItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 3, 4, 0, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 6, 11, 6, 0, -10 },
  { 23, 6, 9, 7, 1, -9 },
  { 30, 6, 9, 7, 0, -9 },
  { 37, 1, 3, 2, 1, -9 },
  { 38, 3, 12, 4, 1, -9 },
  { 43, 4, 12, 4, -1, -9 },
  { 49, 5, 5, 5, 1, -9 },
  { 53, 5, 6, 5, 0, -7 },
  { 57, 3, 4, 3, -1, -1 },
  { 59, 3, 2, 5, 1, -5 },
  { 60, 2, 2, 4, 0, -2 },
  { 61, 5, 10, 4, -1, -9 },
  { 68, 6, 9, 6, 0, -9 },
  { 75, 4, 9, 6, 1, -9 },
  { 80, 6, 9, 6, 0, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 6, 9, 6, 0, -9 },
  { 115, 6, 9, 6, 0, -9 },
  { 122, 6, 9, 6, 0, -9 },
  { 129, 5, 9, 6, 1, -9 },
  { 135, 3, 7, 3, 0, -7 },
  { 138, 4, 10, 3, -1, -7 },
  { 143, 5, 6, 5, 0, -7 },
  { 147, 6, 5, 6, 0, -6 },
  { 151, 5, 5, 5, 0, -6 },
  { 155, 4, 9, 5, 1, -9 },
  { 160, 9, 11, 9, 0, -8 },
  { 173, 7, 9, 7, -1, -9 },
  { 181, 7, 9, 7, 0, -9 },
  { 189, 7, 9, 7, 0, -9 },
  { 197, 6, 9, 7, 0, -9 },
  { 204, 6, 9, 6, 0, -9 },
  { 211, 6, 9, 6, 0, -9 },
  { 218, 7, 9, 7, 0, -9 },
  { 226, 7, 9, 7, 0, -9 },
  { 234, 3, 9, 3, 0, -9 },
  { 238, 6, 9, 6, 0, -9 },
  { 245, 8, 9, 7, 0, -9 },
  { 254, 5, 9, 6, 0, -9 },
  { 260, 9, 9, 9, 0, -9 },
  { 271, 7, 9, 7, 0, -9 },
  { 279, 7, 9, 7, 0, -9 },
  { 287, 7, 9, 7, 0, -9 },
  { 295, 7, 11, 7, 0, -9 },
  { 305, 7, 9, 7, 0, -9 },
  { 313, 6, 9, 6, 0, -9 },
  { 320, 6, 9, 6, 1, -9 },
  { 327, 7, 9, 7, 0, -9 },
  { 335, 7, 9, 7, 1, -9 },
  { 343, 8, 9, 9, 1, -9 },
  { 352, 8, 9, 7, -1, -9 },
  { 361, 6, 9, 6, 1, -9 },
  { 368, 7, 9, 6, 0, -9 },
  { 376, 4, 12, 3, 0, -10 },
  { 382, 3, 10, 4, 1, -9 },
  { 386, 5, 12, 3, -1, -10 },
  { 394, 5, 4, 5, 0, -9 },
  { 397, 5, 1, 5, -1, 0 },
  { 398, 3, 2, 4, 1, -9 },
  { 399, 5, 7, 5, 0, -7 },
  { 404, 5, 9, 6, 0, -9 },
  { 410, 5, 7, 5, 0, -7 },
  { 415, 6, 9, 6, 0, -9 },
  { 422, 5, 7, 6, 0, -7 },
  { 427, 5, 9, 4, 0, -9 },
  { 433, 6, 9, 6, 0, -7 },
  { 440, 5, 9, 6, 0, -9 },
  { 446, 3, 10, 3, 0, -10 },
  { 450, 4, 12, 3, -1, -10 },
  { 456, 6, 9, 6, 0, -9 },
  { 463, 3, 9, 3, 0, -9 },
  { 467, 8, 7, 9, 0, -7 },
  { 474, 5, 7, 6, 0, -7 },
  { 479, 5, 7, 6, 0, -7 },
  { 484, 6, 9, 6, -1, -7 },
  { 491, 6, 9, 6, 0, -7 },
  { 498, 4, 7, 4, 0, -7 },
  { 502, 5, 7, 5, 0, -7 },
  { 507, 4, 8, 4, 0, -8 },
  { 511, 6, 7, 6, 0, -7 },
  { 517, 5, 7, 5, 1, -7 },
  { 522, 7, 7, 7, 1, -7 },
  { 529, 6, 7, 5, 0, -7 },
  { 535, 6, 9, 5, 0, -7 },
  { 542, 5, 7, 5, 0, -7 },
  { 547, 4, 11, 3, 0, -9 },
  { 553, 3, 11, 3, 0, -9 },
  { 558, 3, 11, 3, 0, -9 },
  { 563, 6, 3, 6, 0, -5 },
};

const GFXfont RobotoCondensed_BlackItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_BLACKITALIC12PT7B_H_
