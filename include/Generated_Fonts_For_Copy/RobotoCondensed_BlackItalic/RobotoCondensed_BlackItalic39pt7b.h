#ifndef _ROBOTOCONDENSED_BLACKITALIC39PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x07, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0xFE, 0x1F,
  0xC1, 0xF0, 0x1E, 0x00, 0x78, 0xF7, 0x8F, 0x79, 0xF7, 0x9E, 0x79, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1C, 0xF3, 0xCE, 0x3C, 0xE3, 0xC0, 0x00, 0x79, 0xC0,
  0x07, 0xBC, 0x00, 0x73, 0xC0, 0x0F, 0x38, 0x00, 0xF3, 0x80, 0x0E, 0x78,
  0x01, 0xE7, 0x80, 0x1E, 0x70, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x03, 0x9E, 0x00, 0x79, 0xC0, 0x07, 0xBC, 0x00, 0x73,
  0xC0, 0x0F, 0x3C, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x1E,
  0x70, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x03, 0xCE, 0x00, 0x3D, 0xE0, 0x03,
  0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x87, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xE7, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x87, 0x9E, 0x3C, 0xF3, 0xC7, 0xBC, 0x79, 0xE7, 0x8F, 0x78, 0xF1,
  0xEE, 0x0F, 0x7B, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xF7, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x78, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1D,
  0xFF, 0x87, 0xBC, 0xF1, 0xEF, 0x1E, 0x79, 0xE3, 0xCF, 0x3C, 0x7B, 0xC7,
  0x9E, 0x30, 0xFB, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0xC0, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFD, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF1,
  0xF1, 0xFF, 0x9F, 0x3F, 0xFD, 0xF7, 0xEF, 0xFF, 0x7E, 0xFF, 0xF7, 0xE7,
  0xFE, 0xFE, 0x7F, 0xEF, 0xE3, 0xFC, 0x7E, 0x3F, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xF7, 0xE0, 0xFC, 0x7F, 0x7D, 0xF7, 0xDF,
  0x79, 0xE7, 0xBE, 0xF3, 0xCF, 0x00, 0x00, 0x20, 0x06, 0x01, 0xF0, 0x3F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1C, 0x00, 0x40, 0x01, 0x00, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x08, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x03, 0x8F, 0x3B,
  0xFF, 0x7F, 0xFF, 0xFF, 0x1F, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFE,
  0x03, 0xEF, 0x03, 0xE3, 0xC1, 0xE1, 0xE0, 0x70, 0x70, 0x10, 0x20, 0x00,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x7E, 0x3E, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFB, 0xF7, 0xFF, 0xDF, 0x9E, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87,
  0xE3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFD, 0xF8, 0x7F, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E,
  0x7E, 0x1F, 0x9F, 0x87, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F,
  0x0F, 0x87, 0xE7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0x00, 0x00, 0x10, 0x07, 0x81, 0xFC, 0x3F, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xDF, 0xFC, 0xC7, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7F, 0x3F, 0x8F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x9F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0xC1, 0xF9, 0xFC, 0x3F,
  0x1F, 0x8F, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x7B, 0xF0, 0x3E, 0xFC, 0x1F, 0x3F, 0x07, 0xDF, 0xC3, 0xE7,
  0xE1, 0xF9, 0xF8, 0x7C, 0x7E, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F,
  0xDF, 0xC0, 0x43, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xBE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xF3, 0xFF, 0xFD, 0xF8, 0xFE, 0xFC, 0x3F, 0x7E, 0x1F, 0xFF, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFB, 0xE1, 0xF9, 0xF9, 0xFC, 0xFF, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x87, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x03,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0x7C, 0xFC, 0x3E,
  0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x8F, 0xEF, 0xC7, 0xF7, 0xE3, 0xF3, 0xF1,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xDF, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x87, 0xE7, 0xF3,
  0xF8, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x7E, 0x3F, 0x9F, 0xCF, 0xC3, 0xC0, 0x00, 0x00, 0x3E, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0x30, 0x00, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0xFE,
  0x03, 0xFE, 0x0F, 0xFE, 0x7F, 0xFC, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x38, 0x00, 0x10, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x08, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF,
  0x3F, 0xFE, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0x40, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE,
  0x7E, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE1, 0xF8,
  0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x0E, 0x0F, 0x83, 0xE0, 0xE0, 0xF0, 0xFF, 0x8E, 0x1E, 0x1F, 0xFC,
  0xF1, 0xE3, 0xFF, 0x8F, 0x3C, 0x3C, 0x78, 0xF3, 0xC7, 0xC7, 0x8F, 0x3C,
  0x78, 0x78, 0xF7, 0x8F, 0x8F, 0x0F, 0x78, 0xF0, 0xF0, 0xE7, 0x8F, 0x0F,
  0x0E, 0x79, 0xF0, 0xF1, 0xE7, 0x9F, 0x1E, 0x1E, 0xF1, 0xF1, 0xE1, 0xCF,
  0x1F, 0x1E, 0x3C, 0xF1, 0xF3, 0xE3, 0x8F, 0x1F, 0xFE, 0x78, 0xF0, 0xFF,
  0xFF, 0x0F, 0x0F, 0xEF, 0xE0, 0x70, 0x78, 0x7C, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0,
  0x08, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0,
  0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x01,
  0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xC0,
  0x7E, 0x3F, 0x80, 0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF7, 0xF0, 0x07,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x87, 0xE1, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1,
  0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x3F, 0xE3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xF8,
  0x7F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0x7E, 0x0F, 0xE7, 0xF0, 0x3F,
  0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0x3F, 0x07,
  0xE1, 0xFC, 0x7F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07,
  0xF3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x07, 0xF1, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0xFE,
  0x3F, 0x0F, 0xE1, 0xF8, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x7E,
  0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x0F, 0xF9, 0xF8, 0x7F, 0xCF, 0xC7,
  0xFE, 0x7E, 0x3F, 0xF7, 0xF1, 0xFF, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xFC, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8,
  0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0,
  0xFE, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x8F,
  0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x7E, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0xFF, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x81, 0xF8, 0x7F, 0x80, 0xFC,
  0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F,
  0xDF, 0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF0,
  0x07, 0xF3, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81,
  0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0x78, 0xFB, 0xF0, 0xFD,
  0xE3, 0xFF, 0x83, 0xF7, 0xCF, 0x7E, 0x0F, 0xDF, 0x7D, 0xF8, 0x3F, 0x7D,
  0xF7, 0xE0, 0xFD, 0xFF, 0xBF, 0x87, 0xF3, 0xFE, 0xFE, 0x1F, 0xCF, 0xF3,
  0xF0, 0x7E, 0x3F, 0xCF, 0xC1, 0xF8, 0xFE, 0x3F, 0x07, 0xE3, 0xF9, 0xFC,
  0x1F, 0x8F, 0xE7, 0xF0, 0xFE, 0x3F, 0x1F, 0xC3, 0xF8, 0xFC, 0x7E, 0x0F,
  0xC3, 0xE1, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0x07, 0xE0, 0x3F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0,
  0x7E, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0xFE, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8,
  0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x3F, 0xBC, 0xFC, 0x3F, 0xBD,
  0xFC, 0x3F, 0xBD, 0xFC, 0x3F, 0x3D, 0xF8, 0x3F, 0x1D, 0xF8, 0x3F, 0x1F,
  0xF8, 0x7F, 0x1F, 0xF8, 0x7F, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x0F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x7E,
  0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E,
  0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0,
  0x7F, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x0F, 0xE7,
  0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xFC, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x7E, 0x07, 0xE7, 0xF0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F,
  0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0xFE, 0x03, 0xF7, 0xF0,
  0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x0F, 0xE7, 0xE0, 0x7E, 0x3F, 0x07, 0xF1,
  0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xE3,
  0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07,
  0xF3, 0xF8, 0x7F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7F, 0x07, 0xE3, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1F, 0x83,
  0xF3, 0xF8, 0x3F, 0x3F, 0x83, 0xF1, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF,
  0xC1, 0xFC, 0xFE, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xC3, 0xF8, 0x3F, 0x07, 0xF3, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x3F,
  0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x7F, 0x07,
  0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7,
  0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0xFC, 0x1F, 0x07, 0xFF, 0x87, 0xE1, 0xFF, 0xF0, 0xFC, 0x3F, 0x7E,
  0x1F, 0x87, 0xEF, 0xC7, 0xF1, 0xFD, 0xF8, 0xFE, 0x3F, 0x3F, 0x1F, 0xC7,
  0xE7, 0xE7, 0xF9, 0xFC, 0xFC, 0xFF, 0x3F, 0x1F, 0x9F, 0xE7, 0xE3, 0xF7,
  0xFC, 0xFC, 0x7E, 0xFF, 0xBF, 0x0F, 0xDF, 0xF7, 0xE1, 0xFF, 0xFE, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFB,
  0xFF, 0x83, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xF9, 0xFF, 0x81,
  0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F,
  0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0xC0, 0x07,
  0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x03, 0xF9, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE0, 0xFC,
  0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF7, 0xF0, 0x3F,
  0x9F, 0x83, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE0, 0xF8,
  0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xF7, 0x87, 0xDE, 0x1E, 0x78, 0xF9, 0xE3, 0xC7, 0x9F, 0x1E, 0x7C,
  0x7F, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xC0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9, 0xFC, 0xFC, 0xFE, 0x00,
  0x7E, 0x07, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0xF7, 0xEF, 0xE7, 0xF7,
  0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xEF, 0xC1, 0xE7, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xBE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xE3,
  0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xFD,
  0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xF7, 0xF0, 0xF8, 0xF8, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xF8, 0xFC,
  0xFC, 0x7E, 0xFC, 0x3F, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE1, 0xF9, 0xF0, 0xF8, 0xFC, 0xFC, 0x7F, 0xFE, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE7, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F,
  0x87, 0xE3, 0xF0, 0x7C, 0x3F, 0x07, 0xE3, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0x3E, 0x00, 0x03, 0xF8, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF3, 0xF0, 0xF9, 0xF8, 0x7C,
  0xFC, 0x3E, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x30, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x0F, 0xFC, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFC, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xE7, 0xE1,
  0xFE, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0x1F, 0x8F,
  0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xFC, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFB, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x81, 0x07, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xDF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7,
  0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F,
  0xC7, 0xE3, 0xF0, 0x07, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7C, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x8F, 0xF1, 0xF8, 0xFE, 0x1F, 0x9F,
  0xC1, 0xFB, 0xF8, 0x1F, 0xFF, 0x83, 0xF7, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F,
  0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x80, 0x07, 0xE0,
  0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E,
  0x0F, 0xC0, 0x1F, 0x9E, 0x1F, 0x03, 0xFF, 0xE7, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9,
  0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0xC7, 0xE7, 0xE3, 0xF1, 0xFC, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFE, 0x3F, 0x1F, 0x9F,
  0x8F, 0xE3, 0xF3, 0xF1, 0xF8, 0x7E, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF0, 0x0F, 0xDF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7,
  0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F,
  0x87, 0xE3, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0xF3, 0xF1, 0xF9, 0xF8, 0x7D, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00,
  0x07, 0xEF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xF7, 0xF0, 0x3F, 0x3E, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xE7, 0xE1, 0xFE, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7E, 0x3F, 0x9F, 0xC7, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F,
  0xC3, 0xF1, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x00, 0xF7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xBC,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFB, 0xF1, 0xF8, 0xFC,
  0xFC, 0x7E, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xF3, 0xE1, 0xF9, 0xF8, 0xFC, 0xFC, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x87, 0xFF, 0x7F, 0xE7, 0xFE, 0xFF, 0xE3, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x81, 0xF0, 0x3F,
  0x0F, 0xCF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x1F, 0x9F, 0x87,
  0xE7, 0xE1, 0xF9, 0xF8, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3E, 0x7C, 0x00, 0xFC,
  0x3F, 0x7E, 0x1F, 0xBF, 0x1F, 0xDF, 0x8F, 0xCF, 0xC7, 0xE7, 0xE7, 0xE3,
  0xF3, 0xF0, 0xF9, 0xF8, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x78, 0x7F, 0xF8,
  0xF1, 0xFB, 0xF3, 0xF3, 0xF7, 0xE7, 0xE7, 0xEF, 0xCF, 0xCF, 0x9F, 0xBF,
  0xBF, 0x3F, 0x7F, 0x7C, 0x7D, 0xFE, 0xF8, 0xFB, 0xFF, 0xF1, 0xF7, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xFD, 0xFF, 0x0F, 0xFB, 0xFC, 0x1F, 0xE7, 0xF8,
  0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03,
  0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xBF, 0x03, 0xF9, 0xF0, 0x3F, 0x1F, 0x87, 0xF1, 0xF8, 0x7E,
  0x1F, 0x80, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF9, 0xFC, 0x1F, 0x9F, 0x80, 0xFB, 0xF8, 0x0F, 0xBF,
  0x00, 0xFB, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0xFF, 0xFE, 0x00, 0x00, 0x60, 0x1C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1,
  0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF0, 0x0E, 0x00, 0xC0, 0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0,
  0xE0, 0xE0, 0xE0, 0x02, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xE0, 0x3E, 0x0F, 0xE0, 0xFC,
  0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x00, 0x40, 0x00, 0x0F,
  0x00, 0x0F, 0xE0, 0xF3, 0xFC, 0x3D, 0xFF, 0x9F, 0x7F, 0xFF, 0xDE, 0x3F,
  0xEF, 0x8F, 0xFB, 0xE1, 0xFC, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 28, 10, 0, -28 },
  { 40, 12, 11, 12, 2, -29 },
  { 57, 20, 28, 19, 0, -28 },
  { 127, 18, 36, 19, 1, -32 },
  { 208, 19, 28, 24, 3, -28 },
  { 275, 20, 28, 23, 0, -28 },
  { 345, 6, 11, 6, 2, -29 },
  { 354, 12, 40, 12, 2, -31 },
  { 414, 13, 40, 12, -2, -31 },
  { 479, 17, 17, 18, 2, -28 },
  { 516, 16, 20, 18, 1, -23 },
  { 556, 9, 12, 10, -2, -5 },
  { 570, 10, 5, 16, 3, -14 },
  { 577, 7, 7, 11, 1, -7 },
  { 584, 17, 30, 12, -3, -28 },
  { 648, 18, 28, 19, 1, -28 },
  { 711, 13, 28, 19, 4, -28 },
  { 757, 19, 28, 19, 0, -28 },
  { 824, 19, 28, 19, 0, -28 },
  { 891, 18, 28, 19, 1, -28 },
  { 954, 18, 28, 19, 1, -28 },
  { 1017, 17, 28, 19, 1, -28 },
  { 1077, 19, 28, 19, 1, -28 },
  { 1144, 18, 28, 19, 1, -28 },
  { 1207, 17, 28, 19, 2, -28 },
  { 1267, 9, 22, 11, 1, -22 },
  { 1292, 12, 29, 11, -2, -22 },
  { 1336, 16, 19, 17, 1, -21 },
  { 1374, 17, 14, 20, 1, -19 },
  { 1404, 16, 19, 17, 0, -21 },
  { 1442, 16, 28, 17, 2, -28 },
  { 1498, 28, 36, 29, 0, -27 },
  { 1624, 23, 28, 23, -2, -28 },
  { 1705, 21, 28, 21, 0, -28 },
  { 1779, 21, 28, 22, 1, -28 },
  { 1853, 21, 28, 21, 0, -28 },
  { 1927, 21, 28, 18, 0, -28 },
  { 2001, 20, 28, 18, 0, -28 },
  { 2071, 21, 28, 22, 1, -28 },
  { 2145, 24, 28, 23, 0, -28 },
  { 2229, 11, 28, 11, 0, -28 },
  { 2268, 20, 28, 19, 0, -28 },
  { 2338, 25, 28, 21, 0, -28 },
  { 2426, 16, 28, 18, 0, -28 },
  { 2482, 30, 28, 29, 0, -28 },
  { 2587, 24, 28, 23, 0, -28 },
  { 2671, 21, 28, 23, 1, -28 },
  { 2745, 22, 28, 22, 0, -28 },
  { 2822, 21, 33, 23, 1, -28 },
  { 2909, 21, 28, 21, 0, -28 },
  { 2983, 20, 28, 21, 1, -28 },
  { 3053, 20, 28, 21, 3, -28 },
  { 3123, 22, 28, 22, 1, -28 },
  { 3200, 22, 28, 22, 3, -28 },
  { 3277, 27, 28, 28, 3, -28 },
  { 3372, 26, 28, 21, -2, -28 },
  { 3463, 21, 28, 21, 3, -28 },
  { 3537, 23, 28, 20, -1, -28 },
  { 3618, 14, 39, 10, -1, -32 },
  { 3687, 10, 30, 15, 3, -28 },
  { 3725, 14, 39, 10, -2, -32 },
  { 3794, 14, 14, 15, 1, -28 },
  { 3819, 15, 5, 15, -2, 0 },
  { 3829, 9, 6, 13, 4, -29 },
  { 3836, 17, 21, 18, 0, -21 },
  { 3881, 18, 29, 19, 0, -29 },
  { 3947, 17, 21, 17, 0, -21 },
  { 3992, 20, 29, 19, 0, -29 },
  { 4065, 17, 21, 18, 1, -21 },
  { 4110, 14, 29, 13, 1, -29 },
  { 4161, 19, 29, 19, 0, -21 },
  { 4230, 19, 29, 19, -1, -29 },
  { 4299, 11, 29, 10, 0, -29 },
  { 4339, 16, 37, 10, -5, -29 },
  { 4413, 20, 29, 19, 0, -29 },
  { 4486, 11, 29, 10, 0, -29 },
  { 4526, 27, 21, 28, 0, -21 },
  { 4597, 19, 21, 19, -1, -21 },
  { 4647, 17, 21, 19, 1, -21 },
  { 4692, 20, 29, 19, -2, -21 },
  { 4765, 19, 29, 19, 0, -21 },
  { 4834, 14, 21, 13, 0, -21 },
  { 4871, 17, 21, 17, 0, -21 },
  { 4916, 12, 26, 12, 1, -26 },
  { 4955, 18, 21, 19, 1, -21 },
  { 5003, 17, 21, 17, 2, -21 },
  { 5048, 23, 21, 24, 2, -21 },
  { 5109, 20, 21, 17, -2, -21 },
  { 5162, 20, 29, 17, -1, -21 },
  { 5235, 18, 21, 17, -1, -21 },
  { 5283, 11, 37, 11, 1, -30 },
  { 5334, 8, 33, 10, 1, -28 },
  { 5367, 12, 37, 11, -1, -30 },
  { 5423, 18, 9, 20, 1, -16 },
};

const GFXfont RobotoCondensed_BlackItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_BLACKITALIC39PT7B_H_
