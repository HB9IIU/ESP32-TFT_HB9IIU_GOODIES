#ifndef _ROBOTOCONDENSED_BLACKITALIC34PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x00, 0x03,
  0x81, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xE0, 0x3D, 0xE7, 0x3D, 0xE7, 0xBC,
  0xF7, 0x9C, 0xE3, 0x9C, 0xF3, 0x9C, 0xF3, 0x80, 0x00, 0xE7, 0x00, 0x77,
  0x80, 0x7B, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x3F,
  0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xC1, 0xCE, 0x00, 0xEF, 0x00, 0xF7, 0x00,
  0x73, 0x81, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x0E, 0x70, 0x07, 0x70,
  0x07, 0x38, 0x03, 0x9C, 0x01, 0xDE, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xBE, 0x3F, 0x3E, 0x3F, 0x3F, 0x3E, 0x3F, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFC, 0xF8, 0x7F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0xF3, 0x8E, 0xF3, 0x8E, 0xE3, 0x9C, 0xE3,
  0xBC, 0xE7, 0xB8, 0xFF, 0x70, 0x7F, 0xF0, 0x3D, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0xBC, 0x07, 0xFE, 0x0E, 0xFF, 0x1F, 0xE7, 0x3D, 0xC7, 0x39,
  0xC7, 0x71, 0xCF, 0xF1, 0xCF, 0x21, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0x9E, 0x03, 0xE7,
  0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xE7, 0xCF, 0xF9, 0xF7, 0xFF, 0x79, 0xF7, 0xFE, 0x7C,
  0xFF, 0xBF, 0x3F, 0xCF, 0xC7, 0xF1, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x3E, 0x7E, 0x7B, 0xDE, 0xEF, 0x7B, 0xDE, 0xE7, 0x00,
  0x00, 0x40, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x0C, 0x00, 0x80, 0x04,
  0x01, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x3E, 0x0F,
  0x07, 0x83, 0xE0, 0xF0, 0x38, 0x08, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x63, 0x8F, 0xEE, 0xFF, 0xFF, 0xCF, 0xFE, 0x0F, 0x80, 0x7E,
  0x03, 0xDC, 0x1F, 0x78, 0xF8, 0xE1, 0xC3, 0x80, 0x04, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x83, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C,
  0x78, 0xF0, 0x20, 0x7F, 0x9F, 0xE7, 0xFB, 0xFE, 0x33, 0xEF, 0xFF, 0xF9,
  0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F,
  0x9F, 0x1F, 0x7E, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7, 0xFF,
  0x8F, 0xFF, 0x1F, 0x7E, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE3, 0xE3, 0xEF,
  0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xC0, 0x00, 0xC0, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFA, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87,
  0xE1, 0xF0, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0xBF,
  0x1F, 0x1F, 0x3F, 0x1F, 0x3E, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFB,
  0xF0, 0xF8, 0xF8, 0xFC, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x7E, 0x1F, 0x3F, 0x1F, 0x8F, 0xDF, 0x87, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0x7C, 0x1F, 0xF8,
  0x7B, 0xF1, 0xF7, 0xC3, 0xCF, 0x8F, 0x9F, 0x3E, 0x3E, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3D, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x7F, 0xFC, 0x1C, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0xF8, 0xFC, 0xF8, 0xFC, 0xFD, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0,
  0x0F, 0x80, 0x00, 0x3C, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF,
  0xE7, 0xEF, 0xDF, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFB,
  0xE1, 0xF3, 0xE7, 0xE7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x07, 0xC0, 0x3F,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0x7E,
  0x3F, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1F, 0x7E, 0x1F, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF8, 0x7C, 0xF8, 0xFC, 0x7C, 0xF8, 0x7C,
  0xF8, 0xFC, 0xF8, 0xFC, 0xFD, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0x80, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7E, 0x7D, 0xF1,
  0xF7, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x3F, 0x7F,
  0xFD, 0xFF, 0xF3, 0xFF, 0x87, 0xBE, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x1F,
  0xF8, 0x7F, 0xC1, 0xFE, 0x07, 0xE0, 0x1E, 0x00, 0x0C, 0x1E, 0x3F, 0x3F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xF8, 0xFC,
  0xFC, 0xF8, 0x70, 0x03, 0x03, 0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x0F, 0xFC, 0xFF, 0xE7, 0xFC,
  0x1F, 0xC0, 0x7E, 0x01, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x07,
  0xC0, 0x07, 0x00, 0x04, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF3, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE0, 0x10, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xC0, 0x3F, 0x01, 0xFC, 0x3F, 0xF3, 0xFF, 0x9F, 0xF0, 0x7F, 0x01,
  0xF0, 0x07, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0xFF, 0x8F, 0xFE, 0xFF, 0xF7,
  0xEF, 0xFE, 0x7F, 0xE3, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x78, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x0E, 0x0F, 0x00, 0x07, 0x0E, 0x0F, 0x87, 0x1E, 0x3F, 0xC7, 0x1C,
  0x7F, 0xE7, 0x3C, 0x79, 0xC7, 0x38, 0xF1, 0xC7, 0x78, 0xE3, 0xC7, 0x79,
  0xE3, 0xC7, 0x71, 0xE3, 0x87, 0x71, 0xE3, 0x8F, 0x73, 0xC7, 0x8E, 0xF3,
  0xC7, 0x8E, 0xF3, 0xC7, 0x1E, 0xF3, 0xEF, 0x9C, 0xF1, 0xFF, 0xF8, 0xF1,
  0xFB, 0xF0, 0xF0, 0xF1, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x0E, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x3C, 0x03,
  0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x03, 0xF3, 0xE0, 0x3F,
  0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x0F, 0xCF, 0xC3, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xE1, 0xF9, 0xF8, 0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xC1, 0xF9,
  0xF1, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC3,
  0xF3, 0xE0, 0x7D, 0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0xFC,
  0x1F, 0x3F, 0x07, 0xCF, 0xC3, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xE3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F,
  0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3E, 0x0F, 0xCF, 0x83,
  0xE3, 0xE0, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xC7, 0xC3, 0xF1,
  0xF3, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xDF, 0xCF, 0xC1, 0xF3, 0xF0, 0x7C,
  0xF8, 0x1F, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF1, 0xFF, 0x7C,
  0x7F, 0xBF, 0x1F, 0xEF, 0xC7, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07,
  0xE7, 0xC1, 0xF1, 0xFD, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0,
  0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03,
  0xE1, 0xF8, 0x1F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F,
  0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0,
  0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3,
  0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0xFC, 0x7C, 0x7E,
  0x3E, 0x3F, 0x3F, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0x00, 0x0F, 0x83, 0xF8, 0x7C, 0x3F, 0x83, 0xE1, 0xF8, 0x3F, 0x1F,
  0xC1, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0xE0, 0x1F,
  0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFE, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0xFC, 0x1F, 0x07, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xFC, 0x7F, 0xC3, 0xEF, 0x3F, 0xF0, 0xFB,
  0xCF, 0x7C, 0x3E, 0xF3, 0xFF, 0x0F, 0xBD, 0xEF, 0xC3, 0xEF, 0x7B, 0xE1,
  0xFB, 0xFC, 0xF8, 0x7E, 0xFF, 0x3E, 0x1F, 0x3F, 0xDF, 0x87, 0xC7, 0xE7,
  0xE1, 0xF1, 0xF9, 0xF0, 0xFC, 0x7C, 0x7C, 0x3F, 0x1F, 0x1F, 0x0F, 0xC7,
  0x8F, 0xC3, 0xE1, 0xE3, 0xF0, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x3F, 0x83, 0xE1, 0xFC, 0x1F, 0x0F, 0xF1, 0xF8, 0x7F, 0x8F, 0xC3,
  0xFC, 0x7E, 0x1F, 0xE3, 0xE1, 0xFF, 0x9F, 0x0F, 0xFC, 0xF8, 0x7E, 0xEF,
  0xC3, 0xE7, 0x7E, 0x1F, 0x3B, 0xF0, 0xF9, 0xFF, 0x0F, 0xC7, 0xF8, 0x7E,
  0x3F, 0xC3, 0xF1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F, 0x8F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0x81,
  0xF3, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x07,
  0xE7, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7C, 0xFC, 0x0F,
  0x9F, 0x83, 0xF1, 0xF0, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x3F,
  0x1F, 0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0xDF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x7E, 0x07, 0xCF,
  0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF,
  0x03, 0xF7, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x83, 0xF1, 0xF0, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F,
  0x9F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E,
  0x7C, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8,
  0x7E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF9, 0xF9, 0xF8, 0x7C, 0xFC, 0x3E, 0x7E, 0x1F, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0xDF,
  0xC7, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x07, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F,
  0x8F, 0xC1, 0xF1, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x3F,
  0x3F, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE1, 0xFC,
  0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xC7, 0xC0,
  0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0x7D, 0xF8, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x7C, 0x7F,
  0xF0, 0xF8, 0xFF, 0xE3, 0xF1, 0xF7, 0xC7, 0xE3, 0xEF, 0x8F, 0xCF, 0xDF,
  0x3F, 0x9F, 0x3E, 0x7F, 0x3E, 0x7C, 0xFE, 0xFC, 0xFB, 0xFD, 0xF9, 0xF7,
  0xFB, 0xE3, 0xEF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F,
  0x83, 0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0,
  0xFC, 0x3F, 0x01, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0x3E,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF0, 0x0F, 0xC7,
  0xC0, 0x3F, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F,
  0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x3D, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x87, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1,
  0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0xFC, 0x3E, 0x1F,
  0x0F, 0x87, 0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFE,
  0x0F, 0xE1, 0xFE, 0x1E, 0xE3, 0xCE, 0x3C, 0xE7, 0x8F, 0x78, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F,
  0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xC7, 0xCF, 0x80,
  0x1F, 0x03, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xF3, 0xF7, 0xE7, 0xCF, 0x8F,
  0x9F, 0x3F, 0x3F, 0xFE, 0x7F, 0xFC, 0x7E, 0xF8, 0x79, 0xF0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x78, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x7E, 0xFC, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFB, 0xF8,
  0xF9, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xCF,
  0xC7, 0xDF, 0x0F, 0xBE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE3,
  0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0x9F, 0x07, 0xF7, 0xC1, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0x7E, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x1F,
  0xBF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xBE, 0x00, 0x07,
  0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFF, 0x7E, 0xFD, 0xF1, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x23, 0xF3, 0x8F,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x1F, 0xC1, 0xF8, 0x1F, 0x01, 0xF0, 0x7F, 0xEF, 0xFE, 0xFF, 0xCF,
  0xFC, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x07, 0xCF,
  0x87, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xF3, 0xF3, 0xF1, 0xF9, 0xF0,
  0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0xC7,
  0xC7, 0xE3, 0xF3, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x06, 0x1F, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x78, 0x7F, 0xF8, 0xFF,
  0xF9, 0xFF, 0xF3, 0xF7, 0xE7, 0xC7, 0xDF, 0x8F, 0xBF, 0x1F, 0x7E, 0x3E,
  0xF8, 0xFD, 0xF1, 0xFB, 0xE3, 0xEF, 0xC7, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C,
  0x7E, 0xF8, 0xFD, 0xF1, 0xF0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x70, 0x00,
  0x00, 0x3E, 0x1F, 0x0F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E,
  0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x87, 0xCF,
  0xC3, 0xF7, 0xF0, 0xFD, 0xF8, 0x3E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7C,
  0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x1F,
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87,
  0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x00, 0x1F, 0x78,
  0x78, 0x3F, 0xFB, 0xF8, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xF7, 0xF7,
  0xE7, 0xC7, 0xC7, 0xCF, 0x8F, 0x8F, 0x9F, 0x1F, 0x1F, 0x7E, 0x7E, 0x7E,
  0xFC, 0xFC, 0xFD, 0xF1, 0xF1, 0xF3, 0xE3, 0xE3, 0xE7, 0xC7, 0xC7, 0xCF,
  0x8F, 0x8F, 0xBF, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0xF8, 0xF8, 0xF9, 0xF1,
  0xF1, 0xF0, 0x1F, 0x78, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF, 0xF3, 0xF7, 0xE7,
  0xC7, 0xCF, 0x8F, 0xBF, 0x1F, 0x7E, 0x3E, 0xF8, 0xFD, 0xF1, 0xFB, 0xE3,
  0xEF, 0xC7, 0xDF, 0x8F, 0xBE, 0x1F, 0x7C, 0x7E, 0xF8, 0xFD, 0xF1, 0xF0,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xF7, 0xEF, 0xC7, 0xDF,
  0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7,
  0xCF, 0xDF, 0x9F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0xBC,
  0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3,
  0xE3, 0xF3, 0xFB, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x7D, 0xF8, 0x3E, 0x78,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x9F, 0x1F, 0xDF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x3F, 0x7E, 0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7E,
  0xFC, 0x7C, 0xFC, 0x7C, 0xFC, 0x7C, 0x7C, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x3F, 0xF8, 0x1E, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x71, 0xFF, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF3, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xC7, 0xCF, 0xCF, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xCF, 0x8F, 0x9F, 0x1F, 0x3F,
  0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x1F, 0x87, 0xC1, 0xF0, 0x7C,
  0x7F, 0xDF, 0xFF, 0xFF, 0xFE, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xF1, 0xFC, 0x7E, 0x0F, 0x80, 0x3E,
  0x3E, 0xFC, 0x7D, 0xF8, 0xFB, 0xE3, 0xF7, 0xC7, 0xEF, 0x8F, 0x9F, 0x1F,
  0x7E, 0x3E, 0xFC, 0x7D, 0xF1, 0xFB, 0xE3, 0xF7, 0xC7, 0xCF, 0x8F, 0x9F,
  0xBF, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x7B, 0xE0, 0xF8, 0xFF, 0xE3,
  0xFF, 0x8F, 0xBE, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0xBF, 0x3E, 0xF8, 0xFB,
  0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0xE3, 0xEF, 0x9F, 0x3E, 0xF9, 0xF3,
  0xEF, 0xBF, 0x7C, 0xFB, 0xF7, 0xCF, 0xBF, 0x7C, 0xFF, 0xF7, 0x8F, 0x7F,
  0xF8, 0xF7, 0xFF, 0x8F, 0xFF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0x80, 0x1F, 0x1F, 0x8F, 0x8F, 0x83, 0xEF, 0xC1, 0xF7, 0xC0, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xE0, 0xFC, 0xF8,
  0x7C, 0x7C, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x87, 0xC7, 0xE1, 0xF1, 0xF0,
  0x7C, 0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF8, 0x00, 0x80, 0xE0, 0x7C, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x8F, 0xC3, 0xE0, 0xF0, 0x3E,
  0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x81,
  0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0x0E, 0x1C, 0x38, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x04, 0x01, 0xC0,
  0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x07, 0xC3, 0xF1, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03,
  0x80, 0x40, 0x00, 0x1E, 0x00, 0x3F, 0x0F, 0x7F, 0x8F, 0x7F, 0xDE, 0xFB,
  0xFE, 0xF1, 0xFE, 0xF0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_BlackItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 11, 9, 10, 1, -26 },
  { 44, 17, 24, 17, 0, -24 },
  { 95, 16, 30, 17, 1, -27 },
  { 155, 16, 24, 21, 3, -24 },
  { 203, 18, 24, 20, 0, -24 },
  { 257, 5, 10, 5, 2, -26 },
  { 264, 11, 34, 11, 1, -27 },
  { 311, 10, 35, 11, -1, -27 },
  { 355, 14, 15, 15, 2, -24 },
  { 382, 14, 17, 15, 1, -20 },
  { 412, 8, 11, 9, -2, -4 },
  { 423, 10, 4, 14, 2, -12 },
  { 428, 6, 6, 10, 1, -6 },
  { 433, 14, 26, 10, -2, -24 },
  { 479, 15, 24, 17, 1, -24 },
  { 524, 10, 24, 17, 4, -24 },
  { 554, 16, 24, 17, 0, -24 },
  { 602, 17, 24, 17, 0, -24 },
  { 653, 15, 24, 17, 1, -24 },
  { 698, 16, 24, 17, 1, -24 },
  { 746, 15, 24, 17, 1, -24 },
  { 791, 17, 24, 17, 1, -24 },
  { 842, 16, 24, 17, 1, -24 },
  { 890, 14, 24, 17, 2, -24 },
  { 932, 8, 19, 10, 1, -19 },
  { 951, 10, 26, 9, -1, -19 },
  { 984, 14, 16, 15, 0, -18 },
  { 1012, 15, 11, 17, 1, -16 },
  { 1033, 14, 16, 15, 0, -18 },
  { 1061, 13, 24, 15, 2, -24 },
  { 1100, 24, 31, 25, 0, -23 },
  { 1193, 20, 24, 20, -2, -24 },
  { 1253, 18, 24, 19, 0, -24 },
  { 1307, 18, 24, 19, 1, -24 },
  { 1361, 18, 24, 19, 0, -24 },
  { 1415, 18, 24, 16, 0, -24 },
  { 1469, 17, 24, 16, 0, -24 },
  { 1520, 18, 24, 20, 1, -24 },
  { 1574, 21, 24, 20, 0, -24 },
  { 1637, 10, 24, 9, 0, -24 },
  { 1667, 17, 24, 16, 0, -24 },
  { 1718, 21, 24, 18, 0, -24 },
  { 1781, 14, 24, 16, 0, -24 },
  { 1823, 26, 24, 25, 0, -24 },
  { 1901, 21, 24, 20, 0, -24 },
  { 1964, 19, 24, 20, 1, -24 },
  { 2021, 19, 24, 19, 0, -24 },
  { 2078, 19, 28, 20, 1, -24 },
  { 2145, 19, 24, 19, 0, -24 },
  { 2202, 17, 24, 18, 1, -24 },
  { 2253, 18, 24, 18, 2, -24 },
  { 2307, 19, 24, 19, 1, -24 },
  { 2364, 19, 24, 19, 2, -24 },
  { 2421, 23, 24, 25, 3, -24 },
  { 2490, 22, 24, 19, -1, -24 },
  { 2556, 18, 24, 18, 3, -24 },
  { 2610, 20, 24, 18, -1, -24 },
  { 2670, 12, 34, 9, -1, -28 },
  { 2721, 9, 26, 13, 2, -24 },
  { 2751, 12, 34, 9, -2, -28 },
  { 2802, 12, 12, 13, 1, -24 },
  { 2820, 13, 4, 13, -2, 0 },
  { 2827, 8, 5, 11, 3, -25 },
  { 2832, 15, 18, 15, 0, -18 },
  { 2866, 16, 26, 16, 0, -26 },
  { 2918, 15, 18, 15, 0, -18 },
  { 2952, 18, 26, 16, 0, -26 },
  { 3011, 14, 18, 16, 1, -18 },
  { 3043, 12, 26, 11, 1, -26 },
  { 3082, 17, 25, 17, 0, -18 },
  { 3136, 15, 26, 16, 0, -26 },
  { 3185, 9, 25, 9, 0, -25 },
  { 3214, 13, 32, 8, -4, -25 },
  { 3266, 18, 26, 16, 0, -26 },
  { 3325, 10, 26, 9, 0, -26 },
  { 3358, 23, 18, 24, 0, -18 },
  { 3410, 15, 18, 16, 0, -18 },
  { 3444, 15, 18, 16, 0, -18 },
  { 3478, 17, 25, 16, -1, -18 },
  { 3532, 16, 25, 16, 0, -18 },
  { 3582, 12, 18, 11, 0, -18 },
  { 3609, 15, 18, 15, 0, -18 },
  { 3643, 10, 22, 10, 1, -22 },
  { 3671, 15, 18, 16, 1, -18 },
  { 3705, 14, 18, 15, 2, -18 },
  { 3737, 20, 18, 21, 2, -18 },
  { 3782, 17, 18, 15, -1, -18 },
  { 3821, 18, 25, 15, -1, -18 },
  { 3878, 16, 18, 15, -1, -18 },
  { 3914, 10, 33, 10, 1, -27 },
  { 3956, 7, 28, 8, 1, -24 },
  { 3981, 10, 33, 10, -1, -27 },
  { 4023, 16, 8, 18, 1, -14 },
};

const GFXfont RobotoCondensed_BlackItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_BLACKITALIC34PT7B_H_
