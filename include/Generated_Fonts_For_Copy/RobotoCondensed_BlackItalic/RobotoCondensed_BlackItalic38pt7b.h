#ifndef _ROBOTOCONDENSED_BLACKITALIC38PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x07, 0xF0, 0xFE, 0x0F,
  0x80, 0xE0, 0x00, 0x79, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0xF9, 0xEF, 0x1E,
  0xF1, 0xCF, 0x3C, 0xF3, 0xCE, 0x3C, 0xE3, 0x80, 0x00, 0x7B, 0xC0, 0x0E,
  0x78, 0x03, 0xCE, 0x00, 0x7B, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x7B,
  0xC0, 0x0E, 0x78, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xCF,
  0x00, 0x79, 0xC0, 0x0F, 0x78, 0x01, 0xCF, 0x00, 0x79, 0xC0, 0x7F, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0x38, 0x01, 0xEF, 0x00, 0x39, 0xE0,
  0x0F, 0x38, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x38, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xE3, 0xE1,
  0xF8, 0xF8, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x87,
  0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0xE0,
  0x07, 0xFC, 0x01, 0xEF, 0x04, 0x79, 0xE3, 0xFC, 0x79, 0xEF, 0x1E, 0xF3,
  0xC7, 0x3C, 0xF3, 0xDE, 0x1E, 0xFF, 0x07, 0xFB, 0x80, 0xFF, 0xE0, 0x1E,
  0xF0, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xDE,
  0xF0, 0xFF, 0x3C, 0x7B, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0x8F, 0x3C,
  0xC3, 0xDF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7C, 0xF8,
  0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x1F, 0x1F, 0xF1, 0xF3, 0xFF,
  0xBF, 0x7F, 0xFF, 0xE7, 0xEF, 0xFE, 0x7E, 0xFF, 0xEF, 0xE7, 0xFC, 0xFE,
  0x7F, 0xCF, 0xE3, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xC7, 0xE0, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0xBC, 0xF3,
  0xCF, 0x00, 0x00, 0x20, 0x1C, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x10, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x41, 0xE1, 0x71, 0xC7, 0xFD, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3E, 0xF0, 0x7C,
  0x70, 0x78, 0x78, 0x30, 0x70, 0x10, 0x20, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF8,
  0xFC, 0xFC, 0xFC, 0x3E, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x0F, 0xDF, 0x87,
  0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x7E, 0xFC,
  0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xF1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x30, 0x1F, 0x07, 0xF3, 0xFF, 0x7F, 0xE7, 0xFE, 0xFF, 0xEF, 0x7E, 0x87,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF8, 0xFC, 0x7E, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xDF, 0x83, 0xEF, 0xC1, 0xEF, 0xC1,
  0xF7, 0xE1, 0xF3, 0xF0, 0xF9, 0xF8, 0xF8, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xBE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0x9F, 0xC0, 0x43, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xBC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xF3, 0xFF, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0xFC, 0x3F, 0xFE, 0x1F, 0xBF,
  0x0F, 0xDF, 0x87, 0xE7, 0xC3, 0xF3, 0xE3, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC,
  0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE3,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7E, 0x7E,
  0x7E, 0x1F, 0x3F, 0x0F, 0xDF, 0x87, 0xEF, 0xC7, 0xE7, 0xE3, 0xF3, 0xFF,
  0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3F, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x3F,
  0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x0F, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0xCF, 0xE7, 0xF1, 0xF8, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFC, 0x7E,
  0x3F, 0x1F, 0x87, 0x80, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7F,
  0xF0, 0xFF, 0x81, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x40, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE0, 0x18, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xFE,
  0x1F, 0xFE, 0x7F, 0xF8, 0x7F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF7, 0xFF, 0xEF,
  0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x07, 0xC0,
  0x07, 0x81, 0xF0, 0x00, 0x70, 0x7C, 0x00, 0x0E, 0x0F, 0x03, 0xC1, 0xE3,
  0xC1, 0xFE, 0x3C, 0x78, 0x7F, 0xE3, 0x9E, 0x1F, 0xFC, 0x73, 0xC7, 0xC7,
  0x8E, 0x78, 0xF1, 0xE3, 0xDE, 0x3E, 0x3C, 0x7B, 0xC7, 0x87, 0x8F, 0x78,
  0xF0, 0xF1, 0xEF, 0x3E, 0x3C, 0x39, 0xC7, 0xC7, 0x87, 0x78, 0xF0, 0xF1,
  0xEF, 0x1E, 0x3E, 0x39, 0xE3, 0xC7, 0x8F, 0x3C, 0x7F, 0xFB, 0xC7, 0x87,
  0xFF, 0xF8, 0x70, 0xFD, 0xFE, 0x0E, 0x0F, 0x1F, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x02, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7D,
  0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x7E, 0x7C, 0x01, 0xF9, 0xF0,
  0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE3, 0xF8, 0x1F, 0xCF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x1F, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xC3,
  0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x0F,
  0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1F, 0x83, 0xF3, 0xF0, 0x3F, 0x3F, 0x03,
  0xF7, 0xF0, 0x3F, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC,
  0x7E, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F,
  0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x83, 0xF3, 0xF0, 0x7F, 0x3F, 0x07, 0xF3,
  0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC,
  0x7E, 0x1F, 0xC7, 0xE3, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F,
  0xE1, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0xF9, 0xF8,
  0xFF, 0xCF, 0xC7, 0xFC, 0xFE, 0x3F, 0xE7, 0xF0, 0x3F, 0x3F, 0x81, 0xF8,
  0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE1,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF8, 0x7E, 0x07, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF1, 0xFC, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0xFF, 0x0F, 0xC1, 0xFE, 0x0F, 0xC3, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F, 0xC7,
  0xF0, 0x0F, 0xCF, 0xF0, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x1F, 0x9F,
  0x80, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0x00, 0x7F, 0x3F, 0x80, 0x7E, 0x3F,
  0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F,
  0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x07, 0xDE, 0x1F, 0xF8, 0x3E, 0xF1, 0xFF, 0xC3, 0xF7, 0x8F, 0xFE,
  0x1F, 0xBC, 0xFB, 0xF0, 0xFD, 0xE7, 0xFF, 0x07, 0xEF, 0x3D, 0xF8, 0x3F,
  0x7B, 0xEF, 0xC3, 0xFB, 0xDE, 0x7E, 0x1F, 0x9F, 0xF3, 0xF0, 0xFC, 0xFF,
  0x3F, 0x87, 0xE3, 0xF9, 0xF8, 0x3F, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x7E,
  0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x3E, 0x3F, 0x87, 0xE1, 0xF1, 0xFC, 0x3F,
  0x0F, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8,
  0x7F, 0x03, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0x87, 0xFC, 0x3F, 0x0F,
  0xF8, 0x7E, 0x1F, 0xF0, 0xFC, 0x3F, 0xF1, 0xF8, 0x7F, 0xE7, 0xF0, 0xFF,
  0xCF, 0xC3, 0xFB, 0x9F, 0x87, 0xE7, 0xBF, 0x0F, 0xCF, 0x7E, 0x1F, 0x9E,
  0xFC, 0x3F, 0x3F, 0xF8, 0xFE, 0x3F, 0xE1, 0xFC, 0x7F, 0xC3, 0xF0, 0xFF,
  0x87, 0xE1, 0xFF, 0x0F, 0xC1, 0xFE, 0x1F, 0x83, 0xFC, 0x7F, 0x07, 0xF0,
  0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE3,
  0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x7F, 0x3F, 0x01, 0xFB, 0xF8, 0x1F, 0xDF,
  0xC0, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F,
  0xDF, 0xC0, 0x7E, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x01, 0xF9, 0xFC,
  0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xFC,
  0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0xFE, 0x3F, 0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0x7E,
  0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0, 0xFE,
  0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xDF, 0xC0,
  0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x3F, 0x0F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC, 0x7F, 0x07,
  0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC, 0x1F,
  0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x7E, 0x3F, 0x87, 0xE3,
  0xF8, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xE3,
  0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8, 0xFE,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8,
  0xFE, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1,
  0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F,
  0xE1, 0xFC, 0x7F, 0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xBF,
  0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC,
  0x7E, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xDF, 0x80,
  0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF,
  0xC3, 0xF1, 0xFF, 0xF1, 0xFC, 0x7E, 0xFC, 0x7F, 0x1F, 0xBF, 0x1F, 0xCF,
  0xEF, 0xCF, 0xF3, 0xF3, 0xF3, 0xFC, 0xFC, 0xFC, 0xFF, 0x3F, 0x3F, 0x7F,
  0xDF, 0x8F, 0xDF, 0xF7, 0xE3, 0xF7, 0xFD, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8,
  0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F,
  0xF0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF,
  0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x9F,
  0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07,
  0xFF, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xE1,
  0xF8, 0x7E, 0x3F, 0x03, 0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xF7, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8,
  0x7D, 0xC3, 0xCF, 0x3E, 0x79, 0xE3, 0xDF, 0x1E, 0xF0, 0xFF, 0x87, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x3F, 0x0F,
  0x87, 0xE1, 0xF0, 0x78, 0x01, 0xF8, 0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF,
  0x3F, 0xBF, 0x3F, 0x3F, 0x3F, 0x3F, 0x00, 0x3F, 0x07, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFE, 0x7F, 0x7E, 0xFE, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFD, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFC, 0x7F, 0x7C, 0x1E, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xDE, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF9,
  0xFF, 0xFC, 0xFC, 0x7E, 0x7E, 0x1F, 0x3F, 0x1F, 0x9F, 0x8F, 0xDF, 0x87,
  0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7C, 0xFC, 0x7E, 0xFF,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0x8F, 0x00, 0x01, 0xF8,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0x1F, 0x7E, 0x1F,
  0x7E, 0x1F, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x3E,
  0x7C, 0x7E, 0x7C, 0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x7C, 0xFC, 0x0F, 0xEF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x07,
  0xE3, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F,
  0xFF, 0x7E, 0x3F, 0x7E, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x10, 0xFF, 0xF8, 0x7F,
  0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFF,
  0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xE7,
  0xE1, 0xFE, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7E, 0x1F,
  0x9F, 0xC3, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x08, 0x3F, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF7, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC,
  0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E,
  0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x00, 0x07,
  0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x78,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0xFE, 0x1F, 0x9F, 0xE1, 0xFB, 0xFC, 0x3F, 0x3F, 0x83, 0xF7, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xE7,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x1F, 0xBE, 0x1F, 0x07, 0xFF, 0xDF,
  0xE1, 0xFF, 0xF7, 0xF8, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xC7,
  0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF,
  0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F,
  0x9F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xFB, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E,
  0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x0F,
  0x9F, 0x03, 0xEF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x7E,
  0xFC, 0x7E, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0,
  0x07, 0xEF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE3, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xBE, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC7, 0xC3, 0xFB, 0xF1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8,
  0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F,
  0x1F, 0x0F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7D, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xBC,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0x3F, 0x3F, 0x3E, 0x3F, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0xF8,
  0x7E, 0xF8, 0x7E, 0xFC, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0xFF, 0xDF, 0xFB, 0xFF,
  0xFF, 0xE7, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x7F, 0x07, 0xF8, 0xFF, 0x1F, 0xC1, 0xF8, 0x1F, 0x00,
  0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF1,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7C, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF,
  0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC,
  0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xDF, 0x80, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC,
  0x7E, 0xFC, 0x7E, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0x7D, 0xF8, 0x7D,
  0xF8, 0x7D, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFC,
  0x78, 0xFF, 0xF3, 0xE3, 0xFF, 0xCF, 0x8F, 0xBE, 0x3E, 0x7E, 0xF9, 0xF9,
  0xFB, 0xE7, 0xE7, 0xCF, 0xBF, 0xBF, 0x3E, 0xFE, 0xF8, 0xFB, 0xFB, 0xE3,
  0xFE, 0xEF, 0x8F, 0xFB, 0xFC, 0x3F, 0xEF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xE1, 0xF1, 0xF8, 0x3F,
  0x7F, 0x07, 0xEF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xCF,
  0xC3, 0xF8, 0xF8, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F,
  0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F, 0xBF, 0x80,
  0xFB, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF,
  0xF8, 0x00, 0x40, 0x3C, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x7E,
  0x1F, 0x83, 0xE0, 0x78, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80,
  0xF0, 0x0E, 0x00, 0x80, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E,
  0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x02, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0x7C, 0x07, 0x81, 0xF0, 0xFE, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xE0,
  0x78, 0x04, 0x00, 0x0F, 0x00, 0x0F, 0xE1, 0xF3, 0xFC, 0x7D, 0xFF, 0x9E,
  0x7F, 0xFF, 0x9E, 0x7F, 0xEF, 0x8F, 0xF3, 0xC1, 0xF8, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 27, 10, 0, -27 },
  { 39, 12, 11, 12, 2, -29 },
  { 56, 19, 27, 19, 0, -27 },
  { 121, 18, 35, 19, 1, -31 },
  { 200, 18, 27, 24, 3, -27 },
  { 261, 20, 27, 22, 0, -27 },
  { 329, 6, 11, 6, 2, -29 },
  { 338, 11, 38, 12, 2, -30 },
  { 391, 13, 38, 12, -2, -30 },
  { 453, 16, 17, 17, 2, -27 },
  { 487, 16, 19, 17, 1, -22 },
  { 525, 9, 12, 10, -2, -5 },
  { 539, 10, 5, 16, 3, -14 },
  { 546, 6, 6, 11, 1, -6 },
  { 551, 17, 29, 11, -3, -27 },
  { 613, 17, 27, 19, 1, -27 },
  { 671, 12, 27, 19, 4, -27 },
  { 712, 18, 27, 19, 0, -27 },
  { 773, 19, 27, 19, 0, -27 },
  { 838, 17, 27, 19, 1, -27 },
  { 896, 18, 27, 19, 1, -27 },
  { 957, 17, 27, 19, 1, -27 },
  { 1015, 19, 27, 19, 1, -27 },
  { 1080, 17, 27, 19, 1, -27 },
  { 1138, 16, 27, 19, 2, -27 },
  { 1192, 9, 21, 11, 1, -21 },
  { 1216, 12, 28, 10, -2, -21 },
  { 1258, 15, 19, 17, 1, -21 },
  { 1294, 17, 13, 19, 1, -18 },
  { 1322, 16, 18, 17, 0, -20 },
  { 1358, 15, 27, 17, 2, -27 },
  { 1409, 27, 34, 28, 0, -26 },
  { 1524, 22, 27, 22, -2, -27 },
  { 1599, 21, 27, 21, 0, -27 },
  { 1670, 20, 27, 21, 1, -27 },
  { 1738, 20, 27, 21, 0, -27 },
  { 1806, 20, 27, 18, 0, -27 },
  { 1874, 20, 27, 18, 0, -27 },
  { 1942, 21, 27, 22, 1, -27 },
  { 2013, 23, 27, 22, 0, -27 },
  { 2091, 11, 27, 10, 0, -27 },
  { 2129, 19, 27, 18, 0, -27 },
  { 2194, 24, 27, 21, 0, -27 },
  { 2275, 16, 27, 18, 0, -27 },
  { 2329, 29, 27, 28, 0, -27 },
  { 2427, 23, 27, 22, 0, -27 },
  { 2505, 21, 27, 22, 1, -27 },
  { 2576, 21, 27, 21, 0, -27 },
  { 2647, 21, 32, 22, 1, -27 },
  { 2731, 21, 27, 21, 0, -27 },
  { 2802, 20, 27, 20, 1, -27 },
  { 2870, 19, 27, 20, 3, -27 },
  { 2935, 21, 27, 21, 1, -27 },
  { 3006, 21, 27, 22, 3, -27 },
  { 3077, 26, 27, 27, 3, -27 },
  { 3165, 25, 27, 21, -2, -27 },
  { 3250, 20, 27, 20, 3, -27 },
  { 3318, 22, 27, 20, -1, -27 },
  { 3393, 13, 38, 10, -1, -32 },
  { 3455, 10, 29, 14, 3, -27 },
  { 3492, 13, 38, 10, -2, -32 },
  { 3554, 13, 13, 15, 1, -27 },
  { 3576, 14, 5, 15, -2, 0 },
  { 3585, 9, 6, 13, 4, -29 },
  { 3592, 16, 20, 17, 0, -20 },
  { 3632, 17, 29, 18, 0, -29 },
  { 3694, 16, 20, 17, 0, -20 },
  { 3734, 20, 29, 18, 0, -29 },
  { 3807, 16, 20, 18, 1, -20 },
  { 3847, 14, 29, 12, 1, -29 },
  { 3898, 19, 28, 19, 0, -20 },
  { 3965, 18, 29, 18, -1, -29 },
  { 4031, 10, 28, 10, 0, -28 },
  { 4066, 14, 36, 9, -4, -28 },
  { 4129, 20, 29, 18, 0, -29 },
  { 4202, 11, 29, 10, 0, -29 },
  { 4242, 26, 20, 27, 0, -20 },
  { 4307, 18, 20, 18, -1, -20 },
  { 4352, 16, 20, 18, 1, -20 },
  { 4392, 19, 28, 18, -2, -20 },
  { 4459, 18, 28, 18, 0, -20 },
  { 4522, 14, 20, 13, 0, -20 },
  { 4557, 16, 20, 17, 0, -20 },
  { 4597, 11, 25, 12, 1, -25 },
  { 4632, 17, 20, 18, 1, -20 },
  { 4675, 16, 20, 17, 2, -20 },
  { 4715, 22, 20, 23, 2, -20 },
  { 4770, 19, 20, 17, -1, -20 },
  { 4818, 20, 28, 17, -1, -20 },
  { 4888, 18, 20, 17, -1, -20 },
  { 4933, 11, 37, 11, 1, -30 },
  { 4984, 8, 32, 9, 1, -27 },
  { 5016, 11, 37, 11, -1, -30 },
  { 5067, 18, 9, 20, 1, -16 },
};

const GFXfont RobotoCondensed_BlackItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_BLACKITALIC38PT7B_H_
