#ifndef _ROBOTOCONDENSED_BLACKITALIC36PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x80,
  0x00, 0x00, 0x38, 0x1F, 0x0F, 0xC3, 0xF0, 0x7C, 0x0E, 0x00, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7,
  0x1C, 0x00, 0x73, 0x80, 0x3D, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xEF,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x78, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0xFC, 0x1E, 0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xF7, 0x81, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0xEF, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x0F, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x7B, 0xC0, 0x1C, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F, 0x8F, 0x87, 0xC7, 0xE7,
  0xE3, 0xF3, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE7, 0xE3, 0xF3, 0xF1,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x78, 0xCF, 0x3C, 0x77, 0x9E, 0x7B,
  0xCF, 0x79, 0xE7, 0xB8, 0xF7, 0xBC, 0x3F, 0xFC, 0x1F, 0xDC, 0x07, 0xDE,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87,
  0x7B, 0xC7, 0xB8, 0xE7, 0xBC, 0x73, 0x9E, 0x7B, 0xCF, 0x3D, 0xC3, 0x9E,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0xBF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xE7, 0xCF, 0xFC, 0xF9, 0xFF, 0xDF, 0x7F, 0xFF, 0xCF,
  0x9F, 0xFB, 0xF3, 0xFF, 0x7E, 0x3F, 0xCF, 0xC7, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xF9, 0xF8, 0x7B, 0xDE, 0xF7,
  0xFB, 0xDE, 0xF7, 0x00, 0x00, 0x40, 0x18, 0x0F, 0x81, 0xE0, 0x78, 0x1F,
  0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x60, 0x04, 0x00, 0x02, 0x00, 0x30, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x70, 0x04, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x04, 0x1C, 0x2F, 0x3B, 0xFF,
  0xFF, 0xBF, 0xFF, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xFF, 0x07, 0xCF,
  0x1F, 0x1E, 0x0C, 0x1C, 0x00, 0x20, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E,
  0x3E, 0x7C, 0x78, 0xF8, 0x30, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xC0,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F,
  0x1F, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7E, 0x1F, 0x7E,
  0x3F, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC,
  0x3E, 0xFC, 0x7E, 0xFC, 0x7C, 0x7C, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0x60, 0x3C, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xF7, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x3E, 0x7E, 0x3F, 0x3F, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x03, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF,
  0x87, 0xE3, 0xE1, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0x7C, 0x7F,
  0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x7E, 0x1F, 0x7C,
  0x3E, 0x7C, 0x3C, 0xFC, 0x7C, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xE3, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x3E, 0x1F, 0x9F, 0x0F, 0xCF, 0xCF,
  0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7C, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3E, 0xFC, 0x7E, 0x7C, 0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1F, 0x1F, 0x3F, 0x1F, 0x3F, 0x1F, 0x3F, 0x3F, 0x1F, 0x3F, 0x1F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7C, 0xFC,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0xFC, 0xFF, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xE3, 0xFF, 0xEF, 0xC7, 0xDF, 0x8F, 0xBE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF, 0xDF, 0xDF, 0xFF, 0x3F,
  0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x7F, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xF0, 0x00, 0x0E, 0x0F, 0x8F, 0xC7,
  0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE1, 0xF8, 0xFC, 0x7E, 0x3F, 0x0F, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x70, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xEF, 0xFF, 0x3F, 0xE0, 0xFE,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00,
  0x7C, 0x00, 0x70, 0x00, 0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x38, 0x00, 0x7C,
  0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x7E,
  0x07, 0xFC, 0x3F, 0xF3, 0xFF, 0xC7, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x38,
  0x00, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF,
  0xF1, 0xFF, 0xCF, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xE0, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0x38,
  0x3C, 0x1F, 0x0E, 0x0E, 0x1F, 0xE3, 0x87, 0x8F, 0xFC, 0xE1, 0xC7, 0xCF,
  0x3C, 0xF1, 0xE3, 0x8F, 0x3C, 0xF1, 0xE3, 0xDE, 0x3C, 0x78, 0xF7, 0x9F,
  0x1E, 0x39, 0xE7, 0x87, 0x8E, 0x71, 0xE3, 0xC3, 0x9C, 0x78, 0xF0, 0xEF,
  0x1E, 0x3C, 0x7B, 0xC7, 0x8F, 0x1C, 0xF1, 0xE7, 0x8F, 0x3C, 0x7B, 0xF3,
  0x8F, 0x1F, 0xFF, 0xC3, 0xC3, 0xF7, 0xF0, 0x70, 0x70, 0xF0, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xE3, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x01,
  0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC0, 0xFC, 0xFC,
  0x07, 0xEF, 0xE0, 0x3F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8,
  0x7E, 0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xF0, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x1F, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x1F, 0x3E, 0x07,
  0xEF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF3, 0xF0, 0x3E,
  0x7E, 0x0F, 0xC7, 0xE3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9,
  0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0x7E, 0x3F,
  0x03, 0xE3, 0xF0, 0x3E, 0x3F, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x3F, 0xE7, 0xE3, 0xFC, 0x7E, 0x7F, 0xCF, 0xC7, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xC7, 0xC1, 0xFC, 0x7E, 0x1F,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x1F, 0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x1F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xFC,
  0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x03,
  0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFD, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0x87, 0xF0,
  0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F,
  0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF,
  0xC3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1E, 0xF8, 0x7F, 0xE7, 0xFF,
  0x0F, 0x9E, 0xF7, 0xE1, 0xF3, 0xDE, 0xFC, 0x7E, 0x7F, 0xDF, 0x8F, 0xCF,
  0xF3, 0xE1, 0xF9, 0xFE, 0xFC, 0x3F, 0x3F, 0x9F, 0x87, 0xE7, 0xF3, 0xF0,
  0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0x7C,
  0x7E, 0x1F, 0x87, 0x8F, 0xC0, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFE,
  0x0F, 0xC3, 0xF8, 0x3F, 0x1F, 0xE0, 0xF8, 0x7F, 0x87, 0xE1, 0xFE, 0x1F,
  0x87, 0xFC, 0x7E, 0x1F, 0xF1, 0xF8, 0x7F, 0xC7, 0xE3, 0xF7, 0x1F, 0x0F,
  0xDC, 0xFC, 0x3F, 0x7B, 0xF0, 0xFD, 0xEF, 0xC3, 0xF3, 0xBF, 0x0F, 0xCE,
  0xFC, 0x7E, 0x3F, 0xE1, 0xF8, 0xFF, 0x87, 0xE3, 0xFE, 0x1F, 0x87, 0xF8,
  0x7E, 0x1F, 0xE1, 0xF8, 0x7F, 0x8F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x03, 0xE3, 0xF0,
  0x3E, 0x3E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xC7, 0xC0, 0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8,
  0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F,
  0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0x7E, 0x3F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC,
  0xFC, 0x0F, 0xC7, 0xC0, 0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xE1, 0xF8, 0x7E, 0x3F, 0x07,
  0xE3, 0xF0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC1, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F,
  0xFF, 0xC7, 0xE3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x3F, 0x0F, 0xCF, 0xC1, 0xF3, 0xF0, 0xFC, 0xFC,
  0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0,
  0x7E, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x3F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F,
  0xEF, 0xC0, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF8, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x7C,
  0x7E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x7F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x3E,
  0x1F, 0xFE, 0x3F, 0x1F, 0xBF, 0x1F, 0x8F, 0xDF, 0x8F, 0xC7, 0xEF, 0xCF,
  0xE3, 0xE7, 0xE7, 0xF3, 0xF3, 0xF3, 0xF9, 0xF9, 0xFB, 0xFC, 0xF8, 0xFD,
  0xFE, 0xFC, 0x7E, 0xFF, 0x7E, 0x3F, 0xFF, 0xBE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xBF, 0xF0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xE7, 0xFC,
  0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x07,
  0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF1, 0xFC, 0x03, 0xF1, 0xF8, 0x03,
  0xF3, 0xF8, 0x01, 0xF3, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x0F, 0xEF, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F,
  0xCF, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x87, 0xE0, 0x7F, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7,
  0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0xFC, 0x07,
  0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x00,
  0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7B, 0xC3, 0xDE, 0x3C, 0xF1, 0xE7, 0x9E,
  0x3C, 0xF0, 0xEF, 0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF9, 0xFF,
  0xF3, 0xF3, 0xE7, 0xE7, 0xC0, 0x1F, 0x83, 0xFF, 0x1F, 0xFE, 0xFF, 0xFD,
  0xF9, 0xFF, 0xE3, 0xEF, 0xC7, 0xDF, 0x9F, 0xBF, 0x7F, 0x7F, 0xFE, 0x7F,
  0xFC, 0xFF, 0xF8, 0x7B, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0x1F, 0x3F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C,
  0x3E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xF8, 0xF9, 0xF0, 0x03,
  0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x3E, 0x7E,
  0x3E, 0x7E, 0x3E, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xDF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x8F,
  0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7E, 0x1F,
  0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x7D, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x86, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F,
  0xF0, 0xFF, 0x8F, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0xE3, 0xFF, 0x3F, 0xF9,
  0xFF, 0xC3, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x00, 0x03, 0xCF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F,
  0xFF, 0x8F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x0F,
  0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xF7, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x1C, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xBE, 0x07, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x7E, 0x3F, 0x3F,
  0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xC3, 0xE3, 0xE3, 0xF3, 0xF1, 0xF9,
  0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x1F, 0x1F, 0x80, 0x03,
  0x03, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x1F, 0x87, 0xE1,
  0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0x30, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x9F, 0xC3, 0xE3, 0xF0, 0x7C, 0xFE, 0x1F,
  0xBF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFD,
  0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE1,
  0xF8, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0,
  0x1F, 0x3C, 0x3C, 0x1F, 0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0x3F, 0x1F, 0x3F, 0x3F, 0x1F, 0x3E, 0x3F, 0x1F,
  0x3E, 0x3F, 0x3F, 0x7E, 0x3E, 0x3F, 0x7E, 0x3E, 0x3F, 0x7E, 0x7E, 0x3F,
  0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x7E, 0xFC, 0x7C, 0x7E,
  0xFC, 0x7C, 0x7E, 0xFC, 0xFC, 0x7E, 0xF8, 0xFC, 0x7C, 0x1F, 0x3C, 0x1F,
  0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0x3F, 0x3E, 0x3F, 0x3E,
  0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3E, 0x7C, 0x7E, 0xFC,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC, 0x03,
  0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x3E, 0x1F, 0x7E,
  0x1F, 0x7E, 0x1F, 0x7E, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C,
  0x3F, 0x7C, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F,
  0xC0, 0x07, 0xDF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xE1, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xE7, 0xC0, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xCF, 0x87, 0xF7, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF3, 0xF0,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7C, 0x3F, 0x3E, 0x1F, 0x9F, 0x0F, 0x9F,
  0x87, 0xCF, 0xC7, 0xE3, 0xE3, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x78, 0xFF, 0xC7,
  0xFE, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE3,
  0xE7, 0xC7, 0xCF, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xDF, 0x1F, 0xBE, 0x3F, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F,
  0xE0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0xFF, 0xDF,
  0xF7, 0xFE, 0xFF, 0xC7, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xC0, 0xF8,
  0x3E, 0x1F, 0x3E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E,
  0x7C, 0x3E, 0x7C, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C,
  0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8,
  0x3E, 0xF8, 0xF8, 0x7F, 0xF0, 0xFF, 0xE3, 0xF7, 0xE7, 0xEF, 0xCF, 0x9F,
  0xBF, 0x3F, 0x7E, 0x7E, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xF8, 0xF1, 0xFF, 0xC7, 0x8F, 0xBE, 0x7C, 0x7D, 0xF3, 0xE7,
  0xEF, 0x9F, 0x3E, 0x7D, 0xF9, 0xF3, 0xEF, 0xDF, 0x9F, 0x7E, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF0,
  0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x3E, 0x1F, 0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xE0, 0xF9, 0xF8, 0x3E,
  0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03,
  0xF7, 0xC0, 0xF9, 0xF0, 0x7E, 0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x3F,
  0x7E, 0x07, 0xEF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x00, 0x00, 0xC0, 0x38, 0x0F, 0x03, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F,
  0x01, 0xE0, 0x18, 0x01, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E,
  0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E,
  0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x00, 0x04, 0x00, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0xFC, 0x3F, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x08, 0x00, 0x1F, 0x00, 0x1F, 0xC3,
  0xDF, 0xF3, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0x8F, 0xF3, 0xC3, 0xF8, 0x00,
  0xF0,
};

const GFXglyph RobotoCondensed_BlackItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 12, 10, 11, 1, -27 },
  { 49, 18, 26, 18, 0, -26 },
  { 108, 17, 33, 18, 1, -30 },
  { 179, 17, 26, 22, 3, -26 },
  { 235, 19, 26, 21, 0, -26 },
  { 297, 5, 10, 5, 2, -27 },
  { 304, 11, 36, 11, 2, -28 },
  { 354, 12, 36, 11, -2, -28 },
  { 408, 15, 16, 16, 2, -26 },
  { 438, 15, 19, 16, 1, -21 },
  { 474, 8, 11, 9, -2, -4 },
  { 485, 10, 5, 15, 2, -14 },
  { 492, 6, 6, 11, 1, -6 },
  { 497, 16, 28, 11, -3, -26 },
  { 553, 16, 26, 18, 1, -26 },
  { 605, 11, 26, 18, 4, -26 },
  { 641, 17, 26, 18, 0, -26 },
  { 697, 18, 26, 18, 0, -26 },
  { 756, 16, 26, 18, 1, -26 },
  { 808, 17, 26, 18, 1, -26 },
  { 864, 16, 26, 18, 1, -26 },
  { 916, 18, 26, 18, 1, -26 },
  { 975, 16, 26, 18, 1, -26 },
  { 1027, 15, 26, 18, 2, -26 },
  { 1076, 9, 20, 10, 1, -20 },
  { 1099, 11, 27, 10, -2, -20 },
  { 1137, 14, 18, 16, 1, -20 },
  { 1169, 16, 13, 18, 1, -18 },
  { 1195, 15, 17, 16, 0, -19 },
  { 1227, 14, 26, 16, 2, -26 },
  { 1273, 26, 33, 27, 0, -25 },
  { 1381, 21, 26, 21, -2, -26 },
  { 1450, 20, 26, 20, 0, -26 },
  { 1515, 19, 26, 20, 1, -26 },
  { 1577, 19, 26, 20, 0, -26 },
  { 1639, 19, 26, 17, 0, -26 },
  { 1701, 18, 26, 17, 0, -26 },
  { 1760, 20, 26, 21, 1, -26 },
  { 1825, 22, 26, 21, 0, -26 },
  { 1897, 10, 26, 10, 0, -26 },
  { 1930, 18, 26, 17, 0, -26 },
  { 1989, 23, 26, 19, 0, -26 },
  { 2064, 15, 26, 17, 0, -26 },
  { 2113, 27, 26, 27, 0, -26 },
  { 2201, 22, 26, 21, 0, -26 },
  { 2273, 20, 26, 21, 1, -26 },
  { 2338, 20, 26, 20, 0, -26 },
  { 2403, 20, 31, 21, 1, -26 },
  { 2481, 20, 26, 20, 0, -26 },
  { 2546, 18, 26, 19, 1, -26 },
  { 2605, 18, 26, 19, 3, -26 },
  { 2664, 20, 26, 20, 1, -26 },
  { 2729, 20, 26, 20, 3, -26 },
  { 2794, 25, 26, 26, 3, -26 },
  { 2876, 24, 26, 20, -2, -26 },
  { 2954, 19, 26, 19, 3, -26 },
  { 3016, 21, 26, 19, -1, -26 },
  { 3085, 13, 36, 9, -1, -30 },
  { 3144, 9, 28, 13, 3, -26 },
  { 3176, 13, 36, 9, -2, -30 },
  { 3235, 13, 13, 14, 1, -26 },
  { 3257, 14, 4, 14, -2, 0 },
  { 3264, 8, 5, 12, 4, -27 },
  { 3269, 15, 19, 16, 0, -19 },
  { 3305, 16, 27, 17, 0, -27 },
  { 3359, 16, 19, 16, 0, -19 },
  { 3397, 19, 27, 17, 0, -27 },
  { 3462, 15, 19, 17, 1, -19 },
  { 3498, 13, 27, 12, 1, -27 },
  { 3542, 18, 26, 18, 0, -19 },
  { 3601, 17, 27, 17, -1, -27 },
  { 3659, 10, 27, 9, 0, -27 },
  { 3693, 14, 34, 9, -4, -27 },
  { 3753, 19, 27, 17, 0, -27 },
  { 3818, 10, 27, 9, 0, -27 },
  { 3852, 24, 19, 26, 0, -19 },
  { 3909, 16, 19, 17, 0, -19 },
  { 3947, 16, 19, 17, 0, -19 },
  { 3985, 18, 26, 17, -2, -19 },
  { 4044, 17, 26, 17, 0, -19 },
  { 4100, 13, 19, 12, 0, -19 },
  { 4131, 15, 19, 16, 0, -19 },
  { 4167, 11, 24, 11, 1, -24 },
  { 4200, 16, 19, 17, 1, -19 },
  { 4238, 15, 19, 16, 2, -19 },
  { 4274, 21, 19, 22, 2, -19 },
  { 4324, 18, 19, 16, -1, -19 },
  { 4367, 19, 26, 16, -1, -19 },
  { 4429, 17, 19, 16, -1, -19 },
  { 4470, 11, 34, 10, 1, -28 },
  { 4517, 7, 31, 9, 1, -26 },
  { 4545, 11, 34, 10, -1, -28 },
  { 4592, 17, 8, 19, 1, -14 },
};

const GFXfont RobotoCondensed_BlackItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_BLACKITALIC36PT7B_H_
