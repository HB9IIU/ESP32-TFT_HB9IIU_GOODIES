#ifndef _ROBOTOCONDENSED_BLACKITALIC51PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x3F, 0x1F, 0x3F,
  0x3F, 0x3E, 0x3F, 0x3E, 0x3F, 0x3E, 0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C,
  0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x78, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x03, 0xC7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFD, 0xFE, 0x0F, 0xF8,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x07,
  0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x83, 0xE3, 0xE0, 0xF1, 0xF1,
  0xF0, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x7C, 0x7E, 0x3E, 0x7C, 0x3F,
  0x1F, 0x7C, 0x0F, 0x9F, 0xBE, 0x07, 0xFF, 0xBE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xBF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xDF, 0xFE, 0x07, 0xDF, 0x9F, 0x03, 0xEF,
  0x8F, 0x83, 0xE7, 0xC7, 0xC3, 0xE3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF1, 0xF0,
  0xF8, 0xF9, 0xF0, 0x7C, 0x7C, 0x70, 0x3F, 0xFE, 0x08, 0x1F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x3F, 0x87, 0xFF, 0xC7, 0xF1, 0xFF, 0xF8, 0xFC, 0x7F, 0xFF, 0xBF, 0x8F,
  0xFF, 0xF7, 0xF3, 0xFC, 0xFF, 0xFE, 0x7F, 0x9F, 0xFF, 0x8F, 0xF1, 0xFF,
  0xF1, 0xFE, 0x3F, 0xFE, 0x3F, 0xC3, 0xFF, 0x87, 0xF8, 0x7F, 0xF0, 0xFF,
  0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x06,
  0x00, 0x00, 0x1F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x0E,
  0x0F, 0x87, 0x1F, 0x1E, 0x3E, 0x7F, 0xBF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xEF, 0x80, 0x1F, 0xCF, 0x80, 0x7F, 0x1F, 0x01, 0xFC, 0x1F,
  0x00, 0xF0, 0x3E, 0x00, 0xC0, 0x78, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0x7C, 0x01, 0x80, 0x3F, 0xFD,
  0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0x80, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x0F, 0xF0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE3,
  0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F,
  0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0,
  0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07,
  0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE,
  0x0F, 0xF7, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x1F, 0xC0, 0x7F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x1E, 0x7F, 0x98, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF7, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0xE1,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xF7, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x7F, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xF7, 0xF8, 0x07, 0xE7, 0xF8,
  0x0F, 0xE7, 0xF8, 0x0F, 0xC7, 0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0x8F, 0xF0,
  0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xDF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0x87, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xCF, 0x80,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xEF, 0xFC, 0xFF, 0xBF, 0xE1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F,
  0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xF8, 0x1F, 0xEF,
  0xE0, 0x7F, 0xBF, 0xC3, 0xFE, 0xFF, 0x0F, 0xF1, 0xFE, 0xFF, 0xC7, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F,
  0xF1, 0xFE, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x87, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F,
  0xDF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xBF, 0xE7, 0xF8, 0xFF, 0x7F, 0x87, 0xFB, 0xFC, 0x1F, 0xDF, 0xE0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0x7F, 0x87, 0xFB, 0xFC, 0x7F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFB, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x83, 0xFC,
  0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x07, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC1,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xDF,
  0xF7, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00,
  0x3C, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1E, 0x03, 0xF0,
  0x1F, 0x01, 0xE0, 0x7E, 0x07, 0xFC, 0x1F, 0x07, 0xC1, 0xFF, 0xF1, 0xF0,
  0xFC, 0x3F, 0xFF, 0x0F, 0x0F, 0x83, 0xFF, 0xF0, 0xF1, 0xF8, 0x7E, 0x3F,
  0x0F, 0x1F, 0x0F, 0xC3, 0xF0, 0xF3, 0xF0, 0xFC, 0x3E, 0x0F, 0x3E, 0x1F,
  0x83, 0xE1, 0xF3, 0xE1, 0xF8, 0x7E, 0x1F, 0x3E, 0x1F, 0x87, 0xE1, 0xF7,
  0xE3, 0xF0, 0x7C, 0x1F, 0x7C, 0x3F, 0x07, 0xC1, 0xF7, 0xC3, 0xF0, 0xFC,
  0x1E, 0x7C, 0x3F, 0x0F, 0xC1, 0xE7, 0xC3, 0xF0, 0xF8, 0x3E, 0x7C, 0x7E,
  0x0F, 0x83, 0xEF, 0xC7, 0xE1, 0xF8, 0x3C, 0xFC, 0x7E, 0x1F, 0x87, 0xCF,
  0xC3, 0xE1, 0xF8, 0x78, 0xFC, 0x3F, 0x3F, 0x8F, 0x87, 0xC3, 0xFF, 0xFF,
  0xF0, 0x7C, 0x3F, 0xFF, 0xFE, 0x07, 0xC1, 0xFE, 0x7F, 0xC0, 0x7C, 0x0F,
  0xC3, 0xF8, 0x07, 0xC0, 0x20, 0x0C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFE,
  0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83,
  0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0xC0,
  0x7F, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xE0,
  0x0F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xC3, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFC,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0,
  0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC1, 0xFE, 0x1F, 0xF0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x80,
  0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFF,
  0xFB, 0xFE, 0x1F, 0xFF, 0x7F, 0xC3, 0xFF, 0xEF, 0xF8, 0x7F, 0xF9, 0xFE,
  0x0F, 0xFF, 0x3F, 0xC1, 0xFF, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF,
  0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xF8,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF8,
  0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x80,
  0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x03,
  0xFC, 0x0F, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x07,
  0xFC, 0x1F, 0xF8, 0x07, 0xF8, 0x3F, 0xF0, 0x07, 0xF8, 0x7F, 0xE0, 0x07,
  0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x80, 0x0F,
  0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFD, 0xF0,
  0x7F, 0xFE, 0x03, 0xFB, 0xE0, 0xFD, 0xFC, 0x0F, 0xF7, 0xE1, 0xFF, 0xF8,
  0x1F, 0xEF, 0xC7, 0xFF, 0xF0, 0x3F, 0xDF, 0x8F, 0xDF, 0xE0, 0x7F, 0xBF,
  0x1F, 0xBF, 0xC0, 0xFF, 0x7E, 0x7E, 0xFF, 0x03, 0xFC, 0xFC, 0xFD, 0xFE,
  0x07, 0xF9, 0xFB, 0xF3, 0xFC, 0x0F, 0xF3, 0xF7, 0xE7, 0xF8, 0x1F, 0xE7,
  0xEF, 0xCF, 0xF0, 0x3F, 0xC7, 0xFF, 0x3F, 0xE0, 0x7F, 0x8F, 0xFE, 0x7F,
  0x81, 0xFF, 0x1F, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xF1, 0xFE, 0x07, 0xF8,
  0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0x1F, 0xE1, 0xFE, 0x1F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x7F, 0x81, 0xFF,
  0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xC3, 0xFE, 0x07, 0xF8, 0x3F, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8,
  0x07, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0,
  0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0x03,
  0xFC, 0x1F, 0xFE, 0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0x7F, 0xFC, 0x3F,
  0xC0, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xE1, 0xFE,
  0x0F, 0xFB, 0xE7, 0xFC, 0x1F, 0xF7, 0xCF, 0xF8, 0x3F, 0xCF, 0x9F, 0xE0,
  0x7F, 0x9F, 0x3F, 0xC0, 0xFF, 0x3E, 0x7F, 0x83, 0xFE, 0x3E, 0xFF, 0x07,
  0xFC, 0x7F, 0xFE, 0x0F, 0xF0, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0xF0, 0x3F,
  0xC1, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0x83, 0xFE,
  0x0F, 0xFF, 0x07, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1,
  0xFE, 0x1F, 0xF0, 0x3F, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F,
  0xE0, 0x0F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x07,
  0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F,
  0xBF, 0xC0, 0x1F, 0xF7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0,
  0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01,
  0xFF, 0x0F, 0xF0, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFE, 0x1F, 0xF0, 0x3F,
  0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF7, 0xFC,
  0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xF7,
  0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFF,
  0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xFC, 0x03,
  0xFC, 0x7F, 0xC0, 0x7F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x83,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0xFF,
  0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03, 0xFC,
  0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80,
  0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE,
  0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x3F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80,
  0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0x7F,
  0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0x87, 0xF8, 0x03,
  0xF8, 0xFF, 0x80, 0x3F, 0x8F, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xDF,
  0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xEF,
  0xF0, 0x7F, 0x83, 0xFD, 0xFE, 0x1F, 0xF0, 0xFF, 0xBF, 0xC3, 0xFE, 0x1F,
  0xE7, 0xF8, 0x7F, 0xC3, 0xFC, 0xFF, 0x1F, 0xF8, 0xFF, 0x9F, 0xE3, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0xE3, 0xFC, 0x7F, 0x9F, 0xFC, 0x7F, 0x8F, 0xF3,
  0xFF, 0x9F, 0xE1, 0xFE, 0x7F, 0xF3, 0xFC, 0x3F, 0xDF, 0xFE, 0x7F, 0x87,
  0xFB, 0xFF, 0xDF, 0xE0, 0xFF, 0x7F, 0xFB, 0xFC, 0x1F, 0xFF, 0xFF, 0x7F,
  0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xDF,
  0xFF, 0x81, 0xFF, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0x7F, 0xFC, 0x07, 0xFF,
  0xCF, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFC, 0x03,
  0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFC,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0xE0, 0x03, 0xFC, 0x3F,
  0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xDF,
  0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0,
  0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x3F,
  0xC0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xE0, 0x7F,
  0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF,
  0x1F, 0xE0, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0xFC,
  0xF8, 0x3F, 0x3E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F,
  0x7E, 0x07, 0xDF, 0x81, 0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x3F,
  0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0x8F, 0xF3, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF,
  0x3F, 0xC3, 0xFC, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0x3F, 0x80, 0xF8, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xBF, 0x00, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x3F, 0xF7, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x1F, 0xE7,
  0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F,
  0x83, 0xFC, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0,
  0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xF7, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xE7, 0xFC, 0x1F, 0xC7, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xBF, 0xCF, 0xF0, 0xFF, 0x7F, 0x83,
  0xFB, 0xFC, 0x3F, 0xDF, 0xC1, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x7F,
  0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0xCF, 0xFB, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x3F,
  0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xF7, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE3, 0xFE, 0x7F, 0x8F, 0xF0, 0xFF, 0x7F, 0x83, 0xFD,
  0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x60, 0x7F, 0xEF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7E, 0x1F, 0xC0, 0x7F, 0xEF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x9F, 0xF8, 0x7F, 0xC1,
  0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x04, 0x03, 0xFE,
  0x01, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF9, 0xF0,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0xFF, 0x1F, 0xF8, 0x1F, 0xE3, 0xFE,
  0x03, 0xFC, 0xFF, 0xC0, 0x7F, 0x3F, 0xF0, 0x1F, 0xE7, 0xFC, 0x03, 0xFD,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xE7, 0xFC, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F,
  0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF3,
  0xF0, 0x3E, 0x01, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0xF7, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x8F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x7F, 0x87, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF1, 0xF0,
  0x07, 0xF7, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x3F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFE,
  0x7F, 0x8F, 0xF0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC3,
  0xFC, 0xFF, 0x9F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFD, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8,
  0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F,
  0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xEF, 0xF8, 0x0F, 0xF3, 0xF0, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x0F, 0xF9, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFB,
  0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xFB, 0xFC, 0x0F,
  0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE,
  0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7,
  0xF8, 0x7F, 0x8F, 0xFB, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3E, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF3, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFC, 0x3F,
  0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC,
  0xFE, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC7, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80,
  0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xE0, 0x0F, 0x80, 0x00, 0xFF, 0x83, 0xFD,
  0xFE, 0x1F, 0xF7, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE7, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F,
  0x07, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x1F, 0x87, 0xFF, 0xF0, 0xFC, 0x3F, 0xFF, 0x87, 0xE1, 0xFD, 0xFC,
  0x7F, 0x0F, 0xEF, 0xE3, 0xF8, 0xFF, 0x7F, 0x1F, 0xC7, 0xF3, 0xF9, 0xFE,
  0x3F, 0x9F, 0xCF, 0xF3, 0xFC, 0xFE, 0xFF, 0x9F, 0xC7, 0xF7, 0xFC, 0xFE,
  0x3F, 0xBF, 0xF7, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFB, 0xFF, 0xC3, 0xFF, 0xDF, 0xFC, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xE7,
  0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F, 0x8F, 0xF8,
  0x0F, 0xE3, 0xFC, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x07, 0xF9,
  0xFE, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0xC3, 0xF8, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F,
  0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFF, 0x03, 0xFC,
  0x7F, 0x80, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03,
  0xFD, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x60, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0xFC, 0xFF, 0xC1, 0xF9, 0xFF,
  0xC3, 0xF7, 0xFF, 0x87, 0xEF, 0xFF, 0xFF, 0xBF, 0xBF, 0xFF, 0x7E, 0x3F,
  0xFE, 0xFC, 0x3F, 0xF9, 0xF0, 0x3F, 0xE3, 0xE0, 0x3F, 0xC0, 0x00, 0x3E,
  0x00,
};

const GFXglyph RobotoCondensed_BlackItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 36, 13, 0, -36 },
  { 69, 16, 14, 16, 2, -38 },
  { 97, 26, 36, 25, 0, -36 },
  { 214, 24, 46, 25, 1, -41 },
  { 352, 25, 36, 32, 4, -36 },
  { 465, 27, 37, 30, 0, -36 },
  { 590, 9, 14, 8, 2, -38 },
  { 606, 16, 51, 16, 2, -40 },
  { 708, 16, 51, 16, -2, -40 },
  { 810, 23, 22, 23, 2, -36 },
  { 874, 22, 26, 23, 1, -29 },
  { 946, 12, 16, 13, -3, -6 },
  { 970, 14, 7, 21, 3, -19 },
  { 983, 9, 8, 15, 1, -8 },
  { 992, 23, 39, 15, -4, -36 },
  { 1105, 23, 36, 25, 2, -36 },
  { 1209, 17, 36, 25, 5, -36 },
  { 1286, 25, 36, 25, 0, -36 },
  { 1399, 25, 36, 25, 0, -36 },
  { 1512, 24, 36, 25, 1, -36 },
  { 1620, 24, 36, 25, 1, -36 },
  { 1728, 22, 36, 25, 2, -36 },
  { 1827, 25, 36, 25, 2, -36 },
  { 1940, 24, 36, 25, 1, -36 },
  { 2048, 21, 36, 25, 3, -36 },
  { 2143, 13, 28, 15, 1, -28 },
  { 2189, 15, 38, 14, -2, -28 },
  { 2261, 21, 25, 22, 1, -28 },
  { 2327, 22, 16, 26, 2, -24 },
  { 2371, 20, 24, 22, 1, -27 },
  { 2431, 20, 36, 23, 3, -36 },
  { 2521, 36, 46, 38, 0, -35 },
  { 2728, 29, 36, 30, -2, -36 },
  { 2859, 28, 36, 28, 0, -36 },
  { 2985, 27, 36, 28, 2, -36 },
  { 3107, 27, 36, 28, 0, -36 },
  { 3229, 27, 36, 24, 0, -36 },
  { 3351, 26, 36, 23, 0, -36 },
  { 3468, 27, 36, 29, 2, -36 },
  { 3590, 32, 36, 30, 0, -36 },
  { 3734, 15, 36, 14, 0, -36 },
  { 3802, 26, 36, 24, 0, -36 },
  { 3919, 32, 36, 28, 0, -36 },
  { 4063, 21, 36, 24, 0, -36 },
  { 4158, 39, 36, 38, 0, -36 },
  { 4334, 31, 36, 30, 0, -36 },
  { 4474, 27, 36, 30, 2, -36 },
  { 4596, 28, 36, 28, 0, -36 },
  { 4722, 27, 43, 30, 2, -36 },
  { 4868, 28, 36, 28, 0, -36 },
  { 4994, 27, 36, 27, 1, -36 },
  { 5116, 26, 36, 27, 4, -36 },
  { 5233, 29, 36, 29, 1, -36 },
  { 5364, 28, 36, 29, 4, -36 },
  { 5490, 35, 36, 37, 4, -36 },
  { 5648, 33, 36, 28, -2, -36 },
  { 5797, 27, 36, 27, 4, -36 },
  { 5919, 30, 36, 26, -1, -36 },
  { 6054, 18, 51, 13, -1, -42 },
  { 6169, 13, 39, 19, 4, -36 },
  { 6233, 18, 51, 13, -3, -42 },
  { 6348, 18, 18, 20, 1, -36 },
  { 6389, 19, 6, 20, -3, 0 },
  { 6404, 12, 8, 17, 5, -38 },
  { 6416, 22, 27, 23, 0, -27 },
  { 6491, 23, 38, 24, 0, -38 },
  { 6601, 21, 27, 23, 1, -27 },
  { 6672, 25, 38, 24, 1, -38 },
  { 6791, 22, 27, 24, 1, -27 },
  { 6866, 19, 39, 16, 1, -39 },
  { 6959, 26, 37, 25, -1, -27 },
  { 7080, 24, 38, 25, -1, -38 },
  { 7194, 14, 38, 13, 0, -38 },
  { 7261, 20, 48, 13, -6, -38 },
  { 7381, 27, 38, 24, 0, -38 },
  { 7510, 15, 38, 13, 0, -38 },
  { 7582, 35, 27, 36, 0, -27 },
  { 7701, 24, 27, 25, -1, -27 },
  { 7782, 22, 27, 24, 1, -27 },
  { 7857, 25, 37, 24, -2, -27 },
  { 7973, 23, 37, 24, 1, -27 },
  { 8080, 18, 27, 17, 0, -27 },
  { 8141, 22, 27, 22, 0, -27 },
  { 8216, 15, 34, 15, 2, -34 },
  { 8280, 24, 27, 25, 1, -27 },
  { 8361, 22, 27, 23, 2, -27 },
  { 8436, 29, 27, 31, 3, -27 },
  { 8534, 26, 27, 23, -2, -27 },
  { 8622, 26, 37, 23, -1, -27 },
  { 8743, 24, 27, 23, -1, -27 },
  { 8824, 15, 49, 15, 1, -40 },
  { 8916, 11, 43, 13, 1, -36 },
  { 8976, 16, 49, 15, -2, -40 },
  { 9074, 23, 12, 27, 2, -21 },
};

const GFXfont RobotoCondensed_BlackItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_BLACKITALIC51PT7B_H_
