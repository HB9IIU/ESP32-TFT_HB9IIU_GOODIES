#ifndef _ROBOTOCONDENSED_BLACKITALIC45PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xF8, 0x07, 0x80, 0x3E, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F,
  0x7C, 0x79, 0xF3, 0xE7, 0x8F, 0x9E, 0x3E, 0xF8, 0xF3, 0xE3, 0xCF, 0x0F,
  0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0xF3, 0xE0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0xF9, 0xE0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC0, 0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0xC0,
  0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x7C, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x07, 0x9E, 0x00, 0x1F,
  0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x80, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x0F, 0xF1, 0xFC, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0x9F, 0x0E, 0x7C,
  0x78, 0x7B, 0xE3, 0xC7, 0xDF, 0x1E, 0x7C, 0xF1, 0xF3, 0xC7, 0x8F, 0xBC,
  0x3E, 0x7F, 0xE1, 0xFF, 0xDE, 0x07, 0xFD, 0xE0, 0x1F, 0xFF, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x7F, 0xF8,
  0x07, 0xBF, 0xE0, 0x7F, 0xFF, 0x87, 0xDE, 0x3C, 0x3D, 0xF1, 0xE3, 0xEF,
  0x8F, 0x3E, 0x7C, 0x79, 0xE3, 0xC7, 0xDE, 0x1E, 0x3E, 0xF0, 0xF9, 0xF1,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE3,
  0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC,
  0x3F, 0x1F, 0xFE, 0x3E, 0x3F, 0xFE, 0x7E, 0x3F, 0xFF, 0x7E, 0x7F, 0x7F,
  0xFE, 0x7F, 0x3F, 0xFC, 0x7F, 0x3F, 0xFC, 0xFF, 0x1F, 0xFC, 0xFF, 0x1F,
  0xF8, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFD, 0xFC, 0x07, 0xF1, 0xFE, 0x3E, 0x7C,
  0xF9, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x80, 0x00, 0x08,
  0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0x80, 0x02, 0x00, 0x01, 0x00, 0x03, 0x80, 0x07, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x03, 0x80, 0x04, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x02, 0x07, 0x82, 0x78, 0x79, 0xE7,
  0xF7, 0x7E, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xBC, 0x03, 0xF3, 0xE0, 0x7E, 0x1E,
  0x03, 0xC1, 0xF0, 0x18, 0x0E, 0x00, 0x80, 0x80, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0,
  0xFC, 0x3F, 0x1F, 0x8F, 0xC3, 0xF0, 0xF8, 0x0C, 0x00, 0x7F, 0xF7, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7E, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xC7, 0xE3,
  0xF8, 0x7E, 0x3F, 0x87, 0xE3, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1,
  0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x1F, 0xC3, 0xFF, 0x7F, 0xF9, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0x8F, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xFC, 0x7F,
  0x0F, 0xF1, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0xDF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x81, 0xFC, 0xFF, 0x0F, 0xF1, 0xFC,
  0x7F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xEF, 0xE0, 0x3F, 0x7F, 0x03, 0xF3, 0xF8,
  0x1F, 0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0x8F, 0xF0, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x7C, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0x1F, 0xE0, 0x10, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC3, 0xFC, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF9, 0xF0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xF8, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xE0,
  0x7F, 0x7E, 0x0F, 0xF7, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7, 0xF1, 0xFE, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x8F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0xC7, 0xF1, 0xFC, 0x1F,
  0x8F, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xE7, 0xF0, 0xFE, 0x1F, 0x87, 0xF0,
  0xFC, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF8, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xC7, 0xF3, 0xF8,
  0x7E, 0x7F, 0x0F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7F, 0x0F, 0xEF, 0xE1,
  0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFF, 0x7F, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x0F, 0xE1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7E, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE1,
  0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x04, 0x00, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF8, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F,
  0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFE, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x1E, 0x07, 0xC0, 0xFC, 0x1E, 0x0F, 0x83, 0xFE, 0x0F, 0x0F,
  0x87, 0xFF, 0x8F, 0x1F, 0x0F, 0xFF, 0x8F, 0x1F, 0x0F, 0xCF, 0x8F, 0x1E,
  0x1F, 0x0F, 0x0F, 0x3E, 0x3F, 0x1F, 0x0F, 0x3E, 0x3E, 0x1F, 0x0F, 0x3C,
  0x3E, 0x1F, 0x0F, 0x7C, 0x7C, 0x1E, 0x1F, 0x7C, 0x7C, 0x3E, 0x1F, 0x7C,
  0x7C, 0x3E, 0x1E, 0x78, 0x7C, 0x3E, 0x1E, 0x78, 0xFC, 0x3C, 0x1E, 0x78,
  0xFC, 0x7C, 0x3C, 0xF8, 0xF8, 0x7C, 0x3C, 0xF8, 0xFC, 0x7C, 0x7C, 0xF8,
  0x7C, 0xFC, 0x78, 0xF8, 0x7F, 0xFF, 0xF0, 0x78, 0x7F, 0xBF, 0xF0, 0x78,
  0x3F, 0xBF, 0xE0, 0x78, 0x1E, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE7, 0xF0,
  0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3,
  0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x0F,
  0xEF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x07,
  0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x87,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0,
  0xFF, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x0F,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE,
  0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x0F, 0xFE, 0xFF, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC,
  0xFE, 0x1F, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFE,
  0x7F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x7F,
  0x03, 0xFE, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0x07, 0xFC, 0x07, 0xF0, 0xFF,
  0x80, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F,
  0xE7, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFE, 0xFE, 0x00,
  0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0,
  0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0xE1, 0xF7, 0xF0, 0x7F, 0xFC, 0xFD, 0xFC, 0x3F,
  0x9F, 0x3F, 0xFE, 0x0F, 0xE7, 0xCF, 0xBF, 0x83, 0xF9, 0xF7, 0xEF, 0xE0,
  0xFE, 0x7D, 0xF3, 0xF8, 0x3F, 0x9F, 0x7C, 0xFE, 0x0F, 0xE7, 0xFE, 0x7F,
  0x87, 0xF9, 0xFF, 0x9F, 0xC1, 0xFE, 0x7F, 0xE7, 0xF0, 0x7F, 0x1F, 0xF1,
  0xFC, 0x1F, 0xC7, 0xFC, 0xFF, 0x07, 0xF1, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F,
  0x8F, 0xF0, 0xFF, 0x0F, 0xC3, 0xF8, 0x3F, 0xC3, 0xF0, 0xFE, 0x0F, 0xE0,
  0xF8, 0x3F, 0x83, 0xF8, 0x3E, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xFC, 0x0F,
  0xE0, 0xFF, 0xC1, 0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0xFF, 0xC1, 0xFC, 0x0F,
  0xFC, 0x1F, 0xC0, 0xFF, 0xE1, 0xFC, 0x0F, 0xFE, 0x1F, 0xC1, 0xFF, 0xE3,
  0xFC, 0x1F, 0xFE, 0x3F, 0xC1, 0xFD, 0xE3, 0xF8, 0x1F, 0xDF, 0x3F, 0x81,
  0xFD, 0xF3, 0xF8, 0x3F, 0xCF, 0x3F, 0x83, 0xFC, 0xF7, 0xF8, 0x3F, 0xCF,
  0xFF, 0x83, 0xF8, 0xFF, 0xF0, 0x3F, 0x87, 0xFF, 0x03, 0xF8, 0x7F, 0xF0,
  0x7F, 0x87, 0xFF, 0x07, 0xF8, 0x7F, 0xF0, 0x7F, 0x07, 0xFE, 0x07, 0xF0,
  0x3F, 0xE0, 0x7F, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFE,
  0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF0, 0x0F,
  0xF3, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFC, 0xFF, 0x00,
  0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0,
  0x1F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0xFE,
  0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC1,
  0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F,
  0x07, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F,
  0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF9,
  0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x7F,
  0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x03,
  0xFC, 0x3F, 0xC3, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE,
  0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01,
  0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x3F, 0x87, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x87, 0xFC, 0x7F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xC0,
  0xFF, 0x3F, 0x81, 0xFE, 0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xF1, 0xFE, 0x1F,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x81, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x7F, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE3, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xDF, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F,
  0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1,
  0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xFB, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x0F,
  0xC1, 0xFF, 0xFC, 0x3F, 0x83, 0xFB, 0xF8, 0x7F, 0x07, 0xF7, 0xF0, 0xFE,
  0x1F, 0xEF, 0xE3, 0xFC, 0x3F, 0x9F, 0xC7, 0xF8, 0x7F, 0x3F, 0x8F, 0xF1,
  0xFE, 0x7F, 0x3F, 0xE3, 0xF8, 0xFE, 0x7F, 0xC7, 0xF1, 0xFC, 0xFF, 0x8F,
  0xE3, 0xFB, 0xFF, 0x3F, 0x87, 0xF7, 0xFE, 0x7F, 0x0F, 0xEF, 0xFC, 0xFE,
  0x1F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xEF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xBF, 0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F,
  0xF9, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF,
  0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC3, 0xFE, 0x00, 0xFF, 0x1F, 0xE0,
  0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0,
  0x07, 0xFC, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F,
  0x8F, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0,
  0x7E, 0x3F, 0x80, 0xFC, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xBE, 0x1F, 0xBE, 0x1F, 0x1E, 0x3F, 0x1E, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C,
  0x1F, 0xFC, 0x1F, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0x9F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0x00, 0x0F, 0xE0,
  0x3F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0x3F, 0xBF,
  0xC7, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC7, 0xF3, 0xF9, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xEF, 0xE0, 0xF9, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xFB, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xFE, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFE, 0x1F,
  0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFC,
  0xFF, 0x07, 0xE3, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xF0, 0xFD, 0xFC, 0x3F, 0x7E,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0xFC, 0x3F, 0xBF, 0x8F, 0xEF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x3E, 0x7F, 0x03, 0xFD, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1,
  0xFC, 0x3F, 0x8F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7C, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF,
  0xE3, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x7E, 0x07, 0xFD, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xF7, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x40, 0x7F, 0x01, 0xF3, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFD, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE,
  0x1F, 0xE7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7F, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE7, 0xF8, 0x7F, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x8F, 0xF8, 0x7F, 0x3F, 0xE1, 0xFC, 0x7F, 0x83, 0xF9, 0xFE, 0x07, 0xF7,
  0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0xFE, 0x03,
  0xF9, 0xFC, 0x07, 0xF3, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xCF, 0x81, 0xF0, 0x1F, 0xBF, 0xCF, 0xF0,
  0x7F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x87, 0xF1, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F,
  0x87, 0xF1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xCF, 0xF1, 0xFC, 0x3F, 0x9F, 0xC3,
  0xF8, 0xFF, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC,
  0x7F, 0x9F, 0xC3, 0xF8, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE7, 0xC0, 0x7F, 0x7F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x9F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F,
  0x9F, 0xC3, 0xFC, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC,
  0x3F, 0x9F, 0xE1, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF, 0xE3, 0xFB, 0xF8, 0x7F, 0x7F,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7E, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0x80, 0x03, 0xF3, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x7F, 0x07, 0xF8, 0x7E,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0xCF, 0x80, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE3, 0xF0, 0x7F, 0x9F, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE, 0x0F, 0xE7,
  0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0xC7, 0xF1, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xEF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xCF, 0x1F, 0xDF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x7F, 0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0xFC, 0x1F, 0x9F, 0x87, 0xF3, 0xF8, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x87, 0xFF,
  0xDF, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x87, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0xC3, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xE7, 0xF0, 0xFE, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0x7F, 0x0F, 0xE7, 0xE3, 0xFC, 0xFC, 0x7F, 0x1F, 0x8F,
  0xE3, 0xF3, 0xF8, 0x7E, 0x7F, 0x0F, 0xCF, 0xE1, 0xFB, 0xF8, 0x3F, 0x7F,
  0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7E, 0x1F, 0x0F, 0xCF, 0xC7, 0xE3, 0xF9,
  0xF8, 0xFC, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF8, 0xFC, 0xFE,
  0x7F, 0x1F, 0xBF, 0xCF, 0xC3, 0xF7, 0xF9, 0xF8, 0x7E, 0xFF, 0x7F, 0x0F,
  0xFF, 0xEF, 0xC1, 0xF7, 0xFD, 0xF8, 0x3E, 0xFF, 0xFF, 0x07, 0xFE, 0xFF,
  0xC0, 0xFF, 0xDF, 0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F,
  0xCF, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xBF, 0x00, 0xFE, 0x7E, 0x03,
  0xFC, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0x1F,
  0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFE,
  0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xEF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x00, 0x18, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7C,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1E, 0x00, 0x70, 0x01, 0x80, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x0F,
  0xE0, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x03, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x30, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0x07, 0xCF, 0xFC, 0x3E, 0x7F, 0xF3, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF9, 0xF1, 0xFF, 0xCF, 0x87, 0xFC, 0xF8, 0x1F, 0xC0, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 32, 12, 0, -32 },
  { 53, 14, 12, 14, 2, -34 },
  { 74, 23, 32, 22, 0, -32 },
  { 166, 21, 41, 22, 1, -37 },
  { 274, 21, 32, 28, 4, -32 },
  { 358, 24, 32, 26, 0, -32 },
  { 454, 7, 13, 7, 2, -34 },
  { 466, 14, 45, 14, 2, -35 },
  { 545, 15, 45, 14, -2, -35 },
  { 630, 20, 20, 20, 2, -32 },
  { 680, 19, 23, 20, 1, -26 },
  { 735, 10, 14, 12, -2, -6 },
  { 753, 12, 6, 18, 3, -17 },
  { 762, 8, 8, 13, 1, -8 },
  { 770, 20, 35, 13, -3, -32 },
  { 858, 20, 32, 22, 2, -32 },
  { 938, 14, 32, 22, 5, -32 },
  { 994, 22, 32, 22, 0, -32 },
  { 1082, 22, 32, 22, 0, -32 },
  { 1170, 21, 32, 22, 1, -32 },
  { 1254, 21, 32, 22, 1, -32 },
  { 1338, 20, 32, 22, 1, -32 },
  { 1418, 22, 32, 22, 1, -32 },
  { 1506, 21, 32, 22, 1, -32 },
  { 1590, 19, 32, 22, 3, -32 },
  { 1666, 11, 26, 13, 1, -26 },
  { 1702, 14, 34, 12, -2, -26 },
  { 1762, 18, 21, 20, 1, -24 },
  { 1810, 20, 16, 23, 1, -22 },
  { 1850, 19, 22, 20, 0, -24 },
  { 1903, 17, 32, 20, 3, -32 },
  { 1971, 32, 41, 33, 0, -31 },
  { 2135, 26, 32, 26, -2, -32 },
  { 2239, 24, 32, 25, 0, -32 },
  { 2335, 24, 32, 25, 1, -32 },
  { 2431, 24, 32, 25, 0, -32 },
  { 2527, 24, 32, 21, 0, -32 },
  { 2623, 23, 32, 21, 0, -32 },
  { 2715, 24, 32, 26, 2, -32 },
  { 2811, 28, 32, 27, 0, -32 },
  { 2923, 13, 32, 12, 0, -32 },
  { 2975, 23, 32, 22, 0, -32 },
  { 3067, 28, 32, 24, 0, -32 },
  { 3179, 19, 32, 21, 0, -32 },
  { 3255, 34, 32, 33, 0, -32 },
  { 3391, 28, 32, 27, 0, -32 },
  { 3503, 25, 32, 26, 1, -32 },
  { 3603, 25, 32, 25, 0, -32 },
  { 3703, 25, 38, 26, 1, -32 },
  { 3822, 25, 32, 25, 0, -32 },
  { 3922, 23, 32, 24, 1, -32 },
  { 4014, 23, 32, 24, 3, -32 },
  { 4106, 25, 32, 25, 1, -32 },
  { 4206, 25, 32, 26, 3, -32 },
  { 4306, 31, 32, 32, 4, -32 },
  { 4430, 29, 32, 25, -2, -32 },
  { 4546, 23, 32, 24, 4, -32 },
  { 4638, 26, 32, 23, -1, -32 },
  { 4742, 16, 45, 12, -1, -37 },
  { 4832, 12, 35, 17, 3, -32 },
  { 4885, 16, 45, 12, -3, -37 },
  { 4975, 16, 16, 17, 1, -32 },
  { 5007, 18, 6, 17, -3, 0 },
  { 5021, 10, 7, 15, 5, -34 },
  { 5030, 19, 24, 20, 0, -24 },
  { 5087, 21, 34, 22, 0, -34 },
  { 5177, 18, 24, 20, 1, -24 },
  { 5231, 22, 34, 22, 1, -34 },
  { 5325, 19, 24, 21, 1, -24 },
  { 5382, 16, 34, 14, 1, -34 },
  { 5450, 23, 33, 22, -1, -24 },
  { 5545, 21, 34, 22, -1, -34 },
  { 5635, 12, 34, 11, 0, -34 },
  { 5686, 17, 43, 11, -5, -34 },
  { 5778, 23, 34, 21, 0, -34 },
  { 5876, 13, 34, 11, 0, -34 },
  { 5932, 31, 24, 32, 0, -24 },
  { 6025, 21, 24, 22, -1, -24 },
  { 6088, 19, 24, 22, 1, -24 },
  { 6145, 23, 33, 22, -2, -24 },
  { 6240, 21, 33, 22, 1, -24 },
  { 6327, 16, 24, 15, 0, -24 },
  { 6375, 19, 24, 20, 0, -24 },
  { 6432, 14, 30, 14, 1, -30 },
  { 6485, 21, 24, 22, 1, -24 },
  { 6548, 19, 24, 20, 2, -24 },
  { 6605, 27, 24, 27, 2, -24 },
  { 6686, 23, 24, 20, -2, -24 },
  { 6755, 23, 33, 20, -1, -24 },
  { 6850, 21, 24, 20, -1, -24 },
  { 6913, 13, 43, 13, 1, -35 },
  { 6983, 10, 38, 11, 1, -32 },
  { 7031, 13, 43, 13, -1, -35 },
  { 7101, 21, 10, 24, 1, -18 },
};

const GFXfont RobotoCondensed_BlackItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_BLACKITALIC45PT7B_H_
