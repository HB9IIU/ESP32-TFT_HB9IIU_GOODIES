#ifndef _ROBOTOCONDENSED_BLACKITALIC46PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x0F, 0xF0,
  0x7F, 0x81, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x3E, 0x7C, 0x7C, 0xF9, 0xF9,
  0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3E, 0x3C, 0x7C, 0x78, 0xF9,
  0xF1, 0xF3, 0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x80, 0x0F,
  0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x01, 0xF3,
  0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x80, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x9F, 0x00,
  0x0F, 0x3C, 0x00, 0x3E, 0x78, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x0F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x3E,
  0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x3F,
  0xC7, 0xF0, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7C, 0xF0, 0x73, 0xE3, 0xC3, 0xEF, 0x8F, 0x0F, 0x3E, 0x3C,
  0x7C, 0xF8, 0xF3, 0xE3, 0xE7, 0xCF, 0x0F, 0x9F, 0x78, 0x3F, 0xFB, 0xE0,
  0x7F, 0xFF, 0x00, 0xFF, 0x78, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x7B, 0xFC, 0x03, 0xDF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFB, 0xE7, 0xC3, 0xCF, 0x1F, 0x1F, 0x7C, 0x7C,
  0xF9, 0xF1, 0xF3, 0xC7, 0xC7, 0xDF, 0x1F, 0x1E, 0x78, 0x7C, 0xF8, 0x40,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xE1,
  0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xF7, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0x0F, 0xFE, 0x3F, 0x1F, 0xFE, 0x3F, 0x3F, 0xFF, 0x7F, 0x7F, 0xFF,
  0xFE, 0x7F, 0x3F, 0xFE, 0x7F, 0x3F, 0xFE, 0x7F, 0x1F, 0xFC, 0xFF, 0x1F,
  0xFC, 0xFF, 0x0F, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFE, 0x07, 0xF1,
  0xFE, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0xF8, 0x00, 0x08, 0x00, 0x70, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x02, 0x07, 0x83, 0x3C, 0x78, 0xF7, 0xF7, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0xC0, 0x1F, 0xBE, 0x03, 0xF1, 0xE0, 0x7E, 0x1F, 0x03, 0xC1, 0xF0, 0x1C,
  0x0E, 0x00, 0x80, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xC0, 0x30, 0x00, 0x7F, 0xFB, 0xFF,
  0x9F, 0xFC, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x18, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0xC7, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x7F, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF,
  0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x78,
  0x07, 0xF0, 0x7F, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF9, 0xE7, 0xF2, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F,
  0x07, 0xF1, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x3F,
  0xC7, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC1, 0xFC, 0xFF,
  0x07, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3E, 0xFE, 0x03, 0xF7,
  0xF0, 0x3F, 0x7F, 0x81, 0xFB, 0xFC, 0x1F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F,
  0xC7, 0xF0, 0xFC, 0x3F, 0x87, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0x9F, 0xE0, 0x08, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x7F, 0x8F, 0xF1, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFD, 0xF0, 0x3F, 0xBF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xF8, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F,
  0xF7, 0xF0, 0xFE, 0x7F, 0x1F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0x1F,
  0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF3, 0xFC, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0xE3, 0xF3, 0xF8, 0x7F, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x1F, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC3, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x3F, 0x0F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0x7E, 0x07, 0x80, 0x00, 0x60, 0x07, 0xE0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00,
  0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xE0, 0x07, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x3E, 0x07, 0x81, 0xF0, 0x7F, 0xC3,
  0xC1, 0xF0, 0x7F, 0xF9, 0xE0, 0xF8, 0x7F, 0xF8, 0xF8, 0xF8, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x7C, 0x3E, 0x1F, 0x1F, 0x3E, 0x3F, 0x0F,
  0x0F, 0x9F, 0x1F, 0x0F, 0x87, 0xDF, 0x0F, 0x87, 0xC3, 0xEF, 0x8F, 0xC3,
  0xE1, 0xE7, 0xC7, 0xC1, 0xE0, 0xF3, 0xE3, 0xE1, 0xF0, 0x79, 0xE1, 0xF0,
  0xF8, 0x7C, 0xF0, 0xF8, 0x7C, 0x3C, 0xF8, 0x7C, 0x3E, 0x1E, 0x7C, 0x3E,
  0x3E, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x1F, 0x0F, 0x9F, 0x8F, 0x8F, 0x87,
  0xFF, 0xFF, 0x83, 0xC3, 0xFF, 0xFF, 0x81, 0xE0, 0xFE, 0x7F, 0x80, 0xF0,
  0x3E, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x01, 0x00, 0x00,
  0xFF, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF8,
  0xFC, 0x01, 0xFE, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0x83,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC,
  0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x1F,
  0xCF, 0xF0, 0x0F, 0xE7, 0xF8, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x0F, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0x81, 0xFE, 0x1F, 0xE1, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F,
  0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC3,
  0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xFC,
  0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07,
  0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF,
  0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xFE, 0xFF, 0x0F, 0xFE, 0xFF, 0x1F, 0xFE,
  0xFE, 0x1F, 0xFE, 0xFE, 0x1F, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC,
  0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x8F, 0xFC,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80,
  0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFC,
  0x1F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x3F,
  0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x3F,
  0xC1, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0x80, 0x7F, 0x0F,
  0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xC0,
  0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x3F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0x8F,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0,
  0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xBE, 0x1F, 0xFF, 0x07, 0xF7, 0xC7, 0xEF, 0xE0, 0xFE, 0xF8, 0xFF, 0xF8,
  0x1F, 0xDF, 0x1F, 0x7F, 0x07, 0xFB, 0xE7, 0xEF, 0xE0, 0xFE, 0x7C, 0xF9,
  0xFC, 0x1F, 0xCF, 0xBF, 0x7F, 0x83, 0xF9, 0xF7, 0xEF, 0xF0, 0x7F, 0x3E,
  0xF9, 0xFC, 0x0F, 0xE7, 0xFF, 0x3F, 0x83, 0xFC, 0xFF, 0xC7, 0xF0, 0x7F,
  0x9F, 0xF9, 0xFE, 0x0F, 0xF1, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0xC7, 0xF0,
  0x3F, 0x87, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC7,
  0xF8, 0x3F, 0xC3, 0xF0, 0xFF, 0x07, 0xF8, 0x7E, 0x1F, 0xE0, 0xFE, 0x0F,
  0x83, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0xC0, 0xFE,
  0x0F, 0xFC, 0x0F, 0xE0, 0xFF, 0xC0, 0xFE, 0x0F, 0xFE, 0x1F, 0xE0, 0xFF,
  0xE1, 0xFE, 0x0F, 0xFE, 0x1F, 0xE1, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x1F,
  0xC1, 0xFF, 0xF1, 0xFC, 0x1F, 0xDF, 0x3F, 0xC1, 0xFC, 0xF3, 0xFC, 0x1F,
  0xCF, 0x3F, 0xC3, 0xFC, 0xFB, 0xF8, 0x3F, 0xCF, 0xBF, 0x83, 0xFC, 0xFB,
  0xF8, 0x3F, 0x87, 0xFF, 0x83, 0xF8, 0x7F, 0xF8, 0x3F, 0x87, 0xFF, 0x87,
  0xF8, 0x7F, 0xF0, 0x7F, 0x83, 0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0x7F, 0x03,
  0xFF, 0x07, 0xF0, 0x3F, 0xF0, 0x7F, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF8, 0x07,
  0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00,
  0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0,
  0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF8, 0x7F, 0x07, 0xFC, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0x3F, 0x80,
  0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFF, 0x07,
  0xF8, 0xFF, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0xC3,
  0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x87, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x87, 0xF8,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF8,
  0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F,
  0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0,
  0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x1F, 0xE0,
  0x7F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8,
  0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F,
  0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F,
  0xC1, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xF0, 0xFF, 0x0F, 0xEF, 0xE1, 0xFE,
  0x1F, 0xDF, 0xC7, 0xFC, 0x7F, 0xBF, 0x8F, 0xF8, 0xFE, 0x7F, 0x1F, 0xF1,
  0xFC, 0xFE, 0x3F, 0xE7, 0xF9, 0xFC, 0xFF, 0xCF, 0xE3, 0xF9, 0xFF, 0x9F,
  0xC7, 0xF3, 0xFF, 0x3F, 0x8F, 0xEF, 0xFE, 0xFF, 0x1F, 0xDF, 0xFD, 0xFC,
  0x3F, 0xBF, 0xFB, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0xFC, 0x0F,
  0xFF, 0x7F, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F,
  0xF3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF,
  0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0x07, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFF,
  0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F, 0x80,
  0x03, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x3F, 0xE7, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0x80, 0x1F,
  0xE1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE,
  0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8,
  0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x9F, 0xE0,
  0x3F, 0x9F, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC, 0x0F, 0x9E,
  0x07, 0xCF, 0x07, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF9, 0xF8,
  0x7D, 0xF8, 0x3E, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0x83,
  0xF0, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFC, 0xFE, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x00, 0x0F,
  0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF9,
  0xFE, 0xFF, 0x1F, 0xCF, 0xF1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE3, 0xFC, 0xFF,
  0x7F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xBF, 0xC1,
  0xF1, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xDF, 0x01, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFE,
  0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC,
  0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x7F, 0x87, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1,
  0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xF7, 0xF8, 0x3F, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0xC3, 0xF3, 0xF8, 0x7F, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0xFC,
  0xFE, 0x3F, 0x9F, 0xC7, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x1F, 0x1F, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC,
  0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7F, 0x87, 0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x02, 0x0F, 0xF0, 0x60, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x0F,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x01, 0xFE, 0x7E, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xFC,
  0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x03, 0xEF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x10, 0x1F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFD, 0xF0, 0x0F, 0xEF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0xC7, 0xF0,
  0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE,
  0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F,
  0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0x81, 0xFE,
  0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE3, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0xE7, 0xFC, 0x1F, 0xCF,
  0xF8, 0x1F, 0xCF, 0xF0, 0x1F, 0xDF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xBF, 0x80, 0x7F, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F,
  0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE7,
  0xC1, 0xF0, 0x1F, 0xBF, 0xCF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xF1, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0xC7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE1,
  0xFC, 0xFE, 0x1F, 0xC3, 0xF9, 0xFC, 0x3F, 0x8F, 0xF3, 0xF8, 0xFF, 0x1F,
  0xEF, 0xF1, 0xFE, 0x3F, 0x9F, 0xE3, 0xF8, 0x7F, 0x3F, 0x87, 0xF0, 0xFE,
  0x7F, 0x0F, 0xE1, 0xFC, 0xFE, 0x1F, 0xC7, 0xF9, 0xFC, 0x7F, 0x8F, 0xF7,
  0xF8, 0xFF, 0x1F, 0xCF, 0xE1, 0xFC, 0x3F, 0x9F, 0xC3, 0xF8, 0x7F, 0x3F,
  0x87, 0xF0, 0xFE, 0x7F, 0x0F, 0xE3, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0xBF,
  0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F,
  0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xC3,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0x00, 0x03, 0xF3, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F,
  0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE1, 0xF8, 0x7F, 0xDF, 0xC7, 0xFE, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFE, 0x3F, 0xCF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7,
  0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x0F,
  0xF3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xCF, 0x0F, 0xDF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFC, 0xFE, 0x3F, 0x8F, 0xF3, 0xF8, 0xFF, 0x3F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC,
  0xFE, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0x03, 0xF8,
  0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF,
  0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE,
  0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF, 0xF0,
  0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0x9F, 0xC3, 0xF8, 0xFE, 0x1F, 0xCF,
  0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xE7, 0xF0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE,
  0xFF, 0x1F, 0xEF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xFC, 0x7F, 0x3F,
  0x87, 0xF3, 0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x3E, 0x1F, 0xFF, 0x0F,
  0x87, 0xFF, 0xC7, 0xE3, 0xFB, 0xF1, 0xF8, 0xFE, 0xFC, 0xFE, 0x3F, 0xBF,
  0x3F, 0x8F, 0xCF, 0xCF, 0xE7, 0xF3, 0xF7, 0xF9, 0xF8, 0xFD, 0xFE, 0x7E,
  0x3F, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xDF,
  0xFC, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x83, 0xFE, 0x7F, 0xE0, 0xFF,
  0x9F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80,
  0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0xFF, 0x07, 0xF1, 0xFE, 0x07, 0xF1, 0xFC, 0x03, 0xF3,
  0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xC0, 0x1F, 0xEF, 0xE0, 0x1F, 0xCF,
  0xE0, 0x3F, 0xCF, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0x07,
  0xF0, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0x7F, 0x1F,
  0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x07, 0xF7, 0xF8,
  0x0F, 0xEF, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0xE0, 0x0F, 0x80,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x3C, 0x01, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x81, 0xF1, 0xFF, 0x0F, 0xCF, 0xFC, 0x3E, 0x3F,
  0xF8, 0xF9, 0xFF, 0xFF, 0xE7, 0xC7, 0xFF, 0x1F, 0x0F, 0xFC, 0x7C, 0x3F,
  0xE3, 0xF0, 0x7F, 0x80, 0x00, 0x78, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 33, 12, 0, -33 },
  { 55, 15, 13, 14, 2, -35 },
  { 80, 23, 33, 23, 0, -33 },
  { 175, 22, 42, 23, 1, -38 },
  { 291, 22, 33, 29, 4, -33 },
  { 382, 24, 33, 27, 0, -33 },
  { 481, 8, 13, 7, 2, -35 },
  { 494, 14, 46, 14, 2, -36 },
  { 575, 15, 46, 14, -2, -36 },
  { 662, 20, 20, 21, 2, -33 },
  { 712, 19, 24, 21, 1, -27 },
  { 769, 11, 14, 12, -3, -6 },
  { 789, 13, 6, 19, 3, -17 },
  { 799, 8, 8, 14, 1, -8 },
  { 807, 20, 36, 14, -3, -33 },
  { 897, 20, 33, 23, 2, -33 },
  { 980, 15, 33, 23, 5, -33 },
  { 1042, 22, 33, 23, 0, -33 },
  { 1133, 22, 33, 23, 0, -33 },
  { 1224, 21, 33, 23, 1, -33 },
  { 1311, 22, 33, 23, 1, -33 },
  { 1402, 20, 33, 23, 1, -33 },
  { 1485, 23, 33, 23, 1, -33 },
  { 1580, 21, 33, 23, 1, -33 },
  { 1667, 19, 33, 23, 3, -33 },
  { 1746, 11, 26, 13, 1, -26 },
  { 1782, 14, 34, 13, -2, -26 },
  { 1842, 19, 22, 20, 1, -25 },
  { 1895, 21, 16, 23, 1, -22 },
  { 1937, 19, 23, 20, 0, -25 },
  { 1992, 18, 33, 21, 3, -33 },
  { 2067, 33, 42, 34, 0, -32 },
  { 2241, 26, 33, 27, -2, -33 },
  { 2349, 25, 33, 25, 0, -33 },
  { 2453, 25, 33, 26, 1, -33 },
  { 2557, 25, 33, 25, 0, -33 },
  { 2661, 24, 33, 22, 0, -33 },
  { 2760, 24, 33, 21, 0, -33 },
  { 2859, 24, 33, 26, 2, -33 },
  { 2958, 28, 33, 27, 0, -33 },
  { 3074, 13, 33, 13, 0, -33 },
  { 3128, 23, 33, 22, 0, -33 },
  { 3223, 29, 33, 25, 0, -33 },
  { 3343, 19, 33, 21, 0, -33 },
  { 3422, 35, 33, 34, 0, -33 },
  { 3567, 28, 33, 27, 0, -33 },
  { 3683, 25, 33, 27, 1, -33 },
  { 3787, 26, 33, 26, 0, -33 },
  { 3895, 24, 39, 27, 2, -33 },
  { 4012, 25, 33, 25, 0, -33 },
  { 4116, 24, 33, 25, 1, -33 },
  { 4215, 24, 33, 25, 3, -33 },
  { 4314, 26, 33, 26, 1, -33 },
  { 4422, 26, 33, 26, 3, -33 },
  { 4530, 31, 33, 33, 4, -33 },
  { 4658, 30, 33, 25, -2, -33 },
  { 4782, 24, 33, 25, 4, -33 },
  { 4881, 27, 33, 24, -1, -33 },
  { 4993, 16, 46, 12, -1, -38 },
  { 5085, 12, 36, 17, 3, -33 },
  { 5139, 17, 46, 12, -3, -38 },
  { 5237, 17, 16, 18, 1, -33 },
  { 5271, 18, 6, 18, -3, 0 },
  { 5285, 10, 7, 15, 5, -34 },
  { 5294, 20, 24, 21, 0, -24 },
  { 5354, 21, 35, 22, 0, -35 },
  { 5446, 19, 24, 20, 1, -24 },
  { 5503, 23, 35, 22, 1, -35 },
  { 5604, 20, 24, 22, 1, -24 },
  { 5664, 17, 35, 15, 1, -35 },
  { 5739, 24, 33, 23, -1, -24 },
  { 5838, 22, 35, 22, -1, -35 },
  { 5935, 13, 34, 12, 0, -34 },
  { 5991, 18, 43, 11, -5, -34 },
  { 6088, 24, 35, 22, 0, -35 },
  { 6193, 13, 35, 12, 0, -35 },
  { 6250, 31, 24, 33, 0, -24 },
  { 6343, 22, 24, 22, -1, -24 },
  { 6409, 20, 24, 22, 1, -24 },
  { 6469, 23, 33, 22, -2, -24 },
  { 6564, 21, 33, 22, 1, -24 },
  { 6651, 16, 24, 15, 0, -24 },
  { 6699, 20, 24, 20, 0, -24 },
  { 6759, 13, 30, 14, 2, -30 },
  { 6808, 21, 24, 22, 1, -24 },
  { 6871, 20, 24, 21, 2, -24 },
  { 6931, 26, 24, 28, 3, -24 },
  { 7009, 24, 24, 20, -2, -24 },
  { 7081, 23, 33, 21, -1, -24 },
  { 7176, 22, 24, 20, -1, -24 },
  { 7242, 14, 44, 13, 1, -36 },
  { 7319, 10, 39, 11, 1, -33 },
  { 7368, 13, 44, 13, -1, -36 },
  { 7440, 22, 11, 24, 1, -19 },
};

const GFXfont RobotoCondensed_BlackItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_BLACKITALIC46PT7B_H_
