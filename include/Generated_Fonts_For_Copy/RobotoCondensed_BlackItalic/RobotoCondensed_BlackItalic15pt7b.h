#ifndef _ROBOTOCONDENSED_BLACKITALIC15PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x37, 0x66, 0x66, 0x0E, 0xE0, 0xDD, 0xBB, 0x1A, 0x1E, 0x14,
  0x14, 0x7E, 0x2C, 0x28, 0xFC, 0x78, 0x50, 0x50, 0x04, 0x18, 0x71, 0xF3,
  0x6E, 0x0C, 0x1E, 0x0D, 0xDD, 0xB3, 0xE3, 0x86, 0x00, 0x70, 0xA7, 0x5E,
  0xE7, 0x83, 0x0F, 0x95, 0x7A, 0xB4, 0x38, 0x1C, 0x3E, 0x36, 0x3C, 0x3C,
  0x38, 0x7B, 0xFF, 0xEE, 0xFE, 0x7E, 0xFE, 0x13, 0x66, 0x4C, 0xCC, 0xC8,
  0x88, 0xCC, 0x40, 0x10, 0x86, 0x31, 0x8C, 0x63, 0x18, 0xCC, 0x66, 0x31,
  0x00, 0x10, 0x4D, 0xDF, 0x73, 0x60, 0x80, 0x18, 0x30, 0x63, 0xFF, 0xC6,
  0x0C, 0x18, 0x26, 0x66, 0xC0, 0xFF, 0x1D, 0x80, 0x04, 0x18, 0x20, 0xC1,
  0x82, 0x0C, 0x10, 0x60, 0xC1, 0x06, 0x00, 0x39, 0xFE, 0xF3, 0xCF, 0x3C,
  0xF7, 0xDB, 0xE7, 0x00, 0x1F, 0xF7, 0x76, 0x66, 0x6E, 0xE0, 0x1C, 0x7D,
  0xDB, 0x30, 0xE1, 0x86, 0x18, 0x71, 0xFB, 0xF0, 0x1C, 0x7D, 0xD8, 0x31,
  0xE3, 0x83, 0x87, 0xED, 0xF9, 0xE0, 0x06, 0x1C, 0x78, 0xF3, 0xC5, 0x9B,
  0x7F, 0xFE, 0x38, 0x60, 0x3E, 0x7C, 0xC3, 0x07, 0xCF, 0x83, 0x87, 0xEC,
  0xF9, 0xE0, 0x0E, 0x38, 0xE3, 0x87, 0xCF, 0xDB, 0xB3, 0x6E, 0xF8, 0xE0,
  0x7F, 0x7F, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0x1C,
  0x7D, 0xDB, 0xB3, 0xEF, 0x9B, 0x77, 0xEC, 0xF9, 0xE0, 0x39, 0xFE, 0xF3,
  0xCF, 0xF7, 0xC6, 0x3B, 0xCE, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x60, 0x01,
  0xCE, 0x00, 0x00, 0x06, 0x33, 0x18, 0x80, 0x04, 0x77, 0xB8, 0xF8, 0xE0,
  0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xC0, 0x41, 0xC3, 0xC3, 0x7F, 0xC8, 0x00,
  0x7B, 0xFD, 0xC7, 0x18, 0xE7, 0x18, 0x03, 0x86, 0x00, 0x0F, 0x83, 0x18,
  0xC1, 0x33, 0xB6, 0xD6, 0xB6, 0xF6, 0xD6, 0xD2, 0xDE, 0xDB, 0xF3, 0x00,
  0x32, 0x03, 0xC0, 0x07, 0x03, 0x83, 0xC1, 0xE1, 0xF0, 0xD8, 0xEC, 0x7F,
  0x7F, 0xB9, 0xF8, 0xE0, 0x3E, 0x3F, 0x73, 0x73, 0x7E, 0x7E, 0x66, 0x66,
  0xE6, 0xFE, 0xFC, 0x1E, 0x3F, 0x73, 0x63, 0x60, 0x60, 0x60, 0x67, 0x66,
  0x7E, 0x3C, 0x3C, 0x3E, 0x77, 0x73, 0x67, 0x67, 0x67, 0x66, 0xEE, 0xFC,
  0xF8, 0x3F, 0x3F, 0x70, 0x70, 0x7E, 0x7C, 0x60, 0x60, 0xE0, 0xFC, 0xFC,
  0x3F, 0x3E, 0x70, 0x70, 0x60, 0x7E, 0x7C, 0x60, 0xE0, 0xE0, 0xC0, 0x3C,
  0x7E, 0x66, 0xE7, 0xC0, 0xCE, 0xDE, 0xCE, 0xCE, 0xFE, 0x78, 0x31, 0x98,
  0xDC, 0xEE, 0x77, 0xFB, 0xF9, 0x8C, 0xC6, 0xE7, 0x73, 0xB1, 0x80, 0x33,
  0x77, 0x76, 0x66, 0xEE, 0xE0, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C,
  0x0C, 0xCC, 0xFC, 0x78, 0x33, 0x9B, 0x9D, 0xCF, 0xC7, 0xC3, 0xE1, 0xF0,
  0xD8, 0xEE, 0x77, 0x31, 0x80, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0xE3,
  0xFF, 0xC0, 0x38, 0xE7, 0x1D, 0xE7, 0xBC, 0xF7, 0xBE, 0xD7, 0xDA, 0xF3,
  0x76, 0xEE, 0xDD, 0xBB, 0x37, 0x00, 0x31, 0x98, 0xDE, 0xEF, 0x76, 0xB3,
  0x59, 0xBC, 0xDE, 0xEF, 0x73, 0xB1, 0x80, 0x1E, 0x1F, 0x9C, 0xCE, 0x76,
  0x3B, 0x19, 0x8C, 0xC6, 0x67, 0x3F, 0x0F, 0x00, 0x3E, 0x3F, 0x73, 0x73,
  0x67, 0x7F, 0x7C, 0x60, 0xE0, 0xE0, 0xC0, 0x1E, 0x1F, 0x9C, 0xCE, 0x76,
  0x3B, 0x19, 0x8C, 0xC6, 0x67, 0x3F, 0x0F, 0x01, 0xC0, 0x40, 0x3E, 0x3F,
  0x73, 0x73, 0x67, 0x7E, 0x7C, 0x6C, 0xEE, 0xEE, 0xCE, 0x1E, 0x3F, 0x73,
  0x70, 0x38, 0x3C, 0x0E, 0xE6, 0xE6, 0x7E, 0x3C, 0xFF, 0xFF, 0x38, 0x38,
  0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x70, 0x33, 0x99, 0xDC, 0xCE, 0x66,
  0x33, 0x39, 0x9C, 0xCE, 0x66, 0x3F, 0x0F, 0x00, 0xE7, 0xE7, 0xE6, 0xEE,
  0x6E, 0x6C, 0x7C, 0x78, 0x78, 0x78, 0x70, 0xEC, 0xDD, 0x9B, 0xB7, 0x7E,
  0xCF, 0xD9, 0xFB, 0x3F, 0xE7, 0xB8, 0xF7, 0x1C, 0xE3, 0x98, 0x00, 0x39,
  0xC6, 0xE1, 0xB8, 0x6C, 0x1E, 0x03, 0x81, 0xE0, 0xF8, 0x37, 0x1D, 0xC7,
  0x30, 0xE7, 0x66, 0x6E, 0x6C, 0x7C, 0x78, 0x38, 0x30, 0x70, 0x70, 0x70,
  0x7F, 0x7F, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x70, 0x60, 0xFE, 0xFE, 0x39,
  0xCC, 0xE7, 0x39, 0x8C, 0x63, 0x39, 0xCE, 0x63, 0x9C, 0xCE, 0xE6, 0x66,
  0x66, 0x77, 0x73, 0x39, 0xC6, 0x33, 0x9C, 0xC6, 0x31, 0x8C, 0xE7, 0x33,
  0x9C, 0x18, 0xE2, 0x9A, 0x4C, 0xFF, 0xF0, 0xCC, 0x3D, 0xF6, 0xDF, 0xEF,
  0x3F, 0xDF, 0x30, 0x61, 0xC3, 0x87, 0xCF, 0xD9, 0xB7, 0xEF, 0xDB, 0xF6,
  0xC0, 0x3D, 0xF6, 0xF8, 0xE3, 0x3F, 0xDE, 0x07, 0x07, 0x06, 0x06, 0x36,
  0x7E, 0x6E, 0xEE, 0xEC, 0xCC, 0xFC, 0x7C, 0x3C, 0xF9, 0x9F, 0xFF, 0xFC,
  0x1F, 0x1C, 0x1C, 0xF3, 0x0C, 0x79, 0xE7, 0x18, 0x61, 0x86, 0x38, 0x3E,
  0xFD, 0x9F, 0x7E, 0xFD, 0xBF, 0x3E, 0x1D, 0xF3, 0xC0, 0x30, 0x61, 0xC3,
  0x87, 0xCF, 0xDB, 0xB7, 0xED, 0xDB, 0x36, 0x60, 0x33, 0x07, 0x66, 0x66,
  0xEE, 0xC0, 0x0C, 0x30, 0x07, 0x18, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0xF3,
  0x80, 0x30, 0x30, 0x70, 0x70, 0x6E, 0x6E, 0x7C, 0x78, 0xF8, 0xFC, 0xCC,
  0xCC, 0x33, 0x37, 0x76, 0x66, 0x6E, 0xEC, 0x6D, 0xDF, 0xF6, 0xED, 0xBB,
  0xEC, 0xFB, 0x7C, 0xDF, 0x36, 0x6C, 0xFD, 0xBB, 0x7E, 0xDD, 0xB3, 0x66,
  0x3C, 0xF9, 0xBF, 0x7E, 0xFD, 0x9F, 0x3C, 0x3E, 0x3F, 0x33, 0x37, 0x77,
  0x76, 0x7E, 0x6C, 0x60, 0x60, 0xE0, 0x36, 0xFD, 0xBF, 0x7E, 0xD9, 0xBF,
  0x3E, 0x1C, 0x38, 0x60, 0x6B, 0xDC, 0xCE, 0x73, 0x18, 0x39, 0xF6, 0xDC,
  0x3F, 0x3F, 0xDE, 0x31, 0x9E, 0xF6, 0x31, 0x8C, 0x73, 0x80, 0x66, 0xCD,
  0xBB, 0x7E, 0xDD, 0xBF, 0x3E, 0xDF, 0x7D, 0xBE, 0xF3, 0xCE, 0x38, 0xDB,
  0x6D, 0xBE, 0xDF, 0xCE, 0xE7, 0x73, 0x31, 0x98, 0x37, 0x36, 0x3E, 0x1C,
  0x3C, 0x3C, 0x7C, 0x6E, 0x66, 0xDD, 0xB3, 0xE7, 0x8F, 0x1C, 0x38, 0x61,
  0xC3, 0x00, 0x7E, 0xF8, 0x71, 0xC3, 0x0C, 0x3F, 0x7C, 0x19, 0xCC, 0x63,
  0x3B, 0x98, 0x63, 0x18, 0xC6, 0x30, 0x80, 0x22, 0x22, 0x26, 0x64, 0x44,
  0x4C, 0xC0, 0x22, 0x33, 0x76, 0x33, 0x66, 0x6C, 0xCC, 0x80, 0x72, 0xFD,
  0x30,
};

const GFXglyph RobotoCondensed_BlackItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 1, -11 },
  { 9, 8, 11, 7, 0, -11 },
  { 20, 7, 14, 7, 0, -13 },
  { 33, 7, 11, 9, 1, -11 },
  { 43, 8, 11, 9, 0, -11 },
  { 54, 2, 4, 2, 1, -11 },
  { 55, 4, 15, 5, 1, -12 },
  { 63, 5, 15, 5, -1, -12 },
  { 73, 6, 7, 7, 1, -11 },
  { 79, 7, 8, 7, 0, -9 },
  { 86, 4, 5, 4, -1, -2 },
  { 89, 4, 2, 6, 1, -6 },
  { 90, 3, 3, 4, 0, -3 },
  { 92, 7, 12, 5, -1, -11 },
  { 103, 6, 11, 7, 1, -11 },
  { 112, 4, 11, 7, 2, -11 },
  { 118, 7, 11, 7, 0, -11 },
  { 128, 7, 11, 7, 0, -11 },
  { 138, 7, 11, 7, 0, -11 },
  { 148, 7, 11, 7, 0, -11 },
  { 158, 7, 11, 7, 0, -11 },
  { 168, 8, 11, 7, 0, -11 },
  { 179, 7, 11, 7, 0, -11 },
  { 189, 6, 11, 7, 1, -11 },
  { 198, 4, 9, 4, 0, -9 },
  { 203, 5, 12, 4, -1, -9 },
  { 211, 6, 7, 7, 0, -8 },
  { 217, 7, 5, 8, 0, -7 },
  { 222, 6, 7, 7, 0, -8 },
  { 228, 6, 11, 7, 1, -11 },
  { 237, 11, 13, 11, 0, -10 },
  { 255, 9, 11, 9, -1, -11 },
  { 268, 8, 11, 8, 0, -11 },
  { 279, 8, 11, 8, 0, -11 },
  { 290, 8, 11, 8, 0, -11 },
  { 301, 8, 11, 7, 0, -11 },
  { 312, 8, 11, 7, 0, -11 },
  { 323, 8, 11, 9, 1, -11 },
  { 334, 9, 11, 9, 0, -11 },
  { 347, 4, 11, 4, 0, -11 },
  { 353, 8, 11, 7, 0, -11 },
  { 364, 9, 11, 8, 0, -11 },
  { 377, 6, 11, 7, 0, -11 },
  { 386, 11, 11, 11, 0, -11 },
  { 402, 9, 11, 9, 0, -11 },
  { 415, 9, 11, 9, 0, -11 },
  { 428, 8, 11, 8, 0, -11 },
  { 439, 9, 13, 9, 0, -11 },
  { 454, 8, 11, 8, 0, -11 },
  { 465, 8, 11, 8, 0, -11 },
  { 476, 8, 11, 8, 1, -11 },
  { 487, 9, 11, 8, 0, -11 },
  { 500, 8, 11, 9, 1, -11 },
  { 511, 11, 11, 11, 1, -11 },
  { 527, 10, 11, 8, -1, -11 },
  { 541, 8, 11, 8, 1, -11 },
  { 552, 8, 11, 8, 0, -11 },
  { 563, 5, 16, 4, 0, -13 },
  { 573, 4, 12, 6, 1, -11 },
  { 579, 5, 16, 4, -1, -13 },
  { 589, 6, 5, 6, 0, -11 },
  { 593, 6, 2, 6, -1, 0 },
  { 595, 3, 2, 5, 2, -11 },
  { 596, 6, 8, 7, 0, -8 },
  { 602, 7, 12, 7, 0, -12 },
  { 613, 6, 8, 7, 0, -8 },
  { 619, 8, 12, 7, 0, -12 },
  { 631, 7, 8, 7, 0, -8 },
  { 638, 6, 12, 5, 0, -12 },
  { 647, 7, 11, 7, 0, -8 },
  { 657, 7, 12, 7, 0, -12 },
  { 668, 4, 11, 4, 0, -11 },
  { 674, 6, 14, 4, -2, -11 },
  { 685, 8, 12, 7, 0, -12 },
  { 697, 4, 12, 4, 0, -12 },
  { 703, 10, 8, 11, 0, -8 },
  { 713, 7, 8, 7, 0, -8 },
  { 720, 7, 8, 7, 0, -8 },
  { 727, 8, 11, 7, -1, -8 },
  { 738, 7, 11, 7, 0, -8 },
  { 748, 5, 8, 5, 0, -8 },
  { 753, 6, 8, 7, 0, -8 },
  { 759, 5, 10, 5, 0, -10 },
  { 766, 7, 8, 7, 0, -8 },
  { 773, 6, 8, 7, 1, -8 },
  { 779, 9, 8, 9, 1, -8 },
  { 788, 8, 8, 7, -1, -8 },
  { 796, 7, 11, 7, 0, -8 },
  { 806, 7, 8, 7, 0, -8 },
  { 813, 5, 15, 4, 0, -12 },
  { 823, 4, 13, 4, 0, -11 },
  { 830, 4, 15, 4, 0, -12 },
  { 838, 7, 3, 8, 0, -6 },
};

const GFXfont RobotoCondensed_BlackItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_BLACKITALIC15PT7B_H_
