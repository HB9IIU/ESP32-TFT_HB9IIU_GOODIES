#ifndef _ROBOTOCONDENSED_BLACKITALIC11PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0x36, 0x55, 0x60, 0x18, 0xA7, 0x8C, 0x53, 0xE6, 0x28,
  0x11, 0xDA, 0xD6, 0x1F, 0x6B, 0x71, 0x00, 0xE5, 0x6D, 0xC3, 0xB6, 0xA3,
  0x31, 0xE7, 0x9C, 0x7F, 0xED, 0x9E, 0xE0, 0x12, 0x64, 0x44, 0x44, 0x44,
  0x40, 0x4C, 0x92, 0xDB, 0x5A, 0x00, 0x2A, 0xFE, 0xA0, 0x31, 0xBF, 0xF6,
  0x30, 0x6F, 0x00, 0xE0, 0xF0, 0x08, 0x84, 0x62, 0x11, 0x08, 0xC0, 0x3B,
  0x52, 0xBD, 0xED, 0x4E, 0x3E, 0xA6, 0x66, 0x64, 0x3B, 0xD6, 0x33, 0x33,
  0x9F, 0x3B, 0xC2, 0x33, 0x0F, 0x6E, 0x18, 0xCE, 0xFD, 0xFC, 0xC6, 0x7B,
  0x18, 0xE5, 0x8F, 0x6E, 0x19, 0x98, 0xFD, 0xED, 0x6E, 0x7C, 0x21, 0x84,
  0x30, 0x86, 0x10, 0x3B, 0x5A, 0xF7, 0x6F, 0x6E, 0x7F, 0x9F, 0xF3, 0x6C,
  0x6C, 0x0D, 0x80, 0x6C, 0x01, 0xB4, 0x0B, 0xB0, 0xE1, 0x00, 0x78, 0x1E,
  0x43, 0x85, 0xE8, 0x00, 0xEF, 0x36, 0x40, 0xCC, 0x1E, 0x22, 0x5D, 0x55,
  0xB5, 0xAD, 0xAA, 0xBE, 0x40, 0x78, 0x0C, 0x38, 0x70, 0xA3, 0x47, 0xD9,
  0xB3, 0x79, 0xB6, 0xDB, 0x7B, 0x2D, 0xBE, 0x39, 0xB6, 0xD0, 0xC3, 0x37,
  0x9C, 0x79, 0xF6, 0xD3, 0x4F, 0x2D, 0xBC, 0x7D, 0x86, 0x10, 0x7B, 0x0C,
  0x3E, 0x7D, 0x86, 0x10, 0x7B, 0x0C, 0x30, 0x39, 0xB6, 0x50, 0xDF, 0x37,
  0xDE, 0x66, 0xCD, 0x92, 0x67, 0xD9, 0xB3, 0x66, 0x6D, 0xB5, 0xB6, 0x08,
  0x21, 0x86, 0x18, 0x6F, 0x1C, 0x6E, 0xD9, 0xE3, 0x87, 0x1F, 0x36, 0x6C,
  0x63, 0x18, 0x84, 0x63, 0x1E, 0x73, 0x77, 0x77, 0x57, 0x5F, 0xDA, 0xDE,
  0xD6, 0x66, 0xCD, 0xD3, 0xE5, 0xDB, 0xB7, 0x66, 0x39, 0xB6, 0xD3, 0xCF,
  0x37, 0x9C, 0x79, 0xB6, 0xDB, 0x7B, 0x0C, 0x30, 0x39, 0xB6, 0x53, 0xCF,
  0x37, 0x9E, 0x08, 0x79, 0xB6, 0xDB, 0x7B, 0x6D, 0xB6, 0x39, 0xB6, 0x1C,
  0x3B, 0x2D, 0x9C, 0xF9, 0x18, 0xC6, 0x31, 0x88, 0x65, 0xB6, 0xDB, 0x4F,
  0x3F, 0x9C, 0xCF, 0x6D, 0xB4, 0xF3, 0xC6, 0x18, 0xD3, 0xEF, 0xDF, 0xAF,
  0xDF, 0xB6, 0x6C, 0x6C, 0xD8, 0xE1, 0xC3, 0x0F, 0x36, 0x6C, 0xDB, 0x6D,
  0x1C, 0x61, 0x86, 0x10, 0x7C, 0x31, 0x8C, 0x31, 0x8C, 0x3E, 0x76, 0x66,
  0x44, 0xCC, 0xCC, 0xC0, 0xDB, 0x6D, 0x93, 0x60, 0x33, 0x33, 0x32, 0x26,
  0x66, 0xE0, 0x33, 0x55, 0xF0, 0xC8, 0x72, 0xDF, 0xAF, 0x78, 0x63, 0x18,
  0xF5, 0xEF, 0x7B, 0xF0, 0x72, 0xF1, 0x8D, 0x38, 0x0C, 0x20, 0x9E, 0x5B,
  0x6D, 0xB6, 0x70, 0x72, 0xF7, 0xFD, 0x38, 0x36, 0x6F, 0x64, 0x4C, 0xC0,
  0x7A, 0xF7, 0xBD, 0xBA, 0xDC, 0x63, 0x18, 0xF5, 0xEF, 0x7B, 0xD0, 0x6C,
  0x34, 0xB6, 0xC0, 0x33, 0x03, 0x22, 0x66, 0x66, 0xC0, 0x61, 0x86, 0x1E,
  0x53, 0xCF, 0x34, 0xD8, 0x6D, 0xB4, 0xB6, 0xC0, 0x7E, 0xB5, 0x6E, 0xDD,
  0x7A, 0xC0, 0x7A, 0xF7, 0xBD, 0xE8, 0x72, 0xF7, 0xBD, 0xB8, 0x7A, 0xF7,
  0xBD, 0xFA, 0x10, 0x6A, 0xF7, 0xBD, 0x38, 0xC6, 0x77, 0xCC, 0xCC, 0x72,
  0xD8, 0x6D, 0x38, 0x6E, 0x64, 0x4C, 0x60, 0x6A, 0xF7, 0xBD, 0xB8, 0xBB,
  0xAE, 0xCC, 0xAE, 0xAE, 0xBE, 0xF2, 0xC0, 0x5B, 0x9C, 0xEF, 0x78, 0x5A,
  0xDC, 0xE6, 0x31, 0x18, 0x78, 0x8C, 0xCC, 0x78, 0x22, 0x66, 0x48, 0x44,
  0xC4, 0x40, 0x29, 0x24, 0x94, 0x80, 0x4D, 0xB6, 0xD6, 0xDA, 0x00, 0x6B,
  0x76,
};

const GFXglyph RobotoCondensed_BlackItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 3, 0, -8 },
  { 6, 6, 8, 5, 0, -8 },
  { 12, 5, 10, 5, 0, -9 },
  { 19, 5, 8, 7, 1, -8 },
  { 24, 6, 8, 6, 0, -8 },
  { 30, 1, 3, 2, 1, -8 },
  { 31, 4, 11, 3, 0, -9 },
  { 37, 3, 11, 3, 0, -9 },
  { 42, 4, 5, 5, 1, -8 },
  { 45, 5, 6, 5, 0, -7 },
  { 49, 3, 3, 3, -1, -1 },
  { 51, 3, 1, 5, 1, -4 },
  { 52, 2, 2, 3, 0, -2 },
  { 53, 5, 9, 3, -1, -8 },
  { 59, 5, 8, 5, 0, -8 },
  { 64, 4, 8, 5, 1, -8 },
  { 68, 5, 8, 5, 0, -8 },
  { 73, 5, 8, 5, 0, -8 },
  { 78, 5, 8, 5, 0, -8 },
  { 83, 5, 8, 5, 0, -8 },
  { 88, 5, 8, 5, 0, -8 },
  { 93, 6, 8, 5, 0, -8 },
  { 99, 5, 8, 5, 0, -8 },
  { 104, 4, 8, 5, 1, -8 },
  { 108, 3, 6, 3, 0, -6 },
  { 111, 3, 8, 3, 0, -6 },
  { 114, 5, 5, 5, 0, -6 },
  { 118, 5, 3, 6, 0, -5 },
  { 120, 5, 5, 5, 0, -6 },
  { 124, 4, 8, 5, 1, -8 },
  { 128, 8, 10, 8, 0, -8 },
  { 138, 7, 8, 6, -1, -8 },
  { 145, 6, 8, 6, 0, -8 },
  { 151, 6, 8, 6, 0, -8 },
  { 157, 6, 8, 6, 0, -8 },
  { 163, 6, 8, 5, 0, -8 },
  { 169, 6, 8, 5, 0, -8 },
  { 175, 6, 8, 6, 0, -8 },
  { 181, 7, 8, 7, 0, -8 },
  { 188, 3, 8, 3, 0, -8 },
  { 191, 6, 8, 5, 0, -8 },
  { 197, 7, 8, 6, 0, -8 },
  { 204, 5, 8, 5, 0, -8 },
  { 209, 8, 8, 8, 0, -8 },
  { 217, 7, 8, 7, 0, -8 },
  { 224, 6, 8, 6, 0, -8 },
  { 230, 6, 8, 6, 0, -8 },
  { 236, 6, 9, 6, 0, -8 },
  { 243, 6, 8, 6, 0, -8 },
  { 249, 6, 8, 6, 0, -8 },
  { 255, 5, 8, 6, 1, -8 },
  { 260, 6, 8, 6, 0, -8 },
  { 266, 6, 8, 6, 1, -8 },
  { 272, 7, 8, 8, 1, -8 },
  { 279, 7, 8, 6, 0, -8 },
  { 286, 6, 8, 6, 1, -8 },
  { 292, 6, 8, 6, 0, -8 },
  { 298, 4, 11, 3, 0, -9 },
  { 304, 3, 9, 4, 1, -8 },
  { 308, 4, 11, 3, -1, -9 },
  { 314, 4, 4, 4, 0, -8 },
  { 316, 5, 1, 4, -1, 0 },
  { 317, 3, 2, 4, 1, -9 },
  { 318, 5, 6, 5, 0, -6 },
  { 322, 5, 9, 5, 0, -9 },
  { 328, 5, 6, 5, 0, -6 },
  { 332, 6, 9, 5, 0, -9 },
  { 339, 5, 6, 5, 0, -6 },
  { 343, 4, 9, 4, 0, -9 },
  { 348, 5, 8, 5, 0, -6 },
  { 353, 5, 9, 5, 0, -9 },
  { 359, 3, 9, 3, 0, -9 },
  { 363, 4, 11, 3, -1, -9 },
  { 369, 6, 9, 5, 0, -9 },
  { 376, 3, 9, 3, 0, -9 },
  { 380, 7, 6, 8, 0, -6 },
  { 386, 5, 6, 5, 0, -6 },
  { 390, 5, 6, 5, 0, -6 },
  { 394, 5, 8, 5, 0, -6 },
  { 399, 5, 8, 5, 0, -6 },
  { 404, 4, 6, 4, 0, -6 },
  { 407, 5, 6, 5, 0, -6 },
  { 411, 4, 7, 3, 0, -7 },
  { 415, 5, 6, 5, 0, -6 },
  { 419, 4, 6, 5, 1, -6 },
  { 422, 6, 6, 7, 1, -6 },
  { 427, 5, 6, 5, 0, -6 },
  { 431, 5, 8, 5, 0, -6 },
  { 436, 5, 6, 5, 0, -6 },
  { 440, 4, 11, 3, 0, -9 },
  { 446, 3, 9, 3, 0, -8 },
  { 450, 3, 11, 3, 0, -9 },
  { 455, 5, 3, 6, 0, -5 },
};

const GFXfont RobotoCondensed_BlackItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_BLACKITALIC11PT7B_H_
