#ifndef _ROBOTOCONDENSED_BLACKITALIC31PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x1F, 0x8F,
  0x83, 0x80, 0x79, 0xDE, 0x77, 0xBD, 0xCF, 0x73, 0x9C, 0xE7, 0x3B, 0x8E,
  0xE7, 0x00, 0x01, 0xCE, 0x01, 0xDC, 0x01, 0xDC, 0x03, 0x9C, 0x03, 0xB8,
  0x03, 0xB8, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x07, 0x70, 0x0E, 0x70,
  0x0E, 0xE0, 0x0E, 0xE0, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x39, 0xC0,
  0x3B, 0x80, 0x3B, 0x80, 0x33, 0x80, 0x73, 0x00, 0x77, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xEF, 0x8F, 0xBE, 0x3C, 0xF9, 0xF3, 0xFF,
  0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x3C,
  0x01, 0xF8, 0x0F, 0xF0, 0x39, 0xC7, 0xE7, 0x3B, 0x9D, 0xEE, 0x77, 0x3F,
  0xB8, 0xFF, 0xC0, 0xF7, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xF0, 0x3F, 0xF1,
  0xDF, 0xCE, 0xE7, 0x3B, 0x9D, 0xCE, 0x7E, 0x39, 0xD8, 0xFF, 0x01, 0xF8,
  0x03, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xCF, 0x3F, 0xEF, 0x7F, 0xEF, 0x7D, 0xFF, 0xF9, 0xFE, 0xF8, 0xFE,
  0xF8, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0x3E, 0x39, 0xDE,
  0xF7, 0xB9, 0xCE, 0x70, 0x00, 0x80, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x80, 0xE0, 0x3C, 0x06, 0x00, 0x80, 0x04, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC1,
  0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xF0,
  0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x08, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F,
  0x01, 0xFC, 0x1E, 0xE1, 0xE3, 0x86, 0x1C, 0x10, 0x40, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC3, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7,
  0xFF, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0xF0, 0x40, 0x7F, 0x3F, 0xBF, 0xDF,
  0xE0, 0xF7, 0xFF, 0xF7, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x3F, 0xC1,
  0xFF, 0x87, 0xFE, 0x3E, 0x7C, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D,
  0xF1, 0xF7, 0xC7, 0xFE, 0x1E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E,
  0xF8, 0xF3, 0xE7, 0xC7, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0x00,
  0xC0, 0xF1, 0xFD, 0xFF, 0x7F, 0x9F, 0xEE, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF3,
  0xE7, 0xC7, 0xCF, 0x8F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x00, 0x03, 0xF0, 0x0F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF3, 0xE7, 0xC7, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0xF8, 0x7D, 0xF1, 0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFE,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x1E, 0xF8, 0x77, 0xC3, 0xDF, 0x1E, 0x7C,
  0x79, 0xF3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF1, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x23, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x3C, 0x3E,
  0x78, 0xF8, 0xF9, 0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x1F, 0x81, 0xFC, 0x1F, 0xE1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0xBC, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xCF, 0x9F, 0xFC, 0xFF, 0xC3, 0xFC, 0x0F, 0x80,
  0x3F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87,
  0xFF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0x7F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x7F, 0xF3, 0xE3, 0xCF, 0x8F, 0x3E, 0x3E, 0xF8, 0xF3,
  0xE7, 0xCF, 0xFF, 0x1F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0xFF, 0xE7, 0xCF, 0x3C, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0x7C, 0x07,
  0xC0, 0x7E, 0x1F, 0xE0, 0xFE, 0x07, 0xE0, 0x38, 0x00, 0x1C, 0x7C, 0xF9,
  0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x1F, 0x3E, 0x7C, 0x70,
  0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x0F, 0x87,
  0x81, 0x80, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x0F, 0xF1, 0xFF, 0x3F, 0xF1,
  0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00,
  0x70, 0x00, 0x80, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x10,
  0x00, 0xE0, 0x0F, 0xC0, 0x7F, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0xFF, 0x9F, 0xF0, 0xFE, 0x07, 0xC0, 0x38, 0x02, 0x00, 0x00,
  0x0F, 0x83, 0xFE, 0x7F, 0xEF, 0xFF, 0xF9, 0xFF, 0x9F, 0x01, 0xF0, 0x3F,
  0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF0, 0x1C, 0x07, 0x80, 0x38, 0x3C,
  0x00, 0x61, 0xE1, 0xE1, 0xC7, 0x1F, 0xE7, 0x3C, 0xFF, 0x9C, 0xE3, 0xCE,
  0x73, 0x9E, 0x79, 0xDC, 0x71, 0xC7, 0x73, 0xC7, 0x1D, 0xCF, 0x1C, 0x77,
  0x3C, 0xF1, 0xBC, 0xE3, 0x8E, 0xE3, 0x8E, 0x3B, 0x8E, 0x79, 0xCE, 0x3F,
  0xFF, 0x38, 0xFF, 0xF8, 0xF1, 0xE7, 0xC1, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x08, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0xF8, 0x1F, 0x1E, 0x07, 0xC7, 0x83, 0xE1, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7E,
  0x07, 0xDF, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x3F, 0x3E, 0x1F, 0x1F,
  0x3F, 0x8F, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xF1, 0xF1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0xF9, 0xF0,
  0x7C, 0xF8, 0x7E, 0x7E, 0x7E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0x7E, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF3,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7C, 0x7E, 0x3E, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xE3, 0xF1, 0xF1, 0xF0, 0x79, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x3F, 0xDF, 0x9F, 0xEF, 0x8F, 0xF7, 0xC7, 0xFB, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x3E, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0x00, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E,
  0x07, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xF0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC7,
  0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0xC0, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x1F,
  0x1F, 0xC1, 0xF1, 0xF8, 0x1F, 0x3F, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x03,
  0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xFC,
  0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x0F, 0x87,
  0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF8, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xE3,
  0xFC, 0x3F, 0xE3, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xE7, 0xFC, 0x3D, 0xEF,
  0x7C, 0x3D, 0xEF, 0x78, 0x7D, 0xEE, 0xF8, 0x7C, 0xFE, 0xF8, 0x7C, 0xFC,
  0xF8, 0x7C, 0xFC, 0xF8, 0x7C, 0xFD, 0xF8, 0xFC, 0xF9, 0xF0, 0xF8, 0xF9,
  0xF0, 0xF8, 0xF1, 0xF0, 0xF8, 0xF1, 0xF0, 0x0F, 0x83, 0xE3, 0xF0, 0x7C,
  0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xFC, 0x7C, 0x3F, 0x8F, 0x87, 0xF1, 0xF1,
  0xFE, 0x3E, 0x3F, 0xC7, 0xC7, 0xDD, 0xF0, 0xFB, 0xBE, 0x1F, 0x77, 0xC3,
  0xEE, 0xF8, 0xF8, 0xFF, 0x1F, 0x1F, 0xE3, 0xE3, 0xF8, 0x7C, 0x7F, 0x0F,
  0x8F, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x00,
  0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xF1, 0xF1, 0xF0,
  0xF9, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xDF,
  0x83, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x7C, 0xF8, 0x3E,
  0x3E, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x0F,
  0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0xCF, 0x8F, 0xC7, 0xFF,
  0xE3, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xF1, 0xF1, 0xF0, 0x7D, 0xF8,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xDF, 0x83, 0xEF,
  0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x7C, 0xF8, 0x3E, 0x3E, 0x3E,
  0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x38, 0x00, 0x10, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x1F, 0x3E,
  0x1F, 0x1F, 0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xC1,
  0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xFC, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F,
  0x8F, 0x87, 0xE7, 0xC3, 0xF0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFE, 0x3F, 0x3E, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xCF, 0xC3,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x7E, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x0F, 0xBF, 0x07,
  0xEF, 0xC1, 0xF9, 0xF0, 0x7C, 0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xE1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3F, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x3D,
  0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0xF0,
  0xFF, 0x8F, 0x8F, 0xBC, 0x7C, 0x7D, 0xE3, 0xE3, 0xEF, 0x3F, 0x3E, 0x79,
  0xF9, 0xF3, 0xCF, 0xCF, 0x9E, 0xFE, 0x7C, 0xF7, 0xF7, 0xC7, 0xBF, 0xBE,
  0x3D, 0xFD, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFB,
  0xFC, 0x1F, 0xDF, 0xE0, 0xFE, 0xFF, 0x07, 0xE7, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0xF8,
  0x7E, 0x0F, 0x87, 0xC0, 0xFC, 0xFC, 0x07, 0xCF, 0x80, 0x7D, 0xF0, 0x07,
  0xDF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x3F,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0xBE, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7,
  0xC7, 0xC1, 0xE3, 0xE0, 0xF3, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE1, 0xFC,
  0x3F, 0x00, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x00, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xE1, 0xFC, 0x3B, 0x8F, 0x71, 0xCE, 0x79, 0xCE, 0x3F, 0xC7,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF8, 0xF0, 0xF1, 0xE0,
  0x07, 0xC0, 0xFF, 0x8F, 0xFE, 0x7F, 0xF3, 0xEF, 0x80, 0x7C, 0x03, 0xE1,
  0xFF, 0x3F, 0xFB, 0xFF, 0xFF, 0x7D, 0xF3, 0xEF, 0x9F, 0x7F, 0xFB, 0xFF,
  0xCF, 0xFE, 0x3D, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xEF, 0x0F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xF1, 0xE7,
  0xCF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0x3C, 0x00, 0x07, 0xC0, 0x7F,
  0x87, 0xFC, 0x7F, 0xF3, 0xC7, 0xBE, 0x3D, 0xF1, 0xEF, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xF1, 0xE7, 0x9F, 0x3F, 0xF9, 0xFF, 0x87, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x0F, 0xBE, 0x1F, 0xBE, 0x3F, 0xFE, 0x3F, 0xFC, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0x78, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x1E, 0xF0, 0x07,
  0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x84, 0x7F, 0xF1, 0xFF, 0x87,
  0xFC, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF1, 0xF0, 0x3E, 0x3F,
  0xF7, 0xFC, 0xFF, 0x9F, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x00, 0x07,
  0x9E, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF7, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF0, 0xFB, 0xE1, 0xE3, 0xC7, 0xC7, 0xCF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x1E, 0xF0, 0x03, 0xE1, 0x07, 0xC3, 0xFF,
  0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xEF, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF,
  0xF3, 0xE7, 0xCF, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x3E, 0x7C,
  0xF9, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE7, 0xCF, 0x9F, 0x00,
  0x0F, 0x0F, 0x87, 0xE3, 0xE0, 0xE0, 0x00, 0x00, 0x3E, 0x1E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x87,
  0xC3, 0xE1, 0xF0, 0x00, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x3F, 0x3E, 0x7E, 0x3E, 0xFC, 0x3E, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x7D, 0xF0, 0x79, 0xF0, 0xF9, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x0F, 0x87, 0xC3, 0xE0, 0x1E, 0xF1, 0xE1, 0xFF, 0xDF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xF3, 0xEF, 0x8F,
  0x1F, 0x7C, 0xF8, 0xFB, 0xE7, 0xC7, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0x8F, 0x9F, 0x7C, 0x7C, 0xFB, 0xE7, 0xC7, 0xDF, 0x3E, 0x3C, 0xF9, 0xF3,
  0xE0, 0x3E, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x3E, 0x7D, 0xF1, 0xF7,
  0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xF3, 0xE7, 0xCF, 0xBE, 0x3E, 0xF8, 0xFB,
  0xE3, 0xEF, 0x8F, 0xBE, 0x7C, 0xF9, 0xF0, 0x07, 0xE0, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFE, 0x3E, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xE1,
  0xF7, 0x87, 0xDE, 0x1E, 0x78, 0xF9, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x0F,
  0x80, 0x1F, 0x78, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xF3, 0xE3, 0xE7,
  0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xE1, 0xE7,
  0xE7, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x7D, 0xE0, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xBE, 0x3F,
  0x7C, 0xFF, 0xF1, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E,
  0x78, 0x79, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x8F, 0xFF, 0x1F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFE, 0x7D, 0xF3,
  0xCF, 0xBE, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03,
  0xEF, 0x1F, 0x7D, 0xF9, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x1F, 0x0F, 0x0F,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xC3, 0xE1, 0xF0, 0xFE, 0x7F, 0x1F, 0x87, 0xC0, 0x7C, 0x7D, 0xF1, 0xF7,
  0xC7, 0xDF, 0x1E, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB,
  0xE3, 0xCF, 0x9F, 0x3C, 0x7C, 0xF9, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8,
  0x3D, 0xE0, 0xF8, 0xFD, 0xE3, 0xE7, 0x8F, 0x9E, 0x7C, 0x79, 0xF1, 0xE7,
  0xC7, 0xBE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF1, 0xC7, 0xBC, 0xF1,
  0xEF, 0x3C, 0xFB, 0xCF, 0x3C, 0xF7, 0xCF, 0x3D, 0xF7, 0xCF, 0x7D, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xC0, 0xF0, 0xF0, 0x00, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x0F, 0x7C, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3E,
  0xF0, 0x3E, 0xF0, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0x1F, 0x1F, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF0, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0x1F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0x01, 0x03, 0xC3, 0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3E, 0x1F, 0x0F, 0x07, 0x8F, 0xC7, 0xC3, 0x81, 0xE0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0x00,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC0, 0x04,
  0x07, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xE1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x1E, 0x0E, 0x02, 0x00, 0x1C, 0x01, 0xFC,
  0x77, 0xF3, 0xFF, 0xFF, 0xF3, 0xFB, 0x87, 0xE0, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 22, 8, 0, -22 },
  { 26, 10, 9, 10, 1, -23 },
  { 38, 16, 22, 15, 0, -22 },
  { 82, 14, 28, 15, 1, -25 },
  { 131, 14, 22, 19, 3, -22 },
  { 170, 16, 22, 18, 0, -22 },
  { 214, 5, 9, 5, 1, -23 },
  { 220, 10, 31, 10, 1, -24 },
  { 259, 10, 31, 10, -1, -24 },
  { 298, 13, 14, 14, 2, -22 },
  { 321, 13, 16, 14, 1, -18 },
  { 347, 7, 10, 8, -2, -4 },
  { 356, 9, 4, 13, 2, -12 },
  { 361, 5, 5, 9, 1, -5 },
  { 365, 13, 24, 9, -2, -22 },
  { 404, 14, 22, 15, 1, -22 },
  { 443, 10, 22, 15, 3, -22 },
  { 471, 15, 22, 15, 0, -22 },
  { 513, 15, 22, 15, 0, -22 },
  { 555, 14, 22, 15, 1, -22 },
  { 594, 15, 22, 15, 0, -22 },
  { 636, 13, 22, 15, 1, -22 },
  { 672, 15, 22, 15, 1, -22 },
  { 714, 14, 22, 15, 1, -22 },
  { 753, 13, 22, 15, 2, -22 },
  { 789, 7, 17, 9, 1, -17 },
  { 804, 9, 23, 9, -1, -17 },
  { 830, 13, 15, 13, 0, -17 },
  { 855, 14, 11, 16, 1, -15 },
  { 875, 13, 15, 14, 0, -17 },
  { 900, 12, 22, 14, 2, -22 },
  { 933, 22, 28, 23, 0, -21 },
  { 1010, 18, 22, 18, -2, -22 },
  { 1060, 17, 22, 17, 0, -22 },
  { 1107, 17, 22, 17, 1, -22 },
  { 1154, 17, 22, 17, 0, -22 },
  { 1201, 16, 22, 15, 0, -22 },
  { 1245, 16, 22, 14, 0, -22 },
  { 1289, 17, 22, 18, 1, -22 },
  { 1336, 19, 22, 18, 0, -22 },
  { 1389, 9, 22, 8, 0, -22 },
  { 1414, 16, 22, 15, 0, -22 },
  { 1458, 20, 22, 17, 0, -22 },
  { 1513, 13, 22, 14, 0, -22 },
  { 1549, 24, 22, 23, 0, -22 },
  { 1615, 19, 22, 18, 0, -22 },
  { 1668, 17, 22, 18, 1, -22 },
  { 1715, 17, 22, 17, 0, -22 },
  { 1762, 17, 26, 18, 1, -22 },
  { 1818, 17, 22, 17, 0, -22 },
  { 1865, 16, 22, 17, 1, -22 },
  { 1909, 16, 22, 17, 2, -22 },
  { 1953, 17, 22, 17, 1, -22 },
  { 2000, 18, 22, 18, 2, -22 },
  { 2050, 21, 22, 22, 3, -22 },
  { 2108, 20, 22, 17, -1, -22 },
  { 2163, 17, 22, 17, 2, -22 },
  { 2210, 19, 22, 16, -1, -22 },
  { 2263, 11, 31, 8, -1, -26 },
  { 2306, 8, 24, 12, 2, -22 },
  { 2330, 11, 31, 8, -2, -26 },
  { 2373, 11, 11, 12, 1, -22 },
  { 2389, 12, 4, 12, -2, 0 },
  { 2395, 7, 5, 10, 3, -24 },
  { 2400, 13, 17, 14, 0, -17 },
  { 2428, 14, 23, 15, 0, -23 },
  { 2469, 13, 17, 14, 0, -17 },
  { 2497, 16, 23, 15, 0, -23 },
  { 2543, 13, 17, 15, 1, -17 },
  { 2571, 11, 23, 10, 1, -23 },
  { 2603, 15, 23, 15, 0, -17 },
  { 2647, 14, 23, 15, 0, -23 },
  { 2688, 9, 24, 8, 0, -24 },
  { 2715, 13, 30, 8, -4, -24 },
  { 2764, 16, 23, 15, 0, -23 },
  { 2810, 9, 23, 8, 0, -23 },
  { 2836, 21, 17, 22, 0, -17 },
  { 2881, 14, 17, 15, 0, -17 },
  { 2911, 14, 17, 15, 0, -17 },
  { 2941, 15, 23, 15, -1, -17 },
  { 2985, 15, 23, 15, 0, -17 },
  { 3029, 11, 17, 10, 0, -17 },
  { 3053, 13, 17, 14, 0, -17 },
  { 3081, 9, 20, 9, 1, -20 },
  { 3104, 14, 17, 15, 1, -17 },
  { 3134, 14, 17, 14, 1, -17 },
  { 3164, 18, 17, 19, 2, -17 },
  { 3203, 16, 17, 14, -1, -17 },
  { 3237, 16, 23, 14, -1, -17 },
  { 3283, 15, 17, 14, -1, -17 },
  { 3315, 9, 29, 9, 1, -24 },
  { 3348, 7, 26, 8, 0, -22 },
  { 3371, 9, 30, 9, -1, -24 },
  { 3405, 14, 7, 16, 1, -13 },
};

const GFXfont RobotoCondensed_BlackItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_BLACKITALIC31PT7B_H_
