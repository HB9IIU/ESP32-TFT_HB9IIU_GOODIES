#ifndef _ROBOTOCONDENSED_BLACKITALIC44PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC1, 0xFE, 0x07, 0xF0,
  0x3F, 0x00, 0xF0, 0x00, 0x3C, 0x7D, 0xF1, 0xF7, 0xC7, 0x9F, 0x3E, 0x7C,
  0xF9, 0xE3, 0xE7, 0x8F, 0x3E, 0x3C, 0xF8, 0xF3, 0xC7, 0xCF, 0x1E, 0x3C,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x79, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF8, 0x00,
  0xF3, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x1E, 0x7C, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0,
  0x03, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07,
  0x9F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xF8, 0xFC, 0x3F, 0x87, 0xE1, 0xFC,
  0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F,
  0x87, 0xF1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9F, 0x0E, 0x7C,
  0xF8, 0xFB, 0xC7, 0xCF, 0x9E, 0x3E, 0x78, 0xF1, 0xF7, 0xC7, 0x8F, 0x7C,
  0x3C, 0xFB, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7D,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xCF, 0x07, 0xBE, 0x7C, 0x79, 0xE3, 0xE7, 0xCF,
  0x1F, 0x3C, 0x78, 0xF3, 0xC3, 0xC7, 0xBE, 0x1E, 0x7C, 0x60, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0x0F, 0xFC, 0x7E, 0x3F, 0xFC, 0xFC,
  0xFF, 0xF9, 0xFB, 0xFB, 0xFF, 0xE7, 0xF7, 0xFF, 0xCF, 0xE7, 0xFF, 0xBF,
  0xCF, 0xFE, 0x7F, 0x8F, 0xFC, 0x7F, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xF8,
  0x7F, 0x00, 0x3E, 0x7C, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x79, 0xF3, 0xE7,
  0xC0, 0x00, 0x08, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xE0, 0x03, 0x80, 0x04, 0x00, 0x01, 0x00, 0x06, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x10,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x60, 0xE0, 0xDF, 0x1C, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0x78, 0x0F, 0xCF,
  0x03, 0xF1, 0xF0, 0x7C, 0x1F, 0x03, 0x03, 0x80, 0x00, 0x20, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F,
  0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x0C, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xEF, 0xFE, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xE3,
  0xF9, 0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xE0, 0xFD, 0xFC, 0x3F, 0xBF, 0x87,
  0xF7, 0xF0, 0xFE, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F,
  0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F,
  0x3F, 0x07, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0x1F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x0C,
  0x01, 0xE0, 0x3F, 0x87, 0xFE, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC,
  0xFF, 0xF3, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x8F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF3, 0xF8, 0x1F, 0x9F, 0xC1, 0xFC, 0x7F, 0x1F, 0xE3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xDF, 0xC0, 0xFD, 0xFC,
  0x1F, 0x9F, 0xC1, 0xF1, 0xFC, 0x3F, 0x3F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xE3,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x7C, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0x0F, 0xEF, 0xE1, 0xFD,
  0xFC, 0x3F, 0xBF, 0x07, 0xF7, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0x83, 0xFB,
  0xF0, 0xFF, 0x7F, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE,
  0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0xCF,
  0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xF1, 0xFD, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0x80,
  0x00, 0x0F, 0x83, 0xF8, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x83, 0xF8, 0x7F, 0x8F, 0xF1, 0xFC, 0x1F, 0x81, 0xE0, 0x01, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0,
  0x0F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0,
  0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00,
  0x70, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x08, 0x00, 0x03, 0x80,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0,
  0x07, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0x1E, 0x0F, 0x81, 0xF0, 0x3C, 0x3E, 0x0F, 0xF8, 0x78, 0x78,
  0x3F, 0xF8, 0xF1, 0xF0, 0xFF, 0xF1, 0xE3, 0xC3, 0xF3, 0xE3, 0xCF, 0x87,
  0xC7, 0xC7, 0x9F, 0x1F, 0x0F, 0x0F, 0x3C, 0x3E, 0x1E, 0x1E, 0xF8, 0xF8,
  0x7C, 0x3D, 0xF1, 0xF0, 0xF8, 0x7B, 0xE3, 0xE1, 0xE0, 0xF7, 0x8F, 0xC3,
  0xC3, 0xCF, 0x1F, 0x0F, 0x87, 0x9E, 0x3E, 0x1F, 0x0F, 0x7C, 0x7C, 0x3C,
  0x1C, 0xF8, 0xF8, 0xF8, 0x79, 0xF1, 0xF9, 0xF1, 0xE3, 0xE1, 0xFF, 0xFF,
  0xC7, 0xC3, 0xFF, 0xFF, 0x07, 0x83, 0xF3, 0xFC, 0x0F, 0x03, 0xC3, 0xE0,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x07, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03,
  0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x3F, 0x80,
  0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F,
  0xCF, 0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0,
  0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x03,
  0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x7E, 0x03, 0xFC, 0x7E, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC1,
  0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x0F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x83, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x8F, 0xFE, 0x7F, 0x8F, 0xFE, 0x7F, 0x0F, 0xFE, 0x7F, 0x0F,
  0xFE, 0x7F, 0x0F, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x87, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F,
  0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x83, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x07,
  0xFE, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE3, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE7,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFD, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFD, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF,
  0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0x81, 0xFB, 0xE3, 0xFF, 0xE0, 0x7E, 0xF8, 0xFB,
  0xF8, 0x3F, 0xBE, 0x7E, 0xFE, 0x0F, 0xEF, 0x9F, 0x3F, 0x03, 0xF9, 0xE7,
  0xDF, 0xC0, 0xFE, 0x7B, 0xE7, 0xF0, 0x3F, 0x9E, 0xF9, 0xFC, 0x1F, 0xE7,
  0xFE, 0x7F, 0x07, 0xF1, 0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0xCF, 0xE0, 0x7F,
  0x1F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x3F, 0x83,
  0xFC, 0x7F, 0x1F, 0xE0, 0xFE, 0x1F, 0xC7, 0xF8, 0x3F, 0x83, 0xE1, 0xFC,
  0x0F, 0xE0, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFC,
  0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFC, 0x1F, 0xF0,
  0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x7F, 0xE0, 0xFE, 0x0F, 0xFC, 0x3F, 0xC1,
  0xFF, 0x87, 0xF0, 0x7F, 0xF8, 0xFE, 0x0F, 0xFF, 0x1F, 0xC1, 0xFD, 0xE3,
  0xF8, 0x3F, 0xBC, 0x7F, 0x07, 0xF7, 0x9F, 0xE0, 0xFE, 0xFB, 0xF8, 0x3F,
  0xCF, 0x7F, 0x07, 0xF1, 0xEF, 0xE0, 0xFE, 0x3D, 0xFC, 0x1F, 0xC7, 0xFF,
  0x83, 0xF8, 0xFF, 0xF0, 0xFF, 0x0F, 0xFC, 0x1F, 0xC1, 0xFF, 0x83, 0xF8,
  0x3F, 0xF0, 0x7F, 0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0xC1, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0xFF, 0x7F,
  0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x03, 0xFC, 0x7F, 0x87, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0xFF, 0x1F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F,
  0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x87, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFF, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0x9F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xFE,
  0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F,
  0xE1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x81,
  0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xCF, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F,
  0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x03, 0xF0,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x3F,
  0x9F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC1, 0xFF, 0xF8, 0x7F, 0x0F, 0xEF, 0xE1, 0xFC, 0x3F, 0xBF, 0x8F, 0xF0,
  0xFE, 0xFE, 0x3F, 0xC7, 0xFB, 0xF8, 0xFF, 0x1F, 0xCF, 0xE7, 0xFC, 0x7F,
  0x3F, 0x9F, 0xF3, 0xFC, 0xFC, 0x7F, 0xCF, 0xE3, 0xF3, 0xFF, 0x3F, 0x8F,
  0xCF, 0xFC, 0xFE, 0x3F, 0x3F, 0xF7, 0xF0, 0xFD, 0xFF, 0xDF, 0xC3, 0xF7,
  0xFF, 0x7F, 0x0F, 0xDF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB, 0xFF,
  0xC0, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xE0,
  0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC3,
  0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x83, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xFC,
  0x3F, 0x03, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x8F, 0xE0,
  0x3F, 0x8F, 0xE0, 0x1F, 0x9F, 0xC0, 0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0x80,
  0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x0F, 0xBC, 0x0F, 0xBE, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E,
  0x3E, 0x1E, 0x7E, 0x1E, 0x7C, 0x1E, 0xFC, 0x1F, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x9F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F,
  0x00, 0x0F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFE, 0x3F, 0xBF, 0xC7, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xCF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0x7F, 0x07, 0xCF, 0xE0,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xDF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3,
  0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7E,
  0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xCF, 0xF0, 0xFC, 0x7C, 0x00, 0x01,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xF7, 0xF1, 0xFD, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC3, 0xFB, 0xF0, 0xFC, 0xFC,
  0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3E, 0x7F, 0x03, 0xFD, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3,
  0xF0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0xC3, 0xF3, 0xF8, 0x7F, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x06, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0xFE, 0x07, 0xFD, 0xF8, 0x1F, 0xFB, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83,
  0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x20,
  0x3F, 0x80, 0xF1, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF9, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF1,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87,
  0xF1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F,
  0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0xC0, 0x03, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xF0, 0xFE, 0x3F,
  0xE1, 0xFC, 0xFF, 0x83, 0xF9, 0xFE, 0x07, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xE0, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xCF, 0x83, 0xE0, 0x7F,
  0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xF8, 0x7F, 0x1F, 0xCF, 0xE1, 0xFC,
  0x7F, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE, 0x3F, 0x87, 0xF3, 0xF8, 0xFE, 0x1F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xE3, 0xF9, 0xFC, 0x3F, 0x8F, 0xE7,
  0xF1, 0xFC, 0x3F, 0x9F, 0xC7, 0xF0, 0xFE, 0x7F, 0x1F, 0xC3, 0xF1, 0xFC,
  0x7F, 0x1F, 0xCF, 0xE1, 0xFC, 0x7F, 0x3F, 0x87, 0xF1, 0xFC, 0xFE, 0x3F,
  0x87, 0xF3, 0xF8, 0xFE, 0x1F, 0xCF, 0xE3, 0xF8, 0x7E, 0x00, 0x0F, 0xE7,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xE1, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0xC3, 0xFB, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xBF, 0x07, 0xF7, 0xE0,
  0xFE, 0xFE, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7E,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFE, 0xFF, 0x03, 0xF9, 0xF0, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE3,
  0xF0, 0xFF, 0x7F, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE,
  0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFC, 0x1F, 0xCF,
  0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xCF, 0x1F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFE, 0x00, 0x1F, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0x9F, 0xC7, 0xF3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE1, 0xFF, 0xEF, 0xFF,
  0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x3F,
  0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xE3,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F,
  0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0x3F, 0x00, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFB, 0xF8, 0x7F, 0x7F, 0x1F, 0xE7, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F,
  0x9F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F,
  0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x3E, 0x1F, 0xFF, 0x8F, 0x87, 0xEF, 0xE3,
  0xE3, 0xF9, 0xF9, 0xFC, 0xFE, 0x7E, 0x7F, 0x3F, 0x1F, 0x9F, 0xCF, 0xC7,
  0xEF, 0xF7, 0xF1, 0xF3, 0xFD, 0xF8, 0x7D, 0xFF, 0x7E, 0x1F, 0x7F, 0xFF,
  0x07, 0xDF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF7,
  0xFE, 0x07, 0xFD, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F,
  0xE3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xFE, 0x0F, 0xE3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x3F, 0x7F, 0x00, 0x7E, 0xFE,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0x3F, 0x01, 0xFE, 0x7E, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF1,
  0xFE, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0xFE, 0x03, 0xF3, 0xF8,
  0x0F, 0xDF, 0xE0, 0x3F, 0x7F, 0x00, 0xFD, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x10, 0x03, 0x80, 0x3E,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x0E, 0x00, 0x20, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x03, 0x00,
  0x1C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x81, 0xFC, 0x1F, 0xC1,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x07,
  0xCF, 0xFC, 0x3E, 0x7F, 0xE3, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF1,
  0xFF, 0x8F, 0x07, 0xFC, 0xF8, 0x3F, 0xC0, 0x00, 0x78, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 13, 31, 11, 0, -31 },
  { 52, 14, 12, 14, 2, -33 },
  { 73, 22, 31, 22, 0, -31 },
  { 159, 21, 39, 22, 1, -35 },
  { 262, 21, 31, 27, 4, -31 },
  { 344, 23, 31, 25, 0, -31 },
  { 434, 7, 12, 7, 2, -33 },
  { 445, 14, 45, 14, 2, -35 },
  { 524, 14, 44, 14, -2, -34 },
  { 601, 19, 19, 20, 2, -31 },
  { 647, 18, 22, 20, 1, -26 },
  { 697, 10, 14, 12, -2, -5 },
  { 715, 12, 6, 18, 3, -17 },
  { 724, 8, 7, 13, 1, -7 },
  { 731, 19, 34, 13, -3, -31 },
  { 812, 19, 31, 22, 2, -31 },
  { 886, 14, 31, 22, 5, -31 },
  { 941, 21, 31, 22, 0, -31 },
  { 1023, 21, 31, 22, 0, -31 },
  { 1105, 20, 31, 22, 1, -31 },
  { 1183, 21, 31, 22, 1, -31 },
  { 1265, 19, 31, 22, 1, -31 },
  { 1339, 22, 31, 22, 1, -31 },
  { 1425, 20, 31, 22, 1, -31 },
  { 1503, 18, 31, 22, 3, -31 },
  { 1573, 11, 24, 13, 1, -24 },
  { 1606, 13, 33, 12, -2, -24 },
  { 1660, 18, 21, 19, 1, -24 },
  { 1708, 20, 16, 22, 1, -22 },
  { 1748, 18, 22, 19, 0, -24 },
  { 1798, 17, 31, 20, 3, -31 },
  { 1864, 31, 40, 33, 0, -30 },
  { 2019, 25, 31, 26, -2, -31 },
  { 2116, 24, 31, 24, 0, -31 },
  { 2209, 24, 31, 24, 1, -31 },
  { 2302, 24, 31, 24, 0, -31 },
  { 2395, 23, 31, 21, 0, -31 },
  { 2485, 23, 31, 20, 0, -31 },
  { 2575, 24, 31, 25, 1, -31 },
  { 2668, 27, 31, 26, 0, -31 },
  { 2773, 13, 31, 12, 0, -31 },
  { 2824, 22, 31, 21, 0, -31 },
  { 2910, 28, 31, 24, 0, -31 },
  { 3019, 18, 31, 20, 0, -31 },
  { 3089, 34, 31, 32, 0, -31 },
  { 3221, 27, 31, 26, 0, -31 },
  { 3326, 24, 31, 26, 1, -31 },
  { 3419, 24, 31, 25, 0, -31 },
  { 3512, 24, 37, 26, 1, -31 },
  { 3623, 24, 31, 24, 0, -31 },
  { 3716, 23, 31, 24, 1, -31 },
  { 3806, 23, 31, 24, 3, -31 },
  { 3896, 25, 31, 25, 1, -31 },
  { 3993, 25, 31, 25, 3, -31 },
  { 4090, 30, 31, 32, 4, -31 },
  { 4207, 29, 31, 24, -2, -31 },
  { 4320, 24, 31, 24, 3, -31 },
  { 4413, 26, 31, 23, -1, -31 },
  { 4514, 15, 45, 11, -1, -37 },
  { 4599, 12, 34, 16, 3, -31 },
  { 4650, 16, 45, 11, -3, -37 },
  { 4740, 16, 16, 17, 1, -31 },
  { 4772, 17, 5, 17, -3, 0 },
  { 4783, 11, 7, 15, 4, -33 },
  { 4793, 19, 23, 20, 0, -23 },
  { 4848, 20, 33, 21, 0, -33 },
  { 4931, 18, 23, 20, 1, -23 },
  { 4983, 22, 33, 21, 1, -33 },
  { 5074, 19, 23, 21, 1, -23 },
  { 5129, 16, 33, 14, 1, -33 },
  { 5195, 23, 32, 22, -1, -23 },
  { 5287, 21, 33, 21, -1, -33 },
  { 5374, 12, 32, 11, 0, -32 },
  { 5422, 17, 41, 11, -5, -32 },
  { 5510, 23, 33, 21, 0, -33 },
  { 5605, 13, 33, 11, 0, -33 },
  { 5659, 30, 23, 31, 0, -23 },
  { 5746, 21, 23, 21, -1, -23 },
  { 5807, 19, 23, 21, 1, -23 },
  { 5862, 22, 32, 21, -2, -23 },
  { 5950, 20, 32, 21, 1, -23 },
  { 6030, 16, 23, 15, 0, -23 },
  { 6076, 19, 23, 19, 0, -23 },
  { 6131, 13, 29, 13, 1, -29 },
  { 6179, 20, 23, 21, 1, -23 },
  { 6237, 19, 23, 20, 2, -23 },
  { 6292, 26, 23, 27, 2, -23 },
  { 6367, 23, 23, 20, -2, -23 },
  { 6434, 22, 32, 20, -1, -23 },
  { 6522, 21, 23, 20, -1, -23 },
  { 6583, 13, 42, 13, 1, -34 },
  { 6652, 9, 37, 11, 1, -31 },
  { 6694, 13, 42, 13, -1, -34 },
  { 6763, 21, 10, 23, 1, -18 },
};

const GFXfont RobotoCondensed_BlackItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_BLACKITALIC44PT7B_H_
