#ifndef _ROBOTOCONDENSED_BLACKITALIC30PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0x3E, 0x1F, 0x0F,
  0x83, 0x80, 0x7B, 0xDE, 0xF7, 0x39, 0xCE, 0x73, 0x9C, 0xEE, 0x73, 0x9C,
  0x01, 0xDC, 0x03, 0xB8, 0x06, 0x70, 0x1D, 0xC0, 0x3B, 0x80, 0x67, 0x07,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x1C, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xCE,
  0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x39, 0x80, 0x77, 0x00, 0xEE, 0x03,
  0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0x8F, 0x9E, 0x3E, 0x7C, 0xF1, 0xF3,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xCF, 0x0F, 0x3C, 0x7C, 0xF9, 0xF3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0,
  0x1F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE1,
  0x39, 0xCE, 0xE7, 0x3B, 0x9D, 0xCE, 0xEE, 0x3F, 0xB8, 0xFF, 0xC1, 0xEE,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0xF0, 0x3F, 0xE1, 0xFF, 0xCE, 0xE7, 0x73,
  0x9D, 0xCE, 0x7E, 0x3B, 0xD0, 0xFE, 0x03, 0xF8, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0x38, 0x1E, 0x38, 0x1E, 0x78,
  0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xCF, 0x3F, 0xCF,
  0x7F, 0xFE, 0x7B, 0xFE, 0xF9, 0xFE, 0xF9, 0xFC, 0xF8, 0xFC, 0x7F, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0x3E, 0x39, 0xDE, 0xF7, 0x39, 0xCE, 0x00,
  0x80, 0x60, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x06,
  0x00, 0x80, 0x04, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1,
  0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x02,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE2, 0x7B, 0xB9, 0xFF, 0xE1,
  0xFF, 0x03, 0xE0, 0x1F, 0x80, 0xF7, 0x07, 0x9C, 0x0C, 0x38, 0x10, 0x80,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x9E, 0x38, 0x20, 0x7F, 0xFF, 0xFF, 0xFF,
  0x77, 0xFF, 0xF7, 0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC,
  0x3F, 0xF3, 0xE7, 0x9E, 0x3D, 0xF1, 0xEF, 0x8F, 0x7C, 0x7B, 0xC3, 0xDE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xDF, 0x1E, 0xF9, 0xF7, 0xCF,
  0x1F, 0xF8, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x00, 0xC1, 0xF1, 0xF9, 0xFE,
  0x7F, 0xBF, 0xEC, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x03,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE3, 0xC7, 0xC7, 0x8F, 0x9F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xE7, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xE3, 0xE3, 0xC7, 0xC7, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0xF8,
  0xF9, 0xF1, 0xF1, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE,
  0x03, 0xBC, 0x0F, 0xF8, 0x1D, 0xF0, 0x7B, 0xE1, 0xE7, 0xC3, 0xCF, 0x0F,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x7F, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xE1, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x78,
  0xF8, 0xF1, 0xF1, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0xE1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xBC,
  0x7F, 0xF3, 0xFF, 0x9F, 0xFD, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xF7, 0xCF, 0x9F, 0xF8, 0xFF, 0xC3, 0xFC, 0x0F, 0x80, 0x3F,
  0xFE, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0xFE,
  0x3E, 0x78, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF8, 0x7F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0xE3, 0xE7, 0xCF, 0x8F, 0x3E, 0x7C, 0xF1, 0xF3, 0xE7,
  0xCF, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x07, 0x81, 0xFE, 0x3F,
  0xE7, 0xFF, 0x7C, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF9,
  0xFF, 0xFF, 0x7F, 0xF7, 0xFE, 0x3F, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x7F,
  0x87, 0xF0, 0x7C, 0x07, 0x00, 0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x1F, 0x3E, 0x7C, 0x70, 0x07, 0x07, 0xC7, 0xE1,
  0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x03, 0x00, 0x00, 0x08, 0x03,
  0x80, 0x7C, 0x0F, 0xE3, 0xFF, 0x3F, 0xE1, 0xF8, 0x0F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0x20, 0x3F, 0xFB, 0xFF, 0xDF,
  0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xF7, 0xFF,
  0x3F, 0xF8, 0x10, 0x00, 0xE0, 0x0F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x07, 0xC0, 0x7E, 0x1F, 0xF3, 0xFE, 0x1F, 0xC0, 0xF8, 0x07, 0x00, 0x40,
  0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFE, 0xF9, 0xFF, 0x9F, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x7C, 0x07, 0xC0, 0x78, 0x03, 0x80, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x80, 0xE0, 0x70, 0x07, 0x07,
  0x00, 0x1C, 0x78, 0xF8, 0xE3, 0x8F, 0xE7, 0x3C, 0xFF, 0x19, 0xCF, 0x38,
  0xCE, 0x71, 0xC6, 0xE3, 0x8E, 0x77, 0x3C, 0xF3, 0xB9, 0xC7, 0x1D, 0xCE,
  0x38, 0xFC, 0x71, 0xC6, 0xE3, 0x9E, 0x77, 0x1C, 0xF3, 0xB8, 0xFF, 0xF9,
  0xC7, 0xFF, 0x8E, 0x1C, 0x78, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x08, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7, 0x81,
  0xF3, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0x9F, 0x03, 0xCF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7C, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x7E, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F,
  0xFC, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3E, 0x3E, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xE0, 0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F,
  0x3E, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x7C, 0x7C, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x1F, 0x3E,
  0x1F, 0x7C, 0x1F, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0xFE, 0xF8,
  0xFE, 0xF8, 0xFE, 0xF8, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0x7C,
  0x7C, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xC0, 0x1F, 0x03, 0xC3,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F,
  0x81, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x7C, 0x7C, 0xF9, 0xF1, 0xF3,
  0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x0F, 0xE3,
  0xE1, 0xF8, 0x7C, 0x7E, 0x0F, 0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0xFC, 0x0F,
  0x9F, 0x01, 0xF7, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC7,
  0xF8, 0x7F, 0x8E, 0xF0, 0xF7, 0x3F, 0xE1, 0xEE, 0x7F, 0xC7, 0xDC, 0xEF,
  0x8F, 0xBB, 0xDF, 0x1F, 0x7F, 0x3C, 0x3E, 0xFE, 0xF8, 0x7D, 0xFD, 0xF0,
  0xF9, 0xF3, 0xE3, 0xE3, 0xE7, 0xC7, 0xC7, 0x8F, 0x8F, 0x8F, 0x3E, 0x1F,
  0x1C, 0x7C, 0x00, 0x1F, 0x03, 0xC7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7E, 0x1F,
  0x1F, 0x87, 0xC7, 0xF1, 0xF3, 0xFC, 0x78, 0xFF, 0x3E, 0x3F, 0xCF, 0x8F,
  0xF3, 0xE3, 0xEE, 0xF8, 0xFB, 0xBE, 0x7C, 0xFF, 0x1F, 0x3F, 0xC7, 0xCF,
  0xF1, 0xF1, 0xFC, 0x7C, 0x7F, 0x1F, 0x1F, 0xCF, 0x87, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3F, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7C, 0x7C, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xF1, 0xF0,
  0xF8, 0x78, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F,
  0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xC0, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x1F, 0x3E, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0x7C, 0x7C,
  0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x70, 0x00, 0x20, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF,
  0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F,
  0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF,
  0x8F, 0x9F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0x00, 0x3E, 0x78, 0x3C, 0xF0, 0xF9, 0xF1, 0xF3, 0xFF, 0xE3,
  0xFF, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x0F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x7C, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xBF, 0x0F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3,
  0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E,
  0x0F, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0xF8, 0xFF, 0xC7, 0xC7, 0xFE, 0x3E, 0x7D, 0xF3, 0xF3, 0xEF, 0x9F,
  0x9F, 0x7C, 0xFC, 0xF1, 0xE7, 0xEF, 0x8F, 0x7F, 0x7C, 0x7B, 0xFB, 0xE3,
  0xDF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xBF,
  0xC1, 0xFD, 0xFE, 0x0F, 0xEF, 0xE0, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x1F,
  0x9F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x00, 0x0F, 0x87,
  0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0x79, 0xF8, 0x0F, 0xBE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0x7C, 0x07, 0xE7, 0x80, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE1,
  0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x3C, 0xF8, 0x3C, 0xF8, 0x3D, 0xF0, 0x3D, 0xF0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0xF8, 0xF8, 0x78, 0x78,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8,
  0x00, 0x07, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9C, 0xE7, 0x79,
  0xDC, 0x7F, 0x1C, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF8, 0xF8, 0xF1,
  0xE1, 0xE0, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x7F, 0xF3, 0xCF, 0x80, 0x7C,
  0x3F, 0xC7, 0xFE, 0x7F, 0xF7, 0xCF, 0xBE, 0x7D, 0xF3, 0xEF, 0xFF, 0x7F,
  0xF1, 0xFF, 0x87, 0xBE, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0xCF,
  0x1F, 0x3C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x1E, 0x7C, 0x79, 0xE3, 0xEF,
  0x8F, 0xBF, 0xFC, 0xFF, 0xF3, 0xDF, 0x8F, 0x3C, 0x00, 0x07, 0xC0, 0xFF,
  0x8F, 0xFC, 0x7F, 0xF7, 0xC7, 0xBE, 0x7D, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x3C, 0xF3, 0xE7, 0xFE, 0x3F, 0xF0, 0xFF, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x0F, 0x3C, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x7F,
  0x87, 0xFE, 0x7F, 0xF3, 0xC7, 0xBE, 0x3D, 0xF1, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xDE, 0x00, 0xF8, 0xC7, 0xFE, 0x3F, 0xF8, 0xFF, 0x81, 0xF8, 0x03,
  0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF0, 0x7C, 0x0F, 0x87, 0xFC, 0xFF, 0x9F,
  0xF0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x0F, 0xBE, 0x3F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3C, 0x3C, 0x78, 0x79,
  0xF1, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF8, 0x01, 0xF0, 0x83, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xDE, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x78, 0xF7, 0xC7, 0xBE, 0x3D,
  0xF3, 0xEF, 0x9F, 0x78, 0xFB, 0xC7, 0xFE, 0x3D, 0xF1, 0xEF, 0x9F, 0x7C,
  0xFB, 0xC7, 0xC0, 0x0E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF8, 0xF8, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x7E, 0x3E, 0x7C, 0x3E, 0xF8, 0x3F, 0xF8, 0x3D, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xF9, 0xE0,
  0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0x0F, 0x07, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE0, 0x3E, 0xF1,
  0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3C, 0x78, 0xF3, 0xC7,
  0x8F, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x78,
  0xF1, 0xF7, 0x8F, 0x1E, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E, 0xF9, 0xF3, 0xEF,
  0x9F, 0x3E, 0x3E, 0xF1, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xC7, 0xBE, 0x3D,
  0xF1, 0xEF, 0x9F, 0x7C, 0xFB, 0xC7, 0xDE, 0x3F, 0xF1, 0xEF, 0x8F, 0x7C,
  0xFB, 0xE7, 0xDE, 0x3E, 0x07, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7C,
  0x79, 0xF1, 0xF7, 0xC7, 0xDE, 0x1E, 0x78, 0x7B, 0xE3, 0xE7, 0x8F, 0x9E,
  0x3E, 0x7F, 0xF1, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE1, 0xE3, 0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E,
  0x3C, 0x7C, 0x78, 0xF1, 0xF1, 0xE3, 0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFC,
  0x3E, 0xF0, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x00, 0x0F, 0x3C, 0x7E, 0xF3, 0xFF, 0xCF, 0xFF, 0x7C, 0x7D, 0xF1,
  0xE7, 0x87, 0x9E, 0x3E, 0x78, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3C, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x7D, 0xF7, 0xCF, 0xBE,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x7D, 0xE3, 0xEF, 0xBE,
  0x3F, 0xF1, 0xFF, 0x03, 0xE0, 0x1E, 0x1F, 0x0F, 0x87, 0xC7, 0xFF, 0xFB,
  0xFC, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xFE,
  0x7F, 0x1F, 0x07, 0x80, 0x7C, 0x79, 0xF1, 0xE7, 0xCF, 0x9E, 0x3E, 0x78,
  0xFB, 0xE3, 0xEF, 0x8F, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0xCF, 0x1F, 0x3C,
  0x7C, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0xF8, 0xFB, 0xC7, 0xDE,
  0x7C, 0xF3, 0xE7, 0x9E, 0x3D, 0xF1, 0xEF, 0x8F, 0x78, 0x7F, 0xC3, 0xFC,
  0x1F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0xF3, 0xCF,
  0xF9, 0xE7, 0xFC, 0xF3, 0xDE, 0xFB, 0xEF, 0x7D, 0xE7, 0xBE, 0xF3, 0xFF,
  0x79, 0xFF, 0xF8, 0xFF, 0xFC, 0x7E, 0xFE, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F,
  0x9F, 0x87, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xE0, 0x1E, 0x3E, 0x3E, 0xF8,
  0x7D, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xFF, 0x83, 0xFF, 0x0F, 0x9E, 0x1F, 0x3C,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x3E, 0x1E, 0x7E, 0x1E, 0x7C, 0x1E, 0x7C,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0x01, 0x03, 0x83, 0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C,
  0x1E, 0x0F, 0x07, 0x8F, 0x87, 0xC3, 0x81, 0xE0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x0C, 0x02, 0x00, 0x0E, 0x1C,
  0x38, 0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC0, 0x04, 0x07, 0x03,
  0xC1, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8,
  0x3C, 0x1E, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x78, 0x7C, 0x3C, 0x08, 0x00, 0x3C, 0x01, 0xF8, 0xF7, 0xF3, 0xFF, 0xFE,
  0xF3, 0xFB, 0x8F, 0xC0, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 22, 8, 0, -22 },
  { 26, 10, 8, 9, 1, -23 },
  { 36, 15, 22, 15, 0, -22 },
  { 78, 14, 28, 15, 1, -25 },
  { 127, 14, 22, 19, 3, -22 },
  { 166, 16, 22, 17, 0, -22 },
  { 210, 5, 8, 5, 1, -23 },
  { 215, 10, 31, 9, 1, -24 },
  { 254, 9, 31, 9, -1, -24 },
  { 289, 14, 13, 14, 1, -22 },
  { 312, 12, 16, 13, 1, -18 },
  { 336, 7, 9, 8, -2, -4 },
  { 344, 8, 4, 12, 2, -11 },
  { 348, 5, 5, 9, 1, -5 },
  { 352, 13, 24, 9, -2, -22 },
  { 391, 13, 22, 15, 1, -22 },
  { 427, 10, 22, 15, 3, -22 },
  { 455, 15, 22, 15, 0, -22 },
  { 497, 15, 22, 15, 0, -22 },
  { 539, 15, 22, 15, 0, -22 },
  { 581, 15, 22, 15, 0, -22 },
  { 623, 13, 22, 15, 1, -22 },
  { 659, 15, 22, 15, 1, -22 },
  { 701, 14, 22, 15, 1, -22 },
  { 740, 12, 22, 15, 2, -22 },
  { 773, 7, 17, 9, 1, -17 },
  { 788, 9, 22, 8, -1, -17 },
  { 813, 13, 14, 13, 0, -16 },
  { 836, 13, 11, 15, 1, -15 },
  { 854, 13, 14, 13, 0, -16 },
  { 877, 12, 22, 13, 2, -22 },
  { 910, 21, 28, 22, 0, -21 },
  { 984, 17, 22, 18, -1, -22 },
  { 1031, 16, 22, 17, 0, -22 },
  { 1075, 16, 22, 17, 1, -22 },
  { 1119, 16, 22, 16, 0, -22 },
  { 1163, 16, 22, 14, 0, -22 },
  { 1207, 15, 22, 14, 0, -22 },
  { 1249, 16, 22, 17, 1, -22 },
  { 1293, 19, 22, 18, 0, -22 },
  { 1346, 9, 22, 8, 0, -22 },
  { 1371, 15, 22, 14, 0, -22 },
  { 1413, 19, 22, 16, 0, -22 },
  { 1466, 12, 22, 14, 0, -22 },
  { 1499, 23, 22, 22, 0, -22 },
  { 1563, 18, 22, 18, 0, -22 },
  { 1613, 16, 22, 18, 1, -22 },
  { 1657, 17, 22, 17, 0, -22 },
  { 1704, 16, 26, 18, 1, -22 },
  { 1756, 16, 22, 17, 0, -22 },
  { 1800, 15, 22, 16, 1, -22 },
  { 1842, 16, 22, 16, 2, -22 },
  { 1886, 17, 22, 17, 1, -22 },
  { 1933, 17, 22, 17, 2, -22 },
  { 1980, 21, 22, 22, 2, -22 },
  { 2038, 19, 22, 16, -1, -22 },
  { 2091, 16, 22, 16, 2, -22 },
  { 2135, 18, 22, 16, -1, -22 },
  { 2185, 11, 30, 8, -1, -25 },
  { 2227, 8, 24, 11, 2, -22 },
  { 2251, 11, 30, 8, -2, -25 },
  { 2293, 10, 11, 12, 1, -22 },
  { 2307, 12, 4, 12, -2, 0 },
  { 2313, 7, 5, 10, 3, -23 },
  { 2318, 13, 16, 14, 0, -16 },
  { 2344, 14, 23, 14, 0, -23 },
  { 2385, 13, 16, 13, 0, -16 },
  { 2411, 16, 23, 14, 0, -23 },
  { 2457, 13, 16, 14, 0, -16 },
  { 2483, 11, 23, 10, 1, -23 },
  { 2515, 15, 22, 15, 0, -16 },
  { 2557, 13, 23, 14, 0, -23 },
  { 2595, 8, 23, 8, 0, -23 },
  { 2618, 12, 29, 7, -4, -23 },
  { 2662, 16, 23, 14, 0, -23 },
  { 2708, 9, 23, 8, 0, -23 },
  { 2734, 20, 16, 21, 0, -16 },
  { 2774, 13, 16, 14, 0, -16 },
  { 2800, 14, 16, 14, 0, -16 },
  { 2828, 15, 22, 14, -1, -16 },
  { 2870, 14, 22, 14, 0, -16 },
  { 2909, 11, 16, 10, 0, -16 },
  { 2931, 13, 16, 13, 0, -16 },
  { 2957, 9, 20, 9, 1, -20 },
  { 2980, 14, 16, 14, 1, -16 },
  { 3008, 13, 16, 13, 1, -16 },
  { 3034, 17, 16, 18, 2, -16 },
  { 3068, 15, 16, 13, -1, -16 },
  { 3098, 16, 22, 13, -1, -16 },
  { 3142, 14, 16, 13, -1, -16 },
  { 3170, 9, 28, 9, 1, -23 },
  { 3202, 7, 26, 7, 0, -22 },
  { 3225, 9, 28, 9, -1, -23 },
  { 3257, 14, 7, 16, 1, -12 },
};

const GFXfont RobotoCondensed_BlackItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_BLACKITALIC30PT7B_H_
