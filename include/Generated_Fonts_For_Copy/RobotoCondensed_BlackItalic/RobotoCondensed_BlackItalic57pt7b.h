#ifndef _ROBOTOCONDENSED_BLACKITALIC57PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8,
  0xFE, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x87,
  0xC3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x0C, 0x1F, 0x8F, 0x81, 0xE7, 0xE1, 0xF0, 0x7E, 0xFC, 0x3E, 0x1F, 0x9F,
  0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xC7, 0xE7,
  0xC1, 0xF8, 0xFD, 0xF8, 0x3F, 0xFF, 0x7E, 0x03, 0xFF, 0xEF, 0x80, 0x7F,
  0xFB, 0xF0, 0x07, 0xFE, 0xFC, 0x00, 0x7F, 0x9F, 0x00, 0x01, 0x87, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xEF, 0xFF,
  0x00, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xDF, 0x8F, 0xC1, 0xF3,
  0xF1, 0xF8, 0x7E, 0x7C, 0x3F, 0x1F, 0x8F, 0x87, 0xE3, 0xE3, 0xF0, 0xFC,
  0xFC, 0x7E, 0x1F, 0xBF, 0x0F, 0xC3, 0xE7, 0xC0, 0xF8, 0xFC, 0x78, 0x1F,
  0xFF, 0x82, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF1, 0xFE, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xC3, 0xFF, 0xF8,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0xCF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xF3, 0xFF, 0xFE, 0x7F, 0xCF, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFC, 0x7F, 0xFF, 0x1F, 0xF0, 0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0xE1, 0xFF,
  0x07, 0xFF, 0x07, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xDF, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F,
  0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xE0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x80, 0x7C, 0x04, 0x70, 0x3E, 0x0E, 0x7E, 0x1E, 0x3F, 0x3F, 0xCF, 0x7F,
  0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xF7,
  0xC0, 0x07, 0xF3, 0xF0, 0x07, 0xF0, 0xF8, 0x07, 0xF8, 0x7E, 0x03, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x18, 0x07, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0,
  0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0xC0, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0x00, 0x1E, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x3F, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF8,
  0xFF, 0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE,
  0x07, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F,
  0xE0, 0xFF, 0x9F, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7,
  0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFC, 0xFF, 0x83, 0xFE,
  0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F,
  0xEF, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07,
  0xFC, 0xFF, 0x83, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xF3, 0xF3, 0xFC, 0xE1, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F,
  0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xEF,
  0xF8, 0x01, 0xFD, 0xFF, 0x00, 0x7F, 0x3F, 0xE0, 0x1F, 0xCF, 0xF8, 0x03,
  0xF9, 0xFF, 0x00, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF0, 0xFF,
  0x81, 0xFE, 0x1F, 0xF0, 0x7F, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFD, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0x7F,
  0xF0, 0x0F, 0x83, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE7, 0xE0, 0x3F, 0xEF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x7F, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE,
  0x7F, 0x83, 0xFE, 0x7F, 0x87, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x7F,
  0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x87,
  0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFC, 0xFF, 0x87,
  0xFD, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xBF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7E, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x1F,
  0xE0, 0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x03,
  0xF0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0x87, 0xFD, 0xFF, 0x0F,
  0xFF, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xFF, 0xC0, 0xF8, 0x1F, 0x81, 0xFF,
  0xF8, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE, 0x3E, 0x0F, 0xC0, 0xFF, 0xFE, 0x1F,
  0x07, 0xE0, 0xFF, 0x3F, 0x0F, 0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xE3, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF1, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0xFC, 0x3F, 0x83, 0xF0, 0x7C, 0x7E, 0x1F, 0x81, 0xF8, 0x3E,
  0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x3F, 0x0F, 0xE0, 0xFC, 0x0F, 0x9F, 0x87,
  0xF0, 0x7E, 0x0F, 0xCF, 0xC3, 0xF8, 0x3F, 0x07, 0xC7, 0xE1, 0xF8, 0x3F,
  0x03, 0xE3, 0xE0, 0xFC, 0x1F, 0x81, 0xF1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x7C, 0x1F, 0x87, 0xF0, 0xF8, 0x3E, 0x0F,
  0xC7, 0xF8, 0x7C, 0x1F, 0x07, 0xFF, 0xFC, 0xFC, 0x0F, 0x83, 0xFF, 0xFF,
  0xFE, 0x07, 0xC0, 0xFF, 0xDF, 0xFE, 0x03, 0xE0, 0x7F, 0xCF, 0xFE, 0x01,
  0xF8, 0x1F, 0xC3, 0xFC, 0x00, 0xFC, 0x01, 0x00, 0x30, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F,
  0xF9, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03,
  0xFE, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF,
  0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xF0, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xC7, 0xFC,
  0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00,
  0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03,
  0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x01, 0xFF,
  0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F,
  0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xC7, 0xFE,
  0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xC0, 0xFF, 0xC1, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07,
  0xFC, 0xFF, 0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0xF9, 0xFF, 0x07, 0xFF, 0xE7, 0xFC,
  0x1F, 0xFF, 0x9F, 0xF0, 0x7F, 0xFE, 0xFF, 0xC1, 0xFF, 0xFB, 0xFF, 0x0F,
  0xFF, 0xCF, 0xFC, 0x3F, 0xFF, 0x3F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F,
  0xF3, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xF0, 0x03, 0xFE,
  0x0F, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x7F, 0xC3, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xDF, 0xF0,
  0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFE,
  0xFE, 0x1F, 0xDF, 0xE0, 0x3F, 0xDF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFB, 0xF8,
  0x7F, 0xFF, 0x81, 0xFF, 0x7F, 0x1F, 0xDF, 0xF0, 0x3F, 0xEF, 0xE3, 0xFB,
  0xFE, 0x07, 0xFC, 0xFC, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0x9F, 0xDF, 0xF0,
  0x1F, 0xF3, 0xF3, 0xF3, 0xFE, 0x07, 0xFC, 0x7E, 0xFE, 0x7F, 0xC0, 0xFF,
  0x8F, 0xDF, 0xCF, 0xF8, 0x1F, 0xF1, 0xFF, 0xF1, 0xFF, 0x03, 0xFE, 0x3F,
  0xFE, 0x7F, 0xE0, 0x7F, 0xC7, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0xF1,
  0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE3, 0xFF, 0x87, 0xFC,
  0x0F, 0xF8, 0x7F, 0xF1, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x83,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x81, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xC0, 0x7F, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0xF8,
  0x7F, 0xE0, 0x7F, 0xDF, 0x0F, 0xF8, 0x0F, 0xFB, 0xE1, 0xFF, 0x01, 0xFF,
  0x7E, 0x3F, 0xE0, 0x3F, 0xEF, 0xC7, 0xFC, 0x0F, 0xFD, 0xF8, 0xFF, 0x81,
  0xFF, 0x9F, 0x3F, 0xF0, 0x3F, 0xE3, 0xE7, 0xFC, 0x07, 0xFC, 0x7E, 0xFF,
  0x80, 0xFF, 0x8F, 0xDF, 0xF0, 0x1F, 0xF0, 0xFB, 0xFE, 0x07, 0xFE, 0x1F,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xFE, 0x03, 0xFE,
  0x0F, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0,
  0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x9F, 0xF0, 0x03,
  0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x1F,
  0xF3, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF,
  0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F,
  0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F,
  0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x01,
  0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFD, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE,
  0xFF, 0xC0, 0x0F, 0xF9, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F,
  0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x87,
  0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x1F,
  0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x03,
  0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x0F,
  0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFE,
  0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00,
  0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F,
  0xC0, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE1, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x81, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF7, 0xFC, 0x1F, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0xE0, 0xFF, 0xDF,
  0xF0, 0xFF, 0xC1, 0xFF, 0x3F, 0xE1, 0xFF, 0x83, 0xFE, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0xFF, 0x8F, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xFC, 0x3F, 0xE3,
  0xFE, 0x3F, 0xF8, 0x7F, 0xC7, 0xFC, 0xFF, 0xF1, 0xFF, 0x0F, 0xF9, 0xFF,
  0xE3, 0xFE, 0x1F, 0xF3, 0xFF, 0xC7, 0xFC, 0x3F, 0xEF, 0xFF, 0x9F, 0xF0,
  0x7F, 0xDF, 0xFF, 0x3F, 0xE0, 0xFF, 0xBF, 0xFE, 0x7F, 0xC1, 0xFE, 0xFF,
  0xFD, 0xFF, 0x03, 0xFD, 0xFF, 0xFB, 0xFE, 0x07, 0xFB, 0xFF, 0xF7, 0xFC,
  0x0F, 0xF7, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0xFF, 0xFE,
  0x01, 0xFF, 0xFD, 0xFF, 0xFC, 0x03, 0xFF, 0xF3, 0xFF, 0xF8, 0x07, 0xFF,
  0xE7, 0xFF, 0xE0, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF,
  0x80, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF,
  0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF,
  0xC3, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x03, 0xFF,
  0x3F, 0xE0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0x3F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x07,
  0xFC, 0x03, 0xFC, 0x3F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xE3, 0xFE,
  0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xFB, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF,
  0xC0, 0xFC, 0xFC, 0x1F, 0xC7, 0xC1, 0xF8, 0x7E, 0x3F, 0x87, 0xE3, 0xF8,
  0x7E, 0x7F, 0x07, 0xE7, 0xF0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xF9, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0xC3,
  0xFE, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x8F,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x3F, 0xF7, 0xFC, 0x0F, 0xE7, 0xFC, 0x01, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x1F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07,
  0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF3, 0xFE,
  0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xE3,
  0xFE, 0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F,
  0xE7, 0xFC, 0x0F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0x7F, 0xFC, 0x3F,
  0xCF, 0xFE, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xE1, 0xFE,
  0x3F, 0xC1, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0xC1, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFC,
  0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x10, 0x7F, 0xC0, 0x1F, 0xE7, 0xFC, 0x07, 0xFF,
  0x7F, 0xC0, 0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFC,
  0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xF7, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F,
  0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x80, 0xFF, 0x81, 0xC0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xFE, 0x3F, 0xC0, 0x3F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80,
  0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00,
  0x04, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x02, 0x01,
  0xFF, 0x80, 0x38, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0xFF,
  0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x01,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x13, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0xFF,
  0xE0, 0x3F, 0xE7, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0xFF, 0xC0,
  0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x00,
  0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xF3,
  0xFC, 0x1F, 0xE0, 0x1F, 0xEF, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0xFB, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3,
  0xFE, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF,
  0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0x87, 0xFC,
  0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x8F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x3F, 0xE1, 0xFF,
  0x07, 0xFC, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xE3,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x3F, 0xE1, 0xFF, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F,
  0xE1, 0xFF, 0x1F, 0xF0, 0x7F, 0x9F, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7,
  0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F,
  0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07,
  0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFE,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x3F,
  0xE7, 0xF8, 0x07, 0xFC, 0x08, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0x8F, 0xF0, 0x7F, 0xF3, 0xFC, 0x3F, 0xFE, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xE1, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFC,
  0x7F, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07,
  0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE,
  0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3,
  0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x06, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF8, 0x83, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFF, 0x1F, 0xE1, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0xF8, 0x07, 0xFC, 0xFF, 0x07, 0xFC,
  0xFF, 0x07, 0xFC, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF8, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x04, 0x00, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8,
  0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x83,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F,
  0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xFE, 0xFF,
  0x87, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x8F, 0xFC, 0xFF, 0x8F, 0xF8, 0xFF,
  0x8F, 0xF8, 0x7F, 0x9F, 0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F,
  0xBF, 0xE0, 0x7F, 0xBF, 0xE0, 0x7F, 0xBF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0x83, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0x3F, 0xEF, 0xF0, 0xFF,
  0x1F, 0xF7, 0xF8, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0xC7, 0xF9, 0xFE, 0x3F,
  0xE7, 0xF8, 0xFF, 0x3F, 0xF3, 0xFC, 0x7F, 0x9F, 0xF9, 0xFE, 0x3F, 0xDF,
  0xFD, 0xFE, 0x1F, 0xEF, 0xFE, 0xFF, 0x0F, 0xF7, 0xFF, 0x7F, 0x87, 0xFF,
  0xFF, 0xBF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFB, 0xFF, 0xE0, 0x7F, 0xFD, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF8, 0x1F,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x03,
  0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x1F,
  0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x7F, 0xC0,
  0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x3F,
  0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0xFF,
  0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0x01,
  0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xCF, 0xFC, 0x01, 0xFE,
  0x7F, 0xC0, 0x0F, 0xF7, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFD, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x00,
  0x03, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xF1, 0xFF, 0xC0,
  0xFC, 0xFF, 0xF0, 0x7F, 0x3F, 0xFE, 0x1F, 0xDF, 0xFF, 0xCF, 0xE7, 0xFF,
  0xFF, 0xFB, 0xFC, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x3F, 0x03, 0xFF, 0xCF,
  0xC0, 0xFF, 0xE3, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 17, 42, 15, 0, -41 },
  { 91, 19, 16, 18, 2, -43 },
  { 129, 29, 41, 28, 0, -41 },
  { 278, 27, 54, 28, 1, -48 },
  { 461, 27, 43, 36, 5, -42 },
  { 607, 30, 43, 33, 0, -42 },
  { 769, 9, 16, 9, 3, -43 },
  { 787, 18, 58, 18, 2, -45 },
  { 918, 18, 58, 18, -2, -45 },
  { 1049, 25, 25, 26, 3, -41 },
  { 1128, 24, 30, 26, 1, -34 },
  { 1218, 13, 18, 15, -3, -7 },
  { 1248, 15, 7, 23, 4, -21 },
  { 1262, 10, 10, 17, 1, -9 },
  { 1275, 25, 44, 17, -4, -41 },
  { 1413, 25, 43, 28, 2, -42 },
  { 1548, 18, 41, 28, 6, -41 },
  { 1641, 28, 42, 28, 0, -42 },
  { 1788, 28, 43, 28, 0, -42 },
  { 1939, 27, 41, 28, 1, -41 },
  { 2078, 27, 42, 28, 1, -41 },
  { 2220, 24, 42, 28, 2, -41 },
  { 2346, 28, 41, 28, 2, -41 },
  { 2490, 27, 43, 28, 1, -42 },
  { 2636, 23, 42, 28, 4, -42 },
  { 2757, 14, 32, 16, 1, -31 },
  { 2813, 17, 42, 16, -2, -31 },
  { 2903, 23, 28, 25, 1, -31 },
  { 2984, 25, 19, 29, 2, -27 },
  { 3044, 23, 28, 25, 1, -31 },
  { 3125, 23, 43, 25, 3, -42 },
  { 3249, 41, 52, 42, 0, -39 },
  { 3516, 33, 41, 33, -3, -41 },
  { 3686, 31, 41, 31, 0, -41 },
  { 3845, 30, 43, 32, 2, -42 },
  { 4007, 30, 41, 31, 0, -41 },
  { 4161, 30, 41, 27, 0, -41 },
  { 4315, 29, 41, 26, 0, -41 },
  { 4464, 30, 43, 33, 2, -42 },
  { 4626, 35, 41, 34, 0, -41 },
  { 4806, 17, 41, 16, 0, -41 },
  { 4894, 29, 42, 27, 0, -41 },
  { 5047, 36, 41, 31, 0, -41 },
  { 5232, 24, 41, 27, 0, -41 },
  { 5355, 43, 41, 42, 0, -41 },
  { 5576, 35, 41, 34, 0, -41 },
  { 5756, 31, 43, 33, 2, -42 },
  { 5923, 32, 41, 32, 0, -41 },
  { 6087, 31, 49, 33, 2, -42 },
  { 6277, 31, 41, 31, 0, -41 },
  { 6436, 30, 43, 30, 1, -42 },
  { 6598, 30, 41, 31, 4, -41 },
  { 6752, 31, 42, 32, 2, -41 },
  { 6915, 32, 41, 32, 4, -41 },
  { 7079, 39, 41, 41, 5, -41 },
  { 7279, 36, 41, 31, -2, -41 },
  { 7464, 30, 41, 31, 5, -41 },
  { 7618, 33, 41, 30, -1, -41 },
  { 7788, 20, 57, 15, -1, -47 },
  { 7931, 15, 44, 21, 4, -41 },
  { 8014, 20, 57, 15, -3, -47 },
  { 8157, 20, 20, 22, 2, -41 },
  { 8207, 22, 7, 22, -4, 0 },
  { 8227, 13, 9, 19, 6, -43 },
  { 8242, 24, 32, 26, 0, -31 },
  { 8338, 26, 44, 27, 0, -43 },
  { 8481, 24, 32, 25, 1, -31 },
  { 8577, 28, 44, 27, 1, -43 },
  { 8731, 25, 32, 27, 1, -31 },
  { 8831, 21, 44, 18, 1, -44 },
  { 8947, 29, 43, 28, -1, -31 },
  { 9103, 27, 43, 27, -1, -43 },
  { 9249, 16, 42, 14, 0, -42 },
  { 9333, 23, 54, 14, -7, -42 },
  { 9489, 30, 43, 27, 0, -43 },
  { 9651, 16, 43, 14, 0, -43 },
  { 9737, 39, 31, 41, 0, -31 },
  { 9889, 27, 31, 27, -1, -31 },
  { 9994, 25, 32, 27, 1, -31 },
  { 10094, 28, 43, 27, -2, -31 },
  { 10245, 26, 43, 27, 1, -31 },
  { 10385, 21, 31, 19, -1, -31 },
  { 10467, 24, 32, 25, 0, -31 },
  { 10563, 17, 39, 17, 2, -38 },
  { 10646, 27, 31, 27, 1, -30 },
  { 10751, 24, 30, 25, 3, -30 },
  { 10841, 33, 30, 35, 3, -30 },
  { 10965, 29, 30, 25, -2, -30 },
  { 11074, 29, 42, 26, -1, -30 },
  { 11227, 26, 30, 25, -1, -30 },
  { 11325, 17, 55, 16, 1, -45 },
  { 11442, 12, 49, 14, 1, -41 },
  { 11516, 17, 54, 16, -2, -44 },
  { 11631, 26, 13, 30, 2, -23 },
};

const GFXfont RobotoCondensed_BlackItalic57pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic57pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic57pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOCONDENSED_BLACKITALIC57PT7B_H_
