#ifndef _ROBOTOCONDENSED_BLACKITALIC24PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE0, 0x00,
  0x0E, 0x3C, 0x78, 0x70, 0x77, 0x66, 0x66, 0xEE, 0xEE, 0xEC, 0xCC, 0x03,
  0x60, 0x76, 0x06, 0xE0, 0x6C, 0x0E, 0xC3, 0xFF, 0x3F, 0xF0, 0xD8, 0x19,
  0x81, 0xB8, 0xFF, 0xCF, 0xFC, 0x37, 0x03, 0x60, 0x76, 0x06, 0xE0, 0x6C,
  0x00, 0x03, 0x00, 0x60, 0x3C, 0x0F, 0xE3, 0xFC, 0x73, 0xDE, 0x7B, 0xCF,
  0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x39, 0xC7, 0x38, 0xE7, 0xBC, 0xFF,
  0x8F, 0xE0, 0xF8, 0x0C, 0x01, 0x80, 0x38, 0x0F, 0x83, 0xB9, 0xF7, 0x7C,
  0xFD, 0xDB, 0x1F, 0xC3, 0xF8, 0x06, 0x01, 0xB8, 0x7F, 0x9F, 0xB3, 0x66,
  0xCC, 0xF9, 0x98, 0x3F, 0x03, 0xC0, 0x07, 0x80, 0x7E, 0x07, 0xF8, 0x39,
  0xC1, 0xCE, 0x0E, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x79, 0xFB, 0x9F, 0xFD,
  0xEF, 0xEF, 0x3E, 0x79, 0xF1, 0xFF, 0x8F, 0xFC, 0x3E, 0xF0, 0x77, 0x76,
  0x6E, 0xE0, 0x02, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70,
  0x30, 0x10, 0x08, 0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07,
  0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x3C, 0x38, 0x70, 0xF0,
  0xE0, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x33, 0x2F, 0xFE, 0x7F, 0x87, 0x81,
  0xF0, 0x73, 0x0E, 0x70, 0x88, 0x00, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x87,
  0xFC, 0xFF, 0x9F, 0xF0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x39,
  0xCE, 0xE7, 0x7B, 0x88, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x0F,
  0x03, 0xF0, 0xFF, 0x3C, 0xE7, 0x9C, 0xE3, 0xDC, 0x77, 0x8E, 0xF3, 0xDE,
  0x7B, 0xCF, 0x79, 0xEE, 0x39, 0xEF, 0x3F, 0xC3, 0xF8, 0x3C, 0x00, 0x06,
  0x3F, 0xFF, 0xFF, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1E,
  0x3C, 0x70, 0x07, 0x81, 0xFE, 0x1F, 0xE3, 0xCE, 0x38, 0xF3, 0x8E, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xFF,
  0xCF, 0xFC, 0xFF, 0xC0, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0xCF, 0x3C, 0xF0,
  0x0F, 0x01, 0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x01, 0xC0, 0x1E, 0xF1, 0xEF,
  0x3C, 0x7F, 0xC7, 0xF8, 0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0xFE, 0x1D, 0xC1, 0xDC, 0x3B, 0xC7, 0xBC, 0x7F, 0xE7, 0xFE,
  0xFF, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xC0, 0x3C, 0x03, 0x80, 0x3F, 0x83, 0xFC, 0x7F, 0xC0, 0x1E, 0x01,
  0xE0, 0x1E, 0xF1, 0xC7, 0x3C, 0x7F, 0xC3, 0xF8, 0x1E, 0x00, 0x03, 0x83,
  0xE1, 0xF8, 0xF8, 0x3C, 0x1E, 0x07, 0x73, 0xFE, 0xFF, 0xFC, 0xFF, 0x3F,
  0xCF, 0xE3, 0xFD, 0xEF, 0xF9, 0xFC, 0x3E, 0x00, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x83,
  0xF8, 0xFF, 0x3C, 0xF7, 0x9E, 0xF3, 0x9E, 0xF1, 0xFC, 0x3F, 0x0F, 0xF3,
  0xCE, 0x79, 0xCE, 0x39, 0xEF, 0x3F, 0xE3, 0xF8, 0x3E, 0x00, 0x1E, 0x0F,
  0xC7, 0xFB, 0xCE, 0xF3, 0xB8, 0xEE, 0x3B, 0x9E, 0xFF, 0xBF, 0xE7, 0xF8,
  0x1C, 0x0F, 0x0F, 0x8F, 0xC3, 0xE0, 0xE0, 0x00, 0x1C, 0xF3, 0xC7, 0x00,
  0x00, 0x00, 0x01, 0xC7, 0x9E, 0x70, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0xE0, 0x80, 0x00, 0x40,
  0x70, 0x7C, 0x7F, 0x7F, 0x1F, 0x07, 0x83, 0xF8, 0x3F, 0x83, 0xE0, 0x70,
  0x04, 0x7F, 0xDF, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xFB, 0xFE, 0x20,
  0x0E, 0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0xF0, 0x7C, 0xFF, 0x7F, 0x1F, 0x0E,
  0x02, 0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xEF, 0xF3, 0xC0, 0xE0, 0x78, 0x3C,
  0x1E, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0x07, 0x81, 0xE0, 0x30, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0xC0, 0x61, 0xC0, 0x39, 0xC7,
  0x8C, 0xE7, 0xE6, 0xE7, 0x33, 0x73, 0x39, 0xB3, 0x9C, 0xD9, 0xCC, 0x7C,
  0xC6, 0x7E, 0xE7, 0x37, 0x73, 0x9B, 0x99, 0xD9, 0xCF, 0xFC, 0xE3, 0xBC,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x08, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x77, 0x03,
  0xDC, 0x0F, 0x78, 0x79, 0xE1, 0xE7, 0x8F, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7,
  0x87, 0x9E, 0x0F, 0xF0, 0x3C, 0x1F, 0xC0, 0xFF, 0x8F, 0xFE, 0x78, 0xF3,
  0xC7, 0x9E, 0x3C, 0xF3, 0xE7, 0xFE, 0x7F, 0xE3, 0xFF, 0x1E, 0x3C, 0xF1,
  0xE7, 0x8F, 0x38, 0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x80, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0x79, 0xE7, 0x87, 0x3C, 0x3F, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE3, 0xCF, 0x1E, 0x79, 0xF1, 0xFF, 0x0F, 0xF0, 0x1F,
  0x00, 0x1F, 0x80, 0xFF, 0x0F, 0xFC, 0x79, 0xE3, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE7, 0x0F, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x9F, 0x39, 0xF3,
  0xFF, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF,
  0x3F, 0xF3, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFE, 0x7F, 0xC7, 0xFC,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0xFF, 0x0F, 0xFC, 0x79, 0xE7, 0x87, 0xBC, 0x3D, 0xE0, 0x1E, 0x00,
  0xF3, 0xF7, 0x9F, 0xBC, 0xFD, 0xE1, 0xEF, 0x1E, 0x7C, 0xF1, 0xFF, 0x8F,
  0xF8, 0x1F, 0x00, 0x1E, 0x1E, 0x3C, 0x3C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x87, 0x8F, 0x0F, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC7, 0x87, 0x8E, 0x0E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF0, 0x1E,
  0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C,
  0x78, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF,
  0x87, 0xF0, 0x3E, 0x00, 0x1E, 0x3E, 0x3C, 0xF8, 0xF3, 0xE1, 0xE7, 0x83,
  0xDF, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xBE, 0x0E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xF0,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x07,
  0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xEC, 0xFE, 0x7B, 0x3F, 0x9E, 0xDD, 0xE7, 0xB7, 0x71, 0xED,
  0xBC, 0x7B, 0xEF, 0x1C, 0xFB, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0x9E,
  0x00, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8, 0xF1, 0xF1, 0xE3, 0xF3, 0xC7, 0xE7,
  0x8F, 0xCF, 0x1D, 0x9E, 0x7B, 0xF8, 0xF7, 0xF1, 0xE7, 0xE3, 0xCF, 0xC7,
  0x9F, 0x8E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0x79, 0xE7, 0x87, 0xBC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xF7,
  0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x1E, 0x7C, 0xF1, 0xFF, 0x0F, 0xF0, 0x1F,
  0x00, 0x1F, 0xE0, 0xFF, 0x8F, 0xFE, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE7, 0x1F, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0xF0, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x79, 0xE7,
  0x87, 0xBC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1,
  0xEF, 0x0E, 0x7C, 0xF1, 0xFF, 0x0F, 0xF0, 0x1F, 0xC0, 0x1E, 0x00, 0x70,
  0x01, 0x00, 0x1F, 0xE0, 0xFF, 0x8F, 0xFE, 0x78, 0xF3, 0xC7, 0x9E, 0x3C,
  0xF1, 0xE7, 0x1E, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0xF7, 0x87, 0xBC, 0x38,
  0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE0, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x7C,
  0xF3, 0xC7, 0x9E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x79,
  0xE1, 0xE7, 0x0F, 0x3C, 0xF1, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x00,
  0x3C, 0x79, 0xE3, 0xDE, 0x1E, 0xF0, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCE,
  0x1E, 0xF0, 0xF7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x79, 0xF3, 0xFF,
  0x0F, 0xF0, 0x3F, 0x00, 0xF0, 0xFF, 0x87, 0xFC, 0x3D, 0xE3, 0xEF, 0x1E,
  0x78, 0xF3, 0xCF, 0x0E, 0x78, 0x73, 0xC3, 0xBC, 0x1D, 0xE0, 0xEE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0xF3, 0xCF, 0x79, 0xE7,
  0xBC, 0xF3, 0xDE, 0xF9, 0xCF, 0x7D, 0xE7, 0xBE, 0xF3, 0xFF, 0x71, 0xFF,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87,
  0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xE0, 0x00, 0x1E, 0x1E, 0x3C,
  0x7C, 0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xEE, 0x07, 0x9E, 0x1F,
  0x3C, 0x3C, 0x78, 0xF8, 0xF8, 0xF0, 0xF7, 0x87, 0xBC, 0x78, 0xE3, 0xC7,
  0x3C, 0x3D, 0xC1, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE0, 0x0F, 0x87, 0xC3, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF3, 0xCF, 0x3C, 0xF3, 0xC7, 0x1E,
  0x79, 0xE7, 0x9E, 0x78, 0xE3, 0xCF, 0x3C, 0xF0, 0x1F, 0x1F, 0x1F, 0x0F,
  0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0x0E, 0x1E, 0x1E, 0x3E,
  0x3E, 0x77, 0x77, 0xE7, 0xE7, 0x7F, 0xDF, 0xE7, 0xF8, 0x79, 0xE3, 0x87,
  0x0F, 0x0F, 0xF3, 0xFD, 0xEF, 0x03, 0xC7, 0xF7, 0xFF, 0xEF, 0xF3, 0xBD,
  0xEF, 0xFB, 0xFE, 0x7F, 0x80, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x7F, 0x0F, 0xF1, 0xFF, 0x79, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x9E, 0xE3,
  0xBC, 0xF7, 0xFE, 0xFF, 0x9D, 0xE0, 0x0F, 0x0F, 0xE3, 0xFD, 0xE7, 0x79,
  0xDC, 0x0F, 0x03, 0xC0, 0xF3, 0xFC, 0xE7, 0xF9, 0xFC, 0x3E, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xEE, 0x3E, 0xE7, 0xFE, 0x79,
  0xE7, 0x1E, 0x71, 0xEF, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0xC7, 0xFC, 0x7F,
  0xC3, 0xB8, 0x0F, 0x83, 0xF8, 0xFF, 0x3C, 0xF7, 0x9E, 0xF3, 0xDF, 0xFF,
  0xFE, 0xF0, 0x0F, 0x31, 0xFE, 0x1F, 0xC1, 0xF0, 0x07, 0x87, 0xC7, 0xE3,
  0xC1, 0xE3, 0xF9, 0xFC, 0xFE, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x38, 0x00, 0x1E, 0xF3, 0xFF, 0x3F, 0xE7, 0x9E, 0x79,
  0xE7, 0x1E, 0x71, 0xEF, 0x1E, 0xF1, 0xCF, 0x3C, 0x7F, 0xC7, 0xFC, 0x3F,
  0xC0, 0x3C, 0x47, 0x8F, 0xF8, 0xFF, 0x07, 0xC0, 0x1C, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x7F, 0x0F, 0xF3, 0xFF, 0x79, 0xEF, 0x3D, 0xE7, 0xBC,
  0xE7, 0x3D, 0xE7, 0xBC, 0xF7, 0x9E, 0xF3, 0xDE, 0x70, 0x1C, 0x3C, 0x78,
  0xE0, 0x07, 0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xF1,
  0xE0, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF0, 0xFC, 0x3E, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xDF, 0x3D, 0xE3, 0xBC, 0x7F, 0xC7, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x87, 0xF8, 0xF7, 0x8F, 0x3C, 0xF3, 0xCF, 0x3C, 0x1E, 0x3C, 0x71,
  0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1,
  0xE0, 0x3B, 0xCE, 0x3F, 0xFF, 0x3F, 0xFF, 0x79, 0xE7, 0x79, 0xEF, 0x79,
  0xCF, 0x79, 0xCF, 0x7B, 0xCF, 0x73, 0xCF, 0xF3, 0xCE, 0xF3, 0xCE, 0xF3,
  0xDE, 0xF3, 0x9E, 0x3B, 0xC7, 0xF9, 0xFF, 0xBC, 0xF7, 0x9E, 0xF3, 0xDE,
  0x73, 0x9E, 0xF3, 0xDE, 0x7B, 0xCF, 0x79, 0xEF, 0x38, 0x0F, 0x83, 0xF8,
  0xFF, 0x3C, 0xF7, 0x9E, 0xE3, 0xDC, 0x7F, 0x8F, 0xF1, 0xCE, 0x79, 0xFF,
  0x3F, 0xC1, 0xE0, 0x1D, 0xC1, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x38, 0xE7, 0x9E, 0x7F, 0xE7, 0xFC, 0x7F, 0x87, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0xE7, 0xFD, 0xFF, 0xBC, 0xF7,
  0x9E, 0xE3, 0xFC, 0x77, 0x9E, 0xF3, 0xDE, 0x79, 0xFF, 0x3F, 0xE3, 0xB8,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3B, 0x9F, 0x8F, 0xCF, 0xE7,
  0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x0F, 0x0F,
  0xE7, 0xFD, 0xEF, 0x78, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xB8, 0xEF, 0xF9,
  0xFC, 0x3E, 0x00, 0x3C, 0x78, 0xE7, 0xFF, 0xFF, 0x9E, 0x38, 0x71, 0xE3,
  0xC7, 0x8F, 0x1F, 0x3E, 0x3C, 0x3C, 0xF3, 0x8E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x73, 0xCF, 0x3C, 0x7F, 0xC7, 0xFC, 0x3B,
  0xC0, 0xF3, 0xFC, 0xFF, 0x3B, 0xDE, 0x77, 0x9D, 0xC7, 0xF1, 0xF8, 0x7E,
  0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x00, 0xF3, 0xBF, 0xDE, 0xFF, 0x7B, 0xBD,
  0xEE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFB, 0xE3, 0xEF, 0x8F,
  0xBE, 0x3C, 0xF0, 0xF1, 0xC0, 0x3C, 0xF1, 0xCF, 0x1F, 0xE1, 0xFC, 0x1F,
  0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xFC, 0x7B, 0xC7, 0xBC, 0xF1,
  0xC0, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0xBC, 0x3B, 0xC3, 0xF8, 0x3F, 0x83,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x0E, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x03, 0xC0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xFE, 0x7F, 0xCF, 0xF8, 0x02, 0x07,
  0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0x70,
  0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0x30, 0x10, 0x1C, 0x61, 0x86,
  0x18, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86, 0x38,
  0x08, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1E, 0x0E, 0x06,
  0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0xE0, 0x40, 0x38,
  0xEF, 0x9F, 0xF3, 0x77, 0xEE, 0x7D, 0x87, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 8, 7, 7, 1, -18 },
  { 23, 12, 17, 12, 0, -17 },
  { 49, 11, 21, 12, 1, -19 },
  { 78, 11, 17, 15, 2, -17 },
  { 102, 13, 17, 14, 0, -17 },
  { 130, 4, 7, 4, 1, -18 },
  { 134, 8, 24, 8, 1, -19 },
  { 158, 8, 24, 8, -1, -19 },
  { 182, 11, 11, 11, 1, -17 },
  { 198, 11, 12, 11, 0, -13 },
  { 215, 5, 8, 6, -1, -3 },
  { 220, 6, 3, 10, 2, -9 },
  { 223, 5, 4, 7, 0, -4 },
  { 226, 11, 18, 7, -2, -17 },
  { 251, 11, 17, 12, 1, -17 },
  { 275, 7, 17, 12, 3, -17 },
  { 290, 12, 17, 12, 0, -17 },
  { 316, 12, 17, 12, 0, -17 },
  { 342, 12, 17, 12, 0, -17 },
  { 368, 12, 17, 12, 0, -17 },
  { 394, 10, 17, 12, 1, -17 },
  { 416, 12, 17, 12, 1, -17 },
  { 442, 11, 17, 12, 1, -17 },
  { 466, 10, 17, 12, 2, -17 },
  { 488, 6, 13, 7, 0, -13 },
  { 498, 7, 18, 7, -1, -13 },
  { 514, 10, 12, 10, 0, -13 },
  { 529, 10, 8, 12, 1, -11 },
  { 539, 10, 12, 10, 0, -13 },
  { 554, 10, 17, 11, 1, -17 },
  { 576, 17, 22, 18, 0, -17 },
  { 623, 14, 17, 14, -1, -17 },
  { 653, 13, 17, 13, 0, -17 },
  { 681, 13, 17, 13, 1, -17 },
  { 709, 13, 17, 13, 0, -17 },
  { 737, 13, 17, 11, 0, -17 },
  { 765, 12, 17, 11, 0, -17 },
  { 791, 13, 17, 14, 1, -17 },
  { 819, 15, 17, 14, 0, -17 },
  { 851, 7, 17, 7, 0, -17 },
  { 866, 12, 17, 11, 0, -17 },
  { 892, 15, 17, 13, 0, -17 },
  { 924, 10, 17, 11, 0, -17 },
  { 946, 18, 17, 18, 0, -17 },
  { 985, 15, 17, 14, 0, -17 },
  { 1017, 13, 17, 14, 1, -17 },
  { 1045, 13, 17, 13, 0, -17 },
  { 1073, 13, 20, 14, 1, -17 },
  { 1106, 13, 17, 13, 0, -17 },
  { 1134, 13, 17, 13, 0, -17 },
  { 1162, 12, 17, 13, 2, -17 },
  { 1188, 13, 17, 13, 1, -17 },
  { 1216, 13, 17, 14, 2, -17 },
  { 1244, 17, 17, 17, 2, -17 },
  { 1281, 15, 17, 13, -1, -17 },
  { 1313, 13, 17, 13, 2, -17 },
  { 1341, 14, 17, 12, 0, -17 },
  { 1371, 9, 24, 6, -1, -20 },
  { 1398, 6, 18, 9, 2, -17 },
  { 1412, 8, 24, 6, -1, -20 },
  { 1436, 8, 9, 9, 1, -17 },
  { 1445, 10, 3, 9, -2, 0 },
  { 1449, 6, 4, 8, 2, -18 },
  { 1452, 10, 13, 11, 0, -13 },
  { 1469, 11, 18, 12, 0, -18 },
  { 1494, 10, 13, 11, 0, -13 },
  { 1511, 12, 18, 12, 0, -18 },
  { 1538, 11, 13, 11, 0, -13 },
  { 1556, 9, 18, 8, 0, -18 },
  { 1577, 12, 18, 12, 0, -13 },
  { 1604, 11, 18, 12, 0, -18 },
  { 1629, 7, 18, 6, 0, -18 },
  { 1645, 10, 23, 6, -3, -18 },
  { 1674, 12, 18, 11, 0, -18 },
  { 1701, 7, 18, 6, 0, -18 },
  { 1717, 16, 13, 17, 0, -13 },
  { 1743, 11, 13, 12, 0, -13 },
  { 1761, 11, 13, 11, 0, -13 },
  { 1779, 12, 18, 12, -1, -13 },
  { 1806, 11, 18, 12, 0, -13 },
  { 1831, 9, 13, 8, 0, -13 },
  { 1846, 10, 13, 11, 0, -13 },
  { 1863, 7, 16, 7, 1, -16 },
  { 1877, 12, 13, 12, 0, -13 },
  { 1897, 10, 13, 11, 1, -13 },
  { 1914, 14, 13, 15, 1, -13 },
  { 1937, 12, 13, 11, -1, -13 },
  { 1957, 12, 18, 11, 0, -13 },
  { 1984, 11, 13, 11, 0, -13 },
  { 2002, 8, 23, 7, 0, -19 },
  { 2025, 6, 20, 6, 0, -17 },
  { 2040, 8, 23, 7, -1, -19 },
  { 2063, 11, 6, 13, 1, -10 },
};

const GFXfont RobotoCondensed_BlackItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_BLACKITALIC24PT7B_H_
