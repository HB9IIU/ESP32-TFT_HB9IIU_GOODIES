#ifndef _ROBOTOCONDENSED_BLACKITALIC62PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x80,
  0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x3F,
  0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xE3,
  0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x80, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xCF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x02, 0x07, 0xF1, 0xF8, 0x1E, 0x1F, 0xC7, 0xE0, 0x7C,
  0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F,
  0x87, 0xE3, 0xF0, 0xFE, 0x1F, 0x9F, 0x83, 0xF8, 0xFE, 0x7E, 0x07, 0xE3,
  0xFB, 0xF0, 0x1F, 0x9F, 0xDF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFB,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF3, 0xF0,
  0x00, 0x06, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFD, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xBF, 0x9F, 0x80, 0xFD, 0xFC, 0x7F, 0x07, 0xF7, 0xF0, 0xFC, 0x1F, 0x9F,
  0x83, 0xF0, 0xFC, 0x7E, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xE1,
  0xF8, 0xFC, 0x1F, 0x87, 0xE7, 0xF0, 0x7E, 0x1F, 0x8F, 0x81, 0xFC, 0xFE,
  0x0C, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x9F, 0xF0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE1, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0x87, 0xFF,
  0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x9F, 0xE3, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xE3, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFC, 0x1F, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFD, 0xFF,
  0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xCF, 0xF3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8,
  0x7E, 0x1F, 0x8F, 0xE3, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x40, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x01, 0x80, 0x7C, 0x06, 0x3E, 0x0F, 0x83, 0xCF, 0xF1, 0xF3,
  0xFD, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xFB, 0xF0, 0x01, 0xFE,
  0x3F, 0x00, 0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x1F, 0x00, 0xF8, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07,
  0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x07, 0xC0, 0x02, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFE, 0x0F, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xC3, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF,
  0x01, 0xFF, 0x1F, 0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x3F,
  0xF3, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3, 0xFE, 0x03, 0xFE, 0x3F,
  0xE0, 0x3F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07,
  0xFE, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF,
  0xFC, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFE,
  0x7F, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x3F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xCF,
  0xF9, 0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x3F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x9F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F,
  0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF,
  0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xF7, 0xFE, 0x00, 0x7F, 0xBF, 0xF0, 0x07, 0xF9, 0xFF, 0x80, 0x3F, 0xCF,
  0xF8, 0x03, 0xFC, 0xFF, 0xC0, 0x3F, 0xC7, 0xFE, 0x01, 0xFE, 0x3F, 0xF0,
  0x1F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x78, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF7, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xCF, 0xC0, 0x3F, 0xF7, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0x87, 0xFE, 0x7F,
  0xE0, 0xFF, 0xCF, 0xF8, 0x0F, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xF7, 0xFE,
  0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xF8, 0x1F, 0xF9, 0xFF, 0x07, 0xFE,
  0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xBF, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x1F, 0xF0,
  0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xF9, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xF9, 0xFF, 0x8F,
  0xFC, 0x3F, 0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0x83, 0xFE, 0x7F, 0xC0, 0xFF,
  0x9F, 0xF0, 0x3F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFF, 0x07, 0xFE, 0xFF,
  0xC1, 0xFF, 0xBF, 0xF0, 0x7F, 0xEF, 0xFC, 0x1F, 0xF9, 0xFF, 0xDF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x03, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x03,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x00, 0x10, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xE7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0x81, 0xFC, 0x03, 0xFF, 0x01, 0xF0, 0x3F, 0x01, 0xFF, 0xF8, 0x3F,
  0x0F, 0xE0, 0x7F, 0xFF, 0x87, 0xE1, 0xF8, 0x1F, 0xFF, 0xF0, 0xFC, 0x7F,
  0x03, 0xFF, 0xFE, 0x1F, 0x8F, 0xC0, 0xFF, 0x1F, 0xC3, 0xF3, 0xF8, 0x3F,
  0xC3, 0xF8, 0x7E, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xCF, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFB, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x7F, 0x0F, 0xE0, 0x7F, 0x07,
  0xEF, 0xC1, 0xFC, 0x0F, 0xC0, 0xFD, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xFF,
  0x0F, 0xF0, 0x7F, 0x03, 0xEF, 0xE1, 0xFC, 0x0F, 0xE0, 0x7D, 0xF8, 0x3F,
  0x81, 0xF8, 0x1F, 0xBF, 0x07, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7C, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0x9F, 0x87, 0xF8, 0x3F, 0x03,
  0xF3, 0xF0, 0xFF, 0x07, 0xE0, 0x7C, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0x8F,
  0xC1, 0xFC, 0x3F, 0x83, 0xE1, 0xF8, 0x3F, 0x8F, 0xF0, 0xFC, 0x3F, 0x07,
  0xFF, 0xFF, 0x7F, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xFE,
  0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0x9F, 0xFE, 0x03, 0xF0, 0x1F, 0xE1, 0xFF,
  0x00, 0x7F, 0x00, 0x70, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0x7F, 0xEF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF,
  0xCF, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x1F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F,
  0xE3, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00,
  0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8,
  0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE1, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0xFF, 0x3F,
  0xF0, 0x7F, 0xFF, 0x1F, 0xF8, 0x3F, 0xFF, 0x9F, 0xFC, 0x1F, 0xFF, 0xCF,
  0xFE, 0x0F, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xF9,
  0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF,
  0x80, 0x1F, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F,
  0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFE,
  0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0x7F, 0xC0, 0x7F, 0xDF, 0xC1, 0xFF, 0xFF,
  0x80, 0xFF, 0xBF, 0x83, 0xFB, 0xFF, 0x01, 0xFF, 0x7F, 0x0F, 0xF7, 0xFC,
  0x07, 0xFE, 0x7E, 0x1F, 0xEF, 0xF8, 0x0F, 0xFC, 0xFE, 0x3F, 0xBF, 0xF0,
  0x1F, 0xF9, 0xFC, 0xFF, 0x7F, 0xE0, 0x3F, 0xF3, 0xF9, 0xFC, 0xFF, 0xC0,
  0x7F, 0xE7, 0xF7, 0xF9, 0xFF, 0x80, 0xFF, 0x8F, 0xEF, 0xE3, 0xFE, 0x03,
  0xFF, 0x1F, 0xDF, 0xCF, 0xFC, 0x07, 0xFE, 0x3F, 0xFF, 0x1F, 0xF8, 0x0F,
  0xFC, 0x7F, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xFC, 0x7F, 0xE0, 0x3F,
  0xF1, 0xFF, 0xF1, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xF0, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFE,
  0x1F, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xE0, 0x3F, 0xF7, 0xE1, 0xFF, 0x80,
  0xFF, 0xDF, 0x87, 0xFE, 0x03, 0xFF, 0x7F, 0x1F, 0xF8, 0x0F, 0xFC, 0xFC,
  0x7F, 0xE0, 0x3F, 0xF3, 0xF3, 0xFF, 0x01, 0xFF, 0xCF, 0xCF, 0xFC, 0x07,
  0xFE, 0x3F, 0x3F, 0xF0, 0x1F, 0xF8, 0xFE, 0xFF, 0xC0, 0x7F, 0xE1, 0xFB,
  0xFF, 0x01, 0xFF, 0x87, 0xEF, 0xFC, 0x07, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F,
  0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x3F,
  0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF9,
  0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xE0, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x80,
  0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F,
  0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0,
  0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xE0, 0x07, 0xFE, 0x3F, 0xF0,
  0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF,
  0xC0, 0x07, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xE0, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0x07, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0,
  0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x01, 0xFF,
  0xE7, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x0F,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0x80,
  0x7F, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x1F, 0xFC, 0x1F, 0xF9, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE7, 0xFE, 0x1F,
  0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xE3, 0xFF, 0x1F, 0xFF, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF,
  0x0F, 0xFC, 0x7F, 0xFC, 0x7F, 0xE1, 0xFF, 0x9F, 0xFF, 0x8F, 0xFC, 0x3F,
  0xF3, 0xFF, 0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xFE, 0x7F, 0xE0, 0xFF, 0xDF,
  0xFF, 0xCF, 0xFC, 0x1F, 0xFB, 0xFF, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xFF,
  0x7F, 0xE0, 0x7F, 0xEF, 0xFF, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF7, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0xC0,
  0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00,
  0xFF, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0xCF,
  0xFC, 0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xFE, 0x00,
  0x07, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07,
  0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x01,
  0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x0F, 0xF3, 0xF0, 0x3F,
  0x8F, 0xC1, 0xFE, 0x3F, 0x07, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F,
  0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0xFF, 0x01, 0xFB, 0xFC, 0x07, 0xF0,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xF8, 0x7F, 0xC3,
  0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF,
  0xC7, 0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x3F, 0xF0, 0x7F, 0xC7, 0xFE,
  0x0F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x1F, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB, 0xFF, 0x01, 0xFE, 0x7F, 0xE0,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x9F, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0x81,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF,
  0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x7F,
  0xE0, 0x3F, 0xE3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0,
  0xFF, 0x87, 0xFF, 0x9F, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x07, 0xFD, 0xFF, 0xF0, 0x3F,
  0xE7, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x1F, 0xF9, 0xFF, 0x8F, 0xFC, 0x3F, 0xE3, 0xFE, 0x07, 0xF9, 0xFF, 0x81,
  0xFF, 0x7F, 0xE0, 0x7F, 0xDF, 0xF8, 0x3F, 0xF7, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1F,
  0xF3, 0xFE, 0x0F, 0xFC, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xFE,
  0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0x03, 0xFF, 0x00, 0x3F,
  0xC7, 0xFE, 0x01, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x01, 0xFF,
  0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFC, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x9F,
  0xF0, 0x1F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8, 0x1F,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x10, 0x0F, 0xFC,
  0x07, 0x01, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x01,
  0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07,
  0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F,
  0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xF3, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFD, 0xFF, 0x80, 0x00, 0xC3, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x01, 0x00, 0x3F, 0xF0, 0x03, 0x00, 0xFF, 0xE0, 0x0F, 0xEF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x84, 0x00, 0x0F, 0xF9, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x0F,
  0xFC, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE,
  0x1F, 0xFE, 0x03, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0x0F, 0xFE, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x0F,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xDF, 0xFC, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFE, 0x7F, 0xF9, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x1F,
  0xF8, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x3F, 0xF1, 0xFF, 0x87,
  0xFE, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x1F, 0xF8,
  0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE3, 0xFE, 0x0F, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF,
  0xC7, 0xFE, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0xFF,
  0xC1, 0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x8F, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F,
  0xF8, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF,
  0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFC, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF,
  0x9F, 0xF0, 0x1F, 0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF0,
  0x1F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xFC, 0x07, 0xFD, 0xFF, 0x80,
  0xFF, 0xBF, 0xF0, 0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0x9F,
  0xF8, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFE, 0x0F,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x83,
  0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0xC0,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0xE3, 0xFC,
  0x0F, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83,
  0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE,
  0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81,
  0xFF, 0x8F, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFE,
  0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F,
  0xF9, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x21, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x07, 0xFC, 0xFC, 0x0F, 0xFB,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC7,
  0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0xFF, 0xCF, 0xF8, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x20, 0x00, 0x0F,
  0xFC, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x3F, 0xF0,
  0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0,
  0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x87,
  0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0xBF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xDF, 0xF8, 0x1F, 0xFB, 0xFF, 0x07,
  0xFF, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0x87, 0xFE, 0x1F,
  0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0xFF,
  0xC1, 0xFF, 0x1F, 0xF0, 0x3F, 0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF,
  0x9F, 0xF0, 0x1F, 0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xC3, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0xE7, 0xF8, 0x7F, 0xC3,
  0xFE, 0x7F, 0x87, 0xFC, 0x3F, 0xE7, 0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0x8F,
  0xFC, 0x7F, 0xC7, 0xF8, 0xFF, 0xC7, 0xFC, 0x7F, 0x8F, 0xFC, 0xFF, 0x87,
  0xF9, 0xFF, 0xCF, 0xF8, 0x7F, 0x9F, 0xFC, 0xFF, 0x87, 0xFB, 0xFF, 0xCF,
  0xF0, 0x7F, 0xBF, 0xFD, 0xFF, 0x07, 0xFB, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF,
  0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF, 0xFE, 0x07,
  0xFF, 0xEF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0xFC, 0x07, 0xFF, 0xCF, 0xFF,
  0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xF8,
  0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0,
  0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFF,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xC7, 0xFC,
  0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x03,
  0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xF3, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF,
  0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x1F, 0xC3, 0xFF, 0x81, 0xFC, 0x3F, 0xFE, 0x0F, 0xE3, 0xFF,
  0xF0, 0x7F, 0x1F, 0xFF, 0xC7, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x7F, 0x1F, 0xFF, 0xE7, 0xF8, 0x7F, 0xFE, 0x3F, 0x81, 0xFF, 0xF1,
  0xFC, 0x07, 0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 17, 45, 16, 1, -44 },
  { 97, 20, 17, 19, 2, -47 },
  { 140, 31, 44, 31, 0, -44 },
  { 311, 29, 58, 31, 2, -51 },
  { 522, 30, 46, 39, 5, -45 },
  { 695, 33, 46, 36, 0, -45 },
  { 885, 10, 17, 9, 3, -47 },
  { 907, 19, 63, 20, 3, -49 },
  { 1057, 20, 63, 19, -3, -49 },
  { 1215, 27, 27, 28, 3, -44 },
  { 1307, 26, 33, 28, 1, -37 },
  { 1415, 14, 20, 16, -3, -8 },
  { 1450, 17, 8, 25, 4, -23 },
  { 1467, 11, 11, 18, 1, -10 },
  { 1483, 27, 48, 19, -4, -44 },
  { 1645, 28, 46, 31, 2, -45 },
  { 1806, 19, 44, 31, 7, -44 },
  { 1911, 30, 45, 31, 0, -45 },
  { 2080, 30, 46, 31, 0, -45 },
  { 2253, 29, 44, 31, 1, -44 },
  { 2413, 30, 45, 31, 1, -44 },
  { 2582, 27, 45, 31, 2, -44 },
  { 2734, 30, 44, 31, 2, -44 },
  { 2899, 29, 46, 31, 1, -45 },
  { 3066, 26, 45, 31, 4, -45 },
  { 3213, 15, 35, 18, 1, -34 },
  { 3279, 19, 46, 17, -3, -34 },
  { 3389, 25, 30, 27, 1, -34 },
  { 3483, 27, 22, 31, 2, -30 },
  { 3558, 25, 30, 27, 1, -33 },
  { 3652, 24, 46, 28, 4, -45 },
  { 3790, 43, 57, 46, 1, -43 },
  { 4097, 36, 44, 36, -3, -44 },
  { 4295, 34, 44, 34, 0, -44 },
  { 4482, 33, 46, 34, 2, -45 },
  { 4672, 33, 44, 34, 0, -44 },
  { 4854, 33, 44, 29, 0, -44 },
  { 5036, 32, 44, 29, 0, -44 },
  { 5212, 33, 46, 36, 2, -45 },
  { 5402, 38, 44, 37, 0, -44 },
  { 5611, 18, 44, 17, 0, -44 },
  { 5710, 31, 45, 30, 0, -44 },
  { 5885, 39, 44, 34, 0, -44 },
  { 6100, 26, 44, 29, 0, -44 },
  { 6243, 47, 44, 46, 0, -44 },
  { 6502, 38, 44, 37, 0, -44 },
  { 6711, 34, 46, 36, 2, -45 },
  { 6907, 34, 44, 35, 0, -44 },
  { 7094, 34, 53, 36, 2, -45 },
  { 7320, 34, 44, 34, 0, -44 },
  { 7507, 32, 46, 33, 1, -45 },
  { 7691, 32, 44, 33, 4, -44 },
  { 7867, 34, 45, 35, 2, -44 },
  { 8059, 35, 44, 35, 4, -44 },
  { 8252, 43, 44, 45, 5, -44 },
  { 8489, 40, 44, 34, -3, -44 },
  { 8709, 33, 44, 33, 5, -44 },
  { 8891, 36, 44, 32, -1, -44 },
  { 9089, 22, 63, 16, -2, -52 },
  { 9263, 17, 48, 23, 4, -44 },
  { 9365, 22, 63, 16, -4, -52 },
  { 9539, 22, 22, 24, 2, -44 },
  { 9600, 24, 8, 24, -4, 0 },
  { 9624, 15, 9, 20, 6, -46 },
  { 9641, 27, 35, 28, 0, -34 },
  { 9760, 29, 48, 30, -1, -47 },
  { 9934, 26, 35, 28, 1, -34 },
  { 10048, 31, 48, 30, 1, -47 },
  { 10234, 27, 35, 29, 1, -34 },
  { 10353, 23, 48, 20, 1, -48 },
  { 10491, 31, 47, 31, -1, -34 },
  { 10674, 29, 47, 30, -1, -47 },
  { 10845, 17, 46, 16, 0, -46 },
  { 10943, 24, 59, 15, -7, -46 },
  { 11120, 33, 47, 29, -1, -47 },
  { 11314, 18, 47, 16, 0, -47 },
  { 11420, 42, 34, 44, 0, -34 },
  { 11599, 29, 34, 30, -1, -34 },
  { 11723, 27, 35, 30, 1, -34 },
  { 11842, 31, 47, 30, -3, -34 },
  { 12025, 29, 47, 30, 1, -34 },
  { 12196, 23, 34, 21, -1, -34 },
  { 12294, 26, 35, 27, 0, -34 },
  { 12408, 18, 42, 19, 2, -41 },
  { 12503, 29, 34, 30, 1, -33 },
  { 12627, 27, 33, 28, 3, -33 },
  { 12739, 36, 33, 38, 3, -33 },
  { 12888, 31, 33, 28, -2, -33 },
  { 13016, 31, 46, 28, -1, -33 },
  { 13195, 29, 33, 28, -1, -33 },
  { 13315, 19, 59, 18, 1, -48 },
  { 13456, 14, 52, 15, 1, -44 },
  { 13547, 19, 59, 18, -2, -48 },
  { 13688, 29, 14, 33, 2, -25 },
};

const GFXfont RobotoCondensed_BlackItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_BLACKITALIC62PT7B_H_
