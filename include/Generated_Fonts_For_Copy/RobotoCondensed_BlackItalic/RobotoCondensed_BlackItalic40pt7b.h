#ifndef _ROBOTOCONDENSED_BLACKITALIC40PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x7C, 0xF7, 0xCF, 0x78, 0xF7,
  0x9F, 0x79, 0xFF, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x3C, 0xE3, 0xC0,
  0x00, 0x39, 0xE0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x07, 0x3C, 0x00, 0xF3,
  0xC0, 0x0F, 0x38, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xDE, 0x00, 0x39, 0xE0, 0x07,
  0x9E, 0x00, 0x7B, 0xC0, 0x07, 0x3C, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xE7, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00,
  0x3C, 0xE0, 0x03, 0xDE, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE1,
  0xF9, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00,
  0x3F, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x47, 0x9E, 0x1E,
  0xF3, 0xC7, 0x9E, 0x79, 0xE7, 0x8F, 0x3C, 0x71, 0xEF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x1F, 0xDE, 0x01, 0xF7, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x7C, 0x03, 0xDF, 0xC0, 0xF7, 0xFC, 0x1F, 0xFF, 0x87, 0xBC, 0xF1,
  0xE7, 0x9E, 0x3C, 0xF3, 0xCF, 0x3E, 0x7B, 0xC3, 0xCF, 0x30, 0x7F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xF3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x7C, 0x3F, 0xE3, 0xE3, 0xFF,
  0x3F, 0x3F, 0xFD, 0xF3, 0xF7, 0xEF, 0x9F, 0xBF, 0xFC, 0xFC, 0xFF, 0xEF,
  0xE3, 0xFE, 0x7F, 0x1F, 0xE1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFD, 0xF8, 0x0F, 0xCF, 0xE0, 0x3D, 0xF7, 0xDF,
  0x79, 0xE7, 0xBE, 0xFB, 0xCF, 0x00, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3C, 0x01, 0xC0, 0x08, 0x00, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0x87, 0x0D,
  0xF3, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xFE, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xFF, 0x01, 0xF3, 0xC1, 0xF1, 0xE0, 0xF8, 0x78, 0x38, 0x38, 0x08,
  0x10, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x0F,
  0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F,
  0x03, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFC, 0x30, 0xFB, 0xFF,
  0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87,
  0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0xFD, 0xFC, 0x3F, 0x7F, 0x0F, 0xDF, 0x87, 0xF7, 0xE1, 0xFD, 0xF8, 0x7E,
  0x7E, 0x1F, 0x9F, 0x87, 0xEF, 0xE1, 0xF9, 0xF0, 0x7E, 0x7C, 0x3F, 0x1F,
  0x0F, 0xC7, 0xE7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x18, 0x07, 0xC1, 0xFE, 0x3F, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xCF, 0x7E, 0xE7, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0x9F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE7, 0xF1,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xFC, 0xFE, 0x1F,
  0xC7, 0xE1, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xFE, 0x1F,
  0xCF, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0xFC, 0x1F, 0xBF, 0x07,
  0xCF, 0xC3, 0xE7, 0xF1, 0xF9, 0xFC, 0x7C, 0x7E, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xEF, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8,
  0x7E, 0x3F, 0x9F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xF3, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0xBF, 0x87, 0xEF, 0xE1, 0xFB, 0xF0,
  0x7E, 0x7C, 0x1F, 0x9F, 0x8F, 0xE7, 0xE7, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xE7, 0xF3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7E, 0x00, 0x78, 0x00, 0x06, 0x07, 0xE1, 0xF8, 0xFF, 0x1F, 0x87, 0xE0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x1F, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F, 0x07, 0x80, 0x00, 0xC0, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0x30, 0x00, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x7E, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0xFF, 0xF8,
  0xFF, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08,
  0x1F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0x80, 0x7F, 0xC0, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xC1,
  0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFF, 0x7E, 0x3F, 0x7E,
  0x3F, 0xFE, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0x80,
  0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0x80, 0xF8, 0x00, 0x1E,
  0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3F, 0xC3, 0x87, 0xC3, 0xFF, 0x1C, 0x3C,
  0x3F, 0xF8, 0xE1, 0xE3, 0xE7, 0xC7, 0x1E, 0x3E, 0x3C, 0x38, 0xF1, 0xF1,
  0xE1, 0xC7, 0x8F, 0x0F, 0x0E, 0x78, 0xF8, 0x78, 0xF3, 0xC7, 0xC7, 0xC7,
  0x9E, 0x3C, 0x3C, 0x3C, 0xF1, 0xE1, 0xE1, 0xE7, 0x9F, 0x0F, 0x0E, 0x78,
  0xF8, 0xF8, 0xF3, 0xC7, 0xC7, 0x87, 0x9E, 0x1E, 0x7C, 0x78, 0xF0, 0xFF,
  0xF7, 0x87, 0x87, 0xFF, 0xFC, 0x1C, 0x1F, 0xBF, 0xC0, 0xF0, 0x78, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0xDF, 0x80,
  0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F,
  0xE1, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x0F, 0xF0,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xF8,
  0x3F, 0x87, 0xE7, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC7, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0x87, 0xE1, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0x9F, 0xE1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01,
  0xF8, 0xFC, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F,
  0x87, 0xF1, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xE3, 0xF8, 0x3F, 0x0F, 0xE3,
  0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07,
  0xF1, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0xFE,
  0x3F, 0x07, 0xF1, 0xF8, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0, 0x7F, 0x3F, 0x81, 0xFC,
  0xFC, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x7F, 0xE7, 0xF1, 0xFF, 0x9F, 0x87, 0xFE, 0x7E, 0x1F, 0xF1, 0xF8, 0xFF,
  0xC7, 0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0xC7,
  0xF9, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF8,
  0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F,
  0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x1F,
  0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x01,
  0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x7F, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0xFF, 0x87, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x81, 0xFC, 0x3F,
  0x80, 0xFC, 0x3F, 0xC0, 0x7E, 0x3F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x9F,
  0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xF7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x00,
  0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0x81, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x1F,
  0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xF3, 0xEF, 0xC3, 0xF7, 0xCF, 0xBF,
  0x0F, 0xDF, 0x3D, 0xFC, 0x3F, 0x3D, 0xF7, 0xF0, 0xFC, 0xF7, 0xDF, 0x83,
  0xF3, 0xFE, 0x7E, 0x1F, 0xCF, 0xF9, 0xF8, 0x7F, 0x3F, 0xCF, 0xE1, 0xF8,
  0xFF, 0x3F, 0x87, 0xE3, 0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xF0, 0xFE, 0x3F,
  0x0F, 0xC3, 0xF8, 0xFC, 0x7F, 0x0F, 0xE3, 0xF1, 0xFC, 0x3F, 0x07, 0x87,
  0xF0, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xFC, 0x0F, 0xC1, 0xFE,
  0x07, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xE1, 0xFC, 0x3F,
  0xF0, 0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC, 0x7F, 0x07, 0xEE, 0x3F, 0x83,
  0xF7, 0x9F, 0xC1, 0xFB, 0xCF, 0xC1, 0xFD, 0xE7, 0xE0, 0xFE, 0xF3, 0xF0,
  0x7F, 0x3F, 0xF8, 0x3F, 0x1F, 0xFC, 0x1F, 0x8F, 0xFE, 0x1F, 0xC7, 0xFE,
  0x0F, 0xE3, 0xFF, 0x07, 0xF0, 0xFF, 0x83, 0xF8, 0x7F, 0xC1, 0xF8, 0x3F,
  0xE0, 0xFC, 0x1F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x1F,
  0x8F, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF,
  0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFC,
  0x7E, 0x07, 0xF1, 0xF8, 0x3F, 0x87, 0xF9, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC1, 0xFC, 0x7F,
  0x07, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0xFF, 0x1F, 0x87, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x1F, 0x8F, 0xE0,
  0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F,
  0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E,
  0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0x80, 0xFC, 0x7E, 0x07,
  0xF1, 0xF8, 0x3F, 0x87, 0xF9, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0x0F, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F,
  0x07, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x1F, 0x81, 0xFC, 0x7F, 0x07, 0xE1,
  0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE,
  0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xF3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x83, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7F, 0x0F,
  0xE3, 0xFC, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x7F, 0x03,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF0,
  0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xF0, 0x7F,
  0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F,
  0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF3, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x81, 0xFE, 0xFE,
  0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xE0, 0xFE, 0x1F, 0x83, 0xF8, 0x7E, 0x0F,
  0xE1, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x81,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7E,
  0xFE, 0x3F, 0x87, 0xEF, 0xE3, 0xF8, 0xFE, 0xFE, 0x3F, 0x8F, 0xCF, 0xE7,
  0xF8, 0xFC, 0xFE, 0x7F, 0x9F, 0xCF, 0xE7, 0xF9, 0xF8, 0xFE, 0xFF, 0x9F,
  0x8F, 0xEF, 0xFB, 0xF8, 0xFC, 0xFF, 0xBF, 0x0F, 0xDF, 0xFB, 0xF0, 0xFD,
  0xFF, 0xBF, 0x0F, 0xDF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xEF, 0xFC, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F,
  0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xDF, 0x80,
  0x07, 0xF7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x0F,
  0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xFB, 0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0xFC, 0x1F,
  0xC7, 0xE0, 0xFE, 0x3F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xE7, 0xF0, 0x3F,
  0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F,
  0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x3F,
  0xE0, 0xF7, 0x87, 0xDE, 0x1E, 0x78, 0xF9, 0xE3, 0xE7, 0xDF, 0x0F, 0x7C,
  0x3F, 0xE0, 0xF0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFE, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0xFC, 0xFC, 0x7E, 0x00,
  0x7F, 0x03, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xE3, 0xF7,
  0xF1, 0xFB, 0xF1, 0xFD, 0xF8, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0x87, 0xEF, 0xC1, 0xE7, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xEF, 0x81, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFD,
  0xFC, 0x3F, 0x7F, 0x0F, 0xDF, 0x87, 0xF7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E,
  0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFD, 0xFE, 0x3E, 0x3E,
  0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF9,
  0xF8, 0xFC, 0xFC, 0x7E, 0xFE, 0x3F, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0xFE, 0x7F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0xFC, 0x1F,
  0xEF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0x3F, 0x87,
  0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xF7,
  0xE0, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF3,
  0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x21, 0xFC, 0x30, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F,
  0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1,
  0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xBF, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x02, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFB, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF3, 0xF8, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x8F, 0xC3, 0xF1, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xE3, 0xF1, 0xF8, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x7F, 0x00, 0x07, 0xC1, 0xFC, 0x3F,
  0x87, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x3F, 0x87, 0xE3, 0xFC, 0x3F, 0x3F, 0xC1, 0xFB, 0xFC,
  0x0F, 0xDF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0x7E, 0x7E, 0x07, 0xF3, 0xF8, 0x3F, 0x8F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC0, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x9F, 0x0F, 0x83, 0xFF, 0xF7, 0xF8, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0x3F, 0x8F, 0xCF,
  0xE3, 0xF1, 0xF9, 0xF8, 0xFE, 0x3F, 0x3F, 0x1F, 0xC7, 0xE7, 0xE3, 0xF0,
  0xFC, 0xFC, 0x7E, 0x3F, 0xBF, 0x8F, 0xC7, 0xE7, 0xE1, 0xF8, 0xFC, 0xFC,
  0x7F, 0x1F, 0x9F, 0x8F, 0xE3, 0xF3, 0xF1, 0xF8, 0xFE, 0xFE, 0x3F, 0x1F,
  0xDF, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC, 0x7E, 0x7E, 0x3F, 0x8F, 0xCF, 0xC7,
  0xF1, 0xF8, 0x0F, 0xCF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0x9F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xE7,
  0xF1, 0xFC, 0xFE, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC7, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE3, 0xF8, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF3, 0xF9, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB, 0xF0, 0xFD,
  0xF8, 0xFE, 0xFF, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xEF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0x87, 0xF1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x83, 0xF7, 0xF0, 0x3F, 0x3E, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xCF, 0xC7, 0xFB, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0x9F, 0xCF, 0xE7, 0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0xBF, 0x0F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0xCF, 0xC7, 0xF3,
  0xF1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xBC, 0x7F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0xFF, 0xF3, 0xFC, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFB, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E,
  0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFE, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC,
  0x1F, 0xC7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xEF, 0xFE, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7F, 0x7F, 0x1F, 0xDF, 0x87, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x8F, 0xEF, 0xE3, 0xFB, 0xF0, 0xFC,
  0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF1, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3E, 0x7E, 0x00, 0xFC, 0x3F, 0xFE,
  0x1F, 0xBF, 0x1F, 0xDF, 0x8F, 0xEF, 0xC7, 0xE7, 0xE3, 0xF1, 0xF3, 0xF0,
  0xF9, 0xF8, 0x7C, 0xFC, 0x3E, 0xFC, 0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x7C, 0x7F, 0xF8, 0xF8, 0xFF,
  0xF1, 0xF1, 0xF7, 0xE7, 0xE7, 0xEF, 0xCF, 0xCF, 0xDF, 0xBF, 0x9F, 0x3F,
  0x7F, 0x7E, 0x7E, 0xFE, 0xFC, 0xFF, 0xFD, 0xF1, 0xFF, 0xFB, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFD, 0xFF, 0x0F, 0xFB, 0xFE, 0x1F, 0xF7, 0xFC, 0x3F, 0xCF,
  0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x3F, 0x1F,
  0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0x9F, 0x01, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x20,
  0x0E, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0xFE, 0x0F,
  0xE0, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x07, 0x07, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0xE0, 0xE0, 0x02, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF0, 0x0C,
  0x00, 0x0F, 0x00, 0x03, 0xF8, 0x7C, 0xFF, 0x8F, 0xBF, 0xF3, 0xE7, 0xFF,
  0xFC, 0xF9, 0xFF, 0xBE, 0x3F, 0xE7, 0xC3, 0xF8, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 12, 28, 10, 0, -28 },
  { 43, 12, 11, 12, 2, -30 },
  { 60, 20, 28, 20, 0, -28 },
  { 130, 19, 36, 20, 1, -32 },
  { 216, 19, 28, 25, 3, -28 },
  { 283, 21, 28, 23, 0, -28 },
  { 357, 6, 11, 6, 2, -30 },
  { 366, 12, 40, 13, 2, -31 },
  { 426, 13, 40, 13, -2, -31 },
  { 491, 17, 18, 18, 2, -28 },
  { 530, 17, 21, 18, 1, -23 },
  { 575, 9, 13, 10, -2, -5 },
  { 590, 11, 5, 16, 3, -15 },
  { 597, 7, 7, 12, 1, -7 },
  { 604, 18, 30, 12, -3, -28 },
  { 672, 18, 28, 20, 1, -28 },
  { 735, 13, 28, 20, 4, -28 },
  { 781, 19, 28, 20, 0, -28 },
  { 848, 20, 28, 20, 0, -28 },
  { 918, 18, 28, 20, 1, -28 },
  { 981, 19, 28, 20, 1, -28 },
  { 1048, 18, 28, 20, 1, -28 },
  { 1111, 20, 28, 20, 1, -28 },
  { 1181, 18, 28, 20, 1, -28 },
  { 1244, 16, 28, 20, 3, -28 },
  { 1300, 10, 23, 12, 1, -23 },
  { 1329, 12, 31, 11, -2, -23 },
  { 1376, 16, 20, 17, 1, -22 },
  { 1416, 18, 13, 20, 1, -19 },
  { 1446, 17, 19, 17, 0, -21 },
  { 1487, 16, 28, 18, 2, -28 },
  { 1543, 29, 37, 30, 0, -28 },
  { 1678, 23, 28, 24, -2, -28 },
  { 1759, 22, 28, 22, 0, -28 },
  { 1836, 22, 28, 22, 1, -28 },
  { 1913, 21, 28, 22, 0, -28 },
  { 1987, 21, 28, 19, 0, -28 },
  { 2061, 21, 28, 18, 0, -28 },
  { 2135, 22, 28, 23, 1, -28 },
  { 2212, 25, 28, 24, 0, -28 },
  { 2300, 12, 28, 11, 0, -28 },
  { 2342, 20, 28, 19, 0, -28 },
  { 2412, 25, 28, 22, 0, -28 },
  { 2500, 17, 28, 19, 0, -28 },
  { 2560, 30, 28, 29, 0, -28 },
  { 2665, 25, 28, 24, 0, -28 },
  { 2753, 22, 28, 23, 1, -28 },
  { 2830, 22, 28, 22, 0, -28 },
  { 2907, 22, 33, 23, 1, -28 },
  { 2998, 22, 28, 22, 0, -28 },
  { 3075, 21, 28, 21, 1, -28 },
  { 3149, 21, 28, 22, 3, -28 },
  { 3223, 22, 28, 22, 1, -28 },
  { 3300, 22, 28, 23, 3, -28 },
  { 3377, 28, 28, 29, 3, -28 },
  { 3475, 26, 28, 22, -2, -28 },
  { 3566, 21, 28, 21, 3, -28 },
  { 3640, 24, 28, 21, -1, -28 },
  { 3724, 14, 40, 10, -1, -33 },
  { 3794, 10, 30, 15, 3, -28 },
  { 3832, 14, 40, 10, -2, -33 },
  { 3902, 14, 14, 16, 1, -28 },
  { 3927, 16, 5, 15, -3, 0 },
  { 3937, 9, 6, 13, 4, -30 },
  { 3944, 17, 21, 18, 0, -21 },
  { 3989, 18, 30, 19, 0, -30 },
  { 4057, 17, 21, 18, 0, -21 },
  { 4102, 20, 30, 19, 1, -30 },
  { 4177, 17, 21, 19, 1, -21 },
  { 4222, 15, 30, 13, 1, -30 },
  { 4279, 20, 29, 20, 0, -21 },
  { 4352, 19, 30, 19, -1, -30 },
  { 4424, 11, 29, 10, 0, -29 },
  { 4464, 16, 37, 10, -5, -29 },
  { 4538, 21, 30, 19, 0, -30 },
  { 4617, 11, 30, 10, 0, -30 },
  { 4659, 27, 21, 29, 0, -21 },
  { 4730, 19, 21, 19, -1, -21 },
  { 4780, 17, 21, 19, 1, -21 },
  { 4825, 20, 29, 19, -2, -21 },
  { 4898, 18, 29, 19, 1, -21 },
  { 4964, 14, 21, 13, 0, -21 },
  { 5001, 17, 21, 18, 0, -21 },
  { 5046, 12, 26, 12, 1, -26 },
  { 5085, 18, 21, 19, 1, -21 },
  { 5133, 17, 21, 18, 2, -21 },
  { 5178, 23, 21, 24, 2, -21 },
  { 5239, 21, 21, 18, -2, -21 },
  { 5295, 21, 29, 18, -1, -21 },
  { 5372, 19, 21, 18, -1, -21 },
  { 5422, 12, 38, 11, 1, -31 },
  { 5479, 8, 33, 10, 1, -28 },
  { 5512, 12, 38, 11, -1, -31 },
  { 5569, 19, 9, 21, 1, -16 },
};

const GFXfont RobotoCondensed_BlackItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_BLACKITALIC40PT7B_H_
