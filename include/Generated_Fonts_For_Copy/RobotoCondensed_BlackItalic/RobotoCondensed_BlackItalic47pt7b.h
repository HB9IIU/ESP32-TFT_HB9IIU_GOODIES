#ifndef _ROBOTOCONDENSED_BLACKITALIC47PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3C, 0x00, 0x3E,
  0x3E, 0x7C, 0x7C, 0xF9, 0xFB, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F,
  0x3E, 0x3C, 0x78, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x0F, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x79, 0xF0, 0x00, 0xF9, 0xE0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0xC0,
  0x03, 0xE7, 0x80, 0x03, 0xCF, 0x80, 0x03, 0xCF, 0x80, 0x07, 0xCF, 0x00,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x0F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x7C, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFC, 0xFF,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7C, 0xF8, 0x33, 0xE3, 0xE1, 0xFF, 0x8F, 0x8F, 0xBE, 0x3E, 0x7C,
  0xF8, 0xF9, 0xE3, 0xE3, 0xEF, 0x8F, 0x8F, 0x7C, 0x3E, 0x7F, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC,
  0x1F, 0xFD, 0xF0, 0x7B, 0xE3, 0xC3, 0xEF, 0x8F, 0x1F, 0x3C, 0x3C, 0xF8,
  0xF1, 0xF3, 0xC3, 0xC7, 0xDF, 0x0F, 0x1F, 0x78, 0x3E, 0xFC, 0x40, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1,
  0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x1F, 0x87, 0xFF, 0x1F, 0xC7, 0xFF, 0xCF, 0xC7, 0xFF, 0xE7, 0xE3,
  0xFF, 0xFF, 0xF3, 0xF9, 0xFF, 0xF9, 0xFC, 0xFF, 0xF8, 0xFE, 0x3F, 0xFC,
  0xFF, 0x1F, 0xFC, 0x3F, 0x87, 0xFE, 0x1F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFB,
  0xFC, 0x03, 0xF0, 0xFF, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x0E,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x10, 0x3C, 0x00, 0xE1, 0xE1, 0xCF, 0xCF,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xF3, 0xC0, 0x3F, 0x1F,
  0x03, 0xF0, 0xF8, 0x0F, 0x03, 0xE0, 0x38, 0x1C, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE0, 0xF8, 0x06, 0x00,
  0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x1F, 0xC7, 0xF8, 0x7E, 0x3F, 0x83, 0xF1,
  0xFC, 0x1F, 0x9F, 0xE0, 0xFE, 0xFF, 0x0F, 0xF7, 0xF0, 0x7F, 0x3F, 0x83,
  0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x7F, 0xBF,
  0x83, 0xFD, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC3, 0xFC, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8F, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x07, 0xF8, 0x3F, 0xE3, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFD, 0xE7, 0xF2, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFC,
  0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0x7F,
  0x87, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x83,
  0xFC, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xEF, 0xF0, 0x1F, 0xBF, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x1F,
  0x9F, 0xE0, 0xFE, 0x7F, 0x83, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xDF, 0xE0, 0x1C, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF9, 0xF0, 0x7F,
  0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xF1, 0xFE, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE, 0xFE, 0x3F,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x3F, 0xC3, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF1,
  0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0x8F, 0xE7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE,
  0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xF1, 0xFE, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFB,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC3, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x0F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0x7E, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x01, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x80, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x00, 0x70, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x0F, 0x01,
  0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x3E, 0x07, 0xFC, 0x1E,
  0x0F, 0x83, 0xFF, 0xC7, 0x87, 0xC1, 0xFF, 0xF1, 0xE1, 0xF0, 0xFE, 0x7C,
  0x78, 0xF8, 0x7E, 0x3E, 0x1E, 0x3E, 0x1F, 0x0F, 0x87, 0x8F, 0x8F, 0xC3,
  0xE1, 0xE3, 0xC3, 0xE0, 0xF8, 0x79, 0xF0, 0xF8, 0x7C, 0x1E, 0x7C, 0x7E,
  0x1F, 0x0F, 0x9F, 0x1F, 0x87, 0xC3, 0xE7, 0x87, 0xC1, 0xF0, 0xF1, 0xE1,
  0xF0, 0xF8, 0x3C, 0xF8, 0x7C, 0x3E, 0x1F, 0x3E, 0x1F, 0x0F, 0x87, 0x8F,
  0x87, 0xC7, 0xE3, 0xE3, 0xE1, 0xFB, 0xF8, 0xF0, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1E, 0x0F, 0xF7, 0xFE, 0x07, 0x83, 0xF9, 0xFF, 0x01, 0xF0, 0x7C, 0x3F,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x10, 0x00, 0x07, 0xFC,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xDF,
  0x80, 0x07, 0xFB, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0xCF, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE,
  0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0xFF, 0x80,
  0x3F, 0x9F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF8,
  0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x87, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F,
  0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8,
  0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0xFF,
  0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC7, 0xFC, 0x1F, 0xE0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC,
  0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE3, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0x9F,
  0xE0, 0x3F, 0xCF, 0xE0, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xFE, 0xFF, 0x0F, 0xFF,
  0x7F, 0x87, 0xFF, 0x3F, 0xC3, 0xFF, 0x9F, 0xE1, 0xFF, 0xCF, 0xF1, 0xFF,
  0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0xFF, 0x03,
  0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xE3, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFE,
  0x01, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x83, 0xFF, 0x01, 0xFE, 0x1F, 0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0x1F,
  0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF3,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xFB, 0xFE,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFF,
  0x00, 0x7F, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xDF, 0x07,
  0xFF, 0xC1, 0xFD, 0xF0, 0xFF, 0xF8, 0x1F, 0xDF, 0x0F, 0xFF, 0x81, 0xFD,
  0xF1, 0xFB, 0xF8, 0x1F, 0xDF, 0x1F, 0xBF, 0x81, 0xFD, 0xF1, 0xF7, 0xF8,
  0x3F, 0xDF, 0x3F, 0x7F, 0x83, 0xFD, 0xF3, 0xF7, 0xF0, 0x3F, 0x9F, 0x7E,
  0x7F, 0x03, 0xF9, 0xF7, 0xEF, 0xF0, 0x3F, 0x8F, 0xFC, 0xFF, 0x07, 0xF8,
  0xFF, 0xCF, 0xF0, 0x7F, 0x8F, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x8F, 0xE0,
  0x7F, 0x8F, 0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF1,
  0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0,
  0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x03, 0xFE, 0x07, 0xF8, 0x3F, 0xF8, 0x3F, 0xC1, 0xFF, 0xC1,
  0xFE, 0x0F, 0xFE, 0x0F, 0xE0, 0x7F, 0xF0, 0x7F, 0x03, 0xFF, 0x87, 0xF8,
  0x1F, 0xFE, 0x3F, 0xC1, 0xFF, 0xF1, 0xFE, 0x0F, 0xFF, 0x8F, 0xF0, 0x7F,
  0xBC, 0x7F, 0x03, 0xFD, 0xF3, 0xF8, 0x1F, 0xCF, 0xBF, 0xC0, 0xFE, 0x7D,
  0xFE, 0x0F, 0xF1, 0xEF, 0xF0, 0x7F, 0x8F, 0x7F, 0x83, 0xFC, 0x7F, 0xF8,
  0x1F, 0xC3, 0xFF, 0xC0, 0xFE, 0x1F, 0xFE, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F,
  0x83, 0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0xFF, 0xC0, 0xFE, 0x03,
  0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x07, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F,
  0x9F, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07,
  0xFB, 0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00,
  0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xE0,
  0x0F, 0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0xFE,
  0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8,
  0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x87, 0xFE, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xC7, 0xFC, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xDF,
  0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x7F,
  0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07,
  0xF3, 0xF8, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFC, 0x7F, 0x81,
  0xFE, 0x1F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0,
  0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x1F,
  0xE0, 0x7F, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x0F, 0xF8, 0xFF, 0x1F, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8,
  0x7F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0,
  0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xCF, 0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8,
  0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1,
  0xFE, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F,
  0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0xFE, 0x0F, 0xE0,
  0xFE, 0xFE, 0x1F, 0xE0, 0xFE, 0xFE, 0x1F, 0xE1, 0xFE, 0xFE, 0x1F, 0xE1,
  0xFC, 0xFE, 0x3F, 0xE1, 0xFC, 0xFE, 0x3F, 0xE3, 0xFC, 0xFE, 0x3F, 0xE3,
  0xFC, 0xFE, 0x7F, 0xE3, 0xF8, 0xFE, 0x7F, 0xE7, 0xF8, 0xFE, 0x7F, 0xE7,
  0xF8, 0xFE, 0xFF, 0xE7, 0xF0, 0xFE, 0xFF, 0xEF, 0xF0, 0xFE, 0xFF, 0xEF,
  0xF0, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF,
  0xC0, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xE7, 0xFF,
  0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x03,
  0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF,
  0xC0, 0x7F, 0x8F, 0xE0, 0x7F, 0xC7, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F, 0xC1,
  0xFC, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xBC, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0xFC, 0x3F, 0x7C, 0x0F, 0x80, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1,
  0xFE, 0xFF, 0x1F, 0xC7, 0xF3, 0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x9F,
  0xEF, 0xF1, 0xFE, 0xFF, 0x1F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xF7,
  0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xDF, 0xC3, 0xFD, 0xFC, 0x0F,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFB, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xCF, 0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC,
  0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x7F, 0x83, 0xFB, 0xFC, 0x3F, 0xDF, 0xC1,
  0xFC, 0xFE, 0x0F, 0xE7, 0xF8, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFE, 0xFF, 0xC7, 0xF7, 0xFC, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xDF, 0xE3, 0xFB, 0xF8, 0x7F, 0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0xCF, 0xE0, 0x7F, 0xDF, 0xC1, 0xFF, 0xBF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0x8F, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0x1F, 0xC1,
  0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xBF, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0x87, 0xF7, 0xF8, 0x7F, 0x7F,
  0x07, 0xF7, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x20,
  0xFF, 0x07, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1,
  0xFF, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x7F,
  0x01, 0xFF, 0x7F, 0x03, 0xFF, 0x7F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE,
  0x3F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xE7, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x18, 0x1F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x7E,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0,
  0x7F, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE,
  0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x7F,
  0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x0F,
  0xF1, 0xFC, 0x3F, 0xCF, 0xF0, 0xFE, 0x00, 0x00, 0x40, 0x1F, 0x81, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFF, 0x0F, 0xE3, 0xFE, 0x0F, 0xE7, 0xFC, 0x1F,
  0xE7, 0xF8, 0x1F, 0xEF, 0xF8, 0x1F, 0xDF, 0xF0, 0x1F, 0xDF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xBF, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0,
  0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0x80, 0x0F, 0xE7, 0xC0, 0xF8, 0x0F, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF,
  0xF7, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xE7, 0xFC, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x3F, 0xC7,
  0xF8, 0x7F, 0x3F, 0xC7, 0xF8, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x7F, 0x8F,
  0xF0, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x7F, 0x0F, 0xF1, 0xFE, 0x7F, 0x0F,
  0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0xFF, 0x1F,
  0xE1, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0xFE, 0x1F, 0xE3, 0xFC, 0xFE, 0x1F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x07, 0xF3, 0xE0, 0x3F, 0xBF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFE,
  0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x3F,
  0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F,
  0xE0, 0xFE, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x1F, 0xE1,
  0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xFC,
  0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x8F, 0xF7, 0xF0, 0x7F, 0x7F,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x1F, 0xEF, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xFB, 0xE0, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF8,
  0x3F, 0x8F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x8F,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xEF, 0xFC,
  0x1F, 0xDF, 0xF0, 0x3F, 0x8F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF1, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFD, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF7, 0xF8,
  0x7F, 0xBF, 0xC3, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC3, 0xFC, 0xFE, 0x1F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x1F, 0xBF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xEF, 0x87, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xE2,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFC, 0xFF, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F,
  0xCF, 0xE3, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFC,
  0x0F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x03,
  0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xFE, 0x3F, 0xF1,
  0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F,
  0xE3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3,
  0xF8, 0x7F, 0x9F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0,
  0x7F, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE,
  0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xF7,
  0xF0, 0x1F, 0x9F, 0xC0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xE7,
  0xF1, 0xFE, 0x7F, 0x1F, 0xE7, 0xF1, 0xFC, 0x7F, 0x3F, 0xC7, 0xF3, 0xF8,
  0x7F, 0x3F, 0x87, 0xF7, 0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x0F, 0xFF, 0x87,
  0xE3, 0xFB, 0xF0, 0xFC, 0x7F, 0x7E, 0x3F, 0x8F, 0xEF, 0xC7, 0xF3, 0xF9,
  0xF9, 0xFE, 0x7F, 0x3F, 0x3F, 0xCF, 0xE7, 0xE7, 0xFB, 0xF8, 0xFD, 0xFF,
  0x7F, 0x1F, 0xBF, 0xEF, 0xC3, 0xF7, 0xFD, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xF7, 0xFF, 0x07, 0xFE, 0xFF,
  0xC0, 0xFF, 0x9F, 0xF8, 0x1F, 0xF3, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x7F,
  0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0xFE, 0x07, 0xF1, 0xFE, 0x03, 0xF9, 0xFC, 0x03, 0xFB, 0xFC, 0x03,
  0xFB, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x1F, 0xEF, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F,
  0xCF, 0xE0, 0x3F, 0x87, 0xF0, 0x7F, 0x87, 0xF0, 0xFF, 0x07, 0xF0, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE3, 0xFC, 0x0F,
  0xE3, 0xFC, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F,
  0xEF, 0xF0, 0x0F, 0xEF, 0xF0, 0x0F, 0xEF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xE0, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F,
  0x01, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0x80, 0x02, 0x00,
  0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x00, 0x01, 0x00, 0x0E, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x81, 0xF1, 0xFF, 0x07, 0xCF, 0xFE, 0x3F, 0x3F, 0xFC, 0xFD, 0xFF, 0xFF,
  0xE7, 0xE7, 0xFF, 0x9F, 0x0F, 0xFE, 0x7C, 0x1F, 0xF3, 0xF0, 0x7F, 0x80,
  0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 33, 12, 0, -33 },
  { 59, 15, 13, 14, 2, -35 },
  { 84, 24, 33, 23, 0, -33 },
  { 183, 22, 43, 23, 1, -38 },
  { 302, 22, 33, 29, 4, -33 },
  { 393, 25, 33, 27, 0, -33 },
  { 497, 8, 13, 7, 2, -35 },
  { 510, 15, 47, 15, 2, -37 },
  { 599, 15, 47, 15, -2, -37 },
  { 688, 21, 21, 21, 2, -33 },
  { 744, 20, 25, 21, 1, -28 },
  { 807, 11, 15, 12, -3, -6 },
  { 828, 13, 6, 19, 3, -17 },
  { 838, 8, 8, 14, 1, -8 },
  { 846, 20, 36, 14, -3, -33 },
  { 936, 21, 33, 23, 2, -33 },
  { 1023, 15, 33, 23, 5, -33 },
  { 1085, 23, 33, 23, 0, -33 },
  { 1180, 23, 33, 23, 0, -33 },
  { 1275, 22, 33, 23, 1, -33 },
  { 1366, 22, 33, 23, 1, -33 },
  { 1457, 20, 33, 23, 2, -33 },
  { 1540, 22, 33, 23, 2, -33 },
  { 1631, 22, 33, 23, 1, -33 },
  { 1722, 20, 33, 23, 3, -33 },
  { 1805, 11, 26, 14, 1, -26 },
  { 1841, 14, 35, 13, -2, -26 },
  { 1903, 19, 23, 20, 1, -26 },
  { 1958, 21, 17, 24, 1, -23 },
  { 2003, 20, 22, 21, 0, -25 },
  { 2058, 18, 33, 21, 3, -33 },
  { 2133, 34, 42, 35, 0, -32 },
  { 2312, 27, 33, 28, -2, -33 },
  { 2424, 26, 33, 26, 0, -33 },
  { 2532, 26, 33, 26, 1, -33 },
  { 2640, 25, 33, 26, 0, -33 },
  { 2744, 25, 33, 22, 0, -33 },
  { 2848, 24, 33, 22, 0, -33 },
  { 2947, 25, 33, 27, 2, -33 },
  { 3051, 29, 33, 28, 0, -33 },
  { 3171, 14, 33, 13, 0, -33 },
  { 3229, 24, 33, 22, 0, -33 },
  { 3328, 30, 33, 25, 0, -33 },
  { 3452, 19, 33, 22, 0, -33 },
  { 3531, 36, 33, 35, 0, -33 },
  { 3680, 29, 33, 28, 0, -33 },
  { 3800, 25, 33, 28, 2, -33 },
  { 3904, 26, 33, 26, 0, -33 },
  { 4012, 25, 39, 28, 2, -33 },
  { 4134, 26, 33, 26, 0, -33 },
  { 4242, 24, 33, 25, 1, -33 },
  { 4341, 25, 33, 25, 3, -33 },
  { 4445, 27, 33, 26, 1, -33 },
  { 4557, 27, 33, 27, 3, -33 },
  { 4669, 32, 33, 34, 4, -33 },
  { 4801, 30, 33, 26, -2, -33 },
  { 4925, 25, 33, 25, 4, -33 },
  { 5029, 28, 33, 24, -1, -33 },
  { 5145, 16, 47, 12, -1, -39 },
  { 5239, 13, 36, 18, 3, -33 },
  { 5298, 17, 47, 12, -3, -39 },
  { 5398, 17, 17, 18, 1, -33 },
  { 5435, 18, 6, 18, -3, 0 },
  { 5449, 11, 7, 15, 5, -35 },
  { 5459, 20, 25, 21, 0, -25 },
  { 5522, 21, 35, 23, 0, -35 },
  { 5614, 19, 25, 21, 1, -25 },
  { 5674, 23, 35, 23, 1, -35 },
  { 5775, 20, 25, 22, 1, -25 },
  { 5838, 17, 35, 15, 1, -35 },
  { 5913, 24, 35, 23, -1, -25 },
  { 6018, 22, 35, 23, -1, -35 },
  { 6115, 13, 36, 12, 0, -36 },
  { 6174, 19, 46, 12, -6, -36 },
  { 6284, 24, 35, 22, 0, -35 },
  { 6389, 13, 35, 12, 0, -35 },
  { 6446, 32, 25, 34, 0, -25 },
  { 6546, 22, 25, 23, -1, -25 },
  { 6615, 20, 25, 22, 1, -25 },
  { 6678, 23, 35, 23, -2, -25 },
  { 6779, 21, 35, 23, 1, -25 },
  { 6871, 17, 25, 16, 0, -25 },
  { 6925, 20, 25, 21, 0, -25 },
  { 6988, 13, 31, 14, 2, -31 },
  { 7039, 22, 25, 23, 1, -25 },
  { 7108, 20, 25, 21, 2, -25 },
  { 7171, 27, 25, 28, 3, -25 },
  { 7256, 24, 25, 21, -2, -25 },
  { 7331, 24, 35, 21, -1, -25 },
  { 7436, 22, 25, 21, -1, -25 },
  { 7505, 14, 45, 13, 1, -37 },
  { 7584, 10, 39, 12, 1, -33 },
  { 7633, 14, 45, 13, -1, -37 },
  { 7712, 22, 11, 25, 1, -19 },
};

const GFXfont RobotoCondensed_BlackItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_BLACKITALIC47PT7B_H_
