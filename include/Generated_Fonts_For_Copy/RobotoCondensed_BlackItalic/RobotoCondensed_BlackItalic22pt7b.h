#ifndef _ROBOTOCONDENSED_BLACKITALIC22PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xF3, 0xCF, 0x38, 0xE3, 0x8E, 0x31, 0xC0, 0x00, 0x63, 0xCF,
  0x18, 0x6E, 0xDF, 0xB7, 0x6C, 0xD9, 0x80, 0x06, 0xC0, 0xD8, 0x1B, 0x06,
  0xC0, 0xD8, 0x7F, 0xCF, 0xF8, 0xD8, 0x1B, 0x1F, 0xF3, 0xFE, 0x1B, 0x03,
  0x60, 0xD8, 0x1B, 0x03, 0x60, 0x02, 0x00, 0x80, 0xF0, 0xFE, 0x3F, 0x9E,
  0xF7, 0xBD, 0xE0, 0x78, 0x0F, 0x81, 0xF0, 0x1C, 0x07, 0xB9, 0xEE, 0x73,
  0xFC, 0x7E, 0x0F, 0x01, 0x00, 0x40, 0x78, 0x3F, 0x0C, 0xCF, 0x36, 0xDF,
  0xBE, 0xC7, 0x60, 0x38, 0x0C, 0x06, 0xE3, 0xFC, 0xDB, 0x6E, 0xF3, 0xB0,
  0x7C, 0x1E, 0x07, 0x00, 0xF8, 0x1F, 0xC1, 0xDC, 0x19, 0xC1, 0xF8, 0x1F,
  0x81, 0xE0, 0x3E, 0x77, 0xFE, 0xF7, 0xEF, 0x7E, 0xF3, 0xCF, 0xFC, 0x7F,
  0xC3, 0xDE, 0x66, 0x6E, 0xEC, 0x04, 0x1C, 0x70, 0xC3, 0x86, 0x1C, 0x38,
  0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xE1, 0xC1, 0x83, 0x03, 0x04,
  0x00, 0x08, 0x30, 0x30, 0x60, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0x87, 0x0E, 0x18, 0x70, 0xC3, 0x8E, 0x10, 0x00, 0x06, 0x03, 0x80,
  0xC1, 0xB6, 0xFF, 0xC7, 0x83, 0xC1, 0xD8, 0xE7, 0x00, 0x80, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x7F, 0xDF, 0xE7, 0xF8, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x39, 0xDC, 0xE7, 0x71, 0x00, 0x7D, 0xF7, 0xC0, 0x27, 0xF7, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x00, 0x0F, 0x0F, 0xE3, 0xF9,
  0xCE, 0x73, 0xDC, 0xFF, 0x3B, 0xCE, 0xE3, 0xB8, 0xEE, 0x7B, 0x9E, 0xE7,
  0x3F, 0xC7, 0xE0, 0xF0, 0x02, 0x3D, 0xFB, 0xFF, 0xE3, 0x87, 0x0E, 0x1C,
  0x78, 0xF1, 0xC3, 0x87, 0x0E, 0x3C, 0x0F, 0x83, 0xF8, 0xFF, 0x1C, 0xF7,
  0x9E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xFF, 0x3F, 0xE7, 0xFC, 0x0F, 0x83, 0xF8, 0xFF, 0x1C, 0xF0, 0x1E, 0x03,
  0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x78, 0x0F, 0x79, 0xEF, 0x3C, 0xFF, 0x1F,
  0xC1, 0xF0, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0xFC, 0x1F, 0x87, 0xF1,
  0xDC, 0x3B, 0x8E, 0x71, 0xFF, 0x7F, 0xEF, 0xFC, 0x0E, 0x01, 0xC0, 0x38,
  0x1F, 0xE3, 0xFC, 0x7F, 0x9C, 0x03, 0x80, 0x7E, 0x1F, 0xE3, 0xFC, 0x03,
  0xC0, 0x78, 0x0F, 0x79, 0xE7, 0x38, 0xFF, 0x0F, 0xC0, 0xF0, 0x07, 0x87,
  0x87, 0xC7, 0x87, 0x83, 0xFB, 0xFD, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0xFE,
  0x7F, 0xF9, 0xF8, 0x78, 0x7F, 0xDF, 0xF7, 0xFC, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0x07, 0x83, 0xF8, 0x7F, 0x1E, 0xF3, 0x9E, 0x73, 0x87, 0xF0, 0xFC, 0x3F,
  0x8F, 0x71, 0xCF, 0x39, 0xE7, 0x38, 0xFF, 0x1F, 0xC0, 0xF0, 0x0F, 0x0F,
  0xC3, 0xF9, 0xCE, 0x73, 0xBC, 0xFF, 0x39, 0xCE, 0x7F, 0x9F, 0xE3, 0xF8,
  0x1C, 0x0F, 0x1F, 0x87, 0xC1, 0xC0, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x87, 0x3C, 0x70, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0x40, 0x00, 0x81, 0xC3, 0xE7, 0xF7,
  0xE3, 0x83, 0xF0, 0xFE, 0x1F, 0x03, 0x80, 0x40, 0x7F, 0xBF, 0xDF, 0xE0,
  0x00, 0x07, 0xFB, 0xFD, 0xFE, 0x20, 0x1C, 0x0F, 0x87, 0xE0, 0xF8, 0x3C,
  0x7E, 0xFE, 0x7C, 0x70, 0x20, 0x00, 0x1E, 0x1F, 0x9F, 0xEE, 0xFF, 0x78,
  0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x0E, 0x00, 0x03, 0x03, 0xC1, 0xE0, 0xE0,
  0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x19, 0xE6, 0x33, 0xF3,
  0x33, 0x33, 0x66, 0x73, 0x66, 0x63, 0x6E, 0x66, 0xEE, 0x66, 0xCE, 0xE6,
  0xCE, 0xEC, 0xCF, 0xFC, 0xC7, 0x78, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x3F, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x81, 0xDE, 0x1E, 0xF0, 0xE3, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x3C, 0x39, 0xC1, 0xDE, 0x0F, 0x1F, 0xC3, 0xFE, 0x3F, 0xF3, 0xCF,
  0x38, 0xF3, 0x8F, 0x39, 0xE7, 0xFC, 0x7F, 0xC7, 0x9E, 0x71, 0xE7, 0x1E,
  0xF1, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0x77,
  0x0F, 0xE1, 0xFC, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x87, 0x70, 0xEE, 0x3D,
  0xFF, 0x1F, 0xC1, 0xF0, 0x1F, 0x83, 0xFC, 0x3F, 0xE3, 0xCE, 0x38, 0xF3,
  0x8F, 0x38, 0xF7, 0x8E, 0x78, 0xE7, 0x8E, 0x71, 0xE7, 0x1E, 0xF3, 0xCF,
  0xFC, 0xFF, 0x8F, 0xE0, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xC0, 0x38, 0x03,
  0x80, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0xF8, 0xFF, 0x8F, 0xF8, 0x1F, 0xE7, 0xFC, 0xFF, 0x9E, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0xFE, 0x7F, 0x8F, 0xF1, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0xE7, 0x00, 0xF0,
  0x0F, 0x3E, 0xF7, 0xEF, 0x7E, 0xE1, 0xEE, 0x1C, 0xF1, 0xCF, 0xFC, 0x7F,
  0xC3, 0xF0, 0x1C, 0x3C, 0xF0, 0xE3, 0xC3, 0x8F, 0x1E, 0x38, 0x78, 0xE1,
  0xE3, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xE3, 0xC7, 0x0F, 0x1C, 0x3C, 0xF0,
  0xE3, 0xC3, 0x8F, 0x0E, 0x3C, 0x78, 0x1C, 0x73, 0xCF, 0x3C, 0xE3, 0x8E,
  0x79, 0xE7, 0x9C, 0x71, 0xCF, 0x3C, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x79, 0xCF, 0x79,
  0xFE, 0x1F, 0xC1, 0xE0, 0x1C, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x78, 0x3B,
  0xC0, 0xEF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1E,
  0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0x78, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0xFF,
  0xFF, 0xFF, 0x1E, 0x0F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3,
  0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0xFE, 0xFC, 0x7F, 0x6E, 0x3B, 0xF7, 0x1D,
  0xFF, 0x8E, 0xFB, 0xC7, 0x3D, 0xE7, 0x9C, 0xE3, 0xCE, 0x71, 0xE6, 0x38,
  0x1C, 0x38, 0xF0, 0xE3, 0xE3, 0x8F, 0x9E, 0x3E, 0x78, 0xF9, 0xE3, 0xF7,
  0x1E, 0xDC, 0x7B, 0x71, 0xEF, 0xC7, 0x3F, 0x1C, 0xFC, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0xEF,
  0x0F, 0xF0, 0xFF, 0x0E, 0xF0, 0xEE, 0x1E, 0xE1, 0xEE, 0x1E, 0xF3, 0xCF,
  0xF8, 0x7F, 0x83, 0xE0, 0x1F, 0xC3, 0xFE, 0x3F, 0xF3, 0xCF, 0x38, 0x73,
  0x8F, 0x38, 0xF7, 0x8F, 0x7F, 0xE7, 0xFC, 0x7F, 0x87, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0x8E, 0x70, 0xF7,
  0x0F, 0xF0, 0xFF, 0x0E, 0xF0, 0xEF, 0x1E, 0xE1, 0xEE, 0x1E, 0xF3, 0xCF,
  0xFC, 0x7F, 0x83, 0xF0, 0x07, 0x80, 0x38, 0x01, 0x00, 0x1F, 0xC3, 0xFE,
  0x3F, 0xF3, 0xCF, 0x38, 0xF3, 0x8F, 0x38, 0xF7, 0xFE, 0x7F, 0xC7, 0xF8,
  0x73, 0x87, 0x3C, 0x73, 0xCF, 0x3C, 0xF3, 0xCF, 0x1C, 0x07, 0xC1, 0xFE,
  0x1F, 0xE3, 0xCF, 0x3C, 0xF3, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3C,
  0x01, 0xEF, 0x1E, 0x71, 0xC7, 0xFC, 0x3F, 0x81, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0xF7, 0x8F, 0x78, 0xE7,
  0x8E, 0x70, 0xE7, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xCF, 0x1C, 0xE1, 0xCE,
  0x3C, 0xE3, 0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF,
  0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0x8F, 0x78, 0x77, 0x07, 0x70, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xE3, 0x9F, 0xCF, 0x3B, 0x9E,
  0x77, 0x3D, 0xEE, 0xFB, 0xDD, 0xF7, 0x3B, 0xFE, 0x7F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xE3, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x1E, 0x7C, 0x3C, 0xF0, 0x79,
  0xE0, 0x1E, 0x3C, 0x79, 0xE1, 0xE7, 0x83, 0xBC, 0x0E, 0xF0, 0x3F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0x78, 0x3D, 0xE0,
  0xF7, 0x87, 0x8E, 0x3E, 0x3C, 0xF1, 0xFE, 0x3F, 0xCF, 0x39, 0xC7, 0x78,
  0xEE, 0x1F, 0xC3, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x1E, 0x01, 0xC0, 0x3C,
  0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0xFC,
  0xFF, 0xCF, 0xFC, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x78, 0x78,
  0x78, 0xE7, 0x39, 0xCF, 0x7B, 0xCE, 0x73, 0x9C, 0xF7, 0xBC, 0xE7, 0x38,
  0x1E, 0x1E, 0x1E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0x1C, 0x38,
  0xF1, 0xF7, 0x6C, 0xF9, 0xF3, 0xFF, 0xFF, 0xFF, 0x73, 0xCE, 0x1F, 0x1F,
  0xDF, 0xEF, 0x70, 0x39, 0xFD, 0xFF, 0xEF, 0xF7, 0xFF, 0xBF, 0xCE, 0xE0,
  0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0F, 0xE3, 0xFD, 0xFF, 0x79, 0xDE,
  0x77, 0x1D, 0xCF, 0x73, 0xFC, 0xEF, 0xFB, 0xFE, 0xEF, 0x00, 0x1F, 0x0F,
  0xE7, 0xF9, 0xCE, 0x73, 0x9C, 0x0F, 0x03, 0xC0, 0xF7, 0x9F, 0xC7, 0xF0,
  0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x3B, 0x8F, 0xF3, 0xFE,
  0x73, 0xCE, 0x7B, 0xCF, 0x79, 0xCF, 0x39, 0xE7, 0x3F, 0xE3, 0xFC, 0x3F,
  0x80, 0x0F, 0x0F, 0xE3, 0xFD, 0xC7, 0x71, 0xDF, 0xF7, 0xFF, 0xC0, 0x71,
  0x1F, 0xC7, 0xF8, 0x78, 0x07, 0x87, 0x87, 0xC3, 0x81, 0xC3, 0xF9, 0xF8,
  0xFC, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x00,
  0x1E, 0xE7, 0xFD, 0xFF, 0x3C, 0xE7, 0x1C, 0xE7, 0xBC, 0xF7, 0x9E, 0xF3,
  0x8F, 0xF1, 0xFE, 0x1F, 0xC0, 0x78, 0xFE, 0x3F, 0x83, 0xE0, 0x3C, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0F, 0xE7, 0xF9, 0xFF, 0x7B, 0xDC, 0xF7, 0x3D,
  0xCE, 0xF3, 0xBC, 0xEF, 0x3B, 0x9E, 0xE7, 0x80, 0x08, 0xF3, 0xC6, 0x00,
  0xE3, 0x8E, 0x79, 0xE7, 0x1C, 0x71, 0xCF, 0x3C, 0xE0, 0x01, 0x03, 0xC1,
  0xE0, 0x60, 0x00, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x1F, 0x0F, 0x0F, 0x00, 0x1C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x73, 0xCE, 0xF3, 0xFC, 0x7F, 0x8F, 0xE1, 0xF8,
  0x3F, 0x87, 0xF1, 0xEE, 0x3D, 0xE7, 0xBC, 0xE3, 0x80, 0x1C, 0x73, 0xCF,
  0x3C, 0xE3, 0x8E, 0x79, 0xE7, 0x1C, 0x71, 0xCF, 0x3C, 0xE0, 0x3B, 0x9C,
  0x7F, 0xFD, 0xFF, 0xFB, 0xDE, 0x77, 0xBD, 0xEE, 0x7B, 0xDC, 0xE7, 0xB9,
  0xCE, 0xF3, 0x9D, 0xEF, 0x3B, 0xDE, 0xF7, 0x3D, 0xE0, 0x3F, 0x9F, 0xF7,
  0xFD, 0xEF, 0x73, 0xDC, 0xF7, 0x3B, 0xCE, 0xF3, 0xBC, 0xEE, 0x7B, 0x9E,
  0x0F, 0x0F, 0xE3, 0xFD, 0xC7, 0x71, 0xDC, 0xFF, 0x3F, 0xCF, 0xF3, 0x9F,
  0xE7, 0xF0, 0xF8, 0x1F, 0xC3, 0xFC, 0xFF, 0x9E, 0x73, 0x8E, 0x71, 0xCE,
  0x79, 0xCF, 0x79, 0xCF, 0xF9, 0xFE, 0x3B, 0x87, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x1D, 0xC7, 0xF9, 0xFF, 0x39, 0xE7, 0x3D, 0xE7, 0xBC, 0xE7, 0x9C,
  0xF3, 0x9F, 0xF1, 0xFE, 0x1F, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x3F,
  0x3F, 0x7F, 0x7C, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0x1F,
  0x1F, 0xDE, 0xEE, 0x77, 0x81, 0xF0, 0x7C, 0x1E, 0xE7, 0x7F, 0x9F, 0xC7,
  0x80, 0x38, 0xE7, 0xBF, 0xFF, 0xF7, 0x1C, 0xF3, 0xCE, 0x38, 0xFB, 0xC7,
  0x00, 0x39, 0xE7, 0x39, 0xE7, 0x3C, 0xE7, 0x3C, 0xE7, 0x9C, 0xF3, 0x9C,
  0xF3, 0x8F, 0xF1, 0xFE, 0x1F, 0xC0, 0xF3, 0xBD, 0xEF, 0x73, 0xDC, 0xFF,
  0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xE7, 0x7F, 0x3B,
  0xBB, 0xDD, 0xDE, 0xEE, 0xFE, 0x7F, 0xF3, 0xEF, 0x9F, 0x78, 0xFB, 0xC7,
  0x9E, 0x3C, 0xE1, 0xC7, 0x00, 0x3C, 0xE3, 0xBC, 0x77, 0x0F, 0xE1, 0xF8,
  0x1E, 0x07, 0xC0, 0xF8, 0x3F, 0x87, 0x71, 0xEE, 0x79, 0xC0, 0x79, 0xEF,
  0x79, 0xEF, 0x3D, 0xC7, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x3F, 0xCF, 0xF7, 0xF8,
  0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3F, 0xCF, 0xF3, 0xFC, 0x06,
  0x1C, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0xF3, 0xC7, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC1, 0x81, 0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31,
  0x8C, 0xC6, 0x31, 0x8C, 0x62, 0x30, 0x08, 0x38, 0x70, 0x61, 0xC3, 0x87,
  0x0E, 0x1C, 0x1C, 0x38, 0xF3, 0xC7, 0x0E, 0x1C, 0x38, 0xE1, 0xC7, 0x04,
  0x00, 0x79, 0xDE, 0x7F, 0xFB, 0x3E, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 7, 1, -17 },
  { 19, 11, 16, 11, 0, -16 },
  { 41, 10, 20, 11, 1, -18 },
  { 66, 10, 16, 14, 2, -16 },
  { 86, 12, 16, 13, 0, -16 },
  { 110, 4, 6, 3, 1, -17 },
  { 113, 7, 22, 7, 1, -17 },
  { 133, 7, 22, 7, -1, -17 },
  { 153, 10, 10, 10, 1, -16 },
  { 166, 10, 11, 10, 0, -13 },
  { 180, 5, 7, 6, -1, -3 },
  { 185, 6, 3, 9, 1, -8 },
  { 188, 4, 4, 6, 0, -4 },
  { 190, 10, 17, 7, -2, -16 },
  { 212, 10, 16, 11, 1, -16 },
  { 232, 7, 16, 11, 2, -16 },
  { 246, 11, 16, 11, 0, -16 },
  { 268, 11, 16, 11, 0, -16 },
  { 290, 11, 16, 11, 0, -16 },
  { 312, 11, 16, 11, 0, -16 },
  { 334, 9, 16, 11, 1, -16 },
  { 352, 10, 16, 11, 1, -16 },
  { 372, 11, 16, 11, 0, -16 },
  { 394, 10, 16, 11, 1, -16 },
  { 414, 6, 13, 6, 0, -13 },
  { 424, 7, 17, 6, -1, -13 },
  { 439, 9, 11, 10, 0, -12 },
  { 452, 9, 8, 11, 1, -11 },
  { 461, 9, 11, 10, 0, -12 },
  { 474, 9, 16, 10, 1, -16 },
  { 492, 16, 20, 16, 0, -15 },
  { 532, 13, 16, 13, -1, -16 },
  { 558, 12, 16, 12, 0, -16 },
  { 582, 11, 16, 12, 1, -16 },
  { 604, 12, 16, 12, 0, -16 },
  { 628, 12, 16, 10, 0, -16 },
  { 652, 11, 16, 10, 0, -16 },
  { 674, 12, 16, 13, 1, -16 },
  { 698, 14, 16, 13, 0, -16 },
  { 726, 6, 16, 6, 0, -16 },
  { 738, 11, 16, 11, 0, -16 },
  { 760, 14, 16, 12, 0, -16 },
  { 788, 9, 16, 10, 0, -16 },
  { 806, 17, 16, 16, 0, -16 },
  { 840, 14, 16, 13, 0, -16 },
  { 868, 12, 16, 13, 1, -16 },
  { 892, 12, 16, 12, 0, -16 },
  { 916, 12, 19, 13, 1, -16 },
  { 945, 12, 16, 12, 0, -16 },
  { 969, 12, 16, 12, 0, -16 },
  { 993, 11, 16, 12, 2, -16 },
  { 1015, 12, 16, 12, 1, -16 },
  { 1039, 12, 16, 12, 2, -16 },
  { 1063, 15, 16, 16, 2, -16 },
  { 1093, 14, 16, 12, -1, -16 },
  { 1121, 11, 16, 12, 2, -16 },
  { 1143, 12, 16, 11, 0, -16 },
  { 1167, 8, 22, 6, -1, -18 },
  { 1189, 5, 17, 8, 2, -16 },
  { 1200, 8, 22, 6, -1, -18 },
  { 1222, 7, 8, 9, 1, -16 },
  { 1229, 8, 3, 8, -1, 0 },
  { 1232, 5, 3, 7, 2, -16 },
  { 1234, 9, 12, 10, 0, -12 },
  { 1248, 10, 17, 11, 0, -17 },
  { 1270, 10, 12, 10, 0, -12 },
  { 1285, 11, 17, 11, 0, -17 },
  { 1309, 10, 12, 10, 0, -12 },
  { 1324, 9, 17, 7, 0, -17 },
  { 1344, 11, 16, 11, 0, -12 },
  { 1366, 10, 17, 11, 0, -17 },
  { 1388, 6, 17, 6, 0, -17 },
  { 1401, 9, 21, 5, -3, -17 },
  { 1425, 11, 17, 10, 0, -17 },
  { 1449, 6, 17, 6, 0, -17 },
  { 1462, 15, 12, 16, 0, -12 },
  { 1485, 10, 12, 11, 0, -12 },
  { 1500, 10, 12, 11, 0, -12 },
  { 1515, 11, 16, 11, -1, -12 },
  { 1537, 11, 16, 11, 0, -12 },
  { 1559, 8, 12, 7, 0, -12 },
  { 1571, 9, 12, 10, 0, -12 },
  { 1585, 6, 15, 7, 1, -15 },
  { 1597, 11, 12, 11, 0, -12 },
  { 1614, 10, 12, 10, 1, -12 },
  { 1629, 13, 12, 13, 1, -12 },
  { 1649, 11, 12, 10, -1, -12 },
  { 1666, 11, 16, 10, 0, -12 },
  { 1688, 10, 12, 10, 0, -12 },
  { 1703, 7, 21, 6, 0, -17 },
  { 1722, 5, 19, 5, 0, -16 },
  { 1734, 7, 21, 6, -1, -17 },
  { 1753, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_BlackItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_BLACKITALIC22PT7B_H_
