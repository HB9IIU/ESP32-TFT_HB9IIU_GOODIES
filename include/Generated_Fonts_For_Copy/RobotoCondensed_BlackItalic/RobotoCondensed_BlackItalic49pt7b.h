#ifndef _ROBOTOCONDENSED_BLACKITALIC49PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x01, 0xFC,
  0x03, 0xE0, 0x00, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8,
  0x78, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0x78, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF8,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x07, 0xCF, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF9, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xCF, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0x81, 0x8F, 0x8F, 0x07,
  0xBF, 0x1F, 0x1F, 0x7C, 0x3C, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3,
  0xE3, 0xEF, 0x83, 0xEF, 0xDF, 0x07, 0xFF, 0x7C, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFB, 0xC0, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xCF, 0x80, 0x1F, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xEF, 0xDF, 0x07, 0x9F, 0x1E, 0x1F, 0x7C, 0x3C, 0x7C, 0xF8,
  0xF9, 0xF1, 0xF1, 0xF3, 0xE3, 0xE3, 0xEF, 0x87, 0xC7, 0xCE, 0x0F, 0xDF,
  0x84, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F,
  0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xCF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xF1, 0xFC, 0x7F, 0xFC, 0x7F, 0x1F, 0xFF, 0x9F, 0x8F, 0xFF, 0xE7, 0xE7,
  0xFB, 0xFF, 0xF9, 0xFE, 0xFF, 0xFE, 0x7F, 0x9F, 0xFF, 0x1F, 0xE3, 0xFF,
  0xC7, 0xF0, 0xFF, 0xE1, 0xFC, 0x1F, 0xF8, 0x7F, 0x87, 0xFC, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xCF, 0xF8, 0x03, 0x00, 0x00, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x00,
  0x04, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xC0, 0x03, 0x80, 0x02, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x80,
  0xF0, 0x23, 0x83, 0xC3, 0x9F, 0xCF, 0x7E, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x7D, 0xE0, 0x07, 0xE7, 0xC0, 0x3F, 0x8F, 0x01, 0xFC, 0x3E, 0x03, 0xE0,
  0xFC, 0x03, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFE,
  0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x87, 0xE0, 0xF8, 0x06, 0x00, 0x7F, 0xFD,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xFB, 0xFF, 0xE0, 0x3E, 0x3F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xF9, 0xFC, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFE, 0x7F, 0x87, 0xF0,
  0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF,
  0x7F, 0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F,
  0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07,
  0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xF3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0x3F, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0xFE, 0x03, 0xFE,
  0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7D, 0xFC,
  0xE1, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF9, 0xFE, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x7F,
  0x8F, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0xFE,
  0x00, 0xFB, 0xFC, 0x03, 0xF7, 0xF8, 0x0F, 0xCF, 0xF0, 0x1F, 0x9F, 0xE0,
  0x7E, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF1, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFD, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3C, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF9, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF9, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF9, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xE3, 0xFD, 0xFE, 0x1F, 0xEF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF7,
  0xF0, 0x7F, 0xBF, 0x83, 0xFD, 0xFC, 0x3F, 0xCF, 0xF3, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0x07, 0xF8, 0xFF, 0x0F, 0xE1,
  0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F,
  0xC1, 0xFC, 0x7F, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x0F,
  0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFE,
  0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF9, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF0,
  0xFE, 0x7F, 0x87, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFD, 0xFE, 0x0F, 0xEF,
  0xF0, 0x7F, 0x7F, 0x83, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x0F,
  0xF3, 0xF8, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFB, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8,
  0xFF, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x7F, 0xFF, 0x87,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x10, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x08, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xDF, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00,
  0x78, 0x1F, 0x80, 0xF8, 0x0F, 0x03, 0xE0, 0x7F, 0xC1, 0xE0, 0xFC, 0x1F,
  0xFE, 0x3E, 0x1F, 0x07, 0xFF, 0xC7, 0xC7, 0xE1, 0xFF, 0xF8, 0xF8, 0xF8,
  0x7E, 0x3F, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE7, 0xC3, 0xF0, 0xF8, 0x7C,
  0xF8, 0x7C, 0x1F, 0x0F, 0x9F, 0x1F, 0x87, 0xE1, 0xF7, 0xC3, 0xF0, 0xF8,
  0x3E, 0xF8, 0x7E, 0x1F, 0x07, 0x9F, 0x0F, 0x83, 0xE0, 0xF3, 0xE3, 0xF0,
  0x7C, 0x3E, 0x7C, 0x7E, 0x1F, 0x07, 0xCF, 0x8F, 0xC3, 0xE0, 0xF1, 0xE1,
  0xF8, 0x7C, 0x1E, 0x7C, 0x3F, 0x1F, 0x87, 0xCF, 0x87, 0xE3, 0xF0, 0xF1,
  0xF0, 0xFC, 0xFE, 0x3E, 0x1E, 0x0F, 0xFF, 0xFF, 0x83, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7C, 0x3F, 0xCF, 0xF8, 0x0F, 0x83, 0xF0, 0xFE, 0x01, 0xF0, 0x08,
  0x06, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFB, 0xF8, 0x00,
  0x7F, 0xBF, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0,
  0x3F, 0xC1, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xE0, 0x1F, 0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE7, 0xFC,
  0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0xFF,
  0x07, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87,
  0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F,
  0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF9,
  0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F,
  0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0x83,
  0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0,
  0x7F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF8, 0x7F, 0x9F, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0,
  0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x87, 0xFF, 0xBF, 0xE1, 0xFF, 0xEF, 0xF0, 0xFF, 0xFB, 0xFC, 0x3F,
  0xFC, 0xFF, 0x0F, 0xFF, 0x3F, 0xC3, 0xFF, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC,
  0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFE, 0x07, 0xF8, 0x7F, 0xEF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xFB, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xF8,
  0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF, 0x80, 0x7F, 0x83,
  0xFE, 0x00, 0xFF, 0x0F, 0xFC, 0x01, 0xFE, 0x3F, 0xF0, 0x03, 0xFC, 0x7F,
  0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFB, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFE,
  0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xDF, 0x8F, 0xDF, 0xC0, 0xFE, 0xFC, 0x7E,
  0xFE, 0x07, 0xF3, 0xE3, 0xEF, 0xF0, 0x7F, 0x9F, 0x3F, 0x7F, 0x83, 0xFC,
  0xF9, 0xFB, 0xFC, 0x1F, 0xE7, 0xDF, 0x9F, 0xE0, 0xFF, 0x3E, 0xFC, 0xFE,
  0x07, 0xF9, 0xF7, 0xCF, 0xF0, 0x3F, 0x8F, 0xFE, 0x7F, 0x83, 0xFC, 0x7F,
  0xE3, 0xFC, 0x1F, 0xE3, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xC3,
  0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0x0F, 0xF8, 0x3F, 0xC1, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07,
  0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x81, 0xFF,
  0x81, 0xFE, 0x0F, 0xFE, 0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0,
  0xFF, 0x03, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFE, 0x3F,
  0xC1, 0xFE, 0xF8, 0xFF, 0x07, 0xFB, 0xE3, 0xFC, 0x1F, 0xEF, 0x9F, 0xE0,
  0x7F, 0x9E, 0x7F, 0x81, 0xFE, 0x7D, 0xFE, 0x0F, 0xF1, 0xF7, 0xF8, 0x3F,
  0xC7, 0xDF, 0xE0, 0xFF, 0x1F, 0x7F, 0x03, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0,
  0xFF, 0xF0, 0x3F, 0xC3, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x1F,
  0xFC, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x07, 0xFE,
  0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x83,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0,
  0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F,
  0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC,
  0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xE3,
  0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xE0,
  0x7F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE1, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03,
  0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8,
  0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF,
  0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F,
  0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE1, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0x7F, 0xC0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3,
  0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xF3, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F,
  0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F,
  0xC0, 0xFF, 0x1F, 0xF0, 0x7F, 0x87, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F,
  0x80, 0x3F, 0xCF, 0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x7F,
  0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1,
  0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0xC1, 0xFC, 0x1F, 0xEF, 0xF0, 0xFF, 0x07,
  0xFB, 0xFC, 0x3F, 0xC1, 0xFE, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC,
  0x3F, 0xCF, 0xF1, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0xC3, 0xF8, 0xFF, 0x1F,
  0xF1, 0xFE, 0x3F, 0xCF, 0xFC, 0x7F, 0x8F, 0xF3, 0xFF, 0x1F, 0xC3, 0xFC,
  0xFF, 0xCF, 0xF0, 0xFF, 0x7F, 0xF3, 0xFC, 0x3F, 0xDF, 0xFC, 0xFF, 0x0F,
  0xF7, 0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xF7, 0xF8,
  0x3F, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFB, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF,
  0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFC,
  0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF,
  0xE3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xFC, 0x01, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0x80, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF1, 0xFE,
  0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0,
  0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFF,
  0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF,
  0x03, 0xF7, 0xC0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xE3,
  0xE0, 0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7F, 0x1F, 0xE7, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xBF, 0xCF,
  0xF1, 0xFE, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0xC7, 0xF9, 0xFE, 0x3F,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xDF, 0xE0, 0x7C, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFD, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F,
  0x3F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xFC, 0x1F, 0xCF, 0xF0, 0xFF, 0x3F,
  0x83, 0xFC, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFE, 0x7F, 0x83,
  0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xEF, 0xFC, 0x3F, 0x9F, 0xE0, 0xFE, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x3F, 0xCF, 0xF7, 0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xF3,
  0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x03, 0xF1, 0xFC, 0x07, 0xFB, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xC7, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0x1F, 0xEF, 0xF0, 0x7F, 0x7F, 0x83, 0xFB, 0xF8, 0x3F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x41, 0xFF, 0x9F, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x81, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0xFF, 0x9F,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0,
  0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0x00, 0xFF,
  0x00, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x9F, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3,
  0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F,
  0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0,
  0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xF0, 0x7F, 0x00, 0x00, 0xE0,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xF0, 0xFE,
  0x1F, 0xF0, 0x7F, 0x1F, 0xF0, 0x7F, 0x9F, 0xF8, 0x3F, 0xCF, 0xF8, 0x1F,
  0xEF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xF7, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFD, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x3F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xFF, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE3,
  0xE0, 0x7C, 0x07, 0xF7, 0xF8, 0xFF, 0x83, 0xFF, 0xFE, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0x8F, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC3, 0xFC, 0x3F, 0x9F,
  0xE1, 0xFE, 0x3F, 0xCF, 0xF0, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x0F, 0xF3,
  0xFC, 0x7F, 0x87, 0xF9, 0xFC, 0x3F, 0xC3, 0xFC, 0xFE, 0x1F, 0xE1, 0xFC,
  0xFF, 0x0F, 0xF1, 0xFE, 0x7F, 0x87, 0xF0, 0xFF, 0x3F, 0xC3, 0xF8, 0x7F,
  0x9F, 0xE3, 0xFC, 0x3F, 0xCF, 0xE1, 0xFE, 0x1F, 0xE7, 0xF0, 0xFF, 0x0F,
  0xE7, 0xF8, 0x7F, 0x8F, 0xF3, 0xFC, 0x3F, 0x87, 0xF9, 0xFE, 0x1F, 0xC3,
  0xFC, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF3,
  0xF0, 0x0F, 0xEF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x87, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0x87, 0xF8, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF1, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x83,
  0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x7F,
  0xBF, 0x83, 0xFD, 0xFE, 0x3F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF9,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xDF,
  0xE0, 0x3F, 0x8F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0xFC, 0x1F, 0xE7, 0xF0, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x07, 0xFB, 0xFC,
  0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xFC, 0x3F,
  0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0x8F,
  0xE0, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3E, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x0F, 0xE7, 0xC3, 0xFB, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xF7, 0xFC, 0xFF, 0x1F, 0xE7, 0xF0, 0xFF, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE7, 0xF0, 0xFF, 0x3F,
  0x83, 0xF9, 0xFC, 0x3F, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8, 0xFF,
  0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xE0,
  0xFF, 0x1F, 0xC1, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87,
  0xF8, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xDF, 0xC3, 0xFC, 0xFE, 0x1F, 0xE7, 0xF0, 0xFF, 0x3F, 0x8F, 0xF1,
  0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x3F, 0xC3, 0xF9, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFE, 0xFF, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0x0F, 0xFF, 0xE1, 0xF0, 0xFF,
  0xFE, 0x3F, 0x0F, 0xEF, 0xE3, 0xF0, 0xFE, 0xFE, 0x7F, 0x9F, 0xEF, 0xE7,
  0xF9, 0xFC, 0xFE, 0x7F, 0x9F, 0xCF, 0xCF, 0xFB, 0xF8, 0xFC, 0xFF, 0xBF,
  0x8F, 0xDF, 0xFB, 0xF8, 0xFD, 0xFF, 0xBF, 0x0F, 0xDF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFE, 0xFF,
  0xE0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x3F,
  0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0xFF, 0x1F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0x8F, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0xC1, 0xFC, 0x3F, 0xC0, 0xFE,
  0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xCF, 0xF8, 0x0F,
  0xE7, 0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0x80, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x80, 0x00, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x81, 0xF3, 0xFF, 0x0F, 0xDF, 0xFE, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF,
  0xEF, 0xCF, 0xFF, 0xBF, 0x1F, 0xFC, 0xF8, 0x3F, 0xF3, 0xE0, 0x7F, 0x80,
  0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 14, 35, 13, 0, -35 },
  { 63, 16, 14, 15, 2, -37 },
  { 91, 25, 35, 24, 0, -35 },
  { 201, 23, 45, 24, 1, -40 },
  { 331, 23, 35, 31, 4, -35 },
  { 432, 26, 36, 28, 0, -35 },
  { 549, 8, 14, 7, 2, -37 },
  { 563, 15, 49, 15, 2, -38 },
  { 655, 16, 49, 15, -2, -38 },
  { 753, 22, 21, 22, 2, -35 },
  { 811, 21, 25, 22, 1, -29 },
  { 877, 11, 15, 13, -3, -6 },
  { 898, 14, 6, 20, 3, -18 },
  { 909, 9, 8, 14, 1, -8 },
  { 918, 22, 38, 15, -4, -35 },
  { 1023, 22, 35, 24, 2, -35 },
  { 1120, 16, 35, 24, 5, -35 },
  { 1190, 24, 35, 24, 0, -35 },
  { 1295, 24, 35, 24, 0, -35 },
  { 1400, 23, 35, 24, 1, -35 },
  { 1501, 23, 35, 24, 1, -35 },
  { 1602, 21, 35, 24, 2, -35 },
  { 1694, 24, 35, 24, 2, -35 },
  { 1799, 23, 35, 24, 1, -35 },
  { 1900, 21, 35, 24, 3, -35 },
  { 1992, 12, 27, 14, 1, -27 },
  { 2033, 15, 36, 14, -2, -27 },
  { 2101, 20, 24, 21, 1, -27 },
  { 2161, 21, 16, 25, 2, -23 },
  { 2203, 20, 23, 21, 1, -26 },
  { 2261, 19, 35, 22, 3, -35 },
  { 2345, 35, 45, 36, 0, -34 },
  { 2542, 28, 35, 29, -2, -35 },
  { 2665, 27, 35, 27, 0, -35 },
  { 2784, 26, 35, 27, 2, -35 },
  { 2898, 26, 35, 27, 0, -35 },
  { 3012, 26, 35, 23, 0, -35 },
  { 3126, 25, 35, 23, 0, -35 },
  { 3236, 26, 35, 28, 2, -35 },
  { 3350, 30, 35, 29, 0, -35 },
  { 3482, 14, 35, 13, 0, -35 },
  { 3544, 25, 35, 23, 0, -35 },
  { 3654, 31, 35, 27, 0, -35 },
  { 3790, 20, 35, 23, 0, -35 },
  { 3878, 37, 35, 36, 0, -35 },
  { 4040, 30, 35, 29, 0, -35 },
  { 4172, 26, 35, 29, 2, -35 },
  { 4286, 27, 35, 27, 0, -35 },
  { 4405, 26, 41, 29, 2, -35 },
  { 4539, 27, 35, 27, 0, -35 },
  { 4658, 25, 35, 26, 1, -35 },
  { 4768, 26, 35, 26, 3, -35 },
  { 4882, 28, 35, 27, 1, -35 },
  { 5005, 27, 35, 28, 4, -35 },
  { 5124, 34, 35, 35, 4, -35 },
  { 5273, 32, 35, 27, -2, -35 },
  { 5413, 26, 35, 26, 4, -35 },
  { 5527, 29, 35, 25, -1, -35 },
  { 5654, 17, 49, 13, -1, -41 },
  { 5759, 13, 38, 18, 3, -35 },
  { 5821, 18, 49, 13, -3, -41 },
  { 5932, 18, 17, 19, 1, -35 },
  { 5971, 19, 6, 19, -3, 0 },
  { 5986, 11, 7, 16, 5, -36 },
  { 5996, 21, 26, 22, 0, -26 },
  { 6065, 22, 37, 24, 0, -37 },
  { 6167, 20, 26, 22, 1, -26 },
  { 6232, 24, 37, 24, 1, -37 },
  { 6343, 21, 26, 23, 1, -26 },
  { 6412, 18, 38, 16, 1, -38 },
  { 6498, 25, 36, 24, -1, -26 },
  { 6611, 23, 37, 24, -1, -37 },
  { 6718, 13, 37, 12, 0, -37 },
  { 6779, 20, 47, 12, -6, -37 },
  { 6897, 25, 37, 23, 0, -37 },
  { 7013, 14, 37, 12, 0, -37 },
  { 7078, 33, 26, 35, 0, -26 },
  { 7186, 23, 26, 24, -1, -26 },
  { 7261, 21, 26, 23, 1, -26 },
  { 7330, 24, 36, 24, -2, -26 },
  { 7438, 22, 36, 23, 1, -26 },
  { 7537, 18, 26, 16, 0, -26 },
  { 7596, 21, 26, 22, 0, -26 },
  { 7665, 14, 32, 15, 2, -32 },
  { 7721, 23, 26, 24, 1, -26 },
  { 7796, 21, 26, 22, 2, -26 },
  { 7865, 28, 26, 30, 3, -26 },
  { 7956, 25, 26, 22, -2, -26 },
  { 8038, 25, 36, 22, -1, -26 },
  { 8151, 23, 26, 22, -1, -26 },
  { 8226, 15, 47, 14, 1, -38 },
  { 8315, 10, 41, 12, 1, -35 },
  { 8367, 15, 47, 14, -2, -38 },
  { 8456, 22, 11, 26, 2, -20 },
};

const GFXfont RobotoCondensed_BlackItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_BLACKITALIC49PT7B_H_
