#ifndef _ROBOTOCONDENSED_BLACKITALIC16PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0x07, 0x39, 0xC0, 0xDE, 0xB5, 0x60,
  0x0A, 0x1A, 0x1E, 0x16, 0x7F, 0x34, 0x2C, 0xFE, 0x68, 0x78, 0x58, 0x50,
  0x04, 0x04, 0x1E, 0x3E, 0x37, 0x37, 0x30, 0x38, 0x1C, 0x0E, 0xE6, 0x6E,
  0x7C, 0x38, 0x10, 0x10, 0x70, 0x5A, 0xDA, 0xDE, 0x7C, 0x08, 0x18, 0x36,
  0x2F, 0x6B, 0x4B, 0x0E, 0x1C, 0x3E, 0x36, 0x36, 0x3E, 0x3C, 0x7B, 0x7F,
  0xEF, 0xEE, 0xFE, 0x7F, 0xFF, 0x80, 0x11, 0xCC, 0xC6, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x08, 0x40, 0x10, 0x86, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x33, 0x19, 0x9C, 0x40, 0x18, 0x23, 0x5B, 0xE7, 0x1B, 0x12, 0x00, 0x1C,
  0x30, 0x63, 0xFF, 0xE7, 0x0C, 0x18, 0x36, 0x66, 0xC0, 0xFF, 0x5D, 0x80,
  0x06, 0x18, 0x30, 0x41, 0x83, 0x0C, 0x18, 0x20, 0xC1, 0x86, 0x0C, 0x00,
  0x38, 0xF9, 0xBF, 0x7E, 0xF9, 0xF3, 0x66, 0xCD, 0xBB, 0xE3, 0x80, 0x1B,
  0xFD, 0x63, 0x39, 0xCE, 0x63, 0x19, 0xC0, 0x1E, 0x3E, 0x77, 0x77, 0x06,
  0x0E, 0x1C, 0x18, 0x38, 0x70, 0xFE, 0xFE, 0x1C, 0x3E, 0x77, 0x07, 0x06,
  0x1E, 0x1C, 0x06, 0x06, 0xEE, 0xFC, 0x78, 0x07, 0x0E, 0x0E, 0x1E, 0x3E,
  0x3E, 0x6E, 0xFE, 0xFE, 0x0C, 0x1C, 0x1C, 0x3F, 0x3F, 0x30, 0x70, 0x7C,
  0x7E, 0x06, 0x06, 0x06, 0xEE, 0x7C, 0x38, 0x1C, 0xF7, 0x18, 0xFB, 0xFC,
  0xF3, 0xCF, 0x7F, 0x9C, 0xFF, 0xFC, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x70,
  0xC3, 0x86, 0x00, 0x1E, 0x3E, 0x37, 0x37, 0x36, 0x3E, 0x7C, 0x66, 0xE6,
  0xEE, 0x7C, 0x38, 0x38, 0xFB, 0xB7, 0x7E, 0xFD, 0xFF, 0x3E, 0x1C, 0x71,
  0xC7, 0x00, 0x37, 0x30, 0x00, 0x4E, 0x60, 0x11, 0xC6, 0x00, 0x00, 0x06,
  0x33, 0x18, 0x80, 0x02, 0x1C, 0xF3, 0x8F, 0x0F, 0x87, 0x02, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x40, 0xE1, 0xF0, 0xF1, 0xCF, 0x38, 0x40, 0x7B, 0xFE,
  0xC3, 0x1C, 0xE7, 0x18, 0x01, 0x0E, 0x18, 0x07, 0x83, 0x98, 0xC1, 0x9B,
  0x96, 0xFA, 0xD3, 0x56, 0x4E, 0xD9, 0xDB, 0x7B, 0xEB, 0x36, 0x60, 0x04,
  0x00, 0xFC, 0x0F, 0x80, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF8, 0xFC, 0x6E,
  0x73, 0x3F, 0xBF, 0xDC, 0x7C, 0x30, 0x3E, 0x1F, 0x9C, 0xEE, 0x77, 0x33,
  0xF9, 0xF8, 0xCE, 0x67, 0x73, 0xBF, 0x9F, 0x80, 0x1E, 0x1F, 0x8C, 0xEE,
  0x77, 0x03, 0x01, 0x80, 0xC0, 0x63, 0x33, 0x9F, 0x87, 0x80, 0x3E, 0x1F,
  0x9C, 0xCE, 0x67, 0x33, 0x99, 0x8C, 0xCE, 0x67, 0x73, 0x3F, 0x9F, 0x00,
  0x3F, 0x3F, 0x70, 0x70, 0x70, 0x7E, 0x7E, 0x60, 0x60, 0xE0, 0xFE, 0xFE,
  0x3F, 0x3F, 0x70, 0x70, 0x70, 0x7E, 0x7E, 0x60, 0x60, 0xE0, 0xE0, 0xE0,
  0x1E, 0x7F, 0x67, 0xE3, 0xE0, 0xE0, 0xCF, 0xCF, 0xC6, 0xCE, 0xFE, 0x7C,
  0x31, 0xCC, 0x77, 0x19, 0xC6, 0x71, 0x9F, 0xE7, 0xF9, 0x8E, 0x63, 0x38,
  0xCE, 0x33, 0x9C, 0x39, 0x8C, 0xE7, 0x39, 0xCC, 0x67, 0x39, 0xC0, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0xEE, 0xEC, 0x7C, 0x78, 0x33,
  0xCC, 0xE7, 0x71, 0xD8, 0x7E, 0x1F, 0x07, 0xC1, 0xF8, 0x6E, 0x3B, 0x8E,
  0x73, 0x9C, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0xFF,
  0xE0, 0x38, 0x73, 0x8F, 0x78, 0xF7, 0x9F, 0x79, 0xE6, 0xDE, 0x6F, 0x66,
  0xFE, 0x6E, 0xEE, 0xEE, 0xEE, 0xCE, 0xCC, 0x39, 0xCE, 0x77, 0x99, 0xE6,
  0x79, 0x9F, 0xE6, 0xF9, 0xBE, 0x67, 0x39, 0xCE, 0x73, 0x9C, 0x1C, 0x7E,
  0x67, 0xE3, 0xE3, 0xC7, 0xC7, 0xC7, 0xC6, 0xCE, 0xFC, 0x78, 0x3E, 0x1F,
  0x9C, 0xEE, 0x77, 0x3B, 0x99, 0xFC, 0xFC, 0x60, 0x70, 0x38, 0x1C, 0x00,
  0x1E, 0x7E, 0x67, 0xE3, 0xE3, 0xE7, 0xC7, 0xC7, 0xC6, 0xCE, 0xFC, 0x7C,
  0x0E, 0x04, 0x3E, 0x1F, 0x9C, 0xEE, 0x77, 0x3B, 0xB9, 0xFC, 0xFC, 0x6E,
  0x77, 0x39, 0x9C, 0xE0, 0x1E, 0x1F, 0x8C, 0xCE, 0x73, 0x81, 0xE0, 0x78,
  0x0E, 0xE7, 0x73, 0x9F, 0x87, 0x80, 0xFF, 0xFF, 0x18, 0x18, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x31, 0x98, 0xDC, 0xEE, 0x77, 0x3B,
  0x99, 0x8C, 0xC6, 0x67, 0x33, 0x9F, 0x87, 0x80, 0xE3, 0xF1, 0xF9, 0xCC,
  0xE6, 0x63, 0x71, 0xB0, 0xD8, 0x7C, 0x3C, 0x1E, 0x0E, 0x00, 0xE6, 0x7D,
  0xDF, 0xBB, 0xF7, 0x6F, 0xFD, 0xFF, 0xBF, 0xE7, 0xFC, 0xF7, 0x9E, 0xE3,
  0xDC, 0x73, 0x80, 0x39, 0xC3, 0x38, 0x7E, 0x0F, 0xC1, 0xF0, 0x1E, 0x07,
  0x80, 0xF8, 0x3F, 0x07, 0x61, 0xCC, 0x39, 0xC0, 0xE3, 0x33, 0x99, 0x8D,
  0xC6, 0xC3, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x00, 0x3F, 0xBF,
  0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x3F, 0x9F, 0xC0,
  0x39, 0xCC, 0x67, 0x39, 0xCC, 0x63, 0x39, 0xCE, 0x73, 0x9C, 0xEE, 0xE6,
  0x66, 0x77, 0x77, 0x33, 0x30, 0x1C, 0xF1, 0x86, 0x18, 0xE3, 0x8E, 0x30,
  0xC3, 0x1C, 0x71, 0xCE, 0x38, 0x18, 0x63, 0xCB, 0x6D, 0xB0, 0xFF, 0xF0,
  0xCC, 0x3C, 0xFD, 0xB8, 0x77, 0xFD, 0xBB, 0x7E, 0x6C, 0x30, 0x60, 0xC3,
  0xE7, 0xEC, 0xD9, 0xB3, 0xE7, 0xDF, 0xF6, 0xE0, 0x3C, 0xFD, 0x9F, 0x0E,
  0x1C, 0x3B, 0x3E, 0x78, 0x03, 0x03, 0x07, 0x3F, 0x7F, 0x66, 0xE6, 0xEE,
  0xEE, 0xEE, 0xFC, 0x7C, 0x3C, 0xFD, 0x9B, 0xFF, 0xFC, 0x39, 0x3E, 0x3C,
  0x1C, 0xF3, 0x9E, 0x79, 0xC7, 0x1C, 0x61, 0x86, 0x38, 0x3F, 0x7F, 0x66,
  0xE6, 0xE6, 0xEE, 0xEE, 0x7E, 0x7C, 0x0C, 0xFC, 0xF8, 0x30, 0x61, 0xC3,
  0xE7, 0xEC, 0xD9, 0xB7, 0xEF, 0xDF, 0xB6, 0x60, 0x13, 0x30, 0x77, 0x76,
  0x66, 0xEE, 0xE0, 0x04, 0x30, 0xC0, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8E,
  0x38, 0xCF, 0x38, 0x30, 0x30, 0x30, 0x77, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC,
  0xEC, 0xEC, 0xCE, 0x31, 0x8C, 0xE7, 0x39, 0x8C, 0x67, 0x39, 0xC0, 0x7F,
  0xCF, 0xFD, 0x9B, 0xB3, 0x76, 0xEF, 0xDD, 0xBB, 0xB7, 0x66, 0xCC, 0xC0,
  0x7E, 0xFD, 0x9B, 0x36, 0xFD, 0xFB, 0xF6, 0xCC, 0x3C, 0xFD, 0x9F, 0x3E,
  0x7C, 0xFB, 0xBE, 0x38, 0x3E, 0x3F, 0x33, 0x33, 0x33, 0x73, 0x77, 0x7E,
  0x6E, 0x60, 0x60, 0xE0, 0x3F, 0x7E, 0x66, 0xE6, 0xEE, 0xEE, 0xEE, 0xFC,
  0x7C, 0x0C, 0x1C, 0x1C, 0x7D, 0xF7, 0x18, 0x63, 0x8E, 0x38, 0xC0, 0x3C,
  0xFD, 0xBB, 0x87, 0x83, 0xB3, 0x7E, 0x78, 0x66, 0xFF, 0xEE, 0xCC, 0xCE,
  0xE0, 0x77, 0x76, 0x66, 0x66, 0x6E, 0xEE, 0xEE, 0xFE, 0x7C, 0xCD, 0xBB,
  0x76, 0xCD, 0x9F, 0x3C, 0x78, 0x60, 0xD9, 0xED, 0xF6, 0xDF, 0x6F, 0xF7,
  0x73, 0xB9, 0xDC, 0xCC, 0x00, 0x33, 0x1F, 0x87, 0x83, 0xC1, 0xC1, 0xE0,
  0xF8, 0xEC, 0x66, 0x00, 0x67, 0x6E, 0x6E, 0x6C, 0x7C, 0x78, 0x78, 0x70,
  0x30, 0x70, 0xE0, 0xC0, 0x7E, 0xFC, 0x30, 0xC3, 0x8E, 0x18, 0x7E, 0xFC,
  0x08, 0xCC, 0x63, 0x19, 0xDC, 0xC3, 0x18, 0xC6, 0x31, 0x84, 0x33, 0x22,
  0x22, 0x66, 0x44, 0x44, 0xCC, 0x10, 0xC6, 0x31, 0x8C, 0x63, 0x31, 0x8C,
  0xE6, 0x31, 0x00, 0x33, 0x7B, 0x6E, 0x4E,
};

const GFXglyph RobotoCondensed_BlackItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 4, 5, 1, -12 },
  { 12, 8, 12, 8, 0, -12 },
  { 24, 8, 16, 8, 0, -14 },
  { 40, 8, 12, 10, 1, -12 },
  { 52, 8, 12, 9, 0, -12 },
  { 64, 2, 5, 2, 1, -12 },
  { 66, 5, 17, 5, 1, -13 },
  { 77, 5, 17, 5, -1, -13 },
  { 88, 7, 7, 7, 1, -12 },
  { 95, 7, 8, 7, 0, -9 },
  { 102, 4, 5, 4, -1, -2 },
  { 105, 4, 2, 7, 1, -6 },
  { 106, 3, 3, 5, 0, -3 },
  { 108, 7, 13, 5, -1, -12 },
  { 120, 7, 12, 8, 1, -12 },
  { 131, 5, 12, 8, 2, -12 },
  { 139, 8, 12, 8, 0, -12 },
  { 151, 8, 12, 8, 0, -12 },
  { 163, 8, 12, 8, 0, -12 },
  { 175, 8, 12, 8, 0, -12 },
  { 187, 6, 12, 8, 1, -12 },
  { 196, 7, 12, 8, 1, -12 },
  { 207, 8, 12, 8, 0, -12 },
  { 219, 7, 12, 8, 1, -12 },
  { 230, 4, 9, 5, 0, -9 },
  { 235, 5, 12, 4, -1, -9 },
  { 243, 7, 8, 7, 0, -9 },
  { 250, 6, 6, 8, 1, -8 },
  { 255, 7, 8, 7, 0, -9 },
  { 262, 6, 12, 7, 1, -12 },
  { 271, 11, 15, 12, 0, -11 },
  { 292, 9, 12, 9, -1, -12 },
  { 306, 9, 12, 9, 0, -12 },
  { 320, 9, 12, 9, 0, -12 },
  { 334, 9, 12, 9, 0, -12 },
  { 348, 8, 12, 8, 0, -12 },
  { 360, 8, 12, 7, 0, -12 },
  { 372, 8, 12, 9, 1, -12 },
  { 384, 10, 12, 9, 0, -12 },
  { 399, 5, 12, 4, 0, -12 },
  { 407, 8, 12, 8, 0, -12 },
  { 419, 10, 12, 9, 0, -12 },
  { 434, 7, 12, 7, 0, -12 },
  { 445, 12, 12, 12, 0, -12 },
  { 463, 10, 12, 9, 0, -12 },
  { 478, 8, 12, 9, 1, -12 },
  { 490, 9, 12, 9, 0, -12 },
  { 504, 8, 14, 9, 1, -12 },
  { 518, 9, 12, 9, 0, -12 },
  { 532, 9, 12, 9, 0, -12 },
  { 546, 8, 12, 9, 1, -12 },
  { 558, 9, 12, 9, 0, -12 },
  { 572, 9, 12, 9, 1, -12 },
  { 586, 11, 12, 12, 1, -12 },
  { 603, 11, 12, 9, -1, -12 },
  { 620, 9, 12, 9, 1, -12 },
  { 634, 9, 12, 8, 0, -12 },
  { 648, 5, 16, 4, 0, -13 },
  { 658, 4, 13, 6, 1, -12 },
  { 665, 6, 16, 4, -1, -13 },
  { 677, 6, 6, 6, 0, -12 },
  { 682, 6, 2, 6, -1, 0 },
  { 684, 3, 2, 5, 2, -12 },
  { 685, 7, 9, 7, 0, -9 },
  { 693, 7, 12, 8, 0, -12 },
  { 704, 7, 9, 7, 0, -9 },
  { 712, 8, 12, 8, 0, -12 },
  { 724, 7, 9, 8, 0, -9 },
  { 732, 6, 12, 5, 0, -12 },
  { 741, 8, 12, 8, 0, -9 },
  { 753, 7, 12, 8, 0, -12 },
  { 764, 4, 13, 4, 0, -13 },
  { 771, 6, 16, 4, -2, -13 },
  { 783, 8, 12, 8, 0, -12 },
  { 795, 5, 12, 4, 0, -12 },
  { 803, 11, 9, 11, 0, -9 },
  { 816, 7, 9, 8, 0, -9 },
  { 824, 7, 9, 8, 0, -9 },
  { 832, 8, 12, 8, -1, -9 },
  { 844, 8, 12, 8, 0, -9 },
  { 856, 6, 9, 5, 0, -9 },
  { 863, 7, 9, 7, 0, -9 },
  { 871, 4, 11, 5, 1, -11 },
  { 877, 8, 9, 8, 0, -9 },
  { 886, 7, 9, 7, 1, -9 },
  { 894, 9, 9, 10, 1, -9 },
  { 905, 9, 9, 7, -1, -9 },
  { 916, 8, 12, 7, 0, -9 },
  { 928, 7, 9, 7, 0, -9 },
  { 936, 5, 16, 5, 0, -13 },
  { 946, 4, 14, 4, 0, -12 },
  { 953, 5, 15, 5, -1, -12 },
  { 963, 8, 4, 8, 0, -7 },
};

const GFXfont RobotoCondensed_BlackItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_BLACKITALIC16PT7B_H_
