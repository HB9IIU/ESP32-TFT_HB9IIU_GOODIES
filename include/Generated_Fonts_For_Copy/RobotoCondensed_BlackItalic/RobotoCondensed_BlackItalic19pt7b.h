#ifndef _ROBOTOCONDENSED_BLACKITALIC19PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0xE3, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0xC0, 0x18, 0xE1, 0x80,
  0x6F, 0x3D, 0xB6, 0xD8, 0x0D, 0x83, 0x60, 0xD0, 0x2C, 0x3F, 0xDF, 0xE1,
  0x60, 0xD8, 0xFF, 0x3F, 0xC2, 0xC1, 0xB0, 0x68, 0x16, 0x00, 0x02, 0x01,
  0x03, 0xC3, 0xF3, 0xB9, 0xDC, 0xE0, 0x70, 0x1E, 0x07, 0x81, 0xCC, 0xE6,
  0x73, 0xB9, 0xF8, 0x78, 0x18, 0x08, 0x00, 0x70, 0x7C, 0x36, 0xDB, 0x4F,
  0x63, 0xE0, 0x20, 0x30, 0x37, 0x17, 0x9B, 0x7B, 0x30, 0xF0, 0x70, 0x0E,
  0x07, 0xC3, 0xB0, 0xEE, 0x3B, 0x0F, 0xC1, 0xC0, 0xF7, 0x7F, 0xFB, 0xEE,
  0x7B, 0xDC, 0x7F, 0x8F, 0xE0, 0x6F, 0x6C, 0x08, 0x73, 0x8C, 0x71, 0x86,
  0x38, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0x82, 0x00, 0x10, 0x61,
  0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xC7, 0x18, 0x63, 0x8C, 0x73, 0x8C,
  0x00, 0x0C, 0x08, 0xC9, 0xFF, 0x1C, 0x3C, 0x6C, 0x44, 0x0E, 0x0C, 0x1C,
  0x1C, 0x7F, 0x7F, 0xFF, 0x18, 0x18, 0x38, 0x38, 0x33, 0x76, 0xEC, 0x7F,
  0xC0, 0x6F, 0x60, 0x03, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0x70, 0x60, 0x60, 0xC0, 0xC0, 0x1E, 0x3E, 0x77, 0x67, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE6, 0xEE, 0xEE, 0xFC, 0x78, 0x0C, 0xFF, 0xFF, 0x38,
  0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xC0, 0x0F, 0x0F, 0xCE, 0xEE, 0x77,
  0x38, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0xF7, 0xF8, 0x1E,
  0x1F, 0xCE, 0xEE, 0x70, 0x38, 0x3C, 0x7C, 0x3E, 0x07, 0x01, 0xB9, 0xDF,
  0xE7, 0xE1, 0xE0, 0x03, 0x83, 0xC1, 0xE1, 0xF1, 0xF0, 0xF8, 0xDC, 0xEE,
  0x67, 0x7F, 0xFF, 0xC1, 0xC0, 0xE0, 0x70, 0x1F, 0x9F, 0xCE, 0x07, 0x03,
  0x03, 0xF1, 0xFC, 0x6E, 0x03, 0x03, 0xB9, 0xCE, 0xE7, 0xE1, 0xE0, 0x0E,
  0x1E, 0x3C, 0x70, 0x70, 0xEE, 0xFE, 0xEF, 0xE7, 0xE7, 0xE7, 0xEE, 0xFC,
  0x78, 0x7F, 0xBF, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C,
  0x1E, 0x0E, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0xCE, 0xE7, 0x73, 0xB9, 0xDC,
  0x7C, 0x7E, 0x77, 0x3B, 0xB9, 0xCE, 0xE7, 0xE1, 0xE0, 0x1C, 0x3E, 0x77,
  0xE7, 0xE7, 0xE7, 0xE7, 0x7F, 0x7E, 0x0E, 0x0E, 0x7C, 0x78, 0x60, 0x39,
  0xCE, 0x00, 0x00, 0x0C, 0xF3, 0x00, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x00,
  0x30, 0xC3, 0x1C, 0x61, 0x00, 0x01, 0x07, 0x3F, 0x7C, 0xF0, 0xF8, 0x3E,
  0x0E, 0x02, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x20, 0x38, 0x7C, 0x1F,
  0x07, 0x3F, 0x7C, 0xF0, 0x80, 0x3C, 0x7E, 0xFE, 0xE7, 0x0E, 0x0E, 0x1C,
  0x38, 0x38, 0x30, 0x00, 0x70, 0x70, 0x60, 0x03, 0xE0, 0x3F, 0xC1, 0xC1,
  0x8E, 0x06, 0x33, 0xC9, 0x9F, 0xA6, 0x6C, 0xDB, 0x32, 0xCC, 0xDB, 0x36,
  0x6C, 0xD9, 0xB3, 0xFC, 0xCE, 0xE1, 0x80, 0x06, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x03, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x87, 0x70, 0xEE,
  0x1F, 0xC7, 0xFC, 0xFF, 0xB8, 0x77, 0x0F, 0xE1, 0xC0, 0x3F, 0x0F, 0xF3,
  0xFC, 0xE7, 0x39, 0xDC, 0xF7, 0xF9, 0xFE, 0x73, 0x9C, 0xE7, 0x3B, 0x9E,
  0xFF, 0x3F, 0x80, 0x1F, 0x0F, 0xE7, 0xF9, 0xC7, 0xE1, 0xF8, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0xEE, 0x7B, 0xFC, 0x7E, 0x0F, 0x00, 0x3F, 0x0F, 0xE3,
  0xFC, 0xE7, 0x39, 0xDC, 0x77, 0x1D, 0xC7, 0x73, 0xDC, 0xE7, 0x3B, 0xBC,
  0xFF, 0x3F, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xE0, 0x38, 0x1C, 0x07, 0xF1,
  0xFC, 0x70, 0x1C, 0x07, 0x03, 0xFC, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xE3,
  0xF8, 0xE0, 0x38, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x38, 0x00, 0x1F, 0x0F, 0xE7, 0xB9, 0xC7, 0xF1, 0xF8, 0x0E, 0x03,
  0x9E, 0xEF, 0xB8, 0xEE, 0x3B, 0xFE, 0x7F, 0x0F, 0x80, 0x38, 0x73, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE7, 0xFE, 0x7F, 0xE7, 0xFC, 0x71, 0xC7, 0x1C,
  0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x38, 0x38, 0xE3, 0x8E, 0x39, 0xE7, 0x1C,
  0x71, 0xC7, 0x3C, 0xE3, 0x80, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xCE, 0x73, 0xF8, 0x7E, 0x0F, 0x00, 0x38,
  0xF3, 0x9E, 0x3B, 0xC3, 0xB8, 0x3F, 0x87, 0x70, 0x7E, 0x07, 0xF0, 0x7F,
  0x07, 0x70, 0x77, 0x0E, 0x78, 0xE3, 0x8E, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC7, 0xCF, 0x1F, 0x3C, 0x7D, 0xFB, 0xF7, 0xEF, 0x9F, 0xBE,
  0x77, 0xB9, 0xDE, 0xE7, 0x7B, 0xB9, 0xDE, 0xE7, 0x73, 0x99, 0xC0, 0x38,
  0x73, 0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0xE7, 0x4E, 0x76, 0xE7, 0x7C, 0x77,
  0xC7, 0x7C, 0x73, 0xCE, 0x3C, 0xE3, 0xCE, 0x38, 0x1F, 0x0F, 0xE7, 0xF9,
  0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xB8, 0xEE, 0x3B, 0xFC, 0x7F,
  0x0F, 0x00, 0x3F, 0x87, 0xF8, 0xFF, 0x1C, 0xE3, 0x9C, 0xE3, 0x9F, 0xF3,
  0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x1F, 0x0F,
  0xE7, 0xF9, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xB8, 0xEE, 0x3B,
  0xFC, 0x7F, 0x0F, 0x80, 0x70, 0x08, 0x3F, 0x8F, 0xF3, 0xFC, 0xE7, 0x39,
  0xDC, 0x77, 0x3D, 0xFE, 0x7F, 0x1D, 0xC7, 0x73, 0x9E, 0xE7, 0xB8, 0xE0,
  0x0F, 0x07, 0xF3, 0xFC, 0xE7, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xB8,
  0xEF, 0x39, 0xDE, 0x7F, 0x07, 0x80, 0x7F, 0xDF, 0xFF, 0xFC, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00,
  0x71, 0xDC, 0x77, 0x1D, 0xCF, 0xF3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB9,
  0xEE, 0x73, 0xFC, 0xFE, 0x1F, 0x00, 0xF1, 0xEE, 0x39, 0xC7, 0x39, 0xE7,
  0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x76, 0x0F, 0xC1, 0xF8, 0x1E, 0x03, 0xC0,
  0x70, 0x00, 0xE6, 0x7F, 0x73, 0xBB, 0x9D, 0xDC, 0xEF, 0xEE, 0x6F, 0x73,
  0x7B, 0x9F, 0xF8, 0xFF, 0xC7, 0xBE, 0x3D, 0xE1, 0xEF, 0x0E, 0x78, 0x73,
  0x80, 0x1C, 0x71, 0xCF, 0x1C, 0xE1, 0xDC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xBC, 0x79, 0xCF, 0x1C, 0x71, 0xCE,
  0x79, 0xCE, 0x39, 0xC7, 0x70, 0x6E, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x3F, 0xE7, 0xF9, 0xFF, 0x01, 0xC0,
  0x78, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xCF, 0xF9,
  0xFE, 0x00, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x73,
  0x8E, 0x38, 0xE3, 0x8E, 0x00, 0xE3, 0x9C, 0xE7, 0x39, 0xCE, 0x71, 0xCE,
  0x73, 0x9C, 0xE0, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x71, 0xE3, 0xC0, 0x18, 0xE3, 0xDB, 0x6F,
  0x3C, 0xC0, 0xFF, 0xFC, 0xE7, 0x30, 0x1E, 0x3F, 0x77, 0x07, 0x3F, 0x7F,
  0xE7, 0xEE, 0xFE, 0x7E, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF3, 0xF9, 0xDE,
  0xE7, 0x73, 0xB9, 0xB9, 0xDE, 0xEF, 0xF7, 0xF0, 0x1E, 0x3F, 0x77, 0x77,
  0xE0, 0xE0, 0xE7, 0xEE, 0x7E, 0x3C, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x3B,
  0x9F, 0xE7, 0x79, 0xCE, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x7F, 0x1D, 0x80,
  0x1E, 0x1F, 0x9D, 0xCE, 0x67, 0xF7, 0xFB, 0x80, 0xEC, 0x7E, 0x1F, 0x00,
  0x0E, 0x3C, 0xF1, 0xC7, 0xCF, 0x8E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x1C,
  0x00, 0x3F, 0xBF, 0xDC, 0xEE, 0x7E, 0x3F, 0x3B, 0x9D, 0xEE, 0x7F, 0x3F,
  0x81, 0xC9, 0xCF, 0xE3, 0xC0, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x73, 0xF9,
  0xDC, 0xE6, 0x77, 0x3B, 0xB9, 0xDC, 0xEE, 0x77, 0x38, 0x39, 0xCE, 0x03,
  0xB9, 0xCE, 0x73, 0x9D, 0xCE, 0x70, 0x0E, 0x1C, 0x38, 0x00, 0xE1, 0x87,
  0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x3C, 0xF1, 0xC0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x33, 0x9D, 0xE7, 0xF1, 0xF8, 0x7C, 0x1F, 0x8F, 0xE3,
  0xB8, 0xE7, 0x39, 0xC0, 0x39, 0xCE, 0x73, 0xB9, 0xCE, 0x73, 0x9D, 0xCE,
  0x70, 0x37, 0x73, 0xFF, 0xDD, 0xEE, 0xEE, 0x77, 0x73, 0xBB, 0x9F, 0x9D,
  0xDC, 0xEE, 0xE7, 0x77, 0x73, 0x80, 0x77, 0x3F, 0x9D, 0xEE, 0x77, 0x73,
  0xBB, 0x9D, 0xCE, 0xE7, 0x73, 0x80, 0x1E, 0x1F, 0x9D, 0xCE, 0x7E, 0x3F,
  0x3B, 0x9D, 0xEE, 0x7E, 0x1E, 0x00, 0x1F, 0x8F, 0xE3, 0xBC, 0xE7, 0x39,
  0xCE, 0x67, 0x39, 0xEE, 0x7F, 0x9F, 0xC7, 0x01, 0xC0, 0xE0, 0x38, 0x00,
  0x3F, 0xBF, 0xDD, 0xEE, 0x6E, 0x77, 0x3B, 0x9D, 0xCE, 0x7F, 0x3F, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x76, 0xFD, 0xF3, 0x87, 0x0E, 0x38, 0x70, 0xE1,
  0xC0, 0x1E, 0x7F, 0x77, 0x70, 0x7C, 0x3E, 0x0E, 0xEE, 0xFE, 0x7C, 0x73,
  0x9D, 0xFF, 0xF3, 0x9C, 0xE7, 0x39, 0xE7, 0x00, 0x73, 0xB9, 0xDC, 0xEE,
  0x77, 0x73, 0xBB, 0x9D, 0xEE, 0x7F, 0x3B, 0x80, 0xE7, 0xEE, 0xEE, 0xEE,
  0xFC, 0xFC, 0x78, 0x78, 0x78, 0x70, 0xEE, 0xFD, 0xDF, 0xBF, 0x7F, 0xEF,
  0xF9, 0xEF, 0x3D, 0xE7, 0xB8, 0xE7, 0x1C, 0xE0, 0x39, 0xCE, 0xE1, 0xB8,
  0x7C, 0x1E, 0x07, 0x83, 0xF0, 0xFC, 0x77, 0x1D, 0xC0, 0x73, 0xBB, 0xDD,
  0xCE, 0xE7, 0xE3, 0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0E, 0x0F, 0x07,
  0x00, 0x7F, 0x7F, 0x0F, 0x0E, 0x1C, 0x38, 0x78, 0xF0, 0xFE, 0xFE, 0x04,
  0x71, 0x8E, 0x38, 0xE3, 0x9C, 0xE3, 0x87, 0x1C, 0x71, 0x86, 0x18, 0x70,
  0x80, 0x11, 0x33, 0x33, 0x22, 0x26, 0x66, 0x64, 0x44, 0xC0, 0x10, 0x61,
  0xC7, 0x1C, 0x61, 0x86, 0x0C, 0x73, 0x8E, 0x30, 0xC7, 0x1C, 0xE1, 0x00,
  0x73, 0xFB, 0xDF, 0xCE,
};

const GFXglyph RobotoCondensed_BlackItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 6, 5, 6, 1, -14 },
  { 16, 10, 14, 9, 0, -14 },
  { 34, 9, 18, 9, 0, -16 },
  { 55, 9, 14, 12, 2, -14 },
  { 71, 10, 14, 11, 0, -14 },
  { 89, 3, 5, 3, 1, -14 },
  { 91, 6, 19, 6, 1, -15 },
  { 106, 6, 19, 6, -1, -15 },
  { 121, 8, 8, 9, 1, -14 },
  { 129, 8, 11, 9, 0, -12 },
  { 140, 4, 6, 5, -1, -2 },
  { 143, 5, 2, 8, 1, -7 },
  { 145, 4, 3, 6, 0, -3 },
  { 147, 8, 15, 6, -1, -14 },
  { 162, 8, 14, 9, 1, -14 },
  { 176, 6, 14, 9, 2, -14 },
  { 187, 9, 14, 9, 0, -14 },
  { 203, 9, 14, 9, 0, -14 },
  { 219, 9, 14, 9, 0, -14 },
  { 235, 9, 14, 9, 0, -14 },
  { 251, 8, 14, 9, 1, -14 },
  { 265, 9, 14, 9, 1, -14 },
  { 281, 9, 14, 9, 0, -14 },
  { 297, 8, 14, 9, 1, -14 },
  { 311, 5, 10, 5, 0, -10 },
  { 318, 6, 14, 5, -1, -10 },
  { 329, 8, 9, 8, 0, -10 },
  { 338, 8, 6, 10, 1, -9 },
  { 344, 8, 9, 8, 0, -10 },
  { 353, 8, 14, 8, 1, -14 },
  { 367, 14, 17, 14, 0, -13 },
  { 397, 11, 14, 11, -1, -14 },
  { 417, 10, 14, 10, 0, -14 },
  { 435, 10, 14, 11, 1, -14 },
  { 453, 10, 14, 10, 0, -14 },
  { 471, 10, 14, 9, 0, -14 },
  { 489, 10, 14, 9, 0, -14 },
  { 507, 10, 14, 11, 1, -14 },
  { 525, 12, 14, 11, 0, -14 },
  { 546, 6, 14, 5, 0, -14 },
  { 557, 10, 14, 9, 0, -14 },
  { 575, 12, 14, 10, 0, -14 },
  { 596, 8, 14, 9, 0, -14 },
  { 610, 14, 14, 14, 0, -14 },
  { 635, 12, 14, 11, 0, -14 },
  { 656, 10, 14, 11, 1, -14 },
  { 674, 11, 14, 11, 0, -14 },
  { 694, 10, 16, 11, 1, -14 },
  { 714, 10, 14, 10, 0, -14 },
  { 732, 10, 14, 10, 0, -14 },
  { 750, 10, 14, 10, 1, -14 },
  { 768, 10, 14, 11, 1, -14 },
  { 786, 11, 14, 11, 1, -14 },
  { 806, 13, 14, 14, 2, -14 },
  { 829, 12, 14, 10, -1, -14 },
  { 850, 11, 14, 10, 1, -14 },
  { 870, 11, 14, 10, 0, -14 },
  { 890, 6, 19, 5, 0, -16 },
  { 905, 5, 15, 7, 1, -14 },
  { 915, 7, 19, 5, -1, -16 },
  { 932, 6, 7, 7, 1, -14 },
  { 938, 7, 2, 7, -1, 0 },
  { 940, 4, 3, 6, 2, -14 },
  { 942, 8, 10, 9, 0, -10 },
  { 952, 9, 14, 9, 0, -14 },
  { 968, 8, 10, 8, 0, -10 },
  { 978, 10, 14, 9, 0, -14 },
  { 996, 9, 10, 9, 0, -10 },
  { 1008, 7, 14, 6, 0, -14 },
  { 1021, 9, 14, 9, 0, -10 },
  { 1037, 9, 14, 9, 0, -14 },
  { 1053, 5, 14, 5, 0, -14 },
  { 1062, 7, 18, 5, -2, -14 },
  { 1078, 10, 14, 9, 0, -14 },
  { 1096, 5, 14, 5, 0, -14 },
  { 1105, 13, 10, 14, 0, -10 },
  { 1122, 9, 10, 9, 0, -10 },
  { 1134, 9, 10, 9, 0, -10 },
  { 1146, 10, 14, 9, -1, -10 },
  { 1164, 9, 14, 9, 0, -10 },
  { 1180, 7, 10, 6, 0, -10 },
  { 1189, 8, 10, 8, 0, -10 },
  { 1199, 5, 13, 6, 1, -13 },
  { 1208, 9, 10, 9, 0, -10 },
  { 1220, 8, 10, 8, 1, -10 },
  { 1230, 11, 10, 12, 1, -10 },
  { 1244, 10, 10, 8, -1, -10 },
  { 1257, 9, 14, 9, 0, -10 },
  { 1273, 8, 10, 8, 0, -10 },
  { 1283, 6, 18, 5, 0, -15 },
  { 1297, 4, 17, 5, 0, -14 },
  { 1306, 6, 18, 5, -1, -15 },
  { 1320, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_BlackItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_BLACKITALIC19PT7B_H_
