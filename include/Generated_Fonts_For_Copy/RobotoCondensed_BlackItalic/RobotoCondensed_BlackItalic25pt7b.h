#ifndef _ROBOTOCONDENSED_BLACKITALIC25PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC0,
  0x00, 0x1C, 0x78, 0xF0, 0xE0, 0x77, 0x77, 0x67, 0x66, 0xE6, 0xEE, 0xCE,
  0x03, 0x70, 0x1B, 0x01, 0xD8, 0x0D, 0xC0, 0x6E, 0x1F, 0xF8, 0xFF, 0xC1,
  0xB8, 0x1D, 0x80, 0xEC, 0x06, 0xE1, 0xFF, 0xCF, 0xFE, 0x1B, 0x80, 0xDC,
  0x0E, 0xC0, 0x66, 0x03, 0x70, 0x00, 0x01, 0x80, 0x20, 0x0C, 0x07, 0xC1,
  0xFC, 0x7F, 0xCF, 0x7B, 0xCF, 0x79, 0xEF, 0x00, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0xF7, 0x9E, 0xF3, 0xDE, 0x7B, 0xFE, 0x3F, 0x83, 0xE0, 0x30,
  0x06, 0x00, 0x3C, 0x07, 0xE0, 0xEE, 0x6E, 0xE6, 0xEE, 0xEE, 0xFC, 0x7D,
  0x87, 0xB0, 0x07, 0x00, 0xE0, 0x0D, 0xE1, 0xFF, 0x3F, 0x73, 0x77, 0x77,
  0x76, 0x77, 0x03, 0xE0, 0x1C, 0x07, 0x80, 0x7E, 0x07, 0xF8, 0x3D, 0xC1,
  0xCE, 0x0E, 0x70, 0x7F, 0x03, 0xF8, 0x1F, 0x01, 0xF9, 0xDF, 0xEE, 0xFF,
  0xFF, 0x3F, 0x79, 0xFB, 0xE7, 0x8F, 0xFC, 0x7F, 0xF1, 0xF7, 0x80, 0x77,
  0x77, 0x6E, 0xE0, 0x02, 0x07, 0x0E, 0x1E, 0x1C, 0x38, 0x38, 0x78, 0x70,
  0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60,
  0x70, 0x70, 0x30, 0x10, 0x08, 0x0C, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x3C, 0x38, 0x70, 0xF0, 0xE0, 0x80, 0x07, 0x00, 0xE0, 0x18, 0x33, 0x3F,
  0xFE, 0x7F, 0x87, 0x81, 0xF8, 0x73, 0x0E, 0x70, 0x84, 0x00, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0xF0, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xE1, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x39, 0xCE, 0xF7, 0x7B, 0x88, 0xFD,
  0xFB, 0xF0, 0x77, 0xDE, 0xE0, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x83, 0xF8,
  0xFF, 0x1E, 0xF7, 0x9E, 0xF3, 0xDE, 0x7B, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0x79, 0xEF, 0x3D, 0xE7, 0xBD, 0xE3, 0xFC, 0x7F, 0x07, 0xC0, 0x03, 0x1E,
  0x7E, 0xFE, 0xFE, 0x9E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x0F, 0xFE, 0xFF, 0xCF, 0xFC, 0x07, 0xC1, 0xFE, 0x1F, 0xF3,
  0xCF, 0x3C, 0xF0, 0x0F, 0x01, 0xF0, 0x7E, 0x0F, 0x80, 0xFC, 0x01, 0xE0,
  0x1E, 0x01, 0xEF, 0x1E, 0xFB, 0xE7, 0xFC, 0x7F, 0x81, 0xF0, 0x00, 0xF0,
  0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xE1, 0xDE, 0x3D, 0xE3,
  0x9C, 0x7B, 0xC7, 0xFE, 0x7F, 0xEF, 0xFE, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xC0, 0x3C, 0x03, 0xC0, 0x3B, 0x83,
  0xFC, 0x7F, 0xE1, 0x9E, 0x01, 0xE0, 0x1E, 0x01, 0xEF, 0x1E, 0x7B, 0xC7,
  0xFC, 0x3F, 0x81, 0xF0, 0x03, 0xC0, 0xF8, 0x7F, 0x1F, 0x83, 0xC0, 0xF0,
  0x1F, 0xE3, 0xFE, 0xFF, 0xDE, 0x7B, 0xC7, 0x78, 0xFF, 0x3D, 0xE7, 0xBC,
  0xF3, 0xFC, 0x7F, 0x07, 0xC0, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x0F, 0x83, 0xF8, 0xFF,
  0x9E, 0xF7, 0x9E, 0xF3, 0xCE, 0x79, 0xFE, 0x3F, 0x8F, 0xF3, 0xCF, 0x79,
  0xEF, 0x3D, 0xE7, 0xBD, 0xF7, 0xFC, 0x7F, 0x07, 0xC0, 0x1F, 0x0F, 0xE7,
  0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFE,
  0x07, 0x83, 0xC3, 0xE3, 0xF8, 0xF8, 0x38, 0x00, 0x1C, 0x7C, 0xF8, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0xC7, 0x8E, 0x00, 0x0E, 0x3C, 0x78,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE3, 0x87, 0x0E, 0x3C, 0x71,
  0xC1, 0x80, 0x00, 0x20, 0x38, 0x1F, 0x0F, 0xE7, 0xF0, 0xF8, 0x1E, 0x07,
  0xF0, 0x3F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x7F, 0xEF, 0xF9, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xBF, 0xF7, 0xFC, 0x20, 0x0E, 0x03, 0xE0, 0xFE, 0x0F,
  0xC0, 0xF0, 0x7C, 0xFF, 0x7F, 0x1F, 0x07, 0x02, 0x00, 0x1F, 0x0F, 0xE7,
  0xFD, 0xEF, 0x7B, 0xC0, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x81, 0xC0, 0xF0,
  0x00, 0x00, 0x03, 0x81, 0xE0, 0x78, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0x80, 0x78, 0x70, 0x38, 0x0E, 0x1C, 0x01, 0x86, 0x1C, 0x63, 0x9F, 0xDC,
  0xCF, 0x77, 0x73, 0x99, 0xDD, 0xCE, 0x76, 0x73, 0x9D, 0x9C, 0xE6, 0xE7,
  0x31, 0xB9, 0x9C, 0xEE, 0x77, 0x33, 0x9F, 0xF8, 0xE3, 0x9C, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x81, 0xDE, 0x0F, 0x78, 0x3C, 0xE1, 0xE3, 0x87, 0x8E, 0x3F, 0xFC, 0xFF,
  0xF7, 0xFF, 0xDE, 0x0F, 0xF8, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0xFC, 0x3F, 0xE1,
  0xFF, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x9F, 0x3F, 0xF8,
  0xFF, 0xE3, 0xFE, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x79, 0xF7, 0x87,
  0xBC, 0x3D, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x0F, 0x78, 0x7B, 0xEF, 0x8F, 0xFC, 0x7F, 0xC0, 0xF8, 0x00, 0x1F, 0xC0,
  0xFF, 0x07, 0xFC, 0x79, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C,
  0x7B, 0xC3, 0xDE, 0x1E, 0xF1, 0xF7, 0x8F, 0x3C, 0x7B, 0xEF, 0x9F, 0xFC,
  0xFF, 0xC7, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xFC, 0x3F, 0xE3, 0xFF, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0xFC, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x7D, 0xF7, 0x87,
  0xBC, 0x3D, 0xE0, 0x1F, 0x00, 0xF1, 0xFF, 0x9F, 0xFC, 0xFD, 0xE1, 0xEF,
  0x0F, 0x78, 0x7B, 0xE7, 0xCF, 0xFE, 0x7F, 0xE0, 0xFC, 0x00, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x1F,
  0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F,
  0x3E, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xE0, 0x1E, 0x3C, 0x78, 0xF3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0xF1, 0xE0,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xCF, 0x3C, 0x79, 0xE3, 0xCF,
  0x0F, 0xF0, 0x7F, 0x81, 0xF0, 0x00, 0x1E, 0x3E, 0x1E, 0x3E, 0x1E, 0x7C,
  0x3C, 0xF8, 0x3C, 0xF0, 0x3D, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7D, 0xE0, 0x79, 0xE0, 0xF9, 0xE0,
  0xF1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F,
  0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x8F, 0xE7, 0xF1, 0xDC, 0xFE,
  0x3B, 0xBB, 0xCF, 0x77, 0x71, 0xEE, 0xFE, 0x3D, 0xFB, 0xC7, 0xBF, 0x78,
  0xF7, 0xCF, 0x3E, 0xFB, 0xE7, 0x9E, 0x78, 0xF1, 0xCF, 0x1E, 0x39, 0xE0,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xF8, 0xF3, 0xF1, 0xE7, 0xE7, 0x8F,
  0xCF, 0x1F, 0xDE, 0x3F, 0xBC, 0xF3, 0x79, 0xE6, 0xF3, 0xCF, 0xC7, 0x9F,
  0x8F, 0x3F, 0x3E, 0x3E, 0x78, 0x7C, 0xF0, 0xF9, 0xE1, 0xE0, 0x07, 0xC0,
  0xFF, 0x8F, 0xFC, 0x7D, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xFF, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0x78, 0x7B, 0xE7, 0x8F, 0xFC,
  0x3F, 0xC0, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x8F, 0x1E, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0xF9, 0xFF, 0xE7, 0xFF, 0x1F,
  0xF0, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x7D, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0x78, 0x7B, 0xE7,
  0x8F, 0xFC, 0x3F, 0xC0, 0xFE, 0x00, 0xF8, 0x03, 0x80, 0x08, 0x00, 0x1F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x8F, 0x1E, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F,
  0x1E, 0x3C, 0xF9, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0x7B, 0xE1, 0xE7, 0x8F,
  0x9E, 0x3C, 0x78, 0xF1, 0xF3, 0xC3, 0xC0, 0x03, 0xE0, 0x3F, 0xC1, 0xFF,
  0x87, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3C, 0xF8, 0xF1, 0xE3, 0xC7, 0x9F, 0x1F, 0xF8, 0x3F,
  0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x00, 0x3C, 0x7C, 0xF1,
  0xE7, 0xC7, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x9E, 0x3C, 0xF8,
  0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0xBE, 0x3F,
  0xF0, 0x7F, 0x80, 0x7C, 0x00, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0xBC, 0x3C,
  0xF0, 0xF3, 0xC7, 0x87, 0x9E, 0x1E, 0xF8, 0x7B, 0xC1, 0xEF, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0xF0,
  0x00, 0xF1, 0xC7, 0xF9, 0xE3, 0xFC, 0xF3, 0xFE, 0x79, 0xEF, 0x7C, 0xF7,
  0xBE, 0x7B, 0xDF, 0x79, 0xFF, 0xBC, 0xFF, 0xDE, 0x7F, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xF3, 0xE0, 0xF9,
  0xF0, 0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C,
  0x0F, 0x78, 0x07, 0x78, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8,
  0x7C, 0xF8, 0xF8, 0x78, 0xF0, 0xFF, 0x87, 0x9E, 0x7C, 0xF3, 0xC7, 0x9E,
  0x3D, 0xE1, 0xEF, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x00, 0x3F, 0xFC,
  0xFF, 0xF3, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF0, 0xF8, 0x00, 0xF3,
  0xCF, 0x3C, 0xF3, 0xC7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78,
  0xF8, 0xF8, 0xF8, 0x0E, 0x0F, 0x07, 0x87, 0xE3, 0xF3, 0xB9, 0xDD, 0xC6,
  0xE3, 0x00, 0x7F, 0xDF, 0xF7, 0xFC, 0xF3, 0x9E, 0x70, 0x0F, 0x87, 0xF8,
  0xFF, 0x3C, 0xF0, 0x1E, 0x3F, 0x9F, 0xF7, 0xDE, 0xF3, 0xDE, 0x7B, 0xFF,
  0x7F, 0xE7, 0xBC, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0xF1, 0xFF, 0x3F, 0xEF, 0x3D, 0xE3, 0xBC, 0xF7, 0x9E, 0xF3, 0xDC, 0x7F,
  0xCF, 0xFF, 0xDF, 0xFB, 0x9C, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x3C, 0xF7,
  0x9E, 0xF0, 0x1C, 0x07, 0x80, 0xF3, 0xCE, 0x79, 0xFE, 0x3F, 0xC1, 0xE0,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x7B, 0xC7,
  0xFE, 0x3F, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7,
  0x1E, 0x78, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x0F, 0x83, 0xF8, 0xFF, 0xBC,
  0xF7, 0x9E, 0xFF, 0xDF, 0xFB, 0xFF, 0xF0, 0x0F, 0x31, 0xFF, 0x1F, 0xE1,
  0xF0, 0x03, 0xC3, 0xF0, 0xFC, 0x7C, 0x1E, 0x07, 0x87, 0xF9, 0xFC, 0x7F,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x80, 0x0E, 0x73, 0xFF, 0x3F, 0xF7, 0xCF, 0x78, 0xE7, 0x9E, 0x71, 0xEF,
  0x1E, 0xF1, 0xEF, 0x9E, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0x3C, 0x47, 0xCF,
  0xF8, 0xFF, 0x07, 0xE0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0xF1, 0xFF, 0x7F, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x9E, 0xF3, 0xFC,
  0x7F, 0x9E, 0xF3, 0xDE, 0x7B, 0xCF, 0x00, 0x1C, 0x3C, 0x78, 0xE0, 0x07,
  0x8F, 0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xE0, 0x03,
  0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0xFC, 0x3F, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF3, 0xE7, 0xBE, 0x3F, 0xE3, 0xDE, 0x1F, 0xE0, 0xFE, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xF8, 0x1E,
  0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1E,
  0x38, 0xF1, 0xE3, 0xC0, 0x3F, 0xCF, 0x1F, 0xFF, 0xCF, 0xFF, 0xEF, 0xBC,
  0xF7, 0x9E, 0x7B, 0xCF, 0x3D, 0xE7, 0x9E, 0xF3, 0xCE, 0x7B, 0xCF, 0x79,
  0xE7, 0xBC, 0xF3, 0xDE, 0x79, 0xEF, 0x3C, 0xF0, 0x3F, 0xC7, 0xFC, 0xFF,
  0xBC, 0xF7, 0x9E, 0xF3, 0xDE, 0x7B, 0xCF, 0xF1, 0xFE, 0x7B, 0xCF, 0x79,
  0xEF, 0x3C, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0xF7, 0x9E, 0xF3, 0xDC, 0x7F,
  0x8F, 0xF1, 0xEE, 0x79, 0xFF, 0x1F, 0xC1, 0xF0, 0x1F, 0xE1, 0xFF, 0x1F,
  0xF3, 0xCF, 0x3C, 0x73, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0xDF, 0x7F,
  0xE7, 0xFE, 0x7B, 0x87, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E,
  0xF3, 0xFF, 0x3F, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1,
  0xCF, 0x3C, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x3F, 0x9F, 0xCF, 0xEF, 0xE7, 0xC3, 0xC1, 0xE0, 0xF0, 0x78,
  0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0xF8, 0xFF, 0x3C, 0xF7, 0x80,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xDE, 0x7B, 0xFE, 0x3F, 0xC3, 0xE0, 0x3C,
  0x78, 0xF7, 0xFF, 0xFF, 0xDE, 0x3C, 0x79, 0xE3, 0xC7, 0x8F, 0x1F, 0x3E,
  0x3C, 0x3C, 0xF3, 0xCF, 0x38, 0xF7, 0x8E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x71, 0xEF, 0xBC, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0xF1, 0xFE, 0x7B,
  0xCF, 0x39, 0xC7, 0x78, 0xEF, 0x1D, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF3, 0x9F, 0xE7, 0x3B, 0xDE, 0xF7, 0xBD, 0xEF, 0xFB,
  0x9F, 0xFF, 0x3F, 0x7E, 0x7E, 0xF8, 0xFD, 0xF0, 0xF3, 0xC1, 0xE7, 0x83,
  0x8F, 0x07, 0x1C, 0x00, 0x1C, 0xF8, 0xF7, 0x87, 0xF8, 0x3F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0xF3, 0x8F,
  0x9E, 0x00, 0x78, 0xF7, 0x9F, 0x79, 0xE3, 0xBE, 0x3B, 0xC3, 0xBC, 0x3F,
  0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C,
  0x0F, 0x80, 0xF0, 0x0E, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0x7F, 0xCF, 0xF8, 0x03,
  0x07, 0x0F, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x78, 0x70, 0xF0,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0x70, 0x70, 0x38, 0x38, 0x10, 0x0C,
  0x71, 0x86, 0x18, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x30, 0xC7, 0x18, 0x61,
  0x86, 0x18, 0xE0, 0x08, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E,
  0x1E, 0x0F, 0x07, 0x1F, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x70,
  0xE0, 0x40, 0x38, 0x6F, 0x9F, 0xFB, 0xF7, 0xFE, 0x7D, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 18, 6, 0, -18 },
  { 17, 8, 7, 8, 1, -19 },
  { 24, 13, 18, 12, 0, -18 },
  { 54, 11, 23, 12, 1, -21 },
  { 86, 12, 18, 16, 2, -18 },
  { 113, 13, 18, 14, 0, -18 },
  { 143, 4, 7, 4, 1, -19 },
  { 147, 8, 25, 8, 1, -20 },
  { 172, 8, 26, 8, -1, -20 },
  { 198, 11, 11, 11, 1, -18 },
  { 214, 11, 14, 11, 0, -16 },
  { 234, 5, 8, 7, -1, -3 },
  { 239, 7, 3, 10, 2, -9 },
  { 242, 5, 4, 7, 0, -4 },
  { 245, 11, 20, 8, -2, -18 },
  { 273, 11, 18, 12, 1, -18 },
  { 298, 8, 18, 12, 3, -18 },
  { 316, 12, 18, 12, 0, -18 },
  { 343, 12, 18, 12, 0, -18 },
  { 370, 12, 18, 12, 0, -18 },
  { 397, 12, 18, 12, 0, -18 },
  { 424, 11, 18, 12, 1, -18 },
  { 449, 12, 18, 12, 1, -18 },
  { 476, 11, 18, 12, 1, -18 },
  { 501, 10, 18, 12, 2, -18 },
  { 524, 7, 14, 7, 0, -14 },
  { 537, 7, 19, 7, -1, -14 },
  { 554, 11, 12, 11, 0, -14 },
  { 571, 11, 8, 13, 1, -12 },
  { 582, 10, 12, 11, 0, -13 },
  { 597, 10, 18, 11, 1, -18 },
  { 620, 18, 23, 19, 0, -17 },
  { 672, 14, 18, 15, -1, -18 },
  { 704, 14, 18, 14, 0, -18 },
  { 736, 13, 18, 14, 1, -18 },
  { 766, 13, 18, 14, 0, -18 },
  { 796, 13, 18, 12, 0, -18 },
  { 826, 13, 18, 12, 0, -18 },
  { 856, 13, 18, 14, 1, -18 },
  { 886, 15, 18, 15, 0, -18 },
  { 920, 7, 18, 7, 0, -18 },
  { 936, 13, 18, 12, 0, -18 },
  { 966, 16, 18, 14, 0, -18 },
  { 1002, 10, 18, 12, 0, -18 },
  { 1025, 19, 18, 18, 0, -18 },
  { 1068, 15, 18, 15, 0, -18 },
  { 1102, 13, 18, 15, 1, -18 },
  { 1132, 14, 18, 14, 0, -18 },
  { 1164, 13, 21, 15, 1, -18 },
  { 1199, 14, 18, 14, 0, -18 },
  { 1231, 14, 18, 13, 0, -18 },
  { 1263, 13, 18, 13, 2, -18 },
  { 1293, 14, 18, 14, 1, -18 },
  { 1325, 14, 18, 14, 2, -18 },
  { 1357, 17, 18, 18, 2, -18 },
  { 1396, 16, 18, 14, -1, -18 },
  { 1432, 13, 18, 13, 2, -18 },
  { 1462, 14, 18, 13, 0, -18 },
  { 1494, 9, 25, 7, -1, -21 },
  { 1523, 6, 20, 9, 2, -18 },
  { 1538, 8, 25, 7, -1, -21 },
  { 1563, 9, 9, 10, 1, -18 },
  { 1574, 10, 3, 10, -2, 0 },
  { 1578, 5, 4, 8, 3, -19 },
  { 1581, 11, 13, 11, 0, -13 },
  { 1599, 11, 19, 12, 0, -19 },
  { 1626, 11, 13, 11, 0, -13 },
  { 1644, 13, 19, 12, 0, -19 },
  { 1675, 11, 13, 12, 0, -13 },
  { 1693, 10, 19, 8, 0, -19 },
  { 1717, 12, 18, 12, 0, -13 },
  { 1744, 11, 19, 12, 0, -19 },
  { 1771, 7, 18, 6, 0, -18 },
  { 1787, 10, 23, 6, -3, -18 },
  { 1816, 13, 19, 12, 0, -19 },
  { 1847, 7, 19, 6, 0, -19 },
  { 1864, 17, 13, 18, 0, -13 },
  { 1892, 11, 13, 12, 0, -13 },
  { 1910, 11, 13, 12, 0, -13 },
  { 1928, 12, 18, 12, -1, -13 },
  { 1955, 12, 18, 12, 0, -13 },
  { 1982, 9, 13, 8, 0, -13 },
  { 1997, 11, 13, 11, 0, -13 },
  { 2015, 7, 16, 8, 1, -16 },
  { 2029, 12, 13, 12, 0, -13 },
  { 2049, 11, 13, 11, 1, -13 },
  { 2067, 15, 13, 15, 1, -13 },
  { 2092, 13, 13, 11, -1, -13 },
  { 2114, 12, 18, 11, 0, -13 },
  { 2141, 11, 13, 11, 0, -13 },
  { 2159, 8, 24, 7, 0, -20 },
  { 2183, 6, 21, 6, 0, -18 },
  { 2199, 8, 23, 7, -1, -19 },
  { 2222, 11, 6, 13, 1, -10 },
};

const GFXfont RobotoCondensed_BlackItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_BLACKITALIC25PT7B_H_
