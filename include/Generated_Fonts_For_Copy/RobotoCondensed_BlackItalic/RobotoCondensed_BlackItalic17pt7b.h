#ifndef _ROBOTOCONDENSED_BLACKITALIC17PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x67, 0x39, 0x8C, 0x03, 0x39, 0xC0, 0xDE, 0xF7, 0xA9,
  0x00, 0x0F, 0x05, 0x86, 0x8F, 0xF7, 0xF1, 0xA0, 0xF1, 0xFC, 0xFE, 0x34,
  0x16, 0x0B, 0x00, 0x04, 0x04, 0x1E, 0x3F, 0x3B, 0x33, 0x30, 0x3C, 0x1E,
  0x06, 0xE6, 0x66, 0x7E, 0x3C, 0x10, 0x10, 0x30, 0x3C, 0x16, 0xDB, 0xC7,
  0xC3, 0xE0, 0x7C, 0x3E, 0x3D, 0xB6, 0x93, 0xC0, 0xC0, 0x1E, 0x1F, 0x0D,
  0xC6, 0xE3, 0xE1, 0xE1, 0xF6, 0xFF, 0xEF, 0x77, 0x9F, 0xCF, 0x60, 0xDB,
  0x6C, 0x08, 0xCC, 0xC6, 0x33, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x0C, 0x40,
  0x10, 0x61, 0x82, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x38, 0xC6, 0x38,
  0x40, 0x18, 0x33, 0x5B, 0xF3, 0x8D, 0x12, 0x00, 0x1C, 0x1C, 0x18, 0x7E,
  0xFE, 0x38, 0x38, 0x38, 0x37, 0x66, 0xC0, 0xFF, 0x80, 0x7D, 0x80, 0x06,
  0x0C, 0x30, 0x61, 0x83, 0x04, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x00, 0x3C,
  0xFD, 0x9F, 0x3E, 0x7D, 0xF3, 0xE7, 0xCD, 0xBB, 0xE3, 0x80, 0x0B, 0xFF,
  0x73, 0x19, 0xCE, 0x73, 0x98, 0xC0, 0x1E, 0x3F, 0x77, 0x77, 0x07, 0x0E,
  0x0E, 0x1C, 0x38, 0x70, 0xFE, 0xFE, 0x1E, 0x3F, 0x77, 0x03, 0x07, 0x1E,
  0x1E, 0x06, 0xE7, 0xEE, 0x7E, 0x3C, 0x07, 0x0F, 0x0F, 0x1F, 0x36, 0x36,
  0x6E, 0xFF, 0xFF, 0x0E, 0x0C, 0x0C, 0x3F, 0x3F, 0x30, 0x30, 0x7C, 0x7E,
  0x06, 0x07, 0xE6, 0xEE, 0x7E, 0x38, 0x0C, 0x79, 0xE3, 0x0F, 0xDF, 0xFB,
  0xE7, 0xCF, 0x9B, 0xF3, 0xC0, 0x7F, 0xFF, 0x06, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0xE0, 0xE0, 0x1E, 0x3F, 0x33, 0x37, 0x37, 0x3E, 0x7E,
  0x66, 0xE6, 0xEE, 0x7E, 0x3C, 0x3C, 0xFD, 0xBF, 0x3E, 0xFD, 0xFF, 0xBF,
  0x1C, 0x79, 0xE3, 0x00, 0x33, 0x8C, 0x00, 0x00, 0x0C, 0xE3, 0x00, 0x19,
  0xC6, 0x00, 0x00, 0x00, 0x31, 0x9C, 0xC4, 0x00, 0x02, 0x1C, 0xFB, 0xCF,
  0x0F, 0x87, 0x02, 0xFF, 0xFC, 0x07, 0xEF, 0xC0, 0x20, 0xE0, 0xF0, 0x71,
  0xEF, 0xBC, 0x40, 0x38, 0xFB, 0xBF, 0x71, 0xC7, 0x0C, 0x38, 0x00, 0xC1,
  0x83, 0x00, 0x07, 0xC0, 0xEE, 0x18, 0x23, 0x3B, 0x67, 0x96, 0xD9, 0x4D,
  0xBD, 0x9B, 0xD9, 0x3D, 0xB2, 0xDF, 0x6C, 0xDC, 0xC0, 0x06, 0x00, 0x7E,
  0x01, 0xE0, 0x03, 0x81, 0xE0, 0x78, 0x3E, 0x0D, 0x87, 0x61, 0x98, 0xE6,
  0x3F, 0xDF, 0xF7, 0x1F, 0x87, 0x3F, 0x1F, 0xCC, 0xEE, 0x77, 0x3B, 0xF9,
  0xFC, 0xC6, 0x63, 0x73, 0xBF, 0xDF, 0xC0, 0x1E, 0x3F, 0x9C, 0xDC, 0x7E,
  0x07, 0x03, 0x81, 0x80, 0xC7, 0x77, 0x3F, 0x8F, 0x00, 0x3E, 0x1F, 0x8C,
  0xEE, 0x77, 0x3B, 0x9D, 0xCE, 0xC7, 0x67, 0x73, 0xBF, 0x9F, 0x80, 0x3F,
  0x9F, 0xCC, 0x0E, 0x07, 0x03, 0xF1, 0xF8, 0xC0, 0x60, 0x70, 0x3F, 0x9F,
  0xC0, 0x3F, 0x9F, 0x8C, 0x0E, 0x07, 0x03, 0xF1, 0xF8, 0xC0, 0x60, 0x70,
  0x38, 0x1C, 0x00, 0x1E, 0x3F, 0x9C, 0xDC, 0x7E, 0x07, 0x03, 0xBD, 0x9E,
  0xC7, 0x73, 0xBF, 0xCF, 0x80, 0x38, 0xC7, 0x38, 0xC7, 0x38, 0xE7, 0x1C,
  0xFF, 0x9F, 0xE3, 0x1C, 0x63, 0x9C, 0x73, 0x8E, 0x71, 0x80, 0x39, 0xCC,
  0x67, 0x39, 0xCE, 0x67, 0x39, 0xC0, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x18, 0x0C, 0xEE, 0x77, 0x1F, 0x0F, 0x00, 0x39, 0xC7, 0x78, 0xCE,
  0x3B, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1C, 0xE3, 0x9C, 0x73,
  0x80, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0xFF, 0xF0,
  0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0xF9, 0xE7, 0xDF, 0x3E, 0xF9, 0xF7, 0xCD,
  0xEE, 0x6F, 0x67, 0x73, 0x3B, 0xB9, 0xDD, 0xC0, 0x38, 0xCE, 0x73, 0x9D,
  0xE7, 0x7D, 0xDF, 0x77, 0xD9, 0x9E, 0x67, 0xB9, 0xEE, 0x7B, 0x8C, 0x1E,
  0x1F, 0x9C, 0xDC, 0x7E, 0x3F, 0x1F, 0x8D, 0x8E, 0xC7, 0x77, 0x3F, 0x8F,
  0x80, 0x3F, 0x1F, 0xCC, 0xEE, 0x37, 0x3B, 0x9D, 0xFC, 0xFC, 0x60, 0x70,
  0x38, 0x1C, 0x00, 0x1E, 0x1F, 0x9C, 0xDC, 0x7E, 0x3F, 0x1F, 0x8D, 0x8E,
  0xC7, 0x77, 0xBF, 0x8F, 0x80, 0xE0, 0x20, 0x3F, 0x1F, 0xCC, 0xEE, 0x77,
  0x3B, 0x9D, 0xFC, 0xFC, 0x6E, 0x73, 0xB9, 0xDC, 0xE0, 0x0F, 0x1F, 0xCE,
  0xE6, 0x73, 0x81, 0xF0, 0x7C, 0x0E, 0xE7, 0x33, 0x9F, 0xC7, 0x80, 0x7F,
  0xFF, 0xC7, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E,
  0x00, 0x39, 0xCE, 0x73, 0x1D, 0xC6, 0x73, 0x9C, 0xE7, 0x39, 0x8E, 0x63,
  0x1D, 0xC7, 0xF0, 0xF0, 0xE3, 0xF8, 0xE6, 0x39, 0x9C, 0x67, 0x19, 0x87,
  0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x80, 0xE0, 0xE6, 0x7E, 0x67, 0xEE, 0x6E,
  0xEE, 0xEE, 0xEF, 0xEC, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0x78, 0xF7, 0x8F,
  0x70, 0x38, 0xE3, 0xB8, 0x77, 0x0F, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8,
  0x3B, 0x07, 0x71, 0xCE, 0x39, 0xC0, 0xE3, 0xB1, 0x9D, 0xCE, 0xC7, 0xE1,
  0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x00, 0x3F, 0xDF, 0xE0, 0x38,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x0F, 0xF3, 0xFC, 0x38,
  0xE3, 0x8C, 0x31, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x8E, 0x38, 0xE0,
  0xE7, 0x18, 0xC7, 0x39, 0xCE, 0x71, 0x8C, 0x73, 0x80, 0x1C, 0xF1, 0xC6,
  0x18, 0x63, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC7, 0x3C, 0xE0, 0x1C, 0x73,
  0xCF, 0x6D, 0x90, 0xFF, 0xF0, 0xE6, 0x60, 0x3C, 0xFD, 0xD8, 0x73, 0xFF,
  0xFB, 0xFE, 0x6C, 0x38, 0x30, 0x30, 0x70, 0x7E, 0x7F, 0x77, 0x67, 0x67,
  0xE6, 0xE6, 0xFE, 0xDC, 0x3C, 0xFD, 0x9B, 0x3E, 0x1C, 0x3B, 0xBE, 0x38,
  0x03, 0x81, 0xC0, 0xC0, 0x63, 0xF3, 0xF9, 0x9D, 0xCE, 0xE6, 0x73, 0x3B,
  0x9F, 0xC7, 0xE0, 0x1C, 0x7E, 0x77, 0x7F, 0xFE, 0xE0, 0xE4, 0x7E, 0x3C,
  0x0E, 0x38, 0xE1, 0xC7, 0xCF, 0x9C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x00,
  0x3B, 0x7F, 0x77, 0x67, 0xE7, 0xE6, 0xE6, 0x7E, 0x7E, 0x0E, 0xFC, 0xF8,
  0x38, 0x30, 0x30, 0x70, 0x7E, 0x7E, 0x77, 0x67, 0x66, 0xE6, 0xEE, 0xEE,
  0xEE, 0x31, 0xCC, 0x07, 0x39, 0xCE, 0x63, 0x39, 0xCE, 0x00, 0x0C, 0x1C,
  0x30, 0x01, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x3C, 0x70,
  0x38, 0x18, 0x0C, 0x0E, 0x07, 0x73, 0xF9, 0xF8, 0xF8, 0x7C, 0x7E, 0x3B,
  0x9D, 0xCE, 0xE0, 0x39, 0xCC, 0x67, 0x39, 0xCE, 0x63, 0x39, 0xCE, 0x00,
  0x7E, 0xE7, 0xFE, 0x77, 0x76, 0x66, 0x66, 0x6E, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xE0, 0x7E, 0x7F, 0x77, 0x67, 0x66, 0xE6, 0xEE, 0xEE, 0xEE, 0x1C,
  0x7E, 0x77, 0x67, 0xE7, 0xE6, 0xEE, 0x7E, 0x38, 0x3F, 0x1F, 0xCE, 0xE6,
  0x73, 0x3B, 0x99, 0xCC, 0xFE, 0x7E, 0x30, 0x18, 0x1C, 0x00, 0x3B, 0x7F,
  0x67, 0xE7, 0xE6, 0xEE, 0xEE, 0xFE, 0x7E, 0x0C, 0x0C, 0x1C, 0x7D, 0xF7,
  0xD8, 0x63, 0x8E, 0x38, 0xE0, 0x3C, 0xFD, 0x9B, 0x83, 0xC3, 0xB3, 0xFE,
  0x78, 0x73, 0xBD, 0xEE, 0x73, 0x98, 0xC7, 0x38, 0x77, 0x77, 0x77, 0x67,
  0x66, 0xE6, 0xEE, 0x7E, 0x7E, 0xEF, 0xDB, 0xF7, 0xEF, 0x9F, 0x3C, 0x38,
  0x70, 0xCD, 0xF7, 0x6D, 0xFB, 0x7E, 0xFF, 0x3F, 0xCE, 0xE3, 0xB8, 0xCE,
  0x00, 0x3B, 0x9F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xD8, 0xEC, 0x67, 0x00,
  0x77, 0x77, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0x38, 0x30, 0x70, 0xE0, 0xC0,
  0x7F, 0x7E, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xFC, 0xFC, 0x08, 0xCE, 0x63,
  0x19, 0xDC, 0xE3, 0x18, 0xC6, 0x31, 0x84, 0x33, 0x32, 0x22, 0x66, 0x64,
  0x44, 0xCC, 0x10, 0x61, 0x86, 0x18, 0x61, 0x87, 0x1C, 0xC3, 0x0C, 0x71,
  0xCE, 0x10, 0x67, 0xEF, 0x7C, 0x60,
};

const GFXglyph RobotoCondensed_BlackItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 5, 5, 1, -13 },
  { 13, 9, 12, 8, 0, -12 },
  { 27, 8, 16, 8, 0, -14 },
  { 43, 9, 12, 11, 1, -12 },
  { 57, 9, 12, 10, 0, -12 },
  { 71, 3, 5, 3, 1, -13 },
  { 73, 5, 17, 5, 1, -13 },
  { 84, 6, 17, 5, -1, -13 },
  { 97, 7, 7, 8, 1, -12 },
  { 104, 8, 8, 8, 0, -9 },
  { 112, 4, 5, 4, -1, -2 },
  { 115, 5, 2, 7, 1, -6 },
  { 117, 3, 3, 5, 0, -3 },
  { 119, 7, 13, 5, -1, -12 },
  { 131, 7, 12, 8, 1, -12 },
  { 142, 5, 12, 8, 2, -12 },
  { 150, 8, 12, 8, 0, -12 },
  { 162, 8, 12, 8, 0, -12 },
  { 174, 8, 12, 8, 0, -12 },
  { 186, 8, 12, 8, 0, -12 },
  { 198, 7, 12, 8, 1, -12 },
  { 209, 8, 12, 8, 1, -12 },
  { 221, 8, 12, 8, 0, -12 },
  { 233, 7, 12, 8, 1, -12 },
  { 244, 5, 10, 5, 0, -10 },
  { 251, 5, 13, 5, -1, -10 },
  { 260, 7, 8, 7, 0, -9 },
  { 267, 7, 5, 9, 1, -8 },
  { 272, 7, 8, 7, 0, -9 },
  { 279, 7, 12, 8, 1, -12 },
  { 290, 12, 16, 13, 0, -12 },
  { 314, 10, 12, 10, -1, -12 },
  { 329, 9, 12, 9, 0, -12 },
  { 343, 9, 12, 9, 1, -12 },
  { 357, 9, 12, 9, 0, -12 },
  { 371, 9, 12, 8, 0, -12 },
  { 385, 9, 12, 8, 0, -12 },
  { 399, 9, 12, 10, 1, -12 },
  { 413, 11, 12, 10, 0, -12 },
  { 430, 5, 12, 5, 0, -12 },
  { 438, 9, 12, 8, 0, -12 },
  { 452, 11, 12, 9, 0, -12 },
  { 469, 7, 12, 8, 0, -12 },
  { 480, 13, 12, 13, 0, -12 },
  { 500, 10, 12, 10, 0, -12 },
  { 515, 9, 12, 10, 1, -12 },
  { 529, 9, 12, 9, 0, -12 },
  { 543, 9, 14, 10, 1, -12 },
  { 559, 9, 12, 9, 0, -12 },
  { 573, 9, 12, 9, 0, -12 },
  { 587, 9, 12, 9, 1, -12 },
  { 601, 10, 12, 10, 0, -12 },
  { 616, 10, 12, 10, 1, -12 },
  { 631, 12, 12, 12, 1, -12 },
  { 649, 11, 12, 9, -1, -12 },
  { 666, 9, 12, 9, 1, -12 },
  { 680, 10, 12, 9, 0, -12 },
  { 695, 6, 17, 4, 0, -14 },
  { 708, 5, 13, 6, 1, -12 },
  { 717, 6, 17, 4, -1, -14 },
  { 730, 6, 6, 7, 0, -12 },
  { 735, 6, 2, 7, -1, 0 },
  { 737, 4, 3, 6, 2, -13 },
  { 739, 7, 9, 8, 0, -9 },
  { 747, 8, 13, 8, 0, -13 },
  { 760, 7, 9, 8, 0, -9 },
  { 768, 9, 13, 8, 0, -13 },
  { 783, 8, 9, 8, 0, -9 },
  { 792, 7, 13, 5, 0, -13 },
  { 804, 8, 12, 8, 0, -9 },
  { 816, 8, 13, 8, 0, -13 },
  { 829, 5, 13, 4, 0, -13 },
  { 838, 7, 16, 4, -2, -13 },
  { 852, 9, 13, 8, 0, -13 },
  { 867, 5, 13, 4, 0, -13 },
  { 876, 12, 9, 12, 0, -9 },
  { 890, 8, 9, 8, 0, -9 },
  { 899, 8, 9, 8, 0, -9 },
  { 908, 9, 12, 8, -1, -9 },
  { 922, 8, 12, 8, 0, -9 },
  { 934, 6, 9, 6, 0, -9 },
  { 941, 7, 9, 7, 0, -9 },
  { 949, 5, 11, 5, 1, -11 },
  { 956, 8, 9, 8, 0, -9 },
  { 965, 7, 9, 8, 1, -9 },
  { 973, 10, 9, 10, 1, -9 },
  { 985, 9, 9, 8, -1, -9 },
  { 996, 8, 12, 8, 0, -9 },
  { 1008, 8, 9, 8, 0, -9 },
  { 1017, 5, 16, 5, 0, -13 },
  { 1027, 4, 14, 4, 0, -12 },
  { 1034, 6, 16, 5, -1, -13 },
  { 1046, 7, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_BlackItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_BLACKITALIC17PT7B_H_
