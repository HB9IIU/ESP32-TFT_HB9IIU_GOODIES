#ifndef _ROBOTOCONDENSED_BLACKITALIC18PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x63, 0x19, 0xCE, 0x60, 0x19, 0xC6, 0x00, 0xDE, 0xF7,
  0xB9, 0x00, 0x0D, 0x07, 0x82, 0xC7, 0xF7, 0xF8, 0xB0, 0xD8, 0x68, 0xFF,
  0x7F, 0x9A, 0x0F, 0x05, 0x80, 0x02, 0x03, 0x03, 0x83, 0xE3, 0xB9, 0xDC,
  0xE0, 0x70, 0x1E, 0x07, 0x81, 0xCC, 0xE7, 0x73, 0xF0, 0xF0, 0x20, 0x10,
  0x00, 0x70, 0xF2, 0x93, 0x96, 0xFC, 0xE8, 0x18, 0x3E, 0x2F, 0x7B, 0xDB,
  0x9F, 0x0E, 0x0E, 0x0F, 0x8E, 0xC6, 0x63, 0xF1, 0xF0, 0xF6, 0xFB, 0xEF,
  0xF7, 0xF9, 0xCF, 0xE3, 0xB8, 0x7B, 0x6C, 0x08, 0xCC, 0x66, 0x33, 0x98,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0x61, 0x00, 0x10, 0x61, 0x83, 0x0C, 0x30,
  0xC3, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x1C, 0xE1, 0x00, 0x08, 0x18, 0xDB,
  0xFF, 0x38, 0x68, 0xEC, 0x48, 0x0C, 0x1C, 0x1C, 0x7F, 0x7F, 0xFF, 0x38,
  0x38, 0x38, 0x33, 0x76, 0xEC, 0xFF, 0xC0, 0x6F, 0x60, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0x1C,
  0x3E, 0x76, 0x67, 0xE7, 0xE7, 0xE6, 0xEE, 0xCE, 0xCE, 0xEC, 0xFC, 0x78,
  0x0D, 0xEF, 0xBE, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x70, 0x1E, 0x1F,
  0x9C, 0xEE, 0x70, 0x30, 0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1C, 0x1F, 0xEF,
  0xE0, 0x1E, 0x1F, 0x9C, 0xE0, 0x70, 0x70, 0xF8, 0x78, 0x0E, 0x07, 0x73,
  0xBB, 0xCF, 0xC3, 0xC0, 0x07, 0x83, 0x83, 0xC3, 0xE1, 0xF1, 0xB9, 0xDC,
  0xCC, 0xFF, 0x7F, 0x83, 0x81, 0xC0, 0xE0, 0x3F, 0x9F, 0xCE, 0x06, 0x07,
  0xE3, 0xF8, 0x1C, 0x0E, 0x07, 0x73, 0x9B, 0x8F, 0xC3, 0xC0, 0x0E, 0x7C,
  0xE3, 0x8F, 0xDF, 0xFB, 0xF7, 0xCF, 0x9F, 0xBF, 0xE7, 0x80, 0x7F, 0xFF,
  0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0x1E,
  0x1F, 0x8E, 0xE6, 0x73, 0x31, 0xF8, 0xF8, 0xEE, 0x67, 0x73, 0x99, 0xCF,
  0xC3, 0xC0, 0x1C, 0x7E, 0x76, 0xE7, 0xE7, 0xE7, 0xEE, 0x7E, 0x7E, 0x1C,
  0x3C, 0x78, 0x60, 0x31, 0xCC, 0x00, 0x00, 0x0C, 0xF3, 0x00, 0x18, 0xF1,
  0x80, 0x00, 0x00, 0x00, 0x30, 0xC3, 0x1C, 0x61, 0x00, 0x01, 0x0E, 0x3E,
  0x7C, 0xE0, 0xF8, 0x3E, 0x1C, 0x04, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x20,
  0x70, 0x7C, 0x1F, 0x0E, 0x3E, 0x78, 0xE0, 0x80, 0x3C, 0xFF, 0xBF, 0x70,
  0xE3, 0x8E, 0x18, 0x30, 0x01, 0x83, 0x86, 0x00, 0x03, 0xC0, 0x7F, 0x86,
  0x0C, 0x60, 0x33, 0x39, 0xB3, 0xED, 0xB3, 0x79, 0xB3, 0xDD, 0x96, 0xCD,
  0xB7, 0xF9, 0x9F, 0x8C, 0x00, 0x30, 0x01, 0xFC, 0x03, 0xC0, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1B, 0x87, 0x70, 0xEE, 0x39, 0xC7, 0xF9,
  0xFF, 0x38, 0xEF, 0x1C, 0x3F, 0x0F, 0xE3, 0xBC, 0xC7, 0x73, 0x9F, 0xE7,
  0xF1, 0xCE, 0x73, 0x98, 0xEE, 0x7B, 0xFC, 0xFE, 0x00, 0x1E, 0x1F, 0x9C,
  0xEC, 0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE7, 0x63, 0xBB, 0xDF, 0xC7, 0xC0,
  0x3E, 0x0F, 0xE3, 0xB8, 0xC6, 0x71, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x98,
  0xEE, 0x73, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xE3, 0x80, 0xC0, 0x70, 0x1F,
  0xC7, 0xF1, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x9F,
  0xCE, 0x06, 0x07, 0x03, 0x81, 0xFC, 0xFE, 0x70, 0x30, 0x38, 0x1C, 0x0E,
  0x00, 0x1F, 0x1F, 0xDC, 0xEE, 0x7E, 0x07, 0x03, 0xBF, 0xDF, 0xE7, 0x73,
  0xB9, 0xDF, 0xE3, 0xC0, 0x38, 0xE7, 0x1C, 0xE3, 0x98, 0x77, 0x1C, 0xE3,
  0x9F, 0xF3, 0xFE, 0x71, 0xCC, 0x33, 0x8E, 0x71, 0xCE, 0x38, 0x39, 0xCE,
  0x73, 0x39, 0xCE, 0x73, 0xB9, 0xCE, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x73, 0x3B, 0x8F, 0x83, 0x80, 0x39, 0xE7,
  0x38, 0xEE, 0x1B, 0xC7, 0x70, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0E, 0xE3,
  0x9C, 0x73, 0x8E, 0x78, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xC3, 0x87, 0xFF, 0xE0, 0x3C, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xDF, 0x9F, 0x6C, 0x7D, 0xF1, 0xBD, 0xCE, 0x77, 0x39,
  0x9C, 0xE6, 0x70, 0x38, 0xE7, 0x1C, 0xF3, 0x9E, 0x67, 0xDC, 0xFB, 0x9D,
  0x73, 0xBE, 0x77, 0xCC, 0xF3, 0x9E, 0x71, 0xCE, 0x38, 0x1E, 0x1F, 0x9C,
  0xEC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xBB, 0xDF, 0xC3, 0xC0,
  0x3F, 0x0F, 0xE3, 0x9C, 0xC7, 0x71, 0xDC, 0x77, 0x39, 0xFE, 0x7E, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x1F, 0x9C, 0xEC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF3, 0xBB, 0xCF, 0xC3, 0xE0, 0x78, 0x18, 0x3F, 0x0F,
  0xE3, 0x9C, 0xC7, 0x71, 0xDC, 0xE7, 0xF9, 0xF8, 0x77, 0x19, 0xCE, 0x73,
  0x9C, 0xE7, 0x80, 0x0F, 0x0F, 0xE3, 0xBC, 0xE7, 0x38, 0x0F, 0x01, 0xF0,
  0x3C, 0x03, 0xB8, 0xE7, 0x71, 0xFC, 0x3E, 0x00, 0x7F, 0xBF, 0xE1, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x00, 0x38, 0xC7, 0x38, 0xE7, 0x18, 0xE7, 0x1C, 0xE3, 0x9C, 0x63, 0x9C,
  0x73, 0x8E, 0x71, 0xDE, 0x3F, 0x83, 0xE0, 0xF1, 0xFC, 0xF7, 0x39, 0xCE,
  0x77, 0x1D, 0xC7, 0x71, 0xF8, 0x7E, 0x1F, 0x07, 0xC0, 0xF0, 0x38, 0x00,
  0xE7, 0x3F, 0x3B, 0xB9, 0xDD, 0xDE, 0xE6, 0xF6, 0x37, 0xF1, 0xFF, 0x8F,
  0x7C, 0x7B, 0xC3, 0xDE, 0x1C, 0xF0, 0xE7, 0x07, 0x38, 0x00, 0x1C, 0xF1,
  0xCE, 0x1D, 0xC1, 0xDC, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x83,
  0xB8, 0x3B, 0x87, 0x38, 0x73, 0xC0, 0x73, 0xDC, 0xE7, 0x39, 0xDC, 0x76,
  0x0F, 0x83, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3F,
  0xCF, 0xF0, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0xFC, 0xFF, 0x00, 0x3C, 0xF3, 0x8E, 0x31, 0xC7, 0x1C, 0x71, 0xC7,
  0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0xE7, 0x18, 0xE7, 0x39, 0xCE, 0x71,
  0x8E, 0x73, 0x9C, 0x1C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x8E,
  0x31, 0xC7, 0x1C, 0xF3, 0xC0, 0x1C, 0x38, 0xF1, 0xA6, 0x6C, 0xC0, 0xFF,
  0xFC, 0xE6, 0x70, 0x1C, 0x7E, 0x77, 0x07, 0x3E, 0x7E, 0xEE, 0xEE, 0xFE,
  0x7E, 0x38, 0x38, 0x38, 0x30, 0x7E, 0x7F, 0x77, 0x77, 0x77, 0x67, 0xE7,
  0xE7, 0xFE, 0xFC, 0x1C, 0x3E, 0x77, 0x67, 0xE0, 0xE0, 0xE6, 0xEE, 0x7C,
  0x38, 0x03, 0x81, 0xC0, 0xE0, 0x73, 0xBB, 0xF9, 0xDC, 0xCE, 0xE7, 0x73,
  0xB9, 0xDD, 0xC7, 0xE3, 0xF0, 0x1E, 0x3F, 0x77, 0x67, 0x7F, 0xFF, 0xE0,
  0x74, 0x7E, 0x3C, 0x0E, 0x3C, 0xF1, 0xC7, 0xCF, 0x8C, 0x38, 0x70, 0xE1,
  0xC3, 0x86, 0x1C, 0x00, 0x3F, 0xBF, 0xDD, 0xCC, 0xEE, 0x77, 0x3B, 0x9D,
  0xCE, 0x7E, 0x3F, 0x03, 0x81, 0xCF, 0xC3, 0xC0, 0x38, 0x38, 0x38, 0x30,
  0x7E, 0x7F, 0x77, 0x77, 0x67, 0x67, 0xE7, 0xE6, 0xEE, 0xEE, 0x39, 0xCE,
  0x03, 0x39, 0xCE, 0x73, 0x99, 0xCE, 0x70, 0x0E, 0x1C, 0x38, 0x00, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0E, 0x3C, 0xF1, 0xC0, 0x38,
  0x1C, 0x0E, 0x06, 0x07, 0x7B, 0xB9, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x9D,
  0xCE, 0xE7, 0x38, 0x39, 0xCE, 0x73, 0x39, 0xCE, 0x73, 0x99, 0xCE, 0x70,
  0x7E, 0xF7, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x76, 0x77, 0xE6, 0x7E, 0x67,
  0xEE, 0x6E, 0xEE, 0x7E, 0x7F, 0x77, 0x77, 0x67, 0x67, 0xE7, 0xE6, 0xEE,
  0xEE, 0x1E, 0x3F, 0x77, 0x67, 0xE7, 0xE7, 0xE7, 0xE6, 0x7E, 0x3C, 0x3F,
  0x1F, 0xCE, 0xE7, 0x73, 0xB9, 0x9D, 0xCE, 0xE7, 0x7F, 0x3F, 0x1C, 0x0C,
  0x0E, 0x07, 0x00, 0x3B, 0xBF, 0x9D, 0xCC, 0xEE, 0x77, 0x3B, 0x9D, 0xDC,
  0x7E, 0x3F, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x7D, 0xF7, 0xDC, 0x71, 0x8E,
  0x38, 0xE3, 0x80, 0x3C, 0x7E, 0x77, 0x70, 0x78, 0x3E, 0x0E, 0xEE, 0xFC,
  0x78, 0x73, 0xBF, 0xFE, 0x73, 0x9C, 0xE7, 0x3D, 0xC0, 0x73, 0xB9, 0x9D,
  0xCE, 0xE7, 0x73, 0x3B, 0x9D, 0xDC, 0x7E, 0x3F, 0x00, 0xEE, 0xEE, 0xEE,
  0xFC, 0xFC, 0xF8, 0xF8, 0x78, 0x70, 0x70, 0xEC, 0xFB, 0x7D, 0xDF, 0x76,
  0xDF, 0xBF, 0xEF, 0x73, 0x9C, 0xE7, 0x39, 0x80, 0x3B, 0x8E, 0xE1, 0xF0,
  0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x77, 0x1D, 0xC0, 0x73, 0xBB, 0x9D,
  0xCF, 0xC7, 0xE3, 0xE1, 0xF0, 0x78, 0x38, 0x1C, 0x0C, 0x0E, 0x0E, 0x06,
  0x00, 0x7F, 0x7F, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xFE, 0xFC, 0x08,
  0x71, 0x8E, 0x38, 0xC3, 0x1C, 0x63, 0x86, 0x18, 0x61, 0x86, 0x1C, 0x20,
  0x13, 0x33, 0x32, 0x26, 0x66, 0x64, 0x44, 0xC0, 0x10, 0x61, 0x86, 0x18,
  0x61, 0x87, 0x1C, 0xE3, 0x0C, 0x31, 0xC7, 0x38, 0x40, 0x73, 0xFF, 0xDE,
  0xCE,
};

const GFXglyph RobotoCondensed_BlackItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 5, 5, 6, 1, -14 },
  { 14, 9, 13, 9, 0, -13 },
  { 29, 9, 17, 9, 0, -15 },
  { 49, 8, 13, 11, 2, -13 },
  { 62, 9, 13, 10, 0, -13 },
  { 77, 3, 5, 3, 1, -14 },
  { 79, 5, 18, 6, 1, -14 },
  { 91, 6, 18, 6, -1, -14 },
  { 105, 8, 8, 8, 1, -13 },
  { 113, 8, 9, 8, 0, -11 },
  { 122, 4, 6, 5, -1, -2 },
  { 125, 5, 2, 7, 1, -6 },
  { 127, 4, 3, 5, 0, -3 },
  { 129, 8, 14, 5, -1, -13 },
  { 143, 8, 13, 9, 1, -13 },
  { 156, 6, 13, 9, 2, -13 },
  { 166, 9, 13, 9, 0, -13 },
  { 181, 9, 13, 9, 0, -13 },
  { 196, 9, 13, 9, 0, -13 },
  { 211, 9, 13, 9, 0, -13 },
  { 226, 7, 13, 9, 1, -13 },
  { 238, 8, 13, 9, 1, -13 },
  { 251, 9, 13, 9, 0, -13 },
  { 266, 8, 13, 9, 1, -13 },
  { 279, 5, 10, 5, 0, -10 },
  { 286, 6, 14, 5, -1, -10 },
  { 297, 8, 9, 8, 0, -10 },
  { 306, 7, 5, 9, 1, -8 },
  { 311, 8, 9, 8, 0, -10 },
  { 320, 7, 13, 8, 1, -13 },
  { 332, 13, 16, 13, 0, -12 },
  { 358, 11, 13, 11, -1, -13 },
  { 376, 10, 13, 10, 0, -13 },
  { 393, 9, 13, 10, 1, -13 },
  { 408, 10, 13, 10, 0, -13 },
  { 425, 10, 13, 9, 0, -13 },
  { 442, 9, 13, 8, 0, -13 },
  { 457, 9, 13, 10, 1, -13 },
  { 472, 11, 13, 11, 0, -13 },
  { 490, 5, 13, 5, 0, -13 },
  { 499, 9, 13, 9, 0, -13 },
  { 514, 11, 13, 10, 0, -13 },
  { 532, 7, 13, 8, 0, -13 },
  { 544, 14, 13, 13, 0, -13 },
  { 567, 11, 13, 11, 0, -13 },
  { 585, 9, 13, 11, 1, -13 },
  { 600, 10, 13, 10, 0, -13 },
  { 617, 9, 15, 11, 1, -13 },
  { 634, 10, 13, 10, 0, -13 },
  { 651, 10, 13, 10, 0, -13 },
  { 668, 10, 13, 10, 1, -13 },
  { 685, 11, 13, 10, 0, -13 },
  { 703, 10, 13, 10, 1, -13 },
  { 720, 13, 13, 13, 1, -13 },
  { 742, 12, 13, 10, -1, -13 },
  { 762, 10, 13, 10, 1, -13 },
  { 779, 10, 13, 9, 0, -13 },
  { 796, 6, 18, 5, 0, -15 },
  { 810, 5, 14, 7, 1, -13 },
  { 819, 6, 18, 5, -1, -15 },
  { 833, 7, 6, 7, 0, -13 },
  { 839, 7, 2, 7, -1, 0 },
  { 841, 4, 3, 6, 2, -14 },
  { 843, 8, 10, 8, 0, -10 },
  { 853, 8, 14, 9, 0, -14 },
  { 867, 8, 10, 8, 0, -10 },
  { 877, 9, 14, 9, 0, -14 },
  { 893, 8, 10, 8, 0, -10 },
  { 903, 7, 14, 6, 0, -14 },
  { 916, 9, 14, 9, 0, -10 },
  { 932, 8, 14, 9, 0, -14 },
  { 946, 5, 14, 5, 0, -14 },
  { 955, 7, 18, 4, -2, -14 },
  { 971, 9, 14, 9, 0, -14 },
  { 987, 5, 14, 5, 0, -14 },
  { 996, 12, 10, 13, 0, -10 },
  { 1011, 8, 10, 9, 0, -10 },
  { 1021, 8, 10, 9, 0, -10 },
  { 1031, 9, 14, 9, -1, -10 },
  { 1047, 9, 14, 9, 0, -10 },
  { 1063, 6, 10, 6, 0, -10 },
  { 1071, 8, 10, 8, 0, -10 },
  { 1081, 5, 12, 5, 1, -12 },
  { 1089, 9, 10, 9, 0, -10 },
  { 1101, 8, 10, 8, 1, -10 },
  { 1111, 10, 10, 11, 1, -10 },
  { 1124, 10, 10, 8, -1, -10 },
  { 1137, 9, 14, 8, 0, -10 },
  { 1153, 8, 10, 8, 0, -10 },
  { 1163, 6, 17, 5, 0, -14 },
  { 1176, 4, 15, 4, 0, -13 },
  { 1184, 6, 17, 5, -1, -14 },
  { 1197, 8, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_BlackItalic18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_BLACKITALIC18PT7B_H_
