#ifndef _ROBOTOCONDENSED_BLACKITALIC53PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0,
  0x02, 0x00, 0x00, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3,
  0xF1, 0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E, 0x3E, 0x1F,
  0x1F, 0x0F, 0x8F, 0x8F, 0xCF, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF9, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x00, 0xF8, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xCF,
  0xF0, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0xFF, 0x83, 0xFC, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x87, 0xF8, 0x7F, 0xC3, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xE7, 0xE0, 0xE3, 0xF1, 0xF0, 0x79, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C,
  0x7E, 0x7C, 0x3E, 0x3E, 0x3E, 0x3F, 0x3E, 0x1F, 0x1F, 0xBF, 0x0F, 0x8F,
  0x9F, 0x07, 0xCF, 0xDF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0x80, 0x7F,
  0xEF, 0x80, 0x0F, 0xEF, 0xC0, 0x00, 0x87, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xEF, 0xF0, 0x03, 0xEF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xF7, 0xFF, 0x81, 0xF7, 0xE7, 0xC1, 0xFB, 0xE3,
  0xF0, 0xF9, 0xF1, 0xF8, 0xF9, 0xF8, 0xFC, 0xFC, 0xFC, 0x7E, 0x7C, 0x7E,
  0x3E, 0x7C, 0x3F, 0x1F, 0x7E, 0x1F, 0x8F, 0x9E, 0x07, 0xCF, 0xC2, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x9F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x87, 0xF0, 0xFF, 0xF8, 0x7F, 0x1F, 0xFF, 0xC7, 0xF3, 0xFF,
  0xFE, 0xFE, 0x3F, 0xFF, 0xEF, 0xE7, 0xFD, 0xFF, 0xFE, 0x7F, 0x9F, 0xFF,
  0xE7, 0xF8, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xC7, 0xF8, 0x7F, 0xF8, 0x7F,
  0x83, 0xFF, 0x87, 0xF8, 0x3F, 0xF0, 0x7F, 0xC7, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x3F, 0xE0, 0x06, 0x00, 0x00, 0x3F, 0x3F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8,
  0xF8, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x0C, 0x0F, 0x03, 0x3E,
  0x1E, 0x3E, 0x7F, 0x3D, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xEF,
  0x00, 0x1F, 0xDF, 0x00, 0x7F, 0x3F, 0x01, 0xFC, 0x3E, 0x03, 0xF0, 0x7E,
  0x03, 0xC0, 0x7C, 0x03, 0x80, 0xE0, 0x02, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x07,
  0xC0, 0x18, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0x80, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x7E, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF8, 0xFF,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xF3,
  0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0xBF, 0xE0, 0xFF, 0x7F,
  0xC1, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x03,
  0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F,
  0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x9F, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x07,
  0x80, 0x1F, 0xC0, 0x7F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0x7F, 0x9C, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xF3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x81, 0xFE, 0x3F, 0xE0,
  0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xCF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xEF, 0xF0, 0x07, 0xF7, 0xF8,
  0x07, 0xF7, 0xFC, 0x03, 0xF3, 0xFE, 0x03, 0xF9, 0xFE, 0x03, 0xF8, 0xFF,
  0x01, 0xFC, 0x7F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x7C, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0x80,
  0x18, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x7F,
  0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFF, 0x9F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF9, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xDF,
  0xF0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xFD, 0xFE,
  0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F, 0xDF, 0xE0,
  0xFF, 0x3F, 0xC3, 0xFE, 0x3F, 0xCF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xF9, 0xFE, 0x0F, 0xF8, 0xFF,
  0x07, 0xFC, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xE3, 0xFC, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F,
  0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F,
  0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xCF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xF9, 0xFE, 0x3F,
  0xC3, 0xFC, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83,
  0xFD, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xDF, 0xE1, 0xFF, 0x7F, 0xCF, 0xFD, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7E, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xC0, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xF0,
  0x04, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00,
  0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xF9, 0xFF, 0x7F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7F, 0xE0, 0x78, 0x1F, 0x03, 0xFF, 0xE1,
  0xE0, 0xFC, 0x1F, 0xFF, 0x87, 0xC3, 0xE0, 0xFF, 0xFE, 0x1F, 0x1F, 0x87,
  0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x87, 0xE1, 0xF1, 0xF0, 0xFC, 0x1F, 0x07,
  0xCF, 0xC3, 0xF0, 0x7C, 0x1F, 0x3E, 0x1F, 0xC3, 0xF0, 0x7C, 0xF8, 0x7E,
  0x0F, 0xC3, 0xE7, 0xE1, 0xF8, 0x3E, 0x0F, 0x9F, 0x8F, 0xE0, 0xF8, 0x3E,
  0x7C, 0x3F, 0x07, 0xE0, 0xF9, 0xF0, 0xFC, 0x1F, 0x83, 0xE7, 0xC3, 0xF0,
  0x7C, 0x1F, 0x1F, 0x0F, 0xC3, 0xF0, 0x7C, 0x7C, 0x3F, 0x0F, 0xC1, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0x8F, 0xC3, 0xF1, 0xFC, 0x3E, 0x3F, 0x0F, 0xEF,
  0xF1, 0xF0, 0x7C, 0x3F, 0xFF, 0xFF, 0x81, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xC1, 0xFF, 0x3F, 0xE0, 0x1F, 0x03, 0xF8, 0x7F, 0x00, 0x7C, 0x01, 0x00,
  0x60, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xE7, 0xF0,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x83, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x01, 0xFE, 0x1F, 0xF0,
  0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00,
  0x1F, 0xF7, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x07,
  0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF,
  0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xC0,
  0x1F, 0xF3, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81,
  0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1,
  0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE,
  0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC,
  0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xC3, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xE7, 0xFE, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xFE, 0x7F, 0x83, 0xFF,
  0xEF, 0xF8, 0x3F, 0xFE, 0xFF, 0x87, 0xFF, 0xEF, 0xF8, 0x7F, 0xFC, 0xFF,
  0x87, 0xFF, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x07,
  0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x0F, 0xF8, 0x7F, 0xF7, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC,
  0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8,
  0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F,
  0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x81, 0xFF,
  0xC0, 0x7F, 0xC1, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0xE0, 0x03, 0xFC, 0x7F,
  0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xBF,
  0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x07,
  0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x80,
  0x3F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFB, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xEF, 0xC3, 0xFF, 0xF8,
  0x1F, 0xEF, 0xC3, 0xF7, 0xF8, 0x1F, 0xEF, 0xC7, 0xF7, 0xF8, 0x1F, 0xE7,
  0xC7, 0xE7, 0xF8, 0x1F, 0xE7, 0xC7, 0xEF, 0xF8, 0x3F, 0xE7, 0xCF, 0xCF,
  0xF8, 0x3F, 0xE7, 0xEF, 0xCF, 0xF0, 0x3F, 0xE7, 0xFF, 0xCF, 0xF0, 0x3F,
  0xC7, 0xFF, 0x9F, 0xF0, 0x3F, 0xC7, 0xFF, 0x9F, 0xF0, 0x3F, 0xC7, 0xFF,
  0x1F, 0xF0, 0x7F, 0xC7, 0xFF, 0x1F, 0xE0, 0x7F, 0xC7, 0xFE, 0x1F, 0xE0,
  0x7F, 0xC7, 0xFE, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x3F, 0xE0, 0x7F, 0x83,
  0xFC, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xF8, 0x3F,
  0xC0, 0xFF, 0x83, 0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xF0, 0x7F, 0xC0, 0xFF,
  0x83, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x07, 0xFC, 0x0F, 0xFE, 0x03,
  0xFC, 0x07, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFE,
  0x1F, 0xE0, 0x3F, 0xDF, 0x0F, 0xF0, 0x1F, 0xEF, 0x8F, 0xF8, 0x1F, 0xF7,
  0xC7, 0xFC, 0x0F, 0xFB, 0xF3, 0xFE, 0x07, 0xFC, 0xF9, 0xFF, 0x03, 0xFE,
  0x7C, 0xFF, 0x01, 0xFE, 0x3E, 0x7F, 0x80, 0xFF, 0x1F, 0x7F, 0xC0, 0xFF,
  0x8F, 0xFF, 0xE0, 0x7F, 0xC3, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0xF0, 0x1F,
  0xF0, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0xFC, 0x07, 0xF8, 0x3F, 0xFE, 0x07,
  0xFC, 0x0F, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F,
  0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xFC, 0x01,
  0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE,
  0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF8,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF,
  0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x1F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x7F,
  0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFF, 0x00,
  0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF,
  0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80,
  0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F,
  0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xF7, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xFC,
  0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF,
  0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0,
  0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xF8,
  0x03, 0xFF, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x3F,
  0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0xFF, 0x80,
  0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xBF,
  0xE0, 0xFF, 0x07, 0xFD, 0xFF, 0x07, 0xF8, 0x3F, 0xEF, 0xF8, 0x7F, 0xC1,
  0xFE, 0x7F, 0xC3, 0xFE, 0x0F, 0xF3, 0xFE, 0x1F, 0xF0, 0xFF, 0x9F, 0xF1,
  0xFF, 0x87, 0xFC, 0xFF, 0x8F, 0xFC, 0x3F, 0xC7, 0xFC, 0x7F, 0xE3, 0xFE,
  0x3F, 0xE7, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xF8, 0xFF, 0x0F, 0xF9, 0xFF,
  0xC7, 0xF8, 0x7F, 0xDF, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0xF3, 0xFC, 0x1F,
  0xF7, 0xFF, 0x9F, 0xE0, 0xFF, 0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xFF, 0xEF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x7F, 0xFD, 0xFF, 0xF8, 0x03, 0xFF, 0xE7,
  0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x07,
  0xFF, 0x8F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xFE, 0x7F,
  0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF7, 0xF8, 0x03, 0xFE, 0x7F,
  0x80, 0x7F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xC7, 0xFC, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03,
  0xFC, 0x3F, 0xE0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x7F, 0xC0, 0x1F, 0xE7,
  0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xE3, 0xE0, 0xFC, 0x7C, 0x3F, 0x0F,
  0x87, 0xE1, 0xF1, 0xF8, 0x3F, 0x3F, 0x07, 0xEF, 0xE0, 0xFD, 0xF8, 0x1F,
  0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0x8F, 0xF3,
  0xFE, 0x1F, 0xE7, 0xFC, 0x3F, 0xCF, 0xF8, 0xFF, 0x9F, 0xE1, 0xFF, 0x3F,
  0xC3, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC1, 0xFF, 0x7F, 0x81, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F,
  0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F,
  0xC1, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x83, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0x7F, 0xE0, 0xFE, 0x3F, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xF9, 0xFE,
  0x3F, 0xC3, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3,
  0xFC, 0x3F, 0xCF, 0xF1, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x83, 0xFC, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0xBF, 0xC0, 0xFF,
  0xEF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0xFF,
  0x87, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F,
  0xF1, 0xFE, 0x3F, 0xC1, 0xFC, 0xFF, 0x83, 0xFD, 0xFE, 0x07, 0xFB, 0xFC,
  0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x18, 0x1F, 0xF1, 0xF0, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x07, 0xFF, 0x7F, 0x81,
  0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0,
  0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0xC7, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x18, 0x0F, 0xF8, 0x03, 0xE7, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x87,
  0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F,
  0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8, 0x00, 0x20, 0x03,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF1, 0xFF, 0x80, 0xFF, 0x1F, 0xF8, 0x0F, 0xF3,
  0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFC, 0x01, 0xFE, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF,
  0x80, 0x7F, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0x83, 0xF8, 0x0F, 0xFF,
  0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF9,
  0xFF, 0x1F, 0xE1, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFE, 0x1F, 0xF3,
  0xFE, 0x1F, 0xE1, 0xFF, 0x3F, 0xC3, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xE1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFE, 0x7F, 0xC3,
  0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xC3, 0xFE, 0x7F, 0x87, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7F, 0xC3, 0xFC, 0x7F, 0x87, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x87,
  0xFC, 0xFF, 0x87, 0xF8, 0x7F, 0xCF, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x07,
  0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xF1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xE3, 0xFE,
  0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8,
  0xFF, 0x87, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x8F, 0xF8, 0x7F, 0xC0, 0x00, 0x04, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xC1, 0xFE, 0xFF, 0x03, 0xFD,
  0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFB, 0xFC,
  0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F, 0xDF, 0xE0, 0xFF, 0x3F, 0xE3,
  0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8,
  0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFF, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0x7F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF0, 0x40, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03,
  0xFC, 0x7F, 0x07, 0xFE, 0x7F, 0x0F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0x83, 0xFE, 0xFF, 0x83, 0xFC, 0xFF,
  0x83, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF,
  0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFD,
  0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0xDF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x3F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xC7, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF9, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x80, 0x10, 0x00, 0x1F, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0x87, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF,
  0x07, 0xFC, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F,
  0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFE,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x7F,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x7F,
  0x83, 0xFE, 0xFF, 0x07, 0xFD, 0xFE, 0x1F, 0xF3, 0xFC, 0x3F, 0xE7, 0xF8,
  0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F,
  0xF0, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0x03, 0xFB, 0xFC,
  0x07, 0xF7, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xC3, 0xFD,
  0xFE, 0x1F, 0x87, 0xFB, 0xFC, 0x7F, 0x0F, 0xF7, 0xF8, 0xFE, 0x1F, 0xCF,
  0xE1, 0xFC, 0x7F, 0x9F, 0xC7, 0xF8, 0xFF, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F,
  0x3F, 0xE7, 0xF8, 0xFE, 0x7F, 0xCF, 0xF1, 0xFC, 0xFF, 0x9F, 0xC3, 0xFB,
  0xFF, 0x7F, 0x87, 0xF7, 0xFE, 0xFF, 0x0F, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF,
  0xFB, 0xF8, 0x3F, 0xFD, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xF7,
  0xFF, 0x81, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x3F,
  0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF,
  0x80, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0xFF, 0x87, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F,
  0xCF, 0xF8, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x07,
  0xFD, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8, 0x7F,
  0x81, 0xFF, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F,
  0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF3, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xFB, 0xFE,
  0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x06, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80,
  0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x60, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xF0, 0x3F, 0x3F, 0xF8, 0x3F, 0x3F, 0xF8, 0x3F, 0x7F, 0xFC,
  0x7F, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x3F, 0xFE, 0xFC, 0x3F,
  0xFC, 0xFC, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_BlackItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 15, 39, 14, 0, -38 },
  { 75, 17, 15, 16, 2, -40 },
  { 107, 27, 38, 26, 0, -38 },
  { 236, 25, 50, 26, 1, -44 },
  { 393, 25, 40, 33, 5, -39 },
  { 518, 28, 40, 31, 0, -39 },
  { 658, 8, 15, 8, 3, -40 },
  { 673, 17, 54, 17, 2, -42 },
  { 788, 17, 54, 17, -2, -42 },
  { 903, 23, 23, 24, 3, -38 },
  { 970, 22, 27, 24, 1, -31 },
  { 1045, 12, 17, 14, -3, -7 },
  { 1071, 14, 7, 22, 4, -20 },
  { 1084, 9, 9, 16, 1, -8 },
  { 1095, 23, 41, 16, -4, -38 },
  { 1213, 23, 40, 26, 2, -39 },
  { 1328, 17, 38, 26, 6, -38 },
  { 1409, 26, 39, 26, 0, -39 },
  { 1536, 26, 40, 26, 0, -39 },
  { 1666, 25, 38, 26, 1, -38 },
  { 1785, 25, 39, 26, 1, -38 },
  { 1907, 23, 39, 26, 2, -38 },
  { 2020, 26, 38, 26, 2, -38 },
  { 2144, 25, 40, 26, 1, -39 },
  { 2269, 22, 39, 26, 3, -39 },
  { 2377, 13, 30, 15, 1, -29 },
  { 2426, 16, 39, 15, -2, -29 },
  { 2504, 22, 26, 23, 1, -29 },
  { 2576, 23, 19, 27, 2, -26 },
  { 2631, 21, 25, 23, 1, -28 },
  { 2697, 21, 40, 24, 3, -39 },
  { 2802, 38, 48, 39, 0, -36 },
  { 3030, 31, 38, 31, -3, -38 },
  { 3178, 29, 38, 29, 0, -38 },
  { 3316, 28, 40, 29, 2, -39 },
  { 3456, 28, 38, 29, 0, -38 },
  { 3589, 28, 38, 25, 0, -38 },
  { 3722, 27, 38, 24, 0, -38 },
  { 3851, 28, 40, 30, 2, -39 },
  { 3991, 33, 38, 31, 0, -38 },
  { 4148, 15, 38, 14, 0, -38 },
  { 4220, 27, 39, 25, 0, -38 },
  { 4352, 33, 38, 29, 0, -38 },
  { 4509, 22, 38, 25, 0, -38 },
  { 4614, 40, 38, 39, 0, -38 },
  { 4804, 33, 38, 31, 0, -38 },
  { 4961, 28, 40, 31, 2, -39 },
  { 5101, 29, 38, 30, 0, -38 },
  { 5239, 29, 46, 31, 2, -39 },
  { 5406, 29, 38, 29, 0, -38 },
  { 5544, 28, 40, 28, 1, -39 },
  { 5684, 27, 38, 29, 4, -38 },
  { 5813, 30, 39, 30, 1, -38 },
  { 5960, 29, 38, 30, 4, -38 },
  { 6098, 37, 38, 38, 4, -38 },
  { 6274, 34, 38, 29, -2, -38 },
  { 6436, 28, 38, 28, 4, -38 },
  { 6569, 31, 38, 27, -1, -38 },
  { 6717, 18, 53, 14, -1, -44 },
  { 6837, 14, 41, 20, 4, -38 },
  { 6909, 19, 53, 14, -3, -44 },
  { 7035, 19, 19, 21, 1, -38 },
  { 7081, 20, 7, 20, -3, 0 },
  { 7099, 13, 8, 17, 5, -40 },
  { 7112, 23, 30, 24, 0, -29 },
  { 7199, 24, 41, 25, 0, -40 },
  { 7322, 22, 30, 24, 1, -29 },
  { 7405, 26, 41, 25, 1, -40 },
  { 7539, 23, 30, 25, 1, -29 },
  { 7626, 20, 41, 17, 1, -41 },
  { 7729, 27, 40, 26, -1, -29 },
  { 7864, 25, 40, 26, -1, -40 },
  { 7989, 15, 40, 13, 0, -40 },
  { 8064, 21, 51, 13, -6, -40 },
  { 8198, 28, 40, 25, 0, -40 },
  { 8338, 15, 40, 13, 0, -40 },
  { 8413, 36, 29, 38, 0, -29 },
  { 8544, 25, 29, 26, -1, -29 },
  { 8635, 23, 30, 25, 1, -29 },
  { 8722, 26, 40, 25, -2, -29 },
  { 8852, 24, 40, 25, 1, -29 },
  { 8972, 19, 29, 18, 0, -29 },
  { 9041, 23, 30, 23, 0, -29 },
  { 9128, 15, 36, 16, 2, -35 },
  { 9196, 25, 29, 26, 1, -28 },
  { 9287, 23, 28, 24, 2, -28 },
  { 9368, 31, 28, 32, 3, -28 },
  { 9477, 27, 28, 24, -2, -28 },
  { 9572, 27, 39, 24, -1, -28 },
  { 9704, 25, 28, 24, -1, -28 },
  { 9792, 16, 50, 15, 1, -41 },
  { 9892, 11, 45, 13, 1, -38 },
  { 9954, 16, 50, 15, -2, -41 },
  { 10054, 24, 12, 28, 2, -22 },
};

const GFXfont RobotoCondensed_BlackItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_BLACKITALIC53PT7B_H_
