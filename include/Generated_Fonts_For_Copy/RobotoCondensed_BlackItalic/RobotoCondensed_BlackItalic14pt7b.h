#ifndef _ROBOTOCONDENSED_BLACKITALIC14PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x76, 0x66, 0x60, 0xCC, 0xFB, 0xBA, 0x1E, 0x28, 0x53, 0xF2,
  0x85, 0x3F, 0x28, 0x50, 0xE0, 0x08, 0x38, 0xFB, 0xB7, 0x07, 0x07, 0x06,
  0xEC, 0xF9, 0xE1, 0x00, 0x61, 0xAB, 0x57, 0xC7, 0x87, 0x8F, 0xAB, 0xD6,
  0x18, 0x1C, 0x78, 0xB1, 0xE3, 0x8F, 0xFF, 0xEF, 0xFC, 0xEC, 0xFA, 0x13,
  0x64, 0xCC, 0xC8, 0x88, 0x88, 0xC4, 0x20, 0x86, 0x31, 0x8C, 0x63, 0x11,
  0x8C, 0xC6, 0x20, 0x10, 0xCF, 0xC8, 0x52, 0x40, 0x18, 0x63, 0x9F, 0xFC,
  0xC3, 0x0C, 0x6D, 0xE0, 0xFF, 0xFC, 0x0C, 0x30, 0x86, 0x10, 0xC2, 0x18,
  0x61, 0x0C, 0x00, 0x39, 0xEC, 0xF3, 0xDF, 0x6D, 0xB6, 0xFB, 0xC0, 0x1B,
  0xDE, 0x63, 0x18, 0xC6, 0x73, 0x00, 0x3C, 0xFD, 0xB8, 0x70, 0xC3, 0x0C,
  0x38, 0xFD, 0xF8, 0x3C, 0xFD, 0x98, 0x71, 0xC7, 0x83, 0x66, 0xFC, 0xF0,
  0x0E, 0x1C, 0x71, 0xE2, 0xCD, 0xBF, 0x7E, 0x18, 0x30, 0x3E, 0x7D, 0x83,
  0xC7, 0xC1, 0x83, 0x66, 0x7C, 0xF0, 0x0C, 0xF3, 0x1F, 0x7D, 0xBE, 0xDB,
  0x7C, 0xE0, 0x7E, 0xFC, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x70, 0xC0, 0x1C,
  0x7D, 0xDB, 0x73, 0xCF, 0x9B, 0x76, 0x7C, 0xF0, 0x39, 0xEC, 0xF3, 0xDF,
  0xE7, 0x8E, 0xF3, 0x80, 0x76, 0x00, 0x0E, 0xE0, 0x39, 0x80, 0x00, 0x11,
  0x8C, 0xC0, 0x04, 0x77, 0xB8, 0xF0, 0xE0, 0x80, 0x7C, 0xF8, 0x03, 0xEF,
  0xC0, 0x41, 0xC3, 0xC7, 0x7B, 0x88, 0x00, 0x77, 0xF6, 0x33, 0x31, 0x80,
  0xE6, 0x00, 0x0F, 0x06, 0x23, 0x0D, 0xB9, 0x4B, 0x56, 0x9D, 0x2F, 0x5A,
  0xD6, 0xB6, 0xCC, 0x01, 0x90, 0x3C, 0x00, 0x06, 0x0E, 0x0E, 0x1B, 0x1B,
  0x3B, 0x3F, 0x7F, 0x63, 0x63, 0x3C, 0x7E, 0x77, 0x66, 0x7E, 0x7C, 0x66,
  0xE6, 0xFE, 0xFC, 0x1E, 0x3E, 0x73, 0x63, 0x60, 0x60, 0xE6, 0x66, 0x7C,
  0x38, 0x3C, 0xFD, 0xDB, 0x36, 0x6C, 0xD9, 0xF7, 0xFD, 0xF0, 0x3E, 0xFD,
  0xC3, 0x07, 0xCF, 0x98, 0x70, 0xFD, 0xF8, 0x3E, 0xFD, 0xC3, 0x07, 0xCF,
  0x98, 0x70, 0xC1, 0x80, 0x1E, 0x3F, 0x73, 0x60, 0x6F, 0x6F, 0x66, 0x66,
  0x7E, 0x3C, 0x33, 0xB9, 0x9C, 0xCC, 0x67, 0xF3, 0xF9, 0x9D, 0xCC, 0xC6,
  0x63, 0x00, 0x33, 0x76, 0x66, 0x6E, 0xEC, 0x06, 0x0C, 0x38, 0x60, 0xC1,
  0x83, 0x6E, 0xF8, 0xE0, 0x33, 0x3B, 0x9F, 0x8D, 0x87, 0x83, 0xE1, 0xF1,
  0xD8, 0xCE, 0x67, 0x00, 0x31, 0xC7, 0x18, 0x61, 0x86, 0x38, 0xFF, 0xF0,
  0x39, 0xEF, 0x39, 0xE7, 0x3D, 0xE7, 0xBC, 0xFD, 0x9F, 0xF7, 0xEC, 0xCD,
  0x99, 0x30, 0x33, 0xB9, 0x9C, 0xCF, 0x67, 0xB3, 0x79, 0xBD, 0xDC, 0xCE,
  0x63, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0x63, 0x67, 0x67, 0x66, 0x7E, 0x3C,
  0x3C, 0x7E, 0x77, 0x67, 0x67, 0x7E, 0x7C, 0xE0, 0xC0, 0xC0, 0x1E, 0x3F,
  0x73, 0x63, 0x63, 0x67, 0x67, 0x66, 0x7E, 0x3C, 0x0E, 0x04, 0x3E, 0x7E,
  0x77, 0x66, 0x7E, 0x7C, 0x6C, 0xEC, 0xCC, 0xCE, 0x1C, 0x3E, 0x77, 0x70,
  0x38, 0x1C, 0x0E, 0xEE, 0x7C, 0x38, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x1C,
  0x38, 0x60, 0xC0, 0x33, 0x73, 0x77, 0x67, 0x66, 0x66, 0x66, 0xE6, 0x7C,
  0x38, 0xE7, 0xE6, 0xEE, 0xEC, 0x6C, 0x7C, 0x78, 0x78, 0x70, 0x70, 0xCD,
  0xF7, 0x6D, 0xDB, 0x7E, 0xFF, 0x3F, 0xCF, 0xF3, 0xB8, 0xEE, 0x3B, 0x80,
  0x39, 0x8D, 0xC6, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x6C, 0x76, 0x33, 0x80,
  0xE6, 0xEE, 0x6C, 0x7C, 0x78, 0x70, 0x70, 0x70, 0x60, 0x60, 0x7F, 0x7F,
  0x0E, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xFC, 0xFC, 0x31, 0x9C, 0xC6, 0x31,
  0x8C, 0x67, 0x31, 0x8E, 0x60, 0xCC, 0xEE, 0x66, 0x66, 0x66, 0x70, 0x39,
  0xC6, 0x73, 0x18, 0xC6, 0x33, 0x9C, 0xCE, 0x70, 0x19, 0xCA, 0xD4, 0x80,
  0xFB, 0xE0, 0x62, 0x39, 0xF0, 0xDF, 0xFF, 0x6F, 0x9E, 0x31, 0xC6, 0x1F,
  0x7D, 0xB6, 0xFB, 0xCF, 0xFF, 0x80, 0x39, 0xF6, 0xF8, 0xC3, 0x7F, 0x9C,
  0x06, 0x0C, 0x19, 0xF7, 0xCD, 0xBB, 0x66, 0xCD, 0xF9, 0xF0, 0x39, 0xF6,
  0xFB, 0xFF, 0x07, 0x9E, 0x19, 0xCC, 0xFF, 0xB1, 0x8C, 0x63, 0x38, 0x36,
  0xFD, 0xB7, 0x6C, 0xD9, 0xBF, 0x3E, 0x1D, 0xF3, 0xC0, 0x31, 0xC6, 0x1F,
  0x7D, 0xB6, 0xFB, 0xCF, 0x3D, 0xC0, 0x33, 0x06, 0x66, 0x66, 0xEC, 0xC0,
  0x0C, 0x30, 0x06, 0x18, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0xF3, 0x80, 0x30,
  0xE1, 0x83, 0x76, 0xCF, 0x1E, 0x7C, 0xF9, 0xBB, 0x30, 0x33, 0x76, 0x66,
  0x66, 0xEC, 0xC0, 0x7F, 0x9F, 0xE6, 0xD9, 0xB6, 0xED, 0xB3, 0x6D, 0xDB,
  0x66, 0x7D, 0xF6, 0xDB, 0xEF, 0x3D, 0xF7, 0x39, 0xF6, 0xFB, 0xCF, 0x37,
  0xDE, 0x3E, 0x7C, 0xD9, 0xB7, 0x6C, 0xDF, 0xBE, 0x60, 0xC3, 0x80, 0x36,
  0xF9, 0xB7, 0x6C, 0xD9, 0xBF, 0x3C, 0x18, 0x30, 0x60, 0x7B, 0xD8, 0xCE,
  0x63, 0x18, 0x39, 0xF6, 0x1C, 0x38, 0x6F, 0x9C, 0x33, 0xBC, 0xC6, 0x31,
  0x8E, 0x60, 0x6E, 0xDD, 0xB3, 0x6E, 0xD9, 0xBF, 0x3E, 0xDB, 0x6D, 0xBC,
  0xF3, 0xCE, 0x38, 0xDB, 0xDE, 0xFE, 0xFE, 0xFC, 0xFC, 0xDC, 0xD8, 0x36,
  0x36, 0x3C, 0x1C, 0x3C, 0x3C, 0x7C, 0x6C, 0x6E, 0xD9, 0xB3, 0xC7, 0x8E,
  0x1C, 0x38, 0x61, 0xC3, 0x00, 0x7D, 0xF1, 0x8E, 0x71, 0x8F, 0xBE, 0x13,
  0x33, 0x6E, 0xC6, 0x66, 0x44, 0x40, 0x24, 0x96, 0x92, 0x4B, 0x60, 0x22,
  0x26, 0x63, 0x36, 0x6C, 0xCC, 0x80, 0x76, 0xFF, 0x30,
};

const GFXglyph RobotoCondensed_BlackItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 4, 4, 4, 1, -11 },
  { 8, 7, 10, 7, 0, -10 },
  { 17, 7, 12, 7, 0, -11 },
  { 28, 7, 10, 9, 1, -10 },
  { 37, 7, 10, 8, 0, -10 },
  { 46, 2, 4, 2, 1, -11 },
  { 47, 4, 14, 4, 1, -11 },
  { 54, 5, 14, 4, -1, -11 },
  { 63, 6, 6, 6, 1, -10 },
  { 68, 6, 8, 6, 0, -9 },
  { 74, 3, 4, 4, -1, -2 },
  { 76, 4, 2, 6, 1, -5 },
  { 77, 3, 2, 4, 0, -2 },
  { 78, 6, 11, 4, -1, -10 },
  { 87, 6, 10, 7, 1, -10 },
  { 95, 5, 10, 7, 1, -10 },
  { 102, 7, 10, 7, 0, -10 },
  { 111, 7, 10, 7, 0, -10 },
  { 120, 7, 10, 7, 0, -10 },
  { 129, 7, 10, 7, 0, -10 },
  { 138, 6, 10, 7, 0, -10 },
  { 146, 7, 10, 7, 0, -10 },
  { 155, 7, 10, 7, 0, -10 },
  { 164, 6, 10, 7, 1, -10 },
  { 172, 4, 7, 4, 0, -7 },
  { 176, 5, 9, 4, -1, -7 },
  { 182, 6, 7, 6, 0, -8 },
  { 188, 7, 5, 7, 0, -7 },
  { 193, 6, 7, 6, 0, -8 },
  { 199, 5, 10, 6, 1, -10 },
  { 206, 10, 13, 10, 0, -10 },
  { 223, 8, 10, 8, -1, -10 },
  { 233, 8, 10, 8, 0, -10 },
  { 243, 8, 10, 8, 0, -10 },
  { 253, 7, 10, 8, 0, -10 },
  { 262, 7, 10, 7, 0, -10 },
  { 271, 7, 10, 6, 0, -10 },
  { 280, 8, 10, 8, 0, -10 },
  { 290, 9, 10, 8, 0, -10 },
  { 302, 4, 10, 4, 0, -10 },
  { 307, 7, 10, 7, 0, -10 },
  { 316, 9, 10, 8, 0, -10 },
  { 328, 6, 10, 7, 0, -10 },
  { 336, 11, 10, 10, 0, -10 },
  { 350, 9, 10, 8, 0, -10 },
  { 362, 8, 10, 8, 0, -10 },
  { 372, 8, 10, 8, 0, -10 },
  { 382, 8, 12, 8, 0, -10 },
  { 394, 8, 10, 8, 0, -10 },
  { 404, 8, 10, 7, 0, -10 },
  { 414, 7, 10, 8, 1, -10 },
  { 423, 8, 10, 8, 0, -10 },
  { 433, 8, 10, 8, 1, -10 },
  { 443, 10, 10, 10, 1, -10 },
  { 456, 9, 10, 8, -1, -10 },
  { 468, 8, 10, 8, 1, -10 },
  { 478, 8, 10, 7, 0, -10 },
  { 488, 5, 14, 4, 0, -12 },
  { 497, 4, 11, 5, 1, -10 },
  { 503, 5, 14, 4, -1, -12 },
  { 512, 5, 5, 5, 0, -10 },
  { 516, 6, 2, 5, -1, 0 },
  { 518, 4, 2, 5, 1, -10 },
  { 519, 6, 8, 6, 0, -8 },
  { 525, 6, 11, 7, 0, -11 },
  { 534, 6, 8, 6, 0, -8 },
  { 540, 7, 11, 7, 0, -11 },
  { 550, 6, 8, 7, 0, -8 },
  { 556, 5, 11, 5, 0, -11 },
  { 563, 7, 11, 7, 0, -8 },
  { 573, 6, 11, 7, 0, -11 },
  { 582, 4, 11, 4, 0, -11 },
  { 588, 6, 14, 3, -2, -11 },
  { 599, 7, 11, 7, 0, -11 },
  { 609, 4, 11, 4, 0, -11 },
  { 615, 10, 8, 10, 0, -8 },
  { 625, 6, 8, 7, 0, -8 },
  { 631, 6, 8, 7, 0, -8 },
  { 637, 7, 11, 7, -1, -8 },
  { 647, 7, 11, 7, 0, -8 },
  { 657, 5, 8, 5, 0, -8 },
  { 662, 6, 8, 6, 0, -8 },
  { 668, 5, 9, 4, 0, -9 },
  { 674, 7, 8, 7, 0, -8 },
  { 681, 6, 8, 6, 1, -8 },
  { 687, 8, 8, 8, 1, -8 },
  { 695, 8, 8, 6, -1, -8 },
  { 703, 7, 11, 6, 0, -8 },
  { 713, 6, 8, 6, 0, -8 },
  { 719, 4, 13, 4, 0, -11 },
  { 726, 3, 12, 3, 0, -10 },
  { 731, 4, 13, 4, 0, -11 },
  { 738, 7, 3, 7, 0, -6 },
};

const GFXfont RobotoCondensed_BlackItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_BLACKITALIC14PT7B_H_
