#ifndef _ROBOTOCONDENSED_BLACKITALIC7PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xD8, 0x07, 0x6E, 0xC0, 0x2D, 0xBB, 0xD0, 0x99, 0x76,
  0x66, 0x4A, 0xE0, 0xC0, 0x16, 0xA8, 0x55, 0x60, 0x0D, 0x80, 0x5D, 0x20,
  0xC0, 0x40, 0x80, 0x02, 0x24, 0x40, 0x6E, 0xD6, 0xDE, 0x80, 0x7C, 0xAE,
  0x65, 0x9E, 0x2D, 0xF2, 0x6B, 0x9E, 0x6B, 0xD6, 0x72, 0x24, 0xC0, 0x6D,
  0xDE, 0x6D, 0x94, 0x42, 0x42, 0x80, 0x3B, 0x00, 0xFC, 0x0F, 0x80, 0x65,
  0x04, 0x32, 0x6F, 0xBF, 0x41, 0x80, 0x26, 0x6F, 0xB0, 0x75, 0xEA, 0xE0,
  0x75, 0x8B, 0x60, 0x65, 0xFA, 0xE0, 0x74, 0xE8, 0xE0, 0x74, 0xE8, 0x80,
  0x75, 0xFB, 0x60, 0x55, 0xF9, 0xB0, 0x5E, 0x80, 0x22, 0x2A, 0xE0, 0x56,
  0xEE, 0xA0, 0x4B, 0x4E, 0x4A, 0xEF, 0x5B, 0x80, 0x55, 0xDB, 0xB0, 0x75,
  0x99, 0x60, 0x75, 0xF8, 0x80, 0x75, 0xD9, 0x62, 0x75, 0xEA, 0xA0, 0x65,
  0x6A, 0xE0, 0x72, 0x64, 0x40, 0x55, 0xDB, 0xE0, 0x55, 0x66, 0x60, 0xDD,
  0xDA, 0xA0, 0x56, 0x66, 0xA0, 0xBB, 0x48, 0x72, 0x64, 0xE0, 0x57, 0xA8,
  0x55, 0x40, 0x57, 0xA8, 0x4A, 0x80, 0xC0, 0x80, 0x66, 0xF0, 0x4E, 0xDE,
  0x76, 0x70, 0x26, 0xAA, 0xE0, 0x77, 0xF0, 0x79, 0x48, 0x76, 0xFE, 0x4E,
  0xDA, 0x5E, 0x80, 0x25, 0xA4, 0x80, 0x46, 0xEE, 0xA0, 0x5E, 0x80, 0x7D,
  0x6B, 0x60, 0x76, 0xD0, 0x76, 0xF0, 0x76, 0xF8, 0x76, 0xF2, 0x5A, 0x40,
  0x71, 0xF0, 0x76, 0xC0, 0x76, 0xF0, 0xB5, 0x20, 0xBB, 0xFE, 0xED, 0x50,
  0xB5, 0x2C, 0x00, 0x6D, 0x70, 0x5A, 0xA0, 0x5A, 0xA0, 0x56, 0xA0, 0x54,
};

const GFXglyph RobotoCondensed_BlackItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 2, 0, -5 },
  { 4, 4, 5, 3, 0, -5 },
  { 7, 3, 7, 3, 0, -6 },
  { 10, 3, 5, 4, 1, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 0, -5 },
  { 16, 2, 8, 2, 0, -6 },
  { 18, 2, 7, 2, 0, -5 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 3, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 4, 5, 2, -1, -5 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 2, 5, 3, 1, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 4, 5, 3, 0, -5 },
  { 47, 3, 5, 3, 0, -5 },
  { 49, 3, 5, 3, 0, -5 },
  { 51, 2, 4, 2, 0, -4 },
  { 52, 2, 5, 2, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 2, 4, 0, -3 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 5, 3, 0, -5 },
  { 61, 5, 7, 5, 0, -5 },
  { 66, 4, 5, 4, 0, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 4, 5, 4, 0, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 4, 5, 3, 0, -5 },
  { 81, 4, 5, 3, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 2, 5, 2, 0, -5 },
  { 92, 4, 5, 3, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 3, 5, 3, 0, -5 },
  { 100, 5, 5, 5, 0, -5 },
  { 104, 4, 5, 4, 0, -5 },
  { 107, 4, 5, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 4, 6, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 4, 5, 4, 0, -5 },
  { 131, 4, 5, 5, 1, -5 },
  { 134, 4, 5, 4, 0, -5 },
  { 137, 3, 5, 4, 1, -5 },
  { 139, 4, 5, 4, 0, -5 },
  { 142, 2, 7, 2, 0, -6 },
  { 144, 2, 5, 3, 0, -5 },
  { 146, 2, 7, 2, 0, -6 },
  { 148, 3, 3, 3, 0, -5 },
  { 150, 2, 1, 3, 0, 0 },
  { 151, 1, 1, 2, 1, -5 },
  { 152, 3, 4, 3, 0, -4 },
  { 154, 3, 5, 3, 0, -5 },
  { 156, 3, 4, 3, 0, -4 },
  { 158, 4, 5, 3, 0, -5 },
  { 161, 3, 4, 3, 0, -4 },
  { 163, 3, 5, 2, 0, -5 },
  { 165, 3, 5, 3, 0, -4 },
  { 167, 3, 5, 3, 0, -5 },
  { 169, 2, 5, 2, 0, -5 },
  { 171, 3, 7, 2, -1, -5 },
  { 174, 4, 5, 3, 0, -5 },
  { 177, 2, 5, 2, 0, -5 },
  { 179, 5, 4, 5, 0, -4 },
  { 182, 3, 4, 3, 0, -4 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 3, 5, 3, 0, -4 },
  { 188, 3, 5, 3, 0, -4 },
  { 190, 3, 4, 2, 0, -4 },
  { 192, 3, 4, 3, 0, -4 },
  { 194, 2, 5, 2, 0, -5 },
  { 196, 3, 4, 3, 0, -4 },
  { 198, 3, 4, 3, 0, -4 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 3, 4, 3, 0, -4 },
  { 204, 3, 6, 3, 0, -4 },
  { 207, 3, 4, 3, 0, -4 },
  { 209, 2, 6, 2, 0, -5 },
  { 211, 2, 6, 2, 0, -5 },
  { 213, 2, 6, 2, 0, -5 },
  { 215, 3, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_BlackItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_BLACKITALIC7PT7B_H_
