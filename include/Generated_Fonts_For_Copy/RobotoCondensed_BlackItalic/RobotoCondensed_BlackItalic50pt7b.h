#ifndef _ROBOTOCONDENSED_BLACKITALIC50PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x3F, 0x3E,
  0x3F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF8,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x01,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x79, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0xCF, 0x80, 0x03, 0xE7,
  0xC0, 0x01, 0xF3, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xF9, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x0F, 0xF0,
  0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7E, 0xFC, 0x18, 0x7C, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x7C, 0x7C,
  0xF8, 0x7C, 0xF8, 0xF8, 0x7C, 0xF8, 0xF8, 0xFD, 0xF0, 0xF8, 0xFB, 0xE0,
  0x7D, 0xFB, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xBF,
  0x07, 0xDF, 0x1F, 0x0F, 0xDF, 0x1F, 0x0F, 0x9F, 0x1F, 0x1F, 0x3F, 0x1F,
  0x3E, 0x3E, 0x1F, 0x3E, 0x3E, 0x1F, 0x7C, 0x1F, 0x3E, 0x38, 0x1F, 0x7E,
  0x08, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F,
  0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x1F, 0xFF, 0x9F, 0xCF, 0xFF, 0xE7, 0xF3,
  0xFF, 0xFD, 0xFD, 0xFE, 0xFF, 0xFE, 0x7F, 0x9F, 0xFF, 0x9F, 0xE7, 0xFF,
  0xE7, 0xF8, 0xFF, 0xF1, 0xFE, 0x1F, 0xFC, 0x7F, 0x87, 0xFE, 0x1F, 0xE1,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xF1, 0xFE, 0x00, 0xC0, 0x00,
  0x00, 0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x7C, 0xF8, 0x00, 0x02, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x40, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x03, 0x83, 0xC1, 0xCF, 0x8F, 0x1F, 0x7F, 0xBF, 0xFD,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xF7, 0xC0, 0x1F, 0x9F, 0x00, 0xFE, 0x3E,
  0x07, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x0C, 0x07, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x03,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8,
  0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x01, 0x80, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFE, 0x7F, 0xFB, 0xFF, 0xE0, 0x3E, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFC, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0x3F,
  0x87, 0xF8, 0xFF, 0x1F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xF8, 0x1F, 0xCF,
  0xE0, 0xFF, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0,
  0xFF, 0x7F, 0x83, 0xFD, 0xFC, 0x0F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE,
  0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFC, 0xFE,
  0x07, 0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xF8, 0xFF, 0x1F,
  0xE1, 0xFC, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x1F,
  0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x71, 0xFC, 0xC1, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0x87, 0xFC, 0x7F,
  0xDF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0xFF,
  0x00, 0xFD, 0xFE, 0x03, 0xF3, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0x9F, 0xE0,
  0x7F, 0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xDF, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0x87,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x9F, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFD, 0xF8, 0x1F, 0xDF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xF3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xF0, 0xFF, 0x3F, 0xDF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0x87,
  0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F,
  0x0F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x7F, 0x83, 0xFC, 0xFF, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xF8, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xFC,
  0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF,
  0xF0, 0xFF, 0x0F, 0xF3, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0xFF, 0xBF, 0xC7, 0xF8, 0xFE, 0x7F, 0x87, 0xFB, 0xFC,
  0x3F, 0xDF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0xFB, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0xFE, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x87,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x7F, 0xFF, 0x87,
  0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0x10, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x08, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0x9F, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xFC, 0x1E, 0x0F, 0xC1,
  0xFF, 0xE1, 0xE0, 0xF8, 0x3F, 0xFF, 0x1E, 0x1F, 0x87, 0xFF, 0xE1, 0xE1,
  0xF0, 0x7E, 0x3E, 0x1F, 0x1F, 0x0F, 0xC3, 0xE1, 0xF3, 0xF1, 0xF8, 0x7E,
  0x1F, 0x3E, 0x1F, 0x87, 0xC1, 0xE3, 0xE1, 0xF0, 0x7C, 0x1E, 0x7E, 0x3F,
  0x07, 0xC1, 0xE7, 0xC3, 0xF0, 0xFC, 0x3E, 0x7C, 0x3F, 0x0F, 0x83, 0xE7,
  0xC3, 0xE0, 0xF8, 0x3E, 0x7C, 0x7E, 0x0F, 0x83, 0xC7, 0xC7, 0xE1, 0xF8,
  0x3C, 0x7C, 0x7E, 0x1F, 0x07, 0xCF, 0x87, 0xE1, 0xF0, 0x78, 0xF8, 0x7E,
  0x3F, 0x0F, 0x8F, 0x83, 0xF3, 0xF1, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0x07,
  0xC3, 0xFF, 0xFF, 0xE0, 0x7C, 0x1F, 0xEF, 0xFC, 0x07, 0xC0, 0xFC, 0x7F,
  0x80, 0x7C, 0x02, 0x00, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF9, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0xFF,
  0x3F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F,
  0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC1,
  0xFE, 0x1F, 0xE0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF,
  0x0F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xE1,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xCF, 0xF8, 0x07,
  0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE1, 0xFF, 0xEF, 0xF8, 0x7F, 0xFB, 0xFE, 0x1F, 0xFE, 0xFF, 0x07, 0xFF,
  0xBF, 0xC3, 0xFF, 0xEF, 0xF0, 0xFF, 0xFB, 0xFC, 0x03, 0xFC, 0xFF, 0x00,
  0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF,
  0x81, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0x83, 0xFF,
  0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x81, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE1, 0xFB, 0xF8, 0x1F, 0xEF, 0x87, 0xEF, 0xE0, 0x7F, 0xBE, 0x3F,
  0xFF, 0x81, 0xFC, 0xF8, 0xFD, 0xFE, 0x07, 0xF3, 0xE3, 0xF7, 0xF8, 0x3F,
  0xCF, 0x9F, 0x9F, 0xE0, 0xFF, 0x3E, 0x7E, 0xFF, 0x03, 0xFC, 0xFD, 0xF3,
  0xFC, 0x0F, 0xF3, 0xFF, 0xCF, 0xF0, 0x3F, 0xCF, 0xFF, 0x3F, 0xC0, 0xFF,
  0x3F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0xE7, 0xFC, 0x1F, 0xE1, 0xFF, 0x1F,
  0xE0, 0x7F, 0x87, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE1, 0xFE, 0x07, 0xF8,
  0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xF0, 0xFF,
  0x83, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x3F, 0xC1,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0xFF,
  0xC0, 0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x83, 0xFE, 0x0F, 0xFF,
  0x07, 0xF8, 0x1F, 0xFE, 0x0F, 0xF0, 0x3F, 0xFC, 0x1F, 0xE0, 0x7F, 0xF8,
  0x3F, 0xC0, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0xF1, 0xFF, 0x07, 0xFF, 0xE3,
  0xFC, 0x0F, 0xF7, 0xC7, 0xF8, 0x1F, 0xE7, 0x8F, 0xF0, 0x3F, 0xCF, 0x9F,
  0xE0, 0x7F, 0x9F, 0x7F, 0xC0, 0xFF, 0x3E, 0xFF, 0x83, 0xFE, 0x7D, 0xFE,
  0x07, 0xF8, 0x7F, 0xFC, 0x0F, 0xF0, 0xFF, 0xF8, 0x1F, 0xE1, 0xFF, 0xF0,
  0x3F, 0xC3, 0xFF, 0xE0, 0x7F, 0x87, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x03,
  0xFC, 0x0F, 0xFE, 0x07, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFE,
  0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0x83, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0,
  0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB,
  0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFD, 0xFE, 0x00,
  0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x9F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xF7,
  0xFC, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01,
  0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F,
  0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F,
  0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x87, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF0,
  0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF,
  0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0,
  0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE,
  0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F,
  0xCF, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0x7F,
  0x81, 0xFF, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x3F,
  0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F,
  0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF9, 0xFE, 0x00,
  0x3F, 0xBF, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x07, 0xFB, 0xFC, 0x1F,
  0xE0, 0xFF, 0x7F, 0x83, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x87, 0xF9, 0xFE,
  0x1F, 0xF0, 0xFF, 0x3F, 0xC3, 0xFE, 0x3F, 0xE7, 0xF8, 0xFF, 0xC7, 0xF8,
  0xFF, 0x1F, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0xE7,
  0xF8, 0x7F, 0x9F, 0xFC, 0xFF, 0x0F, 0xF3, 0xFF, 0x9F, 0xE1, 0xFE, 0xFF,
  0xF7, 0xF8, 0x3F, 0xDF, 0xFE, 0xFF, 0x07, 0xFB, 0xFF, 0xDF, 0xE0, 0xFF,
  0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0x00, 0xFF, 0xFB,
  0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xFC, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x3F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F,
  0xE0, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF8, 0x0F,
  0xF9, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xF8,
  0x3F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x87, 0xFC, 0x0F, 0xF1, 0xFE, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07, 0xF7, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F,
  0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07,
  0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0xFC, 0xF8,
  0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x3F, 0x7E,
  0x0F, 0xDF, 0x83, 0xF0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x3F, 0x83,
  0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0x9F, 0xE3, 0xF8, 0xFF, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xF9, 0xFF, 0xBF, 0xCF, 0xF1,
  0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFE, 0x3F, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xDF,
  0xE0, 0x7C, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x7E, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xCF, 0xF8, 0xFF,
  0x0F, 0xF1, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0,
  0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F,
  0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFE, 0x3F, 0xE7, 0xFC,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xF7, 0xFF, 0x0F,
  0xE7, 0xFC, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x3F,
  0xCF, 0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xF9, 0xFE, 0x7F, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0x1F, 0xE0, 0x3F, 0xEF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F,
  0x83, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x9F, 0xE7, 0xF0, 0x7F, 0x7F,
  0x83, 0xFB, 0xFC, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x61, 0xFF, 0x9F, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0xEF, 0xE0, 0x3F, 0xFB,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0x9F, 0xF0, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x10, 0x0F,
  0xF0, 0x07, 0x07, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xBF, 0x01, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x0F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFE,
  0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0xFF,
  0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF0, 0x7F, 0x9F, 0xE0,
  0xFF, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x5F,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xC3,
  0xFC, 0x7F, 0xE0, 0xFE, 0x3F, 0xF0, 0x7F, 0x8F, 0xF8, 0x1F, 0xE7, 0xFC,
  0x07, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F,
  0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE3, 0xE0, 0x7E, 0x03, 0xFB, 0xFE, 0x7F,
  0xC0, 0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x3F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xF0, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0x0F, 0xF3, 0xFC,
  0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0x3F, 0x8F,
  0xF0, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE1, 0xFE,
  0x7F, 0x87, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x87,
  0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC,
  0x3F, 0xCF, 0xF0, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xC3, 0xF8, 0xFF, 0x0F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x80, 0x07, 0xF1, 0xF0, 0x0F, 0xEF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFE, 0x7F, 0x87, 0xF0, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xCF,
  0xF0, 0x7F, 0x9F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF,
  0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x07, 0xF9, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFE, 0x7F, 0x9F, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFB, 0xFC, 0x1F,
  0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xF8, 0x1F, 0xCF,
  0xF0, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF9,
  0xF8, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFE, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xFE, 0x7F,
  0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xDF, 0xF0, 0x1F, 0xE7, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x0F, 0xF9, 0xFC, 0x3F, 0xF7, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xF1, 0xFF, 0x3F,
  0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8,
  0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0x07,
  0xF8, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF8, 0xFF,
  0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE7, 0xC3, 0xFB, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE7, 0xF0, 0xFF, 0x3F, 0x83, 0xF9,
  0xFC, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFA, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F,
  0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xF0,
  0xFF, 0x1F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF1, 0xFE, 0x1F,
  0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFE,
  0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xFC, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F,
  0xC7, 0xF1, 0xFE, 0x1F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0xFF, 0x07,
  0xF3, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0x87, 0xFF,
  0xF0, 0xFC, 0x3F, 0xBF, 0x8F, 0xE3, 0xFD, 0xFC, 0x7F, 0x1F, 0xCF, 0xE3,
  0xF8, 0xFE, 0x7F, 0x3F, 0xCF, 0xF3, 0xF9, 0xFE, 0x7F, 0x1F, 0xDF, 0xF3,
  0xF8, 0xFE, 0xFF, 0x9F, 0xC7, 0xF7, 0xFD, 0xFC, 0x3F, 0x7F, 0xEF, 0xE1,
  0xFB, 0xFF, 0x7F, 0x0F, 0xDF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0x7F,
  0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80,
  0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x81, 0xFE,
  0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF9, 0xFE, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xC0,
  0x1F, 0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x8F,
  0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF, 0x1F, 0xE0,
  0x7F, 0x8F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF7, 0xF8,
  0x07, 0xFB, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0x00, 0x03, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x60, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0xFC, 0xFF, 0xC1, 0xF3, 0xFF, 0xC7, 0xE7, 0xFF, 0xDF,
  0xDF, 0xFF, 0xFF, 0xBF, 0xBF, 0xFE, 0x7E, 0x3F, 0xFC, 0xF8, 0x3F, 0xF1,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_BlackItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 36, 13, 0, -36 },
  { 69, 16, 14, 15, 2, -38 },
  { 97, 25, 36, 25, 0, -36 },
  { 210, 24, 46, 25, 1, -41 },
  { 348, 24, 36, 31, 4, -36 },
  { 456, 26, 37, 29, 0, -36 },
  { 577, 8, 14, 8, 2, -38 },
  { 591, 16, 50, 16, 2, -39 },
  { 691, 16, 50, 16, -2, -39 },
  { 791, 22, 22, 23, 2, -36 },
  { 852, 21, 26, 22, 1, -29 },
  { 921, 12, 16, 13, -3, -6 },
  { 945, 14, 6, 20, 3, -18 },
  { 956, 9, 8, 15, 1, -8 },
  { 965, 22, 39, 15, -4, -36 },
  { 1073, 22, 36, 25, 2, -36 },
  { 1172, 16, 36, 25, 5, -36 },
  { 1244, 24, 36, 25, 0, -36 },
  { 1352, 24, 36, 25, 0, -36 },
  { 1460, 23, 36, 25, 1, -36 },
  { 1564, 24, 36, 25, 1, -36 },
  { 1672, 21, 36, 25, 2, -36 },
  { 1767, 24, 36, 25, 2, -36 },
  { 1875, 23, 36, 25, 1, -36 },
  { 1979, 21, 36, 25, 3, -36 },
  { 2074, 12, 27, 14, 1, -27 },
  { 2115, 15, 37, 14, -2, -27 },
  { 2185, 20, 24, 22, 1, -27 },
  { 2245, 21, 17, 25, 2, -24 },
  { 2290, 20, 24, 22, 1, -27 },
  { 2350, 20, 36, 22, 3, -36 },
  { 2440, 36, 45, 37, 0, -34 },
  { 2643, 28, 36, 29, -2, -36 },
  { 2769, 27, 36, 28, 0, -36 },
  { 2891, 26, 36, 28, 2, -36 },
  { 3008, 27, 36, 27, 0, -36 },
  { 3130, 26, 36, 24, 0, -36 },
  { 3247, 26, 36, 23, 0, -36 },
  { 3364, 26, 36, 29, 2, -36 },
  { 3481, 31, 36, 30, 0, -36 },
  { 3621, 14, 36, 14, 0, -36 },
  { 3684, 25, 36, 24, 0, -36 },
  { 3797, 31, 36, 27, 0, -36 },
  { 3937, 21, 36, 23, 0, -36 },
  { 4032, 38, 36, 37, 0, -36 },
  { 4203, 31, 36, 30, 0, -36 },
  { 4343, 27, 36, 29, 2, -36 },
  { 4465, 28, 36, 28, 0, -36 },
  { 4591, 27, 43, 29, 2, -36 },
  { 4737, 27, 36, 27, 0, -36 },
  { 4859, 26, 36, 27, 1, -36 },
  { 4976, 25, 36, 27, 4, -36 },
  { 5089, 28, 36, 28, 1, -36 },
  { 5215, 28, 36, 28, 4, -36 },
  { 5341, 35, 36, 36, 4, -36 },
  { 5499, 32, 36, 27, -2, -36 },
  { 5643, 26, 36, 27, 4, -36 },
  { 5760, 29, 36, 26, -1, -36 },
  { 5891, 17, 51, 13, -1, -42 },
  { 6000, 13, 39, 19, 4, -36 },
  { 6064, 18, 51, 13, -3, -42 },
  { 6179, 18, 18, 19, 1, -36 },
  { 6220, 19, 6, 19, -3, 0 },
  { 6235, 12, 8, 16, 5, -38 },
  { 6247, 21, 26, 23, 0, -26 },
  { 6316, 23, 38, 24, 0, -38 },
  { 6426, 21, 26, 22, 1, -26 },
  { 6495, 25, 38, 24, 1, -38 },
  { 6614, 21, 26, 23, 1, -26 },
  { 6683, 18, 39, 16, 1, -39 },
  { 6771, 26, 36, 25, -1, -26 },
  { 6888, 23, 38, 24, -1, -38 },
  { 6998, 14, 37, 13, 0, -37 },
  { 7063, 20, 47, 12, -6, -37 },
  { 7181, 26, 38, 24, 0, -38 },
  { 7305, 14, 38, 13, 0, -38 },
  { 7372, 34, 26, 36, 0, -26 },
  { 7483, 23, 26, 24, -1, -26 },
  { 7558, 22, 26, 24, 1, -26 },
  { 7630, 25, 36, 24, -2, -26 },
  { 7743, 23, 36, 24, 1, -26 },
  { 7847, 18, 26, 17, 0, -26 },
  { 7906, 21, 26, 22, 0, -26 },
  { 7975, 14, 33, 15, 2, -33 },
  { 8033, 23, 26, 24, 1, -26 },
  { 8108, 22, 26, 22, 2, -26 },
  { 8180, 29, 26, 30, 3, -26 },
  { 8275, 26, 26, 22, -2, -26 },
  { 8360, 25, 36, 22, -1, -26 },
  { 8473, 23, 26, 22, -1, -26 },
  { 8548, 15, 48, 14, 1, -39 },
  { 8638, 11, 43, 12, 1, -36 },
  { 8698, 16, 48, 14, -2, -39 },
  { 8794, 23, 11, 26, 2, -20 },
};

const GFXfont RobotoCondensed_BlackItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_BLACKITALIC50PT7B_H_
