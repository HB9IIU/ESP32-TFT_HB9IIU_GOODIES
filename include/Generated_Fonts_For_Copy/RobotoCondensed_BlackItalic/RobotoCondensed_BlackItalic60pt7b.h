#ifndef _ROBOTOCONDENSED_BLACKITALIC60PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x00, 0x08, 0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x00,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x3F, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x7C, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E,
  0x3F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x1F,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xE7, 0xE0, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF9, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0xFF,
  0xC3, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x81,
  0xFC, 0xFC, 0x0F, 0x0F, 0xC3, 0xE0, 0x7E, 0x7E, 0x1F, 0x07, 0xE7, 0xE1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF3,
  0xF0, 0x7E, 0x1F, 0x9F, 0x83, 0xF1, 0xFD, 0xF8, 0x0F, 0xFF, 0xDF, 0x80,
  0x7F, 0xFE, 0xFC, 0x01, 0xFF, 0xEF, 0xC0, 0x0F, 0xFE, 0xFC, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x18, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x04, 0x00, 0x03, 0xF3, 0xFC,
  0x00, 0x1F, 0xBF, 0xF0, 0x01, 0xFB, 0xFF, 0xC0, 0x1F, 0xBF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xDF, 0xCF, 0xC0, 0xFC, 0xFC, 0x3E, 0x07, 0xE7,
  0xE1, 0xF8, 0x7E, 0x7F, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87,
  0xE3, 0xF0, 0xFC, 0x3F, 0x3F, 0x07, 0xE1, 0xF8, 0xF8, 0x3F, 0x9F, 0xC3,
  0x80, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFF,
  0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE,
  0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFE, 0x0F, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xF9, 0xFE, 0x3F, 0xEF,
  0xFD, 0xFE, 0x3F, 0xEF, 0xFF, 0xFE, 0x7F, 0xE7, 0xFF, 0xFC, 0x7F, 0xE7,
  0xFF, 0xFC, 0x7F, 0xE3, 0xFF, 0xFC, 0x7F, 0xC3, 0xFF, 0xF8, 0x7F, 0xC1,
  0xFF, 0xF8, 0x7F, 0xC1, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xE1,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xCF, 0xFC, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x8F, 0xC7,
  0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0xE0, 0x7E, 0x06, 0x3E, 0x1F, 0x0F, 0x9F, 0xE7, 0xCF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0xFE, 0x7C, 0x00, 0x7F, 0x9F, 0x80, 0x3F, 0xC3, 0xF0, 0x1F,
  0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x78, 0x07, 0xC0, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xE0, 0x06,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x7F,
  0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF,
  0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xCF, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF,
  0x3F, 0xE0, 0x7F, 0xE7, 0xFC, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0x9F, 0xF0,
  0x3F, 0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3,
  0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8, 0x1F, 0xFB, 0xFF, 0x03,
  0xFE, 0x7F, 0xE0, 0x7F, 0xCF, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F,
  0xE0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3F, 0xF0,
  0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0x8F, 0xF9, 0xC1, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x0F, 0xFC,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F,
  0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x87,
  0xFE, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xEF, 0xF8, 0x00, 0xFE, 0xFF, 0x80, 0x1F, 0xCF, 0xF8,
  0x03, 0xFD, 0xFF, 0x80, 0x3F, 0x9F, 0xF8, 0x07, 0xF9, 0xFF, 0x00, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x3F, 0xE3, 0xFF,
  0x03, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x7E, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0x87, 0xFE, 0x00, 0x18, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF,
  0xC7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0x00, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFE, 0x1F, 0xF9, 0xFF,
  0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F,
  0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x9F, 0xE0, 0x7F, 0xC7, 0xFC,
  0x3F, 0xF1, 0xFF, 0x1F, 0xFC, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0xFF,
  0xC0, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x87, 0xFC, 0x1F,
  0xF8, 0x7F, 0xE3, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xF1,
  0xFF, 0x1F, 0xF0, 0xFF, 0x9F, 0xF8, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xFC,
  0x0F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF,
  0xF8, 0x1F, 0xF7, 0xFE, 0x1F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xBF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xFF, 0xC1, 0xF0, 0x3F, 0x83, 0xFF, 0xFC, 0x3E, 0x07, 0xE0, 0x7F,
  0xFF, 0x87, 0xE1, 0xFC, 0x1F, 0xFF, 0xF0, 0xFC, 0x3F, 0x07, 0xF8, 0xFE,
  0x1F, 0x8F, 0xE0, 0xFE, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xCF, 0xE1, 0xFC, 0x1F, 0xC1, 0xF9, 0xF8,
  0x3F, 0x83, 0xF0, 0x3E, 0x3F, 0x0F, 0xE0, 0x7E, 0x07, 0xC7, 0xE1, 0xFC,
  0x0F, 0xC0, 0xF9, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0x7E,
  0x07, 0xE7, 0xE1, 0xFE, 0x0F, 0xC0, 0xF8, 0xFC, 0x3F, 0x81, 0xF8, 0x1F,
  0x1F, 0x87, 0xF0, 0x7F, 0x07, 0xE3, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x7E,
  0x1F, 0xC1, 0xF8, 0x1F, 0x0F, 0xC3, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x7F,
  0x0F, 0xE0, 0xF8, 0x3F, 0x0F, 0xF3, 0xFC, 0x3F, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x83, 0xFF, 0xBF, 0xFC,
  0x03, 0xF0, 0x3F, 0xE3, 0xFF, 0x00, 0x7E, 0x03, 0xF8, 0x3F, 0xC0, 0x0F,
  0xC0, 0x08, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0E, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x03,
  0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x03,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07,
  0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF,
  0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0xFE, 0x7F, 0xE0, 0xFF, 0xFE,
  0x7F, 0xE0, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xFC,
  0xFF, 0xC1, 0xFF, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8,
  0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xFD, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00,
  0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xFE, 0x7F,
  0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x03,
  0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xE0,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFB, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xEF, 0xE0, 0xFE, 0xFF, 0x80,
  0xFF, 0xBF, 0x83, 0xFF, 0xFE, 0x03, 0xFE, 0xFE, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFB, 0xF8, 0x7F, 0x7F, 0xC0, 0x7F, 0xEF, 0xE3, 0xFD, 0xFF, 0x01, 0xFF,
  0xBF, 0x8F, 0xEF, 0xFC, 0x07, 0xFC, 0xFE, 0x3F, 0xBF, 0xF0, 0x1F, 0xF3,
  0xF9, 0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xE7, 0xF3, 0xFE, 0x01, 0xFF, 0x3F,
  0xBF, 0xCF, 0xF8, 0x0F, 0xFC, 0x7E, 0xFE, 0x7F, 0xE0, 0x3F, 0xF1, 0xFB,
  0xF9, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x1F, 0xFF,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0xE3,
  0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xEF, 0x87, 0xFE, 0x03,
  0xFF, 0x7E, 0x3F, 0xF0, 0x1F, 0xFB, 0xF1, 0xFF, 0x80, 0xFF, 0x9F, 0x8F,
  0xF8, 0x0F, 0xFC, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xF7, 0xFE, 0x03, 0xFF,
  0x1F, 0xBF, 0xF0, 0x1F, 0xF8, 0xFD, 0xFF, 0x80, 0xFF, 0xC7, 0xEF, 0xFC,
  0x07, 0xFC, 0x3F, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xFC, 0x07,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F,
  0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x3F,
  0xF0, 0x03, 0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xFD, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03,
  0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x3F,
  0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xDF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x8F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x1F,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x3F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x1F,
  0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xF9, 0xFF,
  0x80, 0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xC7,
  0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xEF, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF7, 0xFC, 0x1F, 0xFC, 0x1F, 0xFB, 0xFE, 0x0F, 0xFE, 0x0F,
  0xF9, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0xFF, 0x87, 0xFF, 0x87, 0xFE, 0x7F,
  0xC3, 0xFF, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0xE3, 0xFF, 0x1F, 0xF1, 0xFF,
  0xF1, 0xFF, 0x8F, 0xF8, 0xFF, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xFC, 0xFF,
  0xC3, 0xFE, 0x7F, 0xFE, 0x7F, 0xE1, 0xFF, 0x3F, 0xFF, 0x3F, 0xE0, 0xFF,
  0x9F, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xFF, 0xDF, 0xF8, 0x3F, 0xEF, 0xFF,
  0xEF, 0xF8, 0x1F, 0xF7, 0xFF, 0xF7, 0xFC, 0x0F, 0xFB, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xBF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xDF, 0xFF, 0xE0, 0x1F, 0xFF, 0xEF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0x03, 0xFF,
  0xF9, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xC7, 0xFE, 0x00,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07,
  0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xF3,
  0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x01, 0xFE,
  0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFB,
  0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFE, 0x7E, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0, 0x7E, 0x3F,
  0x83, 0xF3, 0xFC, 0x1F, 0x9F, 0xC0, 0xFD, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE,
  0x03, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF7, 0xFE, 0x1F, 0xF8, 0xFF, 0x87, 0xFE, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x9F, 0xF1, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFF, 0x3F, 0xF0,
  0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F,
  0xE1, 0xFF, 0x8F, 0xFD, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xE3,
  0xFE, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF,
  0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xF1, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE3, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xE3, 0xFF, 0x03, 0xFE, 0x3F,
  0xF0, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xDF, 0xFF, 0x07,
  0xF9, 0xFF, 0xC0, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F,
  0xF1, 0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7,
  0xFC, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF9, 0xFF, 0x07,
  0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0xE3, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x08, 0x3F, 0xF0, 0x07, 0xFC,
  0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x01, 0xFF, 0xEF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0,
  0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x1F, 0xF3, 0xFE,
  0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x1F, 0xF7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x40, 0x7F, 0xC0, 0x30, 0x1F,
  0xF8, 0x3E, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0x7F, 0xC0,
  0x7F, 0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFC,
  0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE,
  0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xE3,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0xC7, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x08, 0x03, 0xFF, 0x00, 0x7C, 0x3F, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x08, 0x00, 0x3F,
  0xEF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83,
  0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x3F, 0xF1,
  0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE,
  0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF,
  0xC1, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x0F, 0xFF, 0x03, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x1F, 0xFC, 0x07, 0xFE,
  0x3F, 0xF8, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFC, 0x7F, 0xF0, 0x07, 0xFC,
  0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB,
  0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xE1,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xFE, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xFF,
  0xFB, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF8, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x8F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF1, 0xFF,
  0x87, 0xFE, 0x0F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF,
  0x87, 0xFE, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC7, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE3, 0xFE, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC7, 0xF8, 0x07, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF,
  0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x3F,
  0xF1, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7,
  0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xF8, 0xFF, 0x8F, 0xFC, 0x1F,
  0xF3, 0xFE, 0x07, 0xFD, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF0,
  0x1F, 0xF7, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF,
  0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFC, 0xFF, 0x81,
  0xFF, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0x7F, 0xF8, 0x07, 0xFD, 0xFF, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF,
  0xC0, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1F, 0xF1, 0xFF, 0x03, 0xFF, 0x9F, 0xE0, 0x7F, 0xF9, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF,
  0x8F, 0xFC, 0x0F, 0xF8, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0xFF,
  0x81, 0xFF, 0x8F, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F,
  0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF7, 0xFC, 0x00, 0x08, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFB, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xF1, 0xFF, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF,
  0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x01, 0x80, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF,
  0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x7F,
  0xE3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x87,
  0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x7F, 0xEF, 0xF8, 0x1F, 0xFB, 0xFE,
  0x0F, 0xFC, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0xFF, 0x8F, 0xFC, 0x7F, 0xE1,
  0xFF, 0x1F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF3, 0xFF, 0x07, 0xFC, 0xFF,
  0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xDF, 0xF8, 0x1F, 0xF7, 0xFC, 0x07, 0xFD,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x83, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0x7F, 0xC3,
  0xFC, 0x3F, 0xEF, 0xF8, 0x7F, 0x87, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F,
  0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0xFF, 0xC7, 0xF8, 0xFF, 0x9F, 0xF9, 0xFF,
  0x1F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0xFF, 0xE7, 0xF8, 0x7F, 0x9F, 0xFC,
  0xFF, 0x0F, 0xF3, 0xFF, 0xBF, 0xE0, 0xFE, 0xFF, 0xF7, 0xF8, 0x1F, 0xDF,
  0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xBF, 0xFF, 0x01, 0xFF, 0xF7, 0xFF, 0xE0, 0x3F, 0xFC, 0xFF, 0xF8,
  0x07, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x3F, 0xF0,
  0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0x80, 0x0F,
  0xFD, 0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x07,
  0xFC, 0x7F, 0xC0, 0x1F, 0xF3, 0xFF, 0x00, 0x7F, 0xCF, 0xFC, 0x01, 0xFF,
  0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0x80, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x1F, 0xFC,
  0x07, 0xE1, 0xFF, 0xE0, 0x7E, 0x3F, 0xFF, 0x0F, 0xE7, 0xFF, 0xF0, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xCF, 0xE0,
  0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0x8F, 0xE0, 0x7F, 0xF0, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_BlackItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 44, 15, 1, -43 },
  { 89, 20, 17, 18, 2, -45 },
  { 132, 30, 43, 30, 0, -43 },
  { 294, 28, 57, 30, 2, -50 },
  { 494, 29, 45, 37, 5, -44 },
  { 658, 32, 45, 35, 0, -44 },
  { 838, 9, 17, 9, 3, -45 },
  { 858, 18, 60, 19, 3, -47 },
  { 993, 20, 60, 19, -3, -47 },
  { 1143, 26, 26, 27, 3, -43 },
  { 1228, 26, 30, 27, 1, -35 },
  { 1326, 13, 19, 16, -3, -7 },
  { 1357, 16, 8, 25, 4, -23 },
  { 1373, 11, 11, 18, 1, -10 },
  { 1389, 26, 47, 18, -4, -43 },
  { 1542, 27, 45, 30, 2, -44 },
  { 1694, 19, 43, 30, 6, -43 },
  { 1797, 29, 44, 30, 0, -44 },
  { 1957, 29, 45, 30, 0, -44 },
  { 2121, 28, 43, 30, 1, -43 },
  { 2272, 29, 44, 30, 1, -43 },
  { 2432, 26, 44, 30, 2, -43 },
  { 2575, 29, 43, 30, 2, -43 },
  { 2731, 28, 45, 30, 1, -44 },
  { 2889, 25, 44, 30, 4, -44 },
  { 3027, 15, 34, 17, 1, -33 },
  { 3091, 19, 45, 17, -3, -33 },
  { 3198, 24, 29, 26, 1, -33 },
  { 3285, 26, 21, 30, 2, -29 },
  { 3354, 24, 29, 26, 1, -32 },
  { 3441, 23, 45, 27, 4, -44 },
  { 3571, 43, 54, 45, 0, -41 },
  { 3862, 35, 43, 35, -3, -43 },
  { 4051, 33, 43, 33, 0, -43 },
  { 4229, 32, 45, 33, 2, -44 },
  { 4409, 32, 43, 33, 0, -43 },
  { 4581, 32, 43, 28, 0, -43 },
  { 4753, 31, 43, 28, 0, -43 },
  { 4920, 32, 45, 34, 2, -44 },
  { 5100, 37, 43, 35, 0, -43 },
  { 5299, 17, 43, 16, 0, -43 },
  { 5391, 30, 44, 29, 0, -43 },
  { 5556, 38, 43, 32, 0, -43 },
  { 5761, 25, 43, 28, 0, -43 },
  { 5896, 46, 43, 44, 0, -43 },
  { 6144, 37, 43, 35, 0, -43 },
  { 6343, 32, 45, 35, 2, -44 },
  { 6523, 33, 43, 33, 0, -43 },
  { 6701, 33, 52, 35, 2, -44 },
  { 6916, 33, 43, 33, 0, -43 },
  { 7094, 31, 45, 32, 1, -44 },
  { 7269, 31, 43, 32, 4, -43 },
  { 7436, 33, 44, 34, 2, -43 },
  { 7618, 34, 43, 34, 4, -43 },
  { 7801, 41, 43, 43, 5, -43 },
  { 8022, 39, 43, 33, -3, -43 },
  { 8232, 31, 43, 32, 5, -43 },
  { 8399, 35, 43, 31, -1, -43 },
  { 8588, 22, 60, 16, -2, -50 },
  { 8753, 16, 47, 22, 4, -43 },
  { 8847, 21, 60, 16, -3, -50 },
  { 9005, 21, 21, 23, 2, -43 },
  { 9061, 23, 7, 23, -4, 0 },
  { 9082, 14, 9, 20, 6, -45 },
  { 9098, 26, 34, 27, 0, -33 },
  { 9209, 28, 46, 29, -1, -45 },
  { 9370, 25, 34, 27, 1, -33 },
  { 9477, 30, 46, 29, 1, -45 },
  { 9650, 26, 34, 28, 1, -33 },
  { 9761, 22, 46, 19, 1, -46 },
  { 9888, 30, 45, 30, -1, -33 },
  { 10057, 28, 45, 29, -1, -45 },
  { 10215, 17, 45, 15, 0, -45 },
  { 10311, 24, 57, 15, -7, -45 },
  { 10482, 32, 45, 29, -1, -45 },
  { 10662, 17, 45, 15, 0, -45 },
  { 10758, 41, 33, 43, 0, -33 },
  { 10928, 28, 33, 29, -1, -33 },
  { 11044, 26, 34, 29, 1, -33 },
  { 11155, 30, 45, 29, -3, -33 },
  { 11324, 28, 45, 29, 1, -33 },
  { 11482, 22, 33, 20, -1, -33 },
  { 11573, 26, 34, 26, 0, -33 },
  { 11684, 18, 41, 18, 2, -40 },
  { 11777, 28, 33, 29, 1, -32 },
  { 11893, 26, 32, 27, 3, -32 },
  { 11997, 35, 32, 36, 3, -32 },
  { 12137, 30, 32, 27, -2, -32 },
  { 12257, 30, 44, 27, -1, -32 },
  { 12422, 28, 32, 27, -1, -32 },
  { 12534, 18, 58, 17, 1, -47 },
  { 12665, 13, 51, 15, 1, -43 },
  { 12748, 18, 58, 17, -2, -47 },
  { 12879, 28, 14, 32, 2, -25 },
};

const GFXfont RobotoCondensed_BlackItalic60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_BLACKITALIC60PT7B_H_
