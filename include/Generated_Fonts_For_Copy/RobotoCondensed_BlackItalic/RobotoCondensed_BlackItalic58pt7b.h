#ifndef _ROBOTOCONDENSED_BLACKITALIC58PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x08,
  0x00, 0x1F, 0x8F, 0xE3, 0xF1, 0xFC, 0xFE, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F,
  0xC7, 0xE1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF,
  0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x30, 0x7E,
  0x3F, 0x07, 0x8F, 0xE3, 0xF0, 0x7C, 0xFC, 0x3F, 0x0F, 0xCF, 0xC3, 0xF1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x0F, 0xC3, 0xE3, 0xF0, 0xFC, 0x7E, 0x7E, 0x0F,
  0xC7, 0xEF, 0xC0, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xDF, 0x80, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xBF, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x10, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x80, 0x00, 0x7E, 0xFF, 0x00, 0x0F, 0xDF, 0xF8, 0x01, 0xFB, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xE0, 0x7E, 0xFE, 0x3E, 0x07,
  0xEF, 0xC3, 0xE0, 0xFC, 0xFC, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xFC,
  0x7E, 0x3F, 0x0F, 0x87, 0xE7, 0xE0, 0xFC, 0x7E, 0x7C, 0x0F, 0xC7, 0xE1,
  0xC0, 0xFF, 0xFC, 0x08, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x07, 0xF0, 0x7F, 0xFE, 0x1F, 0xC3,
  0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF, 0xCF, 0xF3, 0xFF,
  0xFF, 0xBF, 0xDF, 0xFB, 0xFF, 0xFE, 0x7F, 0xCF, 0xFF, 0xF9, 0xFF, 0x1F,
  0xFF, 0xE7, 0xFC, 0x3F, 0xFF, 0x1F, 0xF0, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF,
  0xE1, 0xFF, 0x07, 0xFF, 0x87, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xDF, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x03,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7E, 0x3F, 0x1F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x80,
  0x7C, 0x00, 0x70, 0x3E, 0x0E, 0x7E, 0x1F, 0x3F, 0xBF, 0xEF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xF7, 0xC0,
  0x07, 0xF1, 0xF0, 0x07, 0xF8, 0xFC, 0x07, 0xF8, 0x7E, 0x03, 0xF8, 0x1F,
  0x80, 0x78, 0x0F, 0x80, 0x18, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0, 0x7C,
  0x00, 0xC0, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE1,
  0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F,
  0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8,
  0x1F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F,
  0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF,
  0xBF, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0x81,
  0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF,
  0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x3F,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x7E, 0x7F, 0xCE, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0x87,
  0xFC, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFD, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xEF, 0xF8, 0x01, 0xFD, 0xFF, 0x00, 0x7F, 0x3F, 0xE0,
  0x1F, 0xE7, 0xFC, 0x03, 0xF8, 0xFF, 0x80, 0xFF, 0x3F, 0xE0, 0x3F, 0xC7,
  0xFC, 0x07, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xE0, 0x01, 0xFE,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0x7C, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x83,
  0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0x80, 0x7F, 0xDF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0x9F, 0xF9, 0xFF, 0x07, 0xFD, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x03,
  0xFE, 0x7F, 0x83, 0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x1F, 0xF8,
  0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xFE, 0x3F,
  0xC0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF,
  0x83, 0xFE, 0x3F, 0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F,
  0xE3, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0xC1, 0xFE, 0xFF,
  0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF,
  0x83, 0xFE, 0xFF, 0xC7, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xEF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F,
  0x81, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xE0, 0x04, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xE3, 0xFE, 0xFF, 0x87,
  0xFD, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00,
  0x03, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0xFF, 0xE0, 0x7C,
  0x1F, 0xC0, 0xFF, 0xF8, 0x3E, 0x0F, 0xC0, 0xFF, 0xFE, 0x1F, 0x0F, 0xE0,
  0xFF, 0xFF, 0x0F, 0x87, 0xE0, 0xFF, 0x9F, 0x87, 0xC7, 0xF0, 0x7F, 0x1F,
  0x83, 0xE3, 0xF0, 0x7F, 0x0F, 0xC1, 0xF1, 0xF8, 0x7F, 0x07, 0xE0, 0xF9,
  0xF8, 0x3F, 0x83, 0xF0, 0x7C, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x7E, 0x1F,
  0xC1, 0xF8, 0x1F, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0xBF, 0x07, 0xE0, 0x7E,
  0x0F, 0xDF, 0x87, 0xF0, 0x7F, 0x07, 0xCF, 0xC3, 0xF8, 0x3F, 0x03, 0xE7,
  0xE1, 0xFC, 0x1F, 0x81, 0xF3, 0xF0, 0xFE, 0x0F, 0xC1, 0xF9, 0xF8, 0x7E,
  0x0F, 0xE0, 0xF8, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x7C, 0x1F, 0x83, 0xF0,
  0x7C, 0x3E, 0x0F, 0xC3, 0xF8, 0x3E, 0x1F, 0x07, 0xF1, 0xFC, 0x3F, 0x0F,
  0x83, 0xFF, 0xFF, 0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x7F,
  0xEF, 0xFF, 0x01, 0xF8, 0x1F, 0xE3, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0xFF,
  0x00, 0x7E, 0x00, 0x80, 0x0C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x06, 0x00,
  0x00, 0x1F, 0xFE, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x1F,
  0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0x3F, 0xE7, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x0F,
  0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x9F, 0xF0, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x8F,
  0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x87, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F,
  0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF,
  0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x87,
  0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xF1, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0xCF,
  0xFC, 0x3F, 0xFF, 0x9F, 0xF0, 0x7F, 0xFE, 0x3F, 0xE0, 0xFF, 0xFC, 0xFF,
  0xC1, 0xFF, 0xF9, 0xFF, 0x83, 0xFF, 0xF3, 0xFF, 0x07, 0xFF, 0xE7, 0xFE,
  0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xF0, 0x03, 0xFE,
  0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x00,
  0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xDF, 0xF8,
  0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80,
  0xFF, 0x7F, 0x0F, 0xEF, 0xF8, 0x1F, 0xF3, 0xF0, 0xFE, 0xFF, 0x81, 0xFF,
  0x3F, 0x1F, 0xDF, 0xF0, 0x1F, 0xF3, 0xF1, 0xFD, 0xFF, 0x01, 0xFF, 0x3F,
  0x3F, 0x9F, 0xF0, 0x1F, 0xF3, 0xF3, 0xF9, 0xFF, 0x03, 0xFF, 0x3F, 0x3F,
  0x1F, 0xF0, 0x3F, 0xE3, 0xF7, 0xF3, 0xFF, 0x03, 0xFE, 0x3F, 0x7F, 0x3F,
  0xE0, 0x3F, 0xE3, 0xFF, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xFE, 0x3F, 0xE0,
  0x3F, 0xE3, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x1F, 0xFC, 0x7F, 0xE0, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFC, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFC, 0x07,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFC, 0x07, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0x0F,
  0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xBF, 0x1F, 0xF8, 0x0F, 0xFB,
  0xF1, 0xFF, 0x81, 0xFF, 0x9F, 0x1F, 0xF0, 0x1F, 0xF9, 0xF9, 0xFF, 0x01,
  0xFF, 0x9F, 0x9F, 0xF0, 0x1F, 0xF1, 0xFB, 0xFF, 0x01, 0xFF, 0x0F, 0xBF,
  0xF0, 0x1F, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0,
  0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xFE, 0x03,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xFC, 0x07, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F,
  0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x7F,
  0xCF, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x7F,
  0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0,
  0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07,
  0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1,
  0xFF, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x9F,
  0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF,
  0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0xFF, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07,
  0xFE, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF,
  0xC1, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F,
  0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x3F,
  0xE1, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F,
  0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x1F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xBF,
  0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xE3,
  0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x3F, 0xCF, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0xFF,
  0x87, 0xFF, 0x0F, 0xFC, 0xFF, 0x87, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFF,
  0x0F, 0xF8, 0xFF, 0x8F, 0xFF, 0x1F, 0xF8, 0xFF, 0x8F, 0xFF, 0x1F, 0xF0,
  0xFF, 0x8F, 0xFF, 0x1F, 0xF0, 0xFF, 0x9F, 0xFF, 0x3F, 0xF0, 0xFF, 0x9F,
  0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xFF, 0x3F, 0xE0, 0xFF, 0xBF, 0xFF, 0x3F,
  0xE0, 0xFF, 0xBF, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xFF, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF,
  0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF,
  0x01, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFE, 0x7F, 0xC0,
  0x07, 0xFB, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0x7C, 0x07, 0xE7, 0xC0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE1, 0xFC, 0x7E,
  0x1F, 0xC7, 0xE3, 0xF8, 0x7E, 0x3F, 0x87, 0xE7, 0xF0, 0x7F, 0x7F, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xF3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8,
  0xFF, 0xC7, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFC, 0xFF, 0x8F, 0xFC, 0x7F, 0xCF, 0xFC, 0x3F, 0xE7,
  0xFE, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x0F, 0xFC, 0xFF, 0x87, 0xFC,
  0x7F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xF0, 0x1F, 0xCF, 0xF8, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x3F,
  0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF,
  0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE,
  0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xEF, 0xFF, 0x83,
  0xFC, 0xFF, 0xE0, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE1,
  0xFF, 0x3F, 0xE1, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1,
  0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x83, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x87,
  0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x03, 0xFE,
  0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xF0,
  0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC,
  0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x40,
  0x7F, 0xC0, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xF9, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFE, 0x07,
  0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF,
  0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x31, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x10, 0x0F, 0xFC, 0x01, 0xE0, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFD, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF, 0x03,
  0xFE, 0x3F, 0xE0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F,
  0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFF,
  0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x37,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0x83, 0xFE, 0x1F, 0xFC, 0x0F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x9F, 0xFC, 0x03, 0xFE,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xDF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0xF0, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xF1,
  0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF3, 0xFC, 0x1F, 0xE0, 0x1F, 0xEF, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFD,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF,
  0xE3, 0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8,
  0xFF, 0x83, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87,
  0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0x7F,
  0xCF, 0xF8, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xC3, 0xFF, 0x3F, 0xE0,
  0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8,
  0x3F, 0xE1, 0xFF, 0x9F, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x87,
  0xFC, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0xFF, 0x9F,
  0xE0, 0x1F, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F,
  0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF,
  0x83, 0xFE, 0x3F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF8, 0xFF, 0x83, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0,
  0x3F, 0xE3, 0xFE, 0x0F, 0xFC, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x07,
  0xFE, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x3F,
  0xF0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0x9F, 0xF0,
  0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF7,
  0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x07, 0xFC, 0xFF, 0xC3, 0xFE,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFE, 0x03,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xF0, 0x07, 0xFC,
  0xFF, 0x00, 0x3F, 0xF0, 0x60, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x0F, 0xFC, 0xFF, 0x87, 0xFF, 0xDF,
  0xE0, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFE,
  0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x3F, 0xE0,
  0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3,
  0xFE, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xF0, 0x3F, 0xDF,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFE, 0xE0, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF,
  0x07, 0xFC, 0x7F, 0xC7, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x04, 0x00, 0x0F, 0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0,
  0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87,
  0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0xC7, 0xFC, 0x1F,
  0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF,
  0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xE3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8,
  0x3F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0xBF, 0xE0, 0xFF,
  0xDF, 0xF0, 0x7F, 0xCF, 0xF8, 0x7F, 0xE7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF8, 0x7F, 0x8F, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xE7,
  0xFC, 0x0F, 0xF3, 0xFE, 0x07, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x01, 0xFE,
  0xFF, 0x80, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x1F,
  0xEF, 0xF8, 0x7F, 0x0F, 0xFB, 0xFE, 0x3F, 0xC3, 0xFE, 0xFF, 0x0F, 0xF0,
  0xFF, 0x3F, 0xC3, 0xFC, 0x7F, 0xCF, 0xF1, 0xFF, 0x1F, 0xF3, 0xFC, 0x7F,
  0xC7, 0xF8, 0xFF, 0x3F, 0xF1, 0xFE, 0x3F, 0xCF, 0xFC, 0xFF, 0x0F, 0xF3,
  0xFF, 0x3F, 0xC3, 0xFD, 0xFF, 0xCF, 0xF0, 0xFF, 0x7F, 0xF7, 0xF8, 0x3F,
  0xDF, 0xFD, 0xFE, 0x0F, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xF7, 0xDF, 0xC0,
  0xFF, 0xFD, 0xFF, 0xF0, 0x3F, 0xFE, 0x7F, 0xFC, 0x0F, 0xFF, 0x9F, 0xFE,
  0x03, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFC, 0x7F,
  0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x07,
  0xF9, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFB,
  0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x3F, 0xC7,
  0xFC, 0x01, 0xFE, 0x7F, 0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0xBF, 0xF0,
  0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xFC, 0x7F, 0xF0, 0x3F,
  0x1F, 0xFF, 0x07, 0xE3, 0xFF, 0xE1, 0xFC, 0xFF, 0xFF, 0x7F, 0x9F, 0xFF,
  0xFF, 0xF3, 0xF9, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0x9F, 0xC1, 0xFF, 0xE3,
  0xF0, 0x1F, 0xF8, 0x7E, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoCondensed_BlackItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 42, 15, 1, -41 },
  { 85, 19, 16, 18, 2, -44 },
  { 123, 29, 41, 29, 0, -41 },
  { 272, 27, 55, 29, 2, -48 },
  { 458, 28, 43, 36, 5, -42 },
  { 609, 30, 43, 34, 0, -42 },
  { 771, 9, 16, 9, 3, -44 },
  { 789, 18, 59, 18, 3, -46 },
  { 922, 19, 58, 18, -3, -45 },
  { 1060, 25, 25, 26, 3, -41 },
  { 1139, 25, 30, 26, 1, -34 },
  { 1233, 13, 18, 15, -3, -7 },
  { 1263, 16, 7, 24, 4, -21 },
  { 1277, 10, 10, 17, 1, -9 },
  { 1290, 25, 45, 17, -4, -41 },
  { 1431, 26, 43, 29, 2, -42 },
  { 1571, 19, 41, 29, 6, -41 },
  { 1669, 28, 42, 29, 0, -42 },
  { 1816, 28, 43, 29, 0, -42 },
  { 1967, 27, 41, 29, 1, -41 },
  { 2106, 28, 42, 29, 1, -41 },
  { 2253, 25, 42, 29, 2, -41 },
  { 2385, 28, 41, 29, 2, -41 },
  { 2529, 27, 43, 29, 1, -42 },
  { 2675, 24, 42, 29, 4, -42 },
  { 2801, 14, 33, 17, 1, -32 },
  { 2859, 17, 43, 16, -2, -32 },
  { 2951, 24, 28, 25, 1, -32 },
  { 3035, 25, 19, 29, 2, -27 },
  { 3095, 23, 28, 25, 1, -31 },
  { 3176, 23, 43, 26, 3, -42 },
  { 3300, 41, 53, 43, 0, -40 },
  { 3572, 34, 41, 34, -3, -41 },
  { 3747, 32, 41, 32, 0, -41 },
  { 3911, 31, 43, 32, 2, -42 },
  { 4078, 31, 41, 32, 0, -41 },
  { 4237, 31, 41, 27, 0, -41 },
  { 4396, 30, 41, 27, 0, -41 },
  { 4550, 31, 43, 33, 2, -42 },
  { 4717, 36, 41, 34, 0, -41 },
  { 4902, 17, 41, 16, 0, -41 },
  { 4990, 29, 42, 28, 0, -41 },
  { 5143, 36, 41, 31, 0, -41 },
  { 5328, 24, 41, 27, 0, -41 },
  { 5451, 44, 41, 43, 0, -41 },
  { 5677, 36, 41, 34, 0, -41 },
  { 5862, 31, 43, 34, 2, -42 },
  { 6029, 32, 41, 32, 0, -41 },
  { 6193, 31, 50, 34, 2, -42 },
  { 6387, 32, 41, 32, 0, -41 },
  { 6551, 30, 43, 31, 1, -42 },
  { 6713, 30, 41, 31, 4, -41 },
  { 6867, 32, 42, 33, 2, -41 },
  { 7035, 33, 41, 33, 4, -41 },
  { 7205, 40, 41, 42, 5, -41 },
  { 7410, 37, 41, 32, -2, -41 },
  { 7600, 30, 41, 31, 5, -41 },
  { 7754, 34, 41, 30, -1, -41 },
  { 7929, 21, 58, 15, -2, -48 },
  { 8082, 16, 45, 22, 4, -41 },
  { 8172, 20, 58, 15, -3, -48 },
  { 8317, 20, 21, 23, 2, -41 },
  { 8370, 23, 7, 22, -4, 0 },
  { 8391, 13, 9, 19, 6, -44 },
  { 8406, 25, 33, 26, 0, -32 },
  { 8510, 27, 45, 28, 0, -44 },
  { 8662, 24, 33, 26, 1, -32 },
  { 8761, 29, 45, 28, 1, -44 },
  { 8925, 25, 33, 27, 1, -32 },
  { 9029, 22, 45, 19, 1, -45 },
  { 9153, 29, 44, 29, -1, -32 },
  { 9313, 27, 44, 28, -1, -44 },
  { 9462, 16, 43, 15, 0, -43 },
  { 9548, 23, 55, 14, -7, -43 },
  { 9707, 30, 44, 28, 0, -44 },
  { 9872, 17, 44, 15, 0, -44 },
  { 9966, 39, 32, 41, 0, -32 },
  { 10122, 27, 32, 28, -1, -32 },
  { 10230, 25, 33, 28, 1, -32 },
  { 10334, 30, 44, 28, -3, -32 },
  { 10499, 27, 44, 28, 1, -32 },
  { 10648, 22, 32, 19, -1, -32 },
  { 10736, 25, 33, 25, 0, -32 },
  { 10840, 17, 39, 18, 2, -38 },
  { 10923, 27, 32, 28, 1, -31 },
  { 11031, 25, 31, 26, 3, -31 },
  { 11128, 34, 31, 35, 3, -31 },
  { 11260, 30, 31, 26, -2, -31 },
  { 11377, 29, 43, 26, -1, -31 },
  { 11533, 27, 31, 26, -1, -31 },
  { 11638, 18, 55, 17, 1, -45 },
  { 11762, 13, 49, 14, 1, -41 },
  { 11842, 18, 55, 17, -2, -45 },
  { 11966, 27, 13, 30, 2, -23 },
};

const GFXfont RobotoCondensed_BlackItalic58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_BLACKITALIC58PT7B_H_
