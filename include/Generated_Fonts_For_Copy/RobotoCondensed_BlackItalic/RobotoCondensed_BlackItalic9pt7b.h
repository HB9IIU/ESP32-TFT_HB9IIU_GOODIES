#ifndef _ROBOTOCONDENSED_BLACKITALIC9PT7B_H_
#define _ROBOTOCONDENSED_BLACKITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BlackItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BlackItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x21, 0xA0, 0x6E, 0x80, 0x31, 0x9C, 0xCF, 0x32, 0x80, 0x13,
  0x54, 0x61, 0xF6, 0x40, 0xCD, 0xE4, 0x7B, 0x30, 0x32, 0x9C, 0xCF, 0xF9,
  0xC0, 0x58, 0x2D, 0x2D, 0x22, 0x40, 0x49, 0x24, 0x94, 0x80, 0x27, 0x65,
  0x22, 0xF6, 0x40, 0x49, 0x00, 0xC0, 0x30, 0x11, 0x22, 0x24, 0x44, 0x35,
  0x5D, 0xDF, 0x60, 0x7D, 0x24, 0xB0, 0x75, 0x13, 0x64, 0xF0, 0x75, 0x12,
  0x1F, 0x60, 0x13, 0x37, 0x7F, 0x20, 0x74, 0x71, 0x1F, 0x60, 0x36, 0x7D,
  0xDF, 0x60, 0x78, 0x8C, 0x46, 0x21, 0x00, 0x75, 0x56, 0xDF, 0x60, 0x76,
  0xDE, 0xB0, 0x10, 0x30, 0x10, 0x3A, 0x1E, 0xE2, 0x70, 0xF0, 0x46, 0x3E,
  0x80, 0xF5, 0xAC, 0x20, 0x39, 0x15, 0xEB, 0xB6, 0xB8, 0x1C, 0x31, 0x8C,
  0xA5, 0x7E, 0x60, 0x72, 0xD6, 0xED, 0x6B, 0xC0, 0x3A, 0x51, 0x8C, 0x6D,
  0xC0, 0x72, 0xD6, 0xBD, 0xEB, 0x80, 0x7A, 0x10, 0xEC, 0x63, 0xC0, 0x7A,
  0x10, 0xEC, 0x63, 0x00, 0x3A, 0x51, 0xBD, 0xED, 0xC0, 0x49, 0x24, 0x9E,
  0xDB, 0x6D, 0x80, 0x69, 0x2D, 0xB0, 0x10, 0x84, 0x23, 0x5B, 0x80, 0x59,
  0x67, 0x1C, 0xF3, 0xCD, 0x00, 0x44, 0x44, 0xCC, 0xF0, 0x66, 0xDD, 0xB3,
  0x6F, 0x5E, 0xBF, 0x00, 0x69, 0xA6, 0x9A, 0xDB, 0x6D, 0x80, 0x32, 0x53,
  0x9D, 0xED, 0xC0, 0x72, 0xD6, 0xBF, 0x63, 0x00, 0x32, 0x53, 0x9D, 0xED,
  0xC2, 0x72, 0xD6, 0xBF, 0x7B, 0x40, 0x32, 0xD0, 0xE1, 0x69, 0xC0, 0xF6,
  0x44, 0x4C, 0xC0, 0x4A, 0x56, 0xBD, 0xE9, 0xC0, 0x94, 0xAD, 0x4A, 0x73,
  0x00, 0xAE, 0xAE, 0xBA, 0xFB, 0xCB, 0x00, 0x5B, 0xDC, 0x67, 0x6B, 0x40,
  0x9B, 0xAE, 0x4C, 0xC0, 0x78, 0xCC, 0x46, 0x63, 0xC0, 0x69, 0x25, 0xB6,
  0x98, 0xAA, 0xFD, 0x32, 0x22, 0x26, 0x66, 0x44, 0x2D, 0x80, 0x70, 0xD0,
  0x7F, 0x7B, 0xE0, 0x44, 0x75, 0xDF, 0xE0, 0x6D, 0xCB, 0x60, 0x18, 0x9D,
  0xAF, 0x7B, 0xC0, 0x7D, 0xFC, 0x60, 0x26, 0xE4, 0x4C, 0xC0, 0x7D, 0xDF,
  0xF3, 0xE0, 0x44, 0x7D, 0xFF, 0xB0, 0x45, 0xF8, 0x20, 0x96, 0xDA, 0xC0,
  0x42, 0x14, 0xCE, 0x72, 0xC0, 0x49, 0x2D, 0xA0, 0x7D, 0x5F, 0x7F, 0xBC,
  0x7D, 0xDF, 0xB0, 0x7D, 0xDF, 0x60, 0x75, 0xDF, 0xE8, 0x80, 0x7D, 0xFF,
  0xF2, 0x20, 0x6B, 0x68, 0x6F, 0x6A, 0xE0, 0x5D, 0x2C, 0x80, 0x5D, 0xDF,
  0xF0, 0xD7, 0x66, 0x60, 0x7D, 0xE7, 0x96, 0x50, 0x56, 0x6E, 0xA0, 0xD7,
  0x66, 0x44, 0x80, 0x72, 0x6C, 0xE0, 0x29, 0x28, 0xB6, 0x40, 0x55, 0x6A,
  0x55, 0x7E, 0x80, 0x7B,
};

const GFXglyph RobotoCondensed_BlackItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 2, 0, -7 },
  { 4, 3, 3, 3, 0, -7 },
  { 6, 5, 7, 4, 0, -7 },
  { 11, 4, 9, 4, 0, -8 },
  { 16, 4, 7, 6, 1, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 2, 3, 1, 0, -7 },
  { 26, 3, 9, 3, 0, -7 },
  { 30, 3, 9, 3, 0, -7 },
  { 34, 4, 4, 4, 0, -7 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 3, 3, 2, -1, -1 },
  { 41, 2, 1, 4, 1, -3 },
  { 42, 2, 2, 3, 0, -2 },
  { 43, 4, 8, 3, -1, -7 },
  { 47, 4, 7, 4, 0, -7 },
  { 51, 3, 7, 4, 1, -7 },
  { 54, 4, 7, 4, 0, -7 },
  { 58, 4, 7, 4, 0, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 5, 7, 4, 0, -7 },
  { 79, 4, 7, 4, 0, -7 },
  { 83, 3, 7, 4, 1, -7 },
  { 86, 2, 6, 3, 0, -6 },
  { 88, 2, 8, 2, 0, -6 },
  { 90, 4, 4, 4, 0, -5 },
  { 92, 4, 3, 5, 0, -4 },
  { 94, 4, 5, 4, 0, -5 },
  { 97, 3, 7, 4, 1, -7 },
  { 100, 6, 8, 7, 0, -6 },
  { 106, 5, 7, 5, 0, -7 },
  { 111, 5, 7, 5, 0, -7 },
  { 116, 5, 7, 5, 0, -7 },
  { 121, 5, 7, 5, 0, -7 },
  { 126, 5, 7, 4, 0, -7 },
  { 131, 5, 7, 4, 0, -7 },
  { 136, 5, 7, 5, 0, -7 },
  { 141, 6, 7, 5, 0, -7 },
  { 147, 3, 7, 2, 0, -7 },
  { 150, 5, 7, 4, 0, -7 },
  { 155, 6, 7, 5, 0, -7 },
  { 161, 4, 7, 4, 0, -7 },
  { 165, 7, 7, 7, 0, -7 },
  { 172, 6, 7, 5, 0, -7 },
  { 178, 5, 7, 5, 0, -7 },
  { 183, 5, 7, 5, 0, -7 },
  { 188, 5, 8, 5, 0, -7 },
  { 193, 5, 7, 5, 0, -7 },
  { 198, 5, 7, 5, 0, -7 },
  { 203, 4, 7, 5, 1, -7 },
  { 207, 5, 7, 5, 0, -7 },
  { 212, 5, 7, 5, 1, -7 },
  { 217, 6, 7, 7, 1, -7 },
  { 223, 5, 7, 5, 0, -7 },
  { 228, 4, 7, 5, 1, -7 },
  { 232, 5, 7, 5, 0, -7 },
  { 237, 3, 10, 2, 0, -8 },
  { 241, 2, 8, 3, 1, -7 },
  { 243, 4, 10, 2, -1, -8 },
  { 248, 3, 3, 4, 0, -7 },
  { 250, 4, 1, 3, -1, 0 },
  { 251, 2, 2, 3, 1, -7 },
  { 252, 4, 5, 4, 0, -5 },
  { 255, 4, 7, 4, 0, -7 },
  { 259, 4, 5, 4, 0, -5 },
  { 262, 5, 7, 4, 0, -7 },
  { 267, 4, 5, 4, 0, -5 },
  { 270, 4, 7, 3, 0, -7 },
  { 274, 4, 7, 4, 0, -5 },
  { 278, 4, 7, 4, 0, -7 },
  { 282, 2, 7, 2, 0, -7 },
  { 284, 3, 9, 2, -1, -7 },
  { 288, 5, 7, 4, 0, -7 },
  { 293, 3, 7, 2, 0, -7 },
  { 296, 6, 5, 6, 0, -5 },
  { 300, 4, 5, 4, 0, -5 },
  { 303, 4, 5, 4, 0, -5 },
  { 306, 4, 7, 4, 0, -5 },
  { 310, 4, 7, 4, 0, -5 },
  { 314, 3, 5, 3, 0, -5 },
  { 316, 4, 5, 4, 0, -5 },
  { 319, 3, 6, 3, 0, -6 },
  { 322, 4, 5, 4, 0, -5 },
  { 325, 4, 5, 4, 0, -5 },
  { 328, 6, 5, 5, 0, -5 },
  { 332, 4, 5, 4, 0, -5 },
  { 335, 4, 7, 4, 0, -5 },
  { 339, 4, 5, 4, 0, -5 },
  { 342, 3, 9, 3, 0, -7 },
  { 346, 2, 8, 2, 0, -7 },
  { 348, 2, 9, 3, 0, -7 },
  { 351, 4, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_BlackItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BlackItalic9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BlackItalic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_BLACKITALIC9PT7B_H_
