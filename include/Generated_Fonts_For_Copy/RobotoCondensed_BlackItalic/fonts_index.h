#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoCondensed_BlackItalic6pt7b, 6, "RobotoCondensed_BlackItalic6pt7b" },
  { &RobotoCondensed_BlackItalic7pt7b, 7, "RobotoCondensed_BlackItalic7pt7b" },
  { &RobotoCondensed_BlackItalic8pt7b, 8, "RobotoCondensed_BlackItalic8pt7b" },
  { &RobotoCondensed_BlackItalic9pt7b, 9, "RobotoCondensed_BlackItalic9pt7b" },
  { &RobotoCondensed_BlackItalic10pt7b, 10, "RobotoCondensed_BlackItalic10pt7b" },
  { &RobotoCondensed_BlackItalic11pt7b, 11, "RobotoCondensed_BlackItalic11pt7b" },
  { &RobotoCondensed_BlackItalic12pt7b, 12, "RobotoCondensed_BlackItalic12pt7b" },
  { &RobotoCondensed_BlackItalic13pt7b, 13, "RobotoCondensed_BlackItalic13pt7b" },
  { &RobotoCondensed_BlackItalic14pt7b, 14, "RobotoCondensed_BlackItalic14pt7b" },
  { &RobotoCondensed_BlackItalic15pt7b, 15, "RobotoCondensed_BlackItalic15pt7b" },
  { &RobotoCondensed_BlackItalic16pt7b, 16, "RobotoCondensed_BlackItalic16pt7b" },
  { &RobotoCondensed_BlackItalic17pt7b, 17, "RobotoCondensed_BlackItalic17pt7b" },
  { &RobotoCondensed_BlackItalic18pt7b, 18, "RobotoCondensed_BlackItalic18pt7b" },
  { &RobotoCondensed_BlackItalic19pt7b, 19, "RobotoCondensed_BlackItalic19pt7b" },
  { &RobotoCondensed_BlackItalic20pt7b, 20, "RobotoCondensed_BlackItalic20pt7b" },
  { &RobotoCondensed_BlackItalic21pt7b, 21, "RobotoCondensed_BlackItalic21pt7b" },
  { &RobotoCondensed_BlackItalic22pt7b, 22, "RobotoCondensed_BlackItalic22pt7b" },
  { &RobotoCondensed_BlackItalic23pt7b, 23, "RobotoCondensed_BlackItalic23pt7b" },
  { &RobotoCondensed_BlackItalic24pt7b, 24, "RobotoCondensed_BlackItalic24pt7b" },
  { &RobotoCondensed_BlackItalic25pt7b, 25, "RobotoCondensed_BlackItalic25pt7b" },
  { &RobotoCondensed_BlackItalic26pt7b, 26, "RobotoCondensed_BlackItalic26pt7b" },
  { &RobotoCondensed_BlackItalic27pt7b, 27, "RobotoCondensed_BlackItalic27pt7b" },
  { &RobotoCondensed_BlackItalic28pt7b, 28, "RobotoCondensed_BlackItalic28pt7b" },
  { &RobotoCondensed_BlackItalic29pt7b, 29, "RobotoCondensed_BlackItalic29pt7b" },
  { &RobotoCondensed_BlackItalic30pt7b, 30, "RobotoCondensed_BlackItalic30pt7b" },
  { &RobotoCondensed_BlackItalic31pt7b, 31, "RobotoCondensed_BlackItalic31pt7b" },
  { &RobotoCondensed_BlackItalic32pt7b, 32, "RobotoCondensed_BlackItalic32pt7b" },
  { &RobotoCondensed_BlackItalic33pt7b, 33, "RobotoCondensed_BlackItalic33pt7b" },
  { &RobotoCondensed_BlackItalic34pt7b, 34, "RobotoCondensed_BlackItalic34pt7b" },
  { &RobotoCondensed_BlackItalic35pt7b, 35, "RobotoCondensed_BlackItalic35pt7b" },
  { &RobotoCondensed_BlackItalic36pt7b, 36, "RobotoCondensed_BlackItalic36pt7b" },
  { &RobotoCondensed_BlackItalic37pt7b, 37, "RobotoCondensed_BlackItalic37pt7b" },
  { &RobotoCondensed_BlackItalic38pt7b, 38, "RobotoCondensed_BlackItalic38pt7b" },
  { &RobotoCondensed_BlackItalic39pt7b, 39, "RobotoCondensed_BlackItalic39pt7b" },
  { &RobotoCondensed_BlackItalic40pt7b, 40, "RobotoCondensed_BlackItalic40pt7b" },
  { &RobotoCondensed_BlackItalic41pt7b, 41, "RobotoCondensed_BlackItalic41pt7b" },
  { &RobotoCondensed_BlackItalic42pt7b, 42, "RobotoCondensed_BlackItalic42pt7b" },
  { &RobotoCondensed_BlackItalic43pt7b, 43, "RobotoCondensed_BlackItalic43pt7b" },
  { &RobotoCondensed_BlackItalic44pt7b, 44, "RobotoCondensed_BlackItalic44pt7b" },
  { &RobotoCondensed_BlackItalic45pt7b, 45, "RobotoCondensed_BlackItalic45pt7b" },
  { &RobotoCondensed_BlackItalic46pt7b, 46, "RobotoCondensed_BlackItalic46pt7b" },
  { &RobotoCondensed_BlackItalic47pt7b, 47, "RobotoCondensed_BlackItalic47pt7b" },
  { &RobotoCondensed_BlackItalic48pt7b, 48, "RobotoCondensed_BlackItalic48pt7b" },
  { &RobotoCondensed_BlackItalic49pt7b, 49, "RobotoCondensed_BlackItalic49pt7b" },
  { &RobotoCondensed_BlackItalic50pt7b, 50, "RobotoCondensed_BlackItalic50pt7b" },
  { &RobotoCondensed_BlackItalic51pt7b, 51, "RobotoCondensed_BlackItalic51pt7b" },
  { &RobotoCondensed_BlackItalic52pt7b, 52, "RobotoCondensed_BlackItalic52pt7b" },
  { &RobotoCondensed_BlackItalic53pt7b, 53, "RobotoCondensed_BlackItalic53pt7b" },
  { &RobotoCondensed_BlackItalic54pt7b, 54, "RobotoCondensed_BlackItalic54pt7b" },
  { &RobotoCondensed_BlackItalic55pt7b, 55, "RobotoCondensed_BlackItalic55pt7b" },
  { &RobotoCondensed_BlackItalic56pt7b, 56, "RobotoCondensed_BlackItalic56pt7b" },
  { &RobotoCondensed_BlackItalic57pt7b, 57, "RobotoCondensed_BlackItalic57pt7b" },
  { &RobotoCondensed_BlackItalic58pt7b, 58, "RobotoCondensed_BlackItalic58pt7b" },
  { &RobotoCondensed_BlackItalic59pt7b, 59, "RobotoCondensed_BlackItalic59pt7b" },
  { &RobotoCondensed_BlackItalic60pt7b, 60, "RobotoCondensed_BlackItalic60pt7b" },
  { &RobotoCondensed_BlackItalic61pt7b, 61, "RobotoCondensed_BlackItalic61pt7b" },
  { &RobotoCondensed_BlackItalic62pt7b, 62, "RobotoCondensed_BlackItalic62pt7b" },
  { &RobotoCondensed_BlackItalic63pt7b, 63, "RobotoCondensed_BlackItalic63pt7b" },
  { &RobotoCondensed_BlackItalic64pt7b, 64, "RobotoCondensed_BlackItalic64pt7b" },
  { &RobotoCondensed_BlackItalic65pt7b, 65, "RobotoCondensed_BlackItalic65pt7b" },
  { &RobotoCondensed_BlackItalic66pt7b, 66, "RobotoCondensed_BlackItalic66pt7b" },
  { &RobotoCondensed_BlackItalic67pt7b, 67, "RobotoCondensed_BlackItalic67pt7b" },
  { &RobotoCondensed_BlackItalic68pt7b, 68, "RobotoCondensed_BlackItalic68pt7b" },
  { &RobotoCondensed_BlackItalic69pt7b, 69, "RobotoCondensed_BlackItalic69pt7b" },
  { &RobotoCondensed_BlackItalic70pt7b, 70, "RobotoCondensed_BlackItalic70pt7b" },
  { &RobotoCondensed_BlackItalic71pt7b, 71, "RobotoCondensed_BlackItalic71pt7b" },
  { &RobotoCondensed_BlackItalic72pt7b, 72, "RobotoCondensed_BlackItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
