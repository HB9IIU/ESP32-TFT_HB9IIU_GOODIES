#ifndef _IBMPLEXMONO_THINITALIC24PT7B_H_
#define _IBMPLEXMONO_THINITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x44, 0x40, 0x00, 0xC0, 0x4A, 0x63,
  0x29, 0x48, 0x01, 0x88, 0x02, 0x20, 0x04, 0x40, 0x11, 0x00, 0x22, 0x07,
  0xC7, 0xC1, 0x08, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x22, 0x07, 0xC7,
  0xC1, 0x08, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x22, 0x00, 0x01, 0x80,
  0x08, 0x01, 0xF0, 0x32, 0x42, 0x11, 0x10, 0x85, 0x08, 0x04, 0x40, 0x22,
  0x00, 0xD0, 0x01, 0xE0, 0x04, 0x80, 0x42, 0x02, 0x10, 0x10, 0x90, 0x84,
  0x84, 0x23, 0x46, 0x07, 0xC0, 0x10, 0x00, 0x80, 0x00, 0x0E, 0x02, 0x22,
  0x08, 0x82, 0x11, 0x04, 0x44, 0x11, 0x08, 0x24, 0x08, 0x48, 0x0F, 0x20,
  0x00, 0x00, 0x00, 0xE0, 0x36, 0x20, 0x88, 0x41, 0x20, 0x84, 0x41, 0x10,
  0x82, 0x40, 0x88, 0x80, 0xE0, 0x07, 0xC0, 0x21, 0x80, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x82, 0x01, 0x10, 0x3F, 0x81, 0x08, 0x08, 0x20,
  0x20, 0x40, 0x80, 0x82, 0x03, 0x18, 0x14, 0x90, 0xCA, 0x3E, 0x10, 0xFC,
  0x06, 0x10, 0x41, 0x02, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x01, 0x02, 0x02, 0x00, 0x10, 0x10, 0x10, 0x20, 0x40,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x82,
  0x08, 0x00, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x84, 0x17, 0x5E, 0x0E,
  0x00, 0xC0, 0x12, 0x02, 0x20, 0x41, 0x08, 0x08, 0x02, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x29, 0x49, 0x00, 0xFE, 0xC0, 0x00, 0x18, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x83, 0x08, 0x80, 0xA0, 0x14,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x84, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x05,
  0x00, 0xA0, 0x22, 0x08, 0x3E, 0x00, 0x01, 0x80, 0x50, 0x14, 0x0C, 0x83,
  0x10, 0x42, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0xFF, 0xE0, 0x07, 0xC0, 0x82, 0x10, 0x12, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x00, 0xFF, 0xE0, 0x07, 0xC1, 0x82, 0x20,
  0x20, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x0F, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x04, 0x80, 0x44, 0x08, 0x3F, 0x00, 0x00, 0x20,
  0x06, 0x00, 0xA0, 0x12, 0x02, 0x40, 0x44, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x04, 0x40, 0x88, 0x08, 0xFF, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x0F, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x2F, 0x83, 0x04,
  0x20, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x80, 0x46, 0x08,
  0x1F, 0x00, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01, 0x7C,
  0xA0, 0xB0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x09, 0x04, 0x3E, 0x00,
  0x7F, 0xF0, 0x0A, 0x01, 0x40, 0x48, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x00,
  0x07, 0xC0, 0x83, 0x10, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x11, 0x06,
  0x0F, 0x83, 0x84, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x26, 0x0C,
  0x1F, 0x00, 0x1F, 0x18, 0x24, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02,
  0x80, 0xB0, 0xE3, 0xF0, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x84, 0x42, 0x10, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02,
  0x00, 0xC0, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x06, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0xC0, 0x00, 0x1E, 0x30, 0xA0, 0x30, 0x10, 0x08, 0x04,
  0x04, 0x02, 0x06, 0x1C, 0x08, 0x04, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x83, 0x08, 0x40, 0x90, 0x14, 0x02, 0x87, 0x51, 0x1C, 0x42,
  0x90, 0x52, 0x0A, 0x41, 0x48, 0x29, 0x05, 0x13, 0x21, 0xA4, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x1F, 0x80, 0x00, 0x80, 0x14, 0x01, 0x40, 0x24, 0x02,
  0x40, 0x44, 0x04, 0x40, 0x42, 0x08, 0x20, 0x82, 0x10, 0x21, 0xFE, 0x20,
  0x22, 0x01, 0x40, 0x14, 0x01, 0x80, 0x10, 0x1F, 0xC1, 0x02, 0x20, 0x12,
  0x01, 0x20, 0x12, 0x01, 0x20, 0x22, 0x04, 0x3F, 0x84, 0x06, 0x40, 0x24,
  0x02, 0x40, 0x28, 0x02, 0x80, 0x28, 0x04, 0xFF, 0x80, 0x07, 0x83, 0x08,
  0x40, 0x90, 0x14, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0xA0, 0x23, 0x08, 0x1E, 0x00, 0x3F, 0x84, 0x08,
  0x80, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x08, 0xFE, 0x00, 0x3F, 0xF2, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F, 0xC8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0x80, 0x3F,
  0xF2, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F,
  0xC8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x00, 0x07, 0x83, 0x08, 0x80, 0x90, 0x14, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x7E, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x32, 0x0A, 0x3E,
  0x80, 0x10, 0x09, 0x00, 0x48, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80,
  0x48, 0x02, 0x3F, 0xE2, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x40, 0x12,
  0x01, 0x10, 0x08, 0x80, 0x40, 0x1F, 0xF8, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x09, 0x02, 0x20, 0x42, 0x10, 0x3C, 0x00, 0x20, 0x19, 0x01,
  0x10, 0x10, 0x81, 0x04, 0x10, 0x21, 0x01, 0x10, 0x09, 0x00, 0x94, 0x05,
  0x20, 0x10, 0x81, 0x04, 0x08, 0x10, 0x40, 0x82, 0x02, 0x10, 0x10, 0x80,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0x10,
  0x08, 0x80, 0xCC, 0x06, 0x60, 0x52, 0x85, 0x24, 0x29, 0x22, 0x48, 0xA2,
  0x45, 0x12, 0x30, 0x90, 0x89, 0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90,
  0x04, 0x80, 0x40, 0x10, 0x09, 0x80, 0x4A, 0x04, 0x50, 0x22, 0x81, 0x12,
  0x08, 0x90, 0x48, 0x82, 0x42, 0x22, 0x11, 0x10, 0x48, 0x82, 0x44, 0x12,
  0x40, 0x52, 0x03, 0x10, 0x18, 0x80, 0x40, 0x0F, 0x83, 0x08, 0x80, 0xA0,
  0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x28,
  0x05, 0x00, 0xA0, 0x22, 0x08, 0x3E, 0x00, 0x3F, 0xC2, 0x02, 0x20, 0x24,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x47, 0xF8, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F, 0x83, 0x08,
  0x80, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x28, 0x05, 0x01, 0x20, 0x22, 0x08, 0x3E, 0x01, 0x00, 0x11, 0x01,
  0x40, 0x30, 0x3F, 0xC2, 0x02, 0x20, 0x24, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x24, 0x02, 0x40, 0x47, 0xF8, 0x84, 0x08, 0x20, 0x82, 0x08, 0x10, 0x81,
  0x08, 0x08, 0x80, 0x80, 0x07, 0xC0, 0xC1, 0x08, 0x04, 0x40, 0x14, 0x00,
  0x10, 0x00, 0x80, 0x03, 0x00, 0x07, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x40, 0x12, 0x00, 0x8C, 0x18, 0x1F, 0x00, 0xFF, 0xF0, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x20, 0x14,
  0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x48,
  0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x84, 0x10, 0x3E, 0x00,
  0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48, 0x08, 0x40, 0x84, 0x10,
  0x41, 0x04, 0x20, 0x42, 0x04, 0x40, 0x24, 0x02, 0x80, 0x28, 0x03, 0x00,
  0x10, 0x00, 0x40, 0x0A, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x42, 0x12,
  0x18, 0x91, 0x44, 0x8A, 0x24, 0x92, 0x24, 0x91, 0x44, 0x8A, 0x24, 0x51,
  0x43, 0x06, 0x18, 0x30, 0x81, 0x00, 0x10, 0x06, 0x10, 0x08, 0x20, 0x20,
  0x20, 0x80, 0x42, 0x00, 0x88, 0x00, 0x90, 0x01, 0x40, 0x01, 0x00, 0x05,
  0x00, 0x12, 0x00, 0x42, 0x00, 0x84, 0x02, 0x08, 0x08, 0x08, 0x20, 0x18,
  0x80, 0x10, 0x80, 0x0A, 0x00, 0x90, 0x08, 0x40, 0x42, 0x04, 0x08, 0x40,
  0x44, 0x01, 0x40, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x1F, 0xFC, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0xFF, 0xF0,
  0x1F, 0x88, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xC0,
  0x84, 0x21, 0x08, 0x21, 0x08, 0x42, 0x08, 0x42, 0x10, 0x42, 0x10, 0x82,
  0x10, 0x80, 0x1F, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x8F, 0xC0, 0x02, 0x00, 0xA0, 0x24, 0x04, 0x41, 0x08, 0x40, 0x90, 0x12,
  0x01, 0x80, 0x20, 0xFF, 0xE0, 0xA5, 0x1F, 0x44, 0x19, 0x03, 0x40, 0x28,
  0x05, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x31, 0x0A, 0x1E, 0x70, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x13, 0xE2, 0x82, 0x60, 0x48,
  0x05, 0x00, 0xA0, 0x18, 0x05, 0x00, 0xA0, 0x14, 0x04, 0xE1, 0x93, 0xC0,
  0x0F, 0x0C, 0x24, 0x06, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0xE0,
  0x44, 0x30, 0xF0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x87,
  0xD1, 0x06, 0x40, 0xD0, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x01, 0x20, 0x24,
  0x0C, 0x42, 0x87, 0xA0, 0x0F, 0x8C, 0x14, 0x06, 0x01, 0x80, 0x60, 0xEF,
  0xC2, 0x00, 0x80, 0xA0, 0x34, 0x10, 0xF8, 0x00, 0x7E, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x07, 0xFF, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x02, 0x10, 0x02, 0x20, 0x02, 0x40, 0x02, 0x80,
  0x03, 0x00, 0x00, 0x0F, 0xA2, 0x0C, 0x81, 0xA0, 0x14, 0x03, 0x00, 0x60,
  0x14, 0x02, 0x80, 0x48, 0x18, 0x85, 0x0F, 0x20, 0x08, 0x01, 0x00, 0x26,
  0x18, 0x3E, 0x00, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x78,
  0xA3, 0x70, 0x58, 0x14, 0x05, 0x01, 0x40, 0xA0, 0x28, 0x0A, 0x02, 0x80,
  0xA0, 0x20, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x44, 0x21, 0x30, 0x70, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x42, 0x31, 0x04, 0x81, 0x40,
  0x40, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x47, 0x85,
  0x84, 0x60, 0x44, 0x04, 0x40, 0x44, 0x18, 0x8E, 0x08, 0x80, 0x88, 0x38,
  0x44, 0x82, 0x88, 0x10, 0xFC, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x04, 0x8C, 0x48, 0x58, 0x10,
  0x00, 0x2E, 0x72, 0x94, 0x98, 0xC2, 0x84, 0x24, 0x21, 0x21, 0x09, 0x08,
  0x50, 0x42, 0x84, 0x14, 0x21, 0x21, 0x09, 0x08, 0x40, 0x27, 0x8A, 0x37,
  0x04, 0x81, 0x40, 0x50, 0x14, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02,
  0x0F, 0x0C, 0x34, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x24, 0x10, 0xF8, 0x27, 0xC2, 0x82, 0x10, 0x22, 0x01, 0x20, 0x12, 0x01,
  0x40, 0x24, 0x02, 0x40, 0x24, 0x04, 0x70, 0xC8, 0xF0, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x00, 0x1F, 0x48, 0x34, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x0A, 0x02, 0x80, 0xA0, 0x64, 0x28, 0xF2, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0xFB, 0xE1, 0x80, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x1F, 0x84, 0x09, 0x00,
  0xA0, 0x04, 0x00, 0x7C, 0x00, 0x60, 0x02, 0x00, 0x50, 0x0B, 0x02, 0x1F,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x0F, 0xFF, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x41, 0x0C, 0x23, 0x02,
  0xC0, 0x10, 0x00, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x60, 0x28, 0x0A,
  0x02, 0x80, 0xA0, 0xE4, 0x30, 0xF4, 0xF0, 0x44, 0x04, 0x80, 0x90, 0x12,
  0x02, 0x40, 0x88, 0x12, 0x04, 0x40, 0x88, 0x21, 0x18, 0x3C, 0x00, 0x42,
  0x24, 0x22, 0x82, 0x28, 0x41, 0x84, 0x18, 0x41, 0x84, 0x28, 0x42, 0x88,
  0x28, 0x82, 0x94, 0x4E, 0x38, 0x08, 0x71, 0xA4, 0x71, 0x42, 0x04, 0x10,
  0x20, 0x81, 0x00, 0x08, 0x10, 0x80, 0x86, 0x04, 0x50, 0xA6, 0x98, 0xC3,
  0x00, 0x20, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02, 0x80, 0x90, 0x12, 0x02,
  0x40, 0x48, 0x38, 0x85, 0x0F, 0x40, 0x08, 0x01, 0x00, 0x66, 0x18, 0x3C,
  0x00, 0x1F, 0x12, 0x0F, 0x40, 0x24, 0x04, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x84, 0x20, 0x44, 0x04, 0xFE, 0x68, 0x3E, 0x07, 0xE0, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x83, 0xE0, 0x0C, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x03, 0xE0,
  0x11, 0x11, 0x11, 0x22, 0x22, 0x22, 0x44, 0x44, 0x48, 0x88, 0x80, 0x0F,
  0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x0F, 0x83, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x0F, 0x80, 0x18, 0x19, 0x20, 0x90, 0x85, 0x02, 0x48, 0x0C,
  0x00,
};

const GFXglyph IBMPlexMono_ThinItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 5, 6, 14, 6, -18 },
  { 14, 15, 17, 14, 0, -17 },
  { 46, 13, 21, 14, 1, -19 },
  { 81, 15, 17, 14, 0, -17 },
  { 113, 14, 17, 14, 0, -17 },
  { 143, 1, 6, 14, 8, -18 },
  { 144, 7, 21, 14, 6, -18 },
  { 163, 7, 21, 14, 2, -18 },
  { 182, 12, 12, 14, 2, -13 },
  { 200, 11, 13, 14, 2, -14 },
  { 218, 3, 6, 14, 4, -2 },
  { 221, 7, 1, 14, 4, -8 },
  { 222, 2, 1, 14, 5, -1 },
  { 223, 13, 21, 14, 1, -18 },
  { 258, 11, 17, 14, 2, -17 },
  { 282, 11, 17, 14, 1, -17 },
  { 306, 12, 17, 14, 1, -17 },
  { 332, 12, 17, 14, 1, -17 },
  { 358, 12, 17, 14, 1, -17 },
  { 384, 12, 17, 14, 1, -17 },
  { 410, 10, 17, 14, 2, -17 },
  { 432, 11, 17, 14, 3, -17 },
  { 456, 12, 17, 14, 1, -17 },
  { 482, 10, 17, 14, 3, -17 },
  { 504, 4, 12, 14, 5, -12 },
  { 510, 5, 16, 14, 4, -12 },
  { 520, 12, 13, 14, 2, -14 },
  { 540, 13, 5, 14, 1, -10 },
  { 549, 12, 13, 14, 1, -14 },
  { 569, 9, 17, 14, 4, -17 },
  { 589, 11, 20, 14, 2, -17 },
  { 617, 12, 17, 14, 0, -17 },
  { 643, 12, 17, 14, 1, -17 },
  { 669, 11, 17, 14, 2, -17 },
  { 693, 11, 17, 14, 2, -17 },
  { 717, 12, 17, 14, 2, -17 },
  { 743, 12, 17, 14, 2, -17 },
  { 769, 11, 17, 14, 2, -17 },
  { 793, 13, 17, 14, 1, -17 },
  { 821, 13, 17, 14, 1, -17 },
  { 849, 11, 17, 14, 2, -17 },
  { 873, 13, 17, 14, 2, -17 },
  { 901, 10, 17, 14, 2, -17 },
  { 923, 13, 17, 14, 1, -17 },
  { 951, 13, 17, 14, 1, -17 },
  { 979, 11, 17, 14, 2, -17 },
  { 1003, 12, 17, 14, 2, -17 },
  { 1029, 11, 21, 14, 2, -17 },
  { 1058, 12, 17, 14, 2, -17 },
  { 1084, 13, 17, 14, 1, -17 },
  { 1112, 12, 17, 14, 3, -17 },
  { 1138, 12, 17, 14, 2, -17 },
  { 1164, 12, 17, 14, 3, -17 },
  { 1190, 13, 17, 14, 2, -17 },
  { 1218, 15, 17, 14, 0, -17 },
  { 1250, 13, 17, 14, 2, -17 },
  { 1278, 14, 17, 14, 0, -17 },
  { 1308, 9, 21, 14, 5, -18 },
  { 1332, 5, 21, 14, 5, -18 },
  { 1346, 9, 21, 14, 1, -18 },
  { 1370, 11, 9, 14, 2, -17 },
  { 1383, 11, 1, 14, 0, 3 },
  { 1385, 2, 4, 14, 6, -18 },
  { 1386, 11, 12, 14, 2, -12 },
  { 1403, 11, 18, 14, 2, -18 },
  { 1428, 10, 12, 14, 2, -12 },
  { 1443, 11, 18, 14, 2, -18 },
  { 1468, 10, 12, 14, 2, -12 },
  { 1483, 15, 23, 14, 0, -18 },
  { 1527, 11, 17, 14, 1, -12 },
  { 1551, 10, 18, 14, 2, -18 },
  { 1574, 10, 17, 14, 2, -17 },
  { 1596, 9, 22, 14, 3, -17 },
  { 1621, 12, 18, 14, 2, -18 },
  { 1648, 9, 18, 14, 3, -18 },
  { 1669, 13, 12, 14, 1, -12 },
  { 1689, 10, 12, 14, 2, -12 },
  { 1704, 10, 12, 14, 2, -12 },
  { 1719, 12, 17, 14, 1, -12 },
  { 1745, 10, 17, 14, 2, -12 },
  { 1767, 11, 12, 14, 3, -12 },
  { 1784, 11, 12, 14, 2, -12 },
  { 1801, 12, 17, 14, 2, -17 },
  { 1827, 10, 12, 14, 2, -12 },
  { 1842, 11, 12, 14, 2, -12 },
  { 1859, 12, 12, 14, 2, -12 },
  { 1877, 13, 12, 14, 1, -12 },
  { 1897, 11, 17, 14, 1, -12 },
  { 1921, 12, 12, 14, 1, -12 },
  { 1939, 11, 21, 14, 3, -18 },
  { 1968, 4, 21, 14, 5, -18 },
  { 1979, 11, 21, 14, 1, -18 },
  { 2008, 13, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_ThinItalic24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_THINITALIC24PT7B_H_
