#ifndef _IBMPLEXMONO_THINITALIC32PT7B_H_
#define _IBMPLEXMONO_THINITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88, 0x00,
  0x00, 0x0C, 0x60, 0x62, 0x89, 0x12, 0x24, 0x48, 0xA1, 0x44, 0x00, 0x41,
  0x00, 0x08, 0x20, 0x01, 0x08, 0x00, 0x41, 0x00, 0x08, 0x40, 0x01, 0x08,
  0x00, 0x41, 0x01, 0xF8, 0x3F, 0x01, 0x08, 0x00, 0x41, 0x00, 0x08, 0x40,
  0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x40, 0x3E, 0x0F, 0xC0, 0x41, 0x00,
  0x08, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x40, 0x02, 0x08, 0x00,
  0x41, 0x00, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x3F, 0x00,
  0x62, 0x60, 0x41, 0x08, 0x40, 0x82, 0x20, 0x80, 0x10, 0x40, 0x08, 0x20,
  0x04, 0x10, 0x01, 0x08, 0x00, 0xC4, 0x00, 0x1E, 0x00, 0x02, 0xE0, 0x01,
  0x08, 0x00, 0x82, 0x00, 0x41, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x24,
  0x08, 0x11, 0x04, 0x10, 0x62, 0x30, 0x0F, 0xE0, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x03, 0xC0, 0x18, 0x61, 0x00, 0x84, 0x08, 0x08, 0x20,
  0x20, 0x82, 0x02, 0x08, 0x10, 0x10, 0x80, 0x80, 0x84, 0x04, 0x04, 0x40,
  0x10, 0x44, 0x00, 0x7C, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0xF0, 0x01, 0x18, 0x40, 0x11, 0x02, 0x01, 0x08, 0x08, 0x10, 0x40, 0x40,
  0x84, 0x04, 0x08, 0x20, 0x20, 0x80, 0x81, 0x08, 0x04, 0x10, 0x40, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x61, 0x80, 0x10, 0x10, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x20, 0x02, 0x04, 0x00, 0x41,
  0x00, 0x3C, 0xC0, 0x18, 0x60, 0x04, 0x08, 0x00, 0x80, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x10, 0x10, 0x05, 0x06, 0x00, 0xA1, 0x20, 0x12,
  0x42, 0x0C, 0x28, 0x3E, 0x06, 0x00, 0x29, 0x24, 0x94, 0x00, 0x81, 0x01,
  0x01, 0x00, 0x80, 0x80, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x03, 0x00, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0xE1, 0x07, 0x1D, 0x38, 0x03, 0xC0, 0x02, 0x80,
  0x04, 0x80, 0x08, 0x40, 0x08, 0x40, 0x10, 0x20, 0x20, 0x10, 0x40, 0x10,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x11, 0x22, 0x24, 0x48, 0x80, 0xFF,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x00, 0x01, 0xF0, 0x06, 0x0C, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x20,
  0x02, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x41, 0x82, 0x81,
  0x82, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x40, 0x08, 0x40, 0x10, 0x30, 0x60, 0x0F, 0x80, 0x00, 0x60, 0x02,
  0x80, 0x32, 0x01, 0x90, 0x0C, 0x40, 0x41, 0x02, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0xFF, 0xF0,
  0x00, 0xF8, 0x03, 0x06, 0x04, 0x02, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x18, 0x18,
  0x40, 0x10, 0x80, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x30, 0x1F, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x12, 0x00, 0x24, 0x00, 0x86, 0x06, 0x03,
  0xF0, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x24,
  0x00, 0x44, 0x00, 0x84, 0x01, 0x04, 0x01, 0x04, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x10, 0x08, 0x20, 0x08, 0x40, 0x08, 0x80, 0x08, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x07, 0xFF,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x27, 0xE0, 0x28, 0x10, 0x30, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x80, 0x08,
  0x40, 0x10, 0x20, 0x60, 0x1F, 0x80, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x3E, 0x16, 0x0D,
  0x40, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x05, 0x00, 0x46, 0x0C, 0x0F, 0x80, 0x7F, 0xFF, 0x00, 0x0A, 0x00, 0x24,
  0x00, 0x48, 0x01, 0x10, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xF8, 0x06, 0x04, 0x08, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01,
  0x20, 0x02, 0x20, 0x02, 0x10, 0x04, 0x0C, 0x08, 0x03, 0xF0, 0x1C, 0x18,
  0x20, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x40, 0x08, 0x20, 0x30, 0x1F, 0xC0, 0x07, 0xE0, 0x60, 0x63,
  0x00, 0x88, 0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x14, 0x00, 0x90, 0x06, 0x30, 0x70, 0x3E, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x06, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x08,
  0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x0F, 0xC3, 0x02, 0x40, 0x14, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0xE0, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x03, 0xF0,
  0x10, 0x60, 0x80, 0x44, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x7D,
  0x43, 0x0D, 0x10, 0x18, 0x40, 0xA2, 0x02, 0x88, 0x0A, 0x20, 0x28, 0x80,
  0xA2, 0x02, 0x88, 0x12, 0x10, 0xC8, 0x7D, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x00, 0x28, 0x00, 0x28,
  0x00, 0x48, 0x00, 0x48, 0x00, 0x88, 0x00, 0x84, 0x01, 0x04, 0x01, 0x04,
  0x02, 0x04, 0x02, 0x04, 0x04, 0x04, 0x04, 0x02, 0x08, 0x02, 0x0F, 0xFE,
  0x08, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x80, 0x01, 0x1F, 0xF8, 0x20, 0x08, 0x40, 0x08, 0x80, 0x11, 0x00, 0x24,
  0x00, 0x48, 0x00, 0x90, 0x02, 0x20, 0x04, 0x40, 0x10, 0xFF, 0xC2, 0x00,
  0xC4, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x80, 0x05, 0x00, 0x0A,
  0x00, 0x14, 0x00, 0x48, 0x01, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x0C, 0x10,
  0x20, 0x10, 0x80, 0x22, 0x00, 0x24, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x09, 0x00, 0x22, 0x00, 0x42, 0x01, 0x02, 0x0C, 0x03,
  0xE0, 0x00, 0x0F, 0xF0, 0x10, 0x08, 0x10, 0x04, 0x10, 0x02, 0x10, 0x02,
  0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x80, 0x08, 0x80, 0x10, 0x80, 0x60, 0xFF, 0x80, 0x0F, 0xFF,
  0x88, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0x84, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x88,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x08, 0x10,
  0x20, 0x10, 0x80, 0x22, 0x00, 0x28, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x1F, 0xD0, 0x00, 0xA0, 0x02,
  0x40, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x62, 0x01, 0x82, 0x05, 0x03,
  0xF2, 0x00, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x3F, 0xFE,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04,
  0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x1F, 0xFF,
  0x80, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x11, 0x00, 0x22, 0x00, 0x42, 0x01, 0x02, 0x0C,
  0x03, 0xE0, 0x00, 0x18, 0x00, 0xC4, 0x00, 0x41, 0x00, 0x20, 0x40, 0x10,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x00, 0x81, 0x00, 0x20, 0x80, 0x08,
  0x40, 0x02, 0x70, 0x00, 0xA2, 0x00, 0x50, 0x80, 0x18, 0x10, 0x04, 0x04,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x08, 0x01, 0x02, 0x00, 0x20,
  0x80, 0x08, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x7F, 0xFC, 0x08, 0x00, 0xC6, 0x00, 0x31, 0x40, 0x18,
  0x50, 0x0A, 0x14, 0x02, 0x84, 0x81, 0x21, 0x20, 0x88, 0x88, 0x22, 0x22,
  0x11, 0x08, 0x44, 0x42, 0x12, 0x10, 0x85, 0x04, 0x20, 0xC1, 0x10, 0x20,
  0x44, 0x08, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x04, 0x20, 0x01, 0x00, 0x18, 0x01, 0x18, 0x01, 0x18,
  0x01, 0x14, 0x01, 0x24, 0x01, 0x24, 0x02, 0x22, 0x02, 0x22, 0x02, 0x21,
  0x02, 0x21, 0x02, 0x41, 0x02, 0x40, 0x84, 0x40, 0x84, 0x40, 0x84, 0x40,
  0x44, 0x40, 0x44, 0x80, 0x44, 0x80, 0x28, 0x80, 0x28, 0x80, 0x28, 0x80,
  0x18, 0x80, 0x18, 0x01, 0xF0, 0x06, 0x0C, 0x08, 0x02, 0x10, 0x02, 0x10,
  0x02, 0x20, 0x02, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x08, 0x40, 0x08, 0x40, 0x10, 0x30, 0x60, 0x0F, 0x80, 0x0F,
  0xFC, 0x10, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x04, 0x3F, 0xF8, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x06, 0x0C, 0x08,
  0x02, 0x10, 0x02, 0x10, 0x02, 0x20, 0x02, 0x20, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x40, 0x08, 0x40, 0x10, 0x30,
  0x60, 0x0F, 0x80, 0x02, 0x00, 0x01, 0x00, 0x01, 0x04, 0x00, 0x88, 0x00,
  0x50, 0x00, 0x60, 0x0F, 0xFC, 0x10, 0x02, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20,
  0x04, 0x3F, 0xF8, 0x40, 0x80, 0x40, 0x80, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x20, 0x40, 0x20, 0x80, 0x10, 0x80, 0x10, 0x80, 0x08, 0x80, 0x08, 0x01,
  0xF8, 0x03, 0x03, 0x02, 0x00, 0x42, 0x00, 0x11, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x20, 0x00, 0x88, 0x00, 0x83, 0x01, 0x80, 0x7F, 0x00, 0xFF, 0xFF,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x20, 0x02, 0x40, 0x04, 0x80, 0x09,
  0x00, 0x14, 0x00, 0x28, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80,
  0x0A, 0x00, 0x14, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04,
  0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x01, 0x04, 0x0C, 0x07, 0xF0, 0x00,
  0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x40, 0x04, 0x40, 0x08,
  0x40, 0x08, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20, 0x20, 0x20, 0x20, 0x40,
  0x20, 0x40, 0x20, 0x80, 0x21, 0x00, 0x21, 0x00, 0x12, 0x00, 0x12, 0x00,
  0x14, 0x00, 0x14, 0x00, 0x18, 0x00, 0x08, 0x00, 0x40, 0x00, 0xA0, 0x00,
  0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x02,
  0x04, 0x83, 0x04, 0x41, 0x42, 0x21, 0x21, 0x10, 0x90, 0x88, 0x88, 0x84,
  0x44, 0x42, 0x42, 0x21, 0x21, 0x10, 0xA0, 0x50, 0x50, 0x28, 0x28, 0x14,
  0x18, 0x0C, 0x0C, 0x06, 0x04, 0x01, 0x00, 0x08, 0x00, 0x30, 0x40, 0x04,
  0x04, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x10, 0x20, 0x01, 0x04,
  0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x05, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0xA0, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x04,
  0x04, 0x00, 0x80, 0x40, 0x10, 0x02, 0x02, 0x00, 0x20, 0x40, 0x01, 0x0C,
  0x00, 0x10, 0x80, 0x00, 0xD0, 0x00, 0x44, 0x00, 0x10, 0x80, 0x08, 0x20,
  0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x20, 0x80, 0x08, 0x20, 0x01, 0x10,
  0x00, 0x48, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0xFE, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08,
  0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x07,
  0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x0F, 0xF0, 0x00, 0xC0, 0x05, 0x00, 0x24, 0x00, 0x88,
  0x04, 0x20, 0x20, 0x41, 0x01, 0x04, 0x02, 0x20, 0x09, 0x00, 0x28, 0x00,
  0x60, 0x01, 0xFF, 0xFE, 0x91, 0x22, 0x07, 0xE2, 0x18, 0x28, 0x40, 0x31,
  0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x90, 0x06, 0x10, 0x0C, 0x10, 0x68,
  0x1F, 0x1E, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0xF8, 0x2C, 0x10, 0xC0, 0x23, 0x00, 0x88, 0x01, 0x40,
  0x05, 0x00, 0x14, 0x00, 0x50, 0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0,
  0x02, 0x80, 0x13, 0x00, 0x8A, 0x04, 0x27, 0xE0, 0x07, 0xC0, 0xC1, 0x08,
  0x04, 0x80, 0x14, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x01, 0x40, 0x11, 0x01, 0x0C, 0x10, 0x1F, 0x00,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x07, 0xE2, 0x0C, 0x14, 0x10, 0x0C, 0x20, 0x04, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08, 0x80, 0x08,
  0x80, 0x08, 0x80, 0x18, 0x80, 0x30, 0x40, 0x30, 0x20, 0xD0, 0x1F, 0x10,
  0x07, 0xE0, 0x40, 0x8C, 0x02, 0x80, 0x14, 0x00, 0xC0, 0x06, 0x00, 0xD0,
  0x38, 0xFE, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x01, 0xC0, 0x09, 0x00,
  0x8C, 0x18, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFC,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x08, 0x10, 0x00, 0x81, 0x00, 0x06, 0x10, 0x00, 0x31, 0x00, 0x01,
  0x90, 0x00, 0x05, 0x00, 0x00, 0x20, 0x00, 0x07, 0xE2, 0x18, 0x28, 0x40,
  0x31, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x04, 0x80, 0x09,
  0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x90, 0x06, 0x10, 0x0C, 0x10,
  0x68, 0x1F, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x08, 0x04, 0x08, 0x10,
  0x0F, 0xC0, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x7C, 0x24, 0x11, 0x40, 0x4C, 0x02, 0x40, 0x12, 0x00,
  0xA0, 0x05, 0x00, 0x28, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x28,
  0x01, 0x40, 0x12, 0x00, 0x90, 0x04, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x02, 0x10, 0x30, 0x82, 0x04, 0x60, 0x24, 0x02, 0xC0, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x62, 0x01, 0x90, 0x07, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x11, 0xF0, 0x24, 0x10, 0x50, 0x11, 0x40, 0x21, 0x00,
  0x44, 0x00, 0x88, 0x02, 0x10, 0x08, 0x20, 0xE0, 0x8C, 0x01, 0x08, 0x02,
  0x10, 0x0C, 0x10, 0x38, 0x10, 0x90, 0x22, 0x20, 0x28, 0x40, 0x20, 0xFE,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x01, 0x10, 0x21, 0x0C, 0x21, 0x02, 0x60, 0x28, 0x03, 0x00, 0x13,
  0x87, 0x0E, 0x2C, 0x4C, 0x18, 0x22, 0x04, 0x12, 0x04, 0x09, 0x02, 0x04,
  0x81, 0x02, 0x40, 0x82, 0x40, 0x81, 0x20, 0x40, 0x90, 0x20, 0x48, 0x10,
  0x24, 0x08, 0x12, 0x04, 0x12, 0x04, 0x09, 0x02, 0x04, 0x81, 0x02, 0x00,
  0x23, 0xE1, 0x20, 0x8A, 0x02, 0x60, 0x12, 0x00, 0x90, 0x05, 0x00, 0x28,
  0x01, 0x40, 0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x90, 0x04, 0x80, 0x20, 0x07, 0xC0, 0x60, 0xC2, 0x00, 0x90, 0x02, 0x40,
  0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0,
  0x02, 0x80, 0x12, 0x00, 0x44, 0x02, 0x18, 0x30, 0x1F, 0x00, 0x08, 0xF8,
  0x0B, 0x04, 0x0C, 0x02, 0x1C, 0x02, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x02,
  0x20, 0x04, 0x30, 0x08, 0x48, 0x10, 0x47, 0xE0, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07, 0xE2, 0x18, 0x28,
  0x40, 0x31, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x40, 0x04, 0x80,
  0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x90, 0x06, 0x10, 0x0C,
  0x10, 0x68, 0x1F, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0xFC, 0x7E, 0x09, 0x00, 0x1C, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x07, 0xF0, 0x10, 0x18, 0x40, 0x09, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x50, 0x00, 0x90, 0x02, 0x18, 0x18, 0x0F, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x0C, 0x04, 0x18, 0x08, 0x60, 0x08, 0x80,
  0x0B, 0x00, 0x0C, 0x00, 0x20, 0x09, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00,
  0xA0, 0x05, 0x00, 0x48, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x28,
  0x02, 0x40, 0x32, 0x02, 0x8C, 0x24, 0x3E, 0x20, 0xF0, 0x04, 0x40, 0x11,
  0x00, 0x44, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x02, 0x20, 0x08,
  0x80, 0x22, 0x01, 0x08, 0x04, 0x20, 0x20, 0x81, 0x04, 0x08, 0x10, 0xC0,
  0x3C, 0x00, 0x20, 0x42, 0x20, 0x41, 0x20, 0x41, 0x20, 0x81, 0x40, 0x81,
  0x40, 0x81, 0x40, 0x81, 0x40, 0x81, 0x40, 0x81, 0x41, 0x01, 0x81, 0x01,
  0x81, 0x02, 0x81, 0x02, 0x81, 0x02, 0x83, 0x04, 0x44, 0x88, 0x78, 0x70,
  0x02, 0x07, 0x03, 0x46, 0x23, 0x09, 0x0B, 0x02, 0x81, 0x00, 0xC0, 0x40,
  0x30, 0x10, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x02, 0x06, 0x00, 0x81, 0x80, 0x20, 0xA0, 0x28, 0x24, 0x32, 0x11, 0x30,
  0x78, 0x30, 0x00, 0x08, 0x02, 0x10, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00,
  0x22, 0x00, 0x84, 0x01, 0x08, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11,
  0x00, 0x42, 0x00, 0x84, 0x03, 0x08, 0x0A, 0x0C, 0x24, 0x0F, 0x88, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x88, 0x02, 0x0C, 0x18, 0x07, 0xC0, 0x00, 0x0F,
  0x82, 0x60, 0xF4, 0x80, 0x3A, 0x00, 0x24, 0x00, 0x88, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x20, 0x80, 0x42, 0x00, 0x88,
  0x01, 0x3E, 0x02, 0x4F, 0xE4, 0x80, 0xFC, 0x01, 0xFC, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xE0, 0x04, 0x20, 0x82, 0x08,
  0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x0F, 0xE0, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x03, 0xF0, 0x38, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x3F, 0x80, 0x1C, 0x01, 0x22, 0x01, 0x41, 0x02,
  0x80, 0x82, 0x80, 0xC4, 0x80, 0x38,
};

const GFXglyph IBMPlexMono_ThinItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 22, 19, 7, -22 },
  { 15, 7, 8, 19, 8, -24 },
  { 22, 19, 22, 19, 1, -22 },
  { 75, 17, 28, 19, 1, -25 },
  { 135, 21, 22, 19, 0, -22 },
  { 193, 19, 22, 19, 0, -22 },
  { 246, 3, 8, 19, 10, -24 },
  { 249, 9, 28, 19, 8, -24 },
  { 281, 10, 28, 19, 2, -24 },
  { 316, 16, 16, 19, 2, -18 },
  { 348, 16, 15, 19, 2, -17 },
  { 378, 4, 9, 19, 5, -3 },
  { 383, 8, 1, 19, 6, -10 },
  { 384, 2, 2, 19, 7, -2 },
  { 385, 17, 28, 19, 1, -24 },
  { 445, 16, 22, 19, 2, -22 },
  { 489, 14, 22, 19, 2, -22 },
  { 528, 16, 22, 19, 1, -22 },
  { 572, 15, 22, 19, 2, -22 },
  { 614, 16, 22, 19, 1, -22 },
  { 658, 16, 22, 19, 2, -22 },
  { 702, 13, 22, 19, 3, -22 },
  { 738, 15, 22, 19, 4, -22 },
  { 780, 16, 22, 19, 2, -22 },
  { 824, 14, 22, 19, 3, -22 },
  { 863, 5, 17, 19, 7, -17 },
  { 874, 7, 23, 19, 5, -17 },
  { 895, 15, 17, 19, 3, -18 },
  { 927, 16, 7, 19, 2, -13 },
  { 941, 15, 17, 19, 2, -18 },
  { 973, 12, 22, 19, 5, -22 },
  { 1006, 14, 25, 19, 3, -22 },
  { 1050, 16, 22, 19, 0, -22 },
  { 1094, 15, 22, 19, 2, -22 },
  { 1136, 15, 22, 19, 3, -22 },
  { 1178, 16, 22, 19, 2, -22 },
  { 1222, 17, 22, 19, 2, -22 },
  { 1269, 17, 22, 19, 2, -22 },
  { 1316, 15, 22, 19, 3, -22 },
  { 1358, 16, 22, 19, 2, -22 },
  { 1402, 17, 22, 19, 2, -22 },
  { 1449, 15, 22, 19, 2, -22 },
  { 1491, 18, 22, 19, 2, -22 },
  { 1541, 13, 22, 19, 3, -22 },
  { 1577, 18, 22, 19, 1, -22 },
  { 1627, 16, 22, 19, 2, -22 },
  { 1671, 16, 22, 19, 2, -22 },
  { 1715, 16, 22, 19, 2, -22 },
  { 1759, 16, 28, 19, 2, -22 },
  { 1815, 16, 22, 19, 2, -22 },
  { 1859, 17, 22, 19, 1, -22 },
  { 1906, 16, 22, 19, 4, -22 },
  { 1950, 15, 22, 19, 3, -22 },
  { 1992, 16, 22, 19, 4, -22 },
  { 2036, 17, 22, 19, 3, -22 },
  { 2083, 20, 22, 19, 0, -22 },
  { 2138, 18, 22, 19, 3, -22 },
  { 2188, 19, 22, 19, 0, -22 },
  { 2241, 13, 28, 19, 6, -24 },
  { 2287, 8, 28, 19, 6, -24 },
  { 2315, 12, 28, 19, 1, -24 },
  { 2357, 14, 12, 19, 3, -22 },
  { 2378, 15, 1, 19, 0, 4 },
  { 2380, 3, 5, 19, 8, -24 },
  { 2382, 15, 17, 19, 2, -17 },
  { 2414, 14, 24, 19, 3, -24 },
  { 2456, 13, 17, 19, 3, -17 },
  { 2484, 16, 24, 19, 2, -24 },
  { 2532, 13, 17, 19, 3, -17 },
  { 2560, 20, 30, 19, 0, -24 },
  { 2635, 15, 23, 19, 2, -17 },
  { 2679, 13, 24, 19, 3, -24 },
  { 2718, 13, 25, 19, 3, -25 },
  { 2759, 13, 31, 19, 4, -25 },
  { 2810, 15, 24, 19, 3, -24 },
  { 2855, 12, 24, 19, 4, -24 },
  { 2891, 17, 17, 19, 1, -17 },
  { 2928, 13, 17, 19, 3, -17 },
  { 2956, 14, 17, 19, 3, -17 },
  { 2986, 16, 23, 19, 1, -17 },
  { 3032, 15, 23, 19, 2, -17 },
  { 3076, 15, 17, 19, 4, -17 },
  { 3108, 15, 17, 19, 2, -17 },
  { 3140, 16, 22, 19, 2, -22 },
  { 3184, 13, 17, 19, 3, -17 },
  { 3212, 14, 17, 19, 3, -17 },
  { 3242, 16, 17, 19, 2, -17 },
  { 3276, 18, 17, 19, 1, -17 },
  { 3315, 15, 23, 19, 1, -17 },
  { 3359, 15, 17, 19, 2, -17 },
  { 3391, 14, 28, 19, 4, -24 },
  { 3440, 6, 28, 19, 7, -24 },
  { 3461, 14, 28, 19, 2, -24 },
  { 3510, 16, 6, 19, 2, -13 },
};

const GFXfont IBMPlexMono_ThinItalic32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_THINITALIC32PT7B_H_
