#ifndef _IBMPLEXMONO_THINITALIC28PT7B_H_
#define _IBMPLEXMONO_THINITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x00, 0x00,
  0x31, 0x80, 0x45, 0x14, 0x92, 0x8A, 0x28, 0x80, 0x00, 0x84, 0x00, 0x88,
  0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x02, 0x10, 0x3E, 0x1F, 0x42, 0x20,
  0x04, 0x20, 0x04, 0x20, 0x04, 0x40, 0x08, 0x40, 0x08, 0x40, 0xF8, 0x7C,
  0x10, 0x80, 0x10, 0x80, 0x10, 0x80, 0x21, 0x00, 0x21, 0x00, 0x22, 0x00,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x1F, 0x80, 0xC8, 0x82, 0x10, 0x88,
  0x21, 0x90, 0x40, 0x20, 0x80, 0x41, 0x00, 0x44, 0x00, 0xC8, 0x00, 0x78,
  0x00, 0x2C, 0x00, 0x44, 0x00, 0x84, 0x02, 0x08, 0x04, 0x10, 0x08, 0x24,
  0x10, 0x44, 0x21, 0x04, 0x84, 0x07, 0xF0, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x07, 0x80, 0x42, 0x10, 0x21, 0x04, 0x10, 0x81, 0x08, 0x20, 0x42,
  0x08, 0x11, 0x02, 0x08, 0x80, 0x42, 0x40, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x06, 0x42, 0x02, 0x20, 0x81, 0x10, 0x20, 0x44,
  0x08, 0x21, 0x02, 0x10, 0x40, 0x88, 0x08, 0x42, 0x01, 0xE0, 0x03, 0xE0,
  0x04, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x04, 0x10, 0x04, 0x10, 0x1E, 0x60, 0x21, 0x80, 0x41, 0x00, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x80, 0x21, 0x80, 0x51, 0x40, 0x92, 0x61, 0x8A,
  0x1E, 0x04, 0x56, 0xA8, 0x01, 0x06, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0xC0, 0x00, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x03, 0x08, 0x33, 0xA7, 0x01, 0xE0,
  0x05, 0x00, 0x24, 0x01, 0x08, 0x08, 0x20, 0x40, 0x42, 0x01, 0x00, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x13, 0x22, 0x44, 0x80, 0xFE, 0xF0, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x60, 0x84, 0x02, 0x40, 0x12,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x80, 0x0C, 0x10, 0x60, 0xC3, 0x00,
  0x18, 0x00, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x22, 0x02, 0x18, 0x20,
  0x3E, 0x00, 0x00, 0x40, 0x0E, 0x00, 0xD0, 0x08, 0x80, 0x84, 0x18, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x81, 0xFF, 0xF0, 0x03,
  0xE0, 0x10, 0x60, 0x80, 0x84, 0x01, 0x10, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFC, 0x03, 0xE0,
  0x10, 0x60, 0x80, 0x84, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x30, 0x1F, 0x00, 0x06, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x80, 0x11, 0x00, 0x42, 0x06, 0x07, 0xE0, 0x00, 0x08, 0x00,
  0x60, 0x02, 0x80, 0x12, 0x00, 0x90, 0x04, 0x40, 0x21, 0x01, 0x04, 0x04,
  0x10, 0x20, 0x41, 0x02, 0x08, 0x08, 0x40, 0x22, 0x00, 0x8F, 0xFF, 0xC0,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x0F, 0xFC, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x2F, 0x81,
  0x41, 0x82, 0x02, 0x10, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x80, 0x22, 0x00, 0x86, 0x0C, 0x07, 0xC0, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x2F, 0xC5, 0x02, 0x60, 0x14,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x60, 0xC1,
  0xF0, 0x7F, 0xFA, 0x00, 0x60, 0x05, 0x00, 0x28, 0x02, 0x40, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x00, 0x07, 0xE0,
  0x40, 0x84, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x10,
  0x30, 0x7E, 0x0E, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x70, 0x02,
  0x80, 0x14, 0x01, 0x18, 0x30, 0x7E, 0x00, 0x0F, 0x83, 0x06, 0x40, 0x24,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0x60, 0xE1,
  0xF4, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x06,
  0x00, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x04, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0x08, 0x21, 0x04, 0x20,
  0x00, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x0F, 0x86, 0x09, 0x00, 0xE0, 0x18, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x2C, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0xE0, 0x20, 0x82,
  0x02, 0x20, 0x12, 0x00, 0x90, 0x04, 0x87, 0xA8, 0x43, 0x44, 0x0A, 0x20,
  0x92, 0x05, 0x10, 0x28, 0x81, 0x44, 0x0A, 0x20, 0x51, 0x0C, 0x86, 0xE4,
  0x08, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x00, 0x20,
  0x01, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x90, 0x04, 0x40, 0x11, 0x00, 0x84,
  0x02, 0x10, 0x10, 0x40, 0x40, 0x82, 0x02, 0x08, 0x08, 0x7F, 0xE1, 0x00,
  0x88, 0x02, 0x20, 0x05, 0x00, 0x14, 0x00, 0x60, 0x01, 0x1F, 0xE1, 0x00,
  0x88, 0x02, 0x40, 0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x02, 0x40, 0x23,
  0xFE, 0x10, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x14, 0x01, 0x20, 0x19, 0xFF, 0x00, 0x07, 0xC0, 0x41, 0x04, 0x04, 0x40,
  0x24, 0x01, 0xA0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x04, 0x80, 0x44, 0x04, 0x18,
  0x60, 0x7C, 0x00, 0x1F, 0xC0, 0x81, 0x88, 0x04, 0x40, 0x12, 0x00, 0x90,
  0x04, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00,
  0xC0, 0x06, 0x00, 0x50, 0x02, 0x80, 0x24, 0x03, 0x20, 0x31, 0xFE, 0x00,
  0x1F, 0xFC, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x00, 0xFF, 0xE4, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F, 0xF8, 0x1F,
  0xFE, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x7F, 0xE1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xE0, 0x30, 0x41, 0x80, 0x84, 0x02, 0x20, 0x0C, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x7E, 0x80, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x40, 0x11, 0x01, 0xC2, 0x0E, 0x07, 0xC8,
  0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x09, 0x00, 0x24, 0x00,
  0x90, 0x02, 0x40, 0x09, 0xFF, 0xE4, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00,
  0x48, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x08, 0x0F,
  0xFE, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x07, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x80, 0x44, 0x04, 0x10, 0x60, 0x7C, 0x00, 0x10, 0x02,
  0x40, 0x08, 0x80, 0x21, 0x00, 0x82, 0x02, 0x04, 0x08, 0x08, 0x20, 0x20,
  0x80, 0x46, 0x00, 0x94, 0x01, 0x48, 0x03, 0x08, 0x04, 0x10, 0x08, 0x10,
  0x20, 0x20, 0x40, 0x20, 0x80, 0x41, 0x00, 0x42, 0x00, 0x84, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x7F, 0xF0, 0x10, 0x02, 0x30, 0x0C, 0x60, 0x19, 0x40, 0x52,
  0x40, 0xA4, 0x82, 0x49, 0x09, 0x12, 0x12, 0x22, 0x44, 0x85, 0x09, 0x0A,
  0x12, 0x08, 0x24, 0x10, 0x88, 0x01, 0x10, 0x02, 0x20, 0x04, 0x80, 0x09,
  0x00, 0x12, 0x00, 0x44, 0x00, 0x80, 0x10, 0x04, 0xC0, 0x12, 0x80, 0x4A,
  0x01, 0x28, 0x08, 0x90, 0x24, 0x40, 0x91, 0x02, 0x42, 0x09, 0x08, 0x24,
  0x21, 0x10, 0x44, 0x81, 0x12, 0x04, 0x48, 0x09, 0x20, 0x24, 0x80, 0xA2,
  0x01, 0x88, 0x06, 0x20, 0x08, 0x03, 0xE0, 0x60, 0x84, 0x02, 0x40, 0x12,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x22, 0x02, 0x18, 0x20,
  0x3E, 0x00, 0x1F, 0xF0, 0x40, 0x22, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x50, 0x01, 0x40, 0x09, 0x00, 0x47, 0xFE, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x03, 0xE0, 0x60, 0x84, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00,
  0x28, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0A,
  0x00, 0x50, 0x02, 0x80, 0x22, 0x02, 0x18, 0x20, 0x3E, 0x00, 0x40, 0x01,
  0x08, 0x04, 0xC0, 0x2C, 0x00, 0x80, 0x1F, 0xF0, 0x40, 0x22, 0x00, 0x48,
  0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x09, 0x00, 0x47,
  0xFE, 0x10, 0x80, 0x41, 0x01, 0x04, 0x08, 0x08, 0x20, 0x20, 0x80, 0x42,
  0x01, 0x08, 0x02, 0x20, 0x08, 0x03, 0xE0, 0x18, 0x30, 0x40, 0x11, 0x00,
  0x12, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0F, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x80,
  0x08, 0x80, 0x20, 0x80, 0x80, 0xFE, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x24, 0x00, 0x90, 0x02, 0x40,
  0x09, 0x00, 0x24, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x08, 0x80, 0x21, 0x01, 0x06, 0x0C, 0x0F, 0xC0, 0x80, 0x0C, 0x00, 0x60,
  0x05, 0x00, 0x28, 0x02, 0x40, 0x12, 0x01, 0x10, 0x08, 0x40, 0x82, 0x04,
  0x10, 0x40, 0x82, 0x04, 0x20, 0x21, 0x00, 0x90, 0x04, 0x80, 0x28, 0x01,
  0x40, 0x0C, 0x00, 0x20, 0x00, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00,
  0x24, 0x00, 0x48, 0x00, 0x90, 0x41, 0x20, 0x84, 0x43, 0x08, 0x8A, 0x11,
  0x14, 0x24, 0x48, 0x88, 0x89, 0x12, 0x12, 0x24, 0x28, 0x50, 0x50, 0xA0,
  0xA1, 0x41, 0x43, 0x03, 0x06, 0x02, 0x00, 0x08, 0x00, 0x84, 0x00, 0x81,
  0x00, 0x80, 0x80, 0x80, 0x20, 0x40, 0x10, 0x40, 0x04, 0x40, 0x02, 0x40,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x28, 0x00, 0x22, 0x00, 0x21,
  0x00, 0x20, 0x40, 0x10, 0x20, 0x10, 0x08, 0x10, 0x04, 0x10, 0x01, 0x10,
  0x00, 0x80, 0x80, 0x03, 0x00, 0x09, 0x00, 0x22, 0x00, 0x82, 0x01, 0x04,
  0x04, 0x0C, 0x10, 0x08, 0x40, 0x11, 0x00, 0x12, 0x00, 0x28, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xC4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xFC, 0x00, 0x82, 0x08, 0x20, 0x82, 0x04,
  0x10, 0x41, 0x02, 0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x02, 0x08, 0x20,
  0x81, 0x04, 0x0F, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0xFE,
  0x00, 0x00, 0x80, 0x0C, 0x00, 0x90, 0x08, 0x80, 0x82, 0x04, 0x10, 0x40,
  0x44, 0x02, 0x40, 0x12, 0x00, 0x60, 0x02, 0xFF, 0xF8, 0x92, 0x22, 0x0F,
  0x98, 0x83, 0x88, 0x0C, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04,
  0x80, 0x24, 0x01, 0x20, 0x19, 0x01, 0x86, 0x14, 0x0F, 0x1C, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x78, 0x2C,
  0x31, 0x80, 0x88, 0x02, 0x40, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x28, 0x02,
  0x40, 0x12, 0x00, 0xB0, 0x09, 0x41, 0x89, 0xF8, 0x00, 0x07, 0x81, 0x86,
  0x20, 0x24, 0x01, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x02,
  0x80, 0x24, 0x04, 0x20, 0x81, 0xF0, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x83, 0xE4, 0x10, 0x70, 0x80, 0xC4,
  0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x22,
  0x01, 0x88, 0x0A, 0x18, 0x50, 0x1E, 0x40, 0x07, 0xC1, 0x83, 0x20, 0x14,
  0x01, 0x40, 0x18, 0x02, 0x81, 0xCF, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x34,
  0x02, 0x20, 0xC1, 0xF0, 0x00, 0x3F, 0x80, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x1F, 0xFE, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x04, 0x10, 0x03, 0x08, 0x00, 0xC4, 0x00, 0x12, 0x00, 0x05, 0x00, 0x01,
  0x00, 0x00, 0x07, 0xCC, 0x20, 0xE1, 0x01, 0x88, 0x02, 0x40, 0x09, 0x00,
  0x24, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x44, 0x03, 0x10, 0x14, 0x30,
  0xA0, 0x3C, 0x80, 0x02, 0x00, 0x08, 0x00, 0x22, 0x01, 0x04, 0x18, 0x0F,
  0xC0, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x3C, 0x24, 0x23, 0x81, 0x30, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x28, 0x02, 0x80, 0x40, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x81, 0x10, 0x62, 0x30, 0x4C, 0x16,
  0x01, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x08, 0x10, 0x41,
  0x02, 0x20, 0x12, 0x00, 0xE0, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0xF8, 0x2C, 0x10, 0xC0,
  0x42, 0x01, 0x08, 0x04, 0x40, 0x21, 0x03, 0x04, 0xF0, 0x11, 0x00, 0x44,
  0x06, 0x08, 0x28, 0x11, 0x20, 0x58, 0x80, 0xC0, 0x7E, 0x10, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x81, 0x10, 0xC2, 0x30, 0x98, 0x16, 0x03,
  0x00, 0x27, 0x1C, 0x51, 0x44, 0xC3, 0x09, 0x04, 0x12, 0x08, 0x28, 0x20,
  0x90, 0x41, 0x20, 0x82, 0x41, 0x04, 0x82, 0x0A, 0x08, 0x14, 0x10, 0x48,
  0x20, 0x90, 0x41, 0x00, 0x23, 0xC2, 0x42, 0x38, 0x13, 0x01, 0x20, 0x12,
  0x01, 0x40, 0x14, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x80, 0x28,
  0x04, 0x07, 0xC0, 0xC1, 0x08, 0x04, 0x80, 0x24, 0x01, 0x40, 0x0E, 0x00,
  0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x08, 0x80, 0x42, 0x0C, 0x0F, 0x80,
  0x11, 0xE0, 0x58, 0x61, 0x80, 0x84, 0x01, 0x10, 0x04, 0x80, 0x12, 0x00,
  0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x00, 0x98, 0x04, 0x50, 0x61, 0x3F,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x0F,
  0x98, 0x83, 0x88, 0x0C, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04,
  0x80, 0x24, 0x01, 0x20, 0x19, 0x01, 0x46, 0x14, 0x0F, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0xFC, 0xFC, 0x14, 0x00,
  0x60, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x81,
  0x88, 0x02, 0x80, 0x04, 0x00, 0x10, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x80, 0x05, 0x00, 0x26, 0x06, 0x0F, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x0F, 0xFF, 0xC1, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x0C,
  0x08, 0x40, 0x46, 0x01, 0x60, 0x06, 0x00, 0x40, 0x28, 0x05, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x03, 0x40, 0xCC,
  0x28, 0xF9, 0x00, 0xF8, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x88,
  0x04, 0x40, 0x44, 0x02, 0x20, 0x21, 0x01, 0x08, 0x10, 0x41, 0x02, 0x30,
  0x1E, 0x00, 0x61, 0x09, 0x04, 0x24, 0x10, 0x50, 0x41, 0x41, 0x05, 0x08,
  0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x28, 0x20, 0xA1, 0x84, 0x8A,
  0x31, 0xC7, 0x80, 0x04, 0x1C, 0x34, 0x45, 0x85, 0x0C, 0x0C, 0x10, 0x18,
  0x20, 0x20, 0x40, 0x40, 0x00, 0x80, 0x81, 0x01, 0x06, 0x02, 0x0C, 0x04,
  0x28, 0x78, 0x8B, 0x0E, 0x08, 0x00, 0x10, 0x08, 0x80, 0x44, 0x02, 0x40,
  0x12, 0x00, 0x90, 0x08, 0x80, 0x44, 0x02, 0x20, 0x12, 0x00, 0x90, 0x0C,
  0x40, 0xC3, 0x0A, 0x0F, 0x90, 0x00, 0x80, 0x04, 0x00, 0x44, 0x02, 0x10,
  0x60, 0x7C, 0x00, 0x0F, 0x84, 0x41, 0xD2, 0x00, 0xC8, 0x02, 0x20, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x42, 0x01, 0x18, 0x04,
  0xBF, 0x92, 0x03, 0xE0, 0x01, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x0F,
  0xC0, 0x07, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x1F, 0x80, 0x08, 0x42, 0x21,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x84, 0x42, 0x10,
  0x80, 0x0F, 0xE0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x0F, 0x81, 0x80,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0xFE, 0x00, 0x38, 0x05, 0x10, 0x28, 0x20, 0xA0,
  0x44, 0x80, 0xE0,
};

const GFXglyph IBMPlexMono_ThinItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 6, 7, 17, 7, -21 },
  { 20, 16, 20, 17, 1, -20 },
  { 60, 15, 26, 17, 1, -23 },
  { 109, 18, 20, 17, 0, -20 },
  { 154, 16, 20, 17, 0, -20 },
  { 194, 2, 7, 17, 9, -21 },
  { 196, 8, 25, 17, 7, -21 },
  { 221, 9, 25, 17, 2, -21 },
  { 250, 14, 14, 17, 2, -15 },
  { 275, 13, 15, 17, 2, -16 },
  { 300, 4, 7, 17, 4, -2 },
  { 304, 7, 1, 17, 5, -9 },
  { 305, 2, 2, 17, 6, -2 },
  { 306, 15, 25, 17, 1, -21 },
  { 353, 13, 20, 17, 2, -20 },
  { 386, 13, 20, 17, 1, -20 },
  { 419, 14, 20, 17, 1, -20 },
  { 454, 14, 20, 17, 1, -20 },
  { 489, 14, 20, 17, 1, -20 },
  { 524, 14, 20, 17, 2, -20 },
  { 559, 12, 20, 17, 2, -20 },
  { 589, 13, 20, 17, 3, -20 },
  { 622, 13, 20, 17, 2, -20 },
  { 655, 12, 20, 17, 3, -20 },
  { 685, 4, 15, 17, 6, -15 },
  { 693, 6, 20, 17, 4, -15 },
  { 708, 13, 15, 17, 3, -16 },
  { 733, 15, 6, 17, 1, -12 },
  { 745, 14, 15, 17, 1, -16 },
  { 772, 11, 20, 17, 4, -20 },
  { 800, 13, 23, 17, 2, -20 },
  { 838, 14, 20, 17, 0, -20 },
  { 873, 13, 20, 17, 2, -20 },
  { 906, 13, 20, 17, 3, -20 },
  { 939, 13, 20, 17, 2, -20 },
  { 972, 14, 20, 17, 2, -20 },
  { 1007, 15, 20, 17, 2, -20 },
  { 1045, 14, 20, 17, 2, -20 },
  { 1080, 14, 20, 17, 2, -20 },
  { 1115, 15, 20, 17, 1, -20 },
  { 1153, 13, 20, 17, 2, -20 },
  { 1186, 15, 20, 17, 2, -20 },
  { 1224, 11, 20, 17, 3, -20 },
  { 1252, 15, 20, 17, 1, -20 },
  { 1290, 14, 20, 17, 2, -20 },
  { 1325, 13, 20, 17, 2, -20 },
  { 1358, 14, 20, 17, 2, -20 },
  { 1393, 13, 25, 17, 2, -20 },
  { 1434, 14, 20, 17, 2, -20 },
  { 1469, 15, 20, 17, 1, -20 },
  { 1507, 15, 20, 17, 3, -20 },
  { 1545, 14, 20, 17, 2, -20 },
  { 1580, 13, 20, 17, 4, -20 },
  { 1613, 15, 20, 17, 2, -20 },
  { 1651, 17, 20, 17, 0, -20 },
  { 1694, 15, 20, 17, 3, -20 },
  { 1732, 17, 20, 17, 0, -20 },
  { 1775, 10, 25, 17, 6, -21 },
  { 1807, 6, 25, 17, 6, -21 },
  { 1826, 11, 25, 17, 1, -21 },
  { 1861, 13, 11, 17, 2, -20 },
  { 1879, 13, 1, 17, 0, 3 },
  { 1881, 3, 5, 17, 7, -22 },
  { 1883, 13, 14, 17, 2, -14 },
  { 1906, 13, 21, 17, 2, -21 },
  { 1941, 12, 14, 17, 2, -14 },
  { 1962, 14, 21, 17, 2, -21 },
  { 1999, 12, 14, 17, 2, -14 },
  { 2020, 17, 27, 17, 0, -21 },
  { 2078, 14, 20, 17, 1, -14 },
  { 2113, 12, 21, 17, 2, -21 },
  { 2145, 11, 21, 17, 3, -21 },
  { 2174, 12, 27, 17, 3, -21 },
  { 2215, 14, 21, 17, 2, -21 },
  { 2252, 11, 21, 17, 3, -21 },
  { 2281, 15, 14, 17, 1, -14 },
  { 2308, 12, 14, 17, 2, -14 },
  { 2329, 13, 14, 17, 2, -14 },
  { 2352, 14, 20, 17, 1, -14 },
  { 2387, 13, 20, 17, 2, -14 },
  { 2420, 14, 14, 17, 3, -14 },
  { 2445, 13, 14, 17, 2, -14 },
  { 2468, 14, 20, 17, 2, -20 },
  { 2503, 11, 14, 17, 3, -14 },
  { 2523, 13, 14, 17, 2, -14 },
  { 2546, 14, 14, 17, 2, -14 },
  { 2571, 15, 14, 17, 1, -14 },
  { 2598, 13, 20, 17, 1, -14 },
  { 2631, 14, 14, 17, 1, -14 },
  { 2656, 13, 25, 17, 3, -21 },
  { 2697, 5, 25, 17, 6, -21 },
  { 2713, 13, 25, 17, 1, -21 },
  { 2754, 14, 5, 17, 2, -11 },
};

const GFXfont IBMPlexMono_ThinItalic28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_THINITALIC28PT7B_H_
