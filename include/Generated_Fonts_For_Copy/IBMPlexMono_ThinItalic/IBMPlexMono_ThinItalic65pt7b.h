#ifndef _IBMPLEXMONO_THINITALIC65PT7B_H_
#define _IBMPLEXMONO_THINITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x10, 0x19,
  0x80, 0xCC, 0x04, 0x60, 0x23, 0x01, 0x10, 0x18, 0x80, 0xCC, 0x06, 0x60,
  0x23, 0x01, 0x18, 0x18, 0x80, 0xC4, 0x06, 0x60, 0x33, 0x01, 0x18, 0x08,
  0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x01, 0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x08, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0x04, 0x3C, 0x00, 0x03, 0x00, 0x80, 0xC0,
  0x00, 0x80, 0x10, 0x06, 0x00, 0x20, 0x02, 0x00, 0x60, 0x08, 0x00, 0xC0,
  0x04, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x40, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x01, 0xE2, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x08, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x06, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x10, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x08, 0x10, 0x00, 0x40, 0x03, 0x06, 0x00, 0x08, 0x00, 0x40, 0x60, 0x01,
  0x00, 0x18, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x03,
  0x01, 0x00, 0xC0, 0x00, 0x1E, 0x20, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x40, 0x04, 0x00, 0x10, 0x00, 0x10, 0x01, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x08, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x20, 0x02,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x04, 0x00, 0x04, 0x00, 0x06, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x18, 0x00, 0x10, 0x18, 0x00, 0x03, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x80, 0x80, 0x00, 0x06, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x60, 0x08, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x01, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x04, 0x03, 0x03, 0x00, 0x00, 0x01, 0x80, 0x80,
  0x30, 0x00, 0x00, 0x60, 0x20, 0x03, 0x00, 0x00, 0x08, 0x08, 0x00, 0x20,
  0x00, 0x02, 0x03, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x40, 0x08, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x20, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x03,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x40, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x01, 0x00, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x03, 0xE8, 0x18, 0x00, 0x00, 0x60, 0x67, 0x00, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x01, 0x00, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x02, 0xC0, 0x06, 0x00, 0x00, 0x12, 0x00, 0x58, 0x00, 0x00, 0x98,
  0x06, 0x40, 0x00, 0x08, 0x40, 0x22, 0x00, 0x00, 0x41, 0x02, 0x18, 0x00,
  0x04, 0x0C, 0x30, 0x60, 0x00, 0x40, 0x21, 0x01, 0x80, 0x04, 0x01, 0x90,
  0x03, 0x01, 0xC0, 0x07, 0x80, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x18, 0x84,
  0x63, 0x18, 0x84, 0x23, 0x18, 0xC4, 0x21, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F,
  0x00, 0x08, 0x00, 0x78, 0xF0, 0x04, 0x01, 0xF0, 0x0F, 0x02, 0x07, 0x80,
  0x00, 0xF3, 0x3E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x40, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x04, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x18,
  0x0C, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x68, 0x00, 0x70, 0x00, 0x90, 0x00, 0xE0,
  0x01, 0x60, 0x01, 0xC0, 0x02, 0xC0, 0x03, 0x80, 0x0D, 0x80, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x40, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x07, 0x20, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x10, 0x07,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80, 0x08, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x80,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x40, 0x00, 0x04, 0x00, 0x60, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x0F, 0xF8, 0x00, 0x04, 0x30, 0x0E,
  0x00, 0x04, 0xC0, 0x01, 0x80, 0x0D, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x0F, 0xF0, 0x00,
  0x87, 0x00, 0xE0, 0x19, 0x80, 0x03, 0x01, 0x30, 0x00, 0x08, 0x34, 0x00,
  0x00, 0x42, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x27, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFD, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x04, 0x40, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x04, 0x01, 0x80, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x22, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0E, 0x40, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x14,
  0x20, 0x00, 0x03, 0x41, 0x00, 0x00, 0x6C, 0x0C, 0x00, 0x18, 0x80, 0x70,
  0x0E, 0x18, 0x00, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xE0,
  0xF0, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00, 0x41, 0x80, 0x00,
  0x31, 0x80, 0x00, 0x09, 0x80, 0x00, 0x06, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x10, 0x01, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x02, 0x01, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x30, 0xC0, 0x07, 0xF0, 0xC2, 0x00, 0x70, 0x22, 0x08, 0x03, 0x00,
  0x48, 0x60, 0x18, 0x00, 0xA1, 0x80, 0x40, 0x02, 0x84, 0x02, 0x00, 0x06,
  0x10, 0x08, 0x00, 0x18, 0x40, 0x60, 0x00, 0x43, 0x01, 0x00, 0x01, 0x0C,
  0x04, 0x00, 0x04, 0x20, 0x30, 0x00, 0x10, 0x80, 0xC0, 0x00, 0xC2, 0x03,
  0x00, 0x03, 0x18, 0x08, 0x00, 0x08, 0x60, 0x20, 0x00, 0x21, 0x80, 0x80,
  0x00, 0x84, 0x02, 0x00, 0x02, 0x10, 0x08, 0x00, 0x18, 0x40, 0x20, 0x00,
  0x61, 0x00, 0x80, 0x01, 0x04, 0x02, 0x00, 0x0C, 0x30, 0x08, 0x00, 0x50,
  0xC0, 0x30, 0x03, 0x43, 0x00, 0x40, 0x1B, 0x0C, 0x00, 0xC0, 0xCC, 0x30,
  0x01, 0xFC, 0x20, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x30, 0x00, 0x10, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x08,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x04, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x18, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x00, 0x81, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x00, 0x80, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0x80, 0x03, 0x80, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30,
  0x01, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x03, 0x00, 0x40, 0x00, 0x06, 0x00, 0x40, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F,
  0xFF, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x0A, 0x03, 0x00, 0x00,
  0x48, 0x06, 0x00, 0x02, 0x20, 0x0C, 0x00, 0x31, 0x80, 0x0C, 0x03, 0x86,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x60,
  0x7F, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x08, 0x01, 0x00, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0xC0,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x0C, 0x0D, 0x00, 0x00, 0x00, 0xC1, 0x98, 0x00, 0x00,
  0x08, 0x30, 0x80, 0x00, 0x00, 0x86, 0x0C, 0x00, 0x00, 0x08, 0xC0, 0x40,
  0x00, 0x01, 0x98, 0x06, 0x00, 0x00, 0x1B, 0x00, 0x20, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x10, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x1C, 0x05, 0x00, 0x00, 0x03, 0x80, 0xA0, 0x00, 0x00, 0xB0, 0x36,
  0x00, 0x00, 0x34, 0x06, 0xC0, 0x00, 0x04, 0x80, 0xC8, 0x00, 0x01, 0x90,
  0x11, 0x00, 0x00, 0x62, 0x02, 0x30, 0x00, 0x08, 0xC0, 0x42, 0x00, 0x03,
  0x18, 0x18, 0x40, 0x00, 0x42, 0x03, 0x0C, 0x00, 0x10, 0x40, 0x60, 0x80,
  0x06, 0x08, 0x08, 0x10, 0x00, 0x81, 0x01, 0x02, 0x00, 0x30, 0x60, 0x20,
  0x60, 0x0C, 0x0C, 0x0C, 0x04, 0x01, 0x01, 0x01, 0x80, 0x80, 0x60, 0x20,
  0x30, 0x18, 0x08, 0x04, 0x04, 0x01, 0x03, 0x00, 0x80, 0x80, 0x20, 0xC0,
  0x30, 0x10, 0x04, 0x10, 0x06, 0x06, 0x00, 0xC6, 0x00, 0x80, 0xC0, 0x08,
  0x80, 0x10, 0x18, 0x01, 0x20, 0x02, 0x02, 0x00, 0x2C, 0x00, 0x40, 0x40,
  0x03, 0x00, 0x18, 0x08, 0x00, 0x60, 0x03, 0x03, 0x00, 0x08, 0x00, 0x40,
  0x60, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0xE0, 0x00, 0x00, 0x40, 0x50, 0x00, 0x00, 0x20, 0x2C,
  0x00, 0x00, 0x30, 0x36, 0x00, 0x00, 0x18, 0x19, 0x00, 0x00, 0x08, 0x08,
  0xC0, 0x00, 0x04, 0x04, 0x60, 0x00, 0x02, 0x02, 0x10, 0x00, 0x01, 0x03,
  0x0C, 0x00, 0x01, 0x81, 0x82, 0x00, 0x00, 0xC0, 0xC1, 0x00, 0x00, 0x40,
  0x40, 0xC0, 0x00, 0x20, 0x20, 0x20, 0x00, 0x10, 0x10, 0x10, 0x00, 0x08,
  0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x02, 0x00, 0x06, 0x06, 0x01, 0x00, 0x02,
  0x02, 0x00, 0xC0, 0x01, 0x01, 0x00, 0x20, 0x00, 0x80, 0x80, 0x10, 0x00,
  0x40, 0xC0, 0x0C, 0x00, 0x60, 0x60, 0x02, 0x00, 0x30, 0x30, 0x01, 0x80,
  0x10, 0x10, 0x00, 0xC0, 0x08, 0x08, 0x00, 0x20, 0x04, 0x04, 0x00, 0x18,
  0x02, 0x06, 0x00, 0x04, 0x03, 0x03, 0x00, 0x02, 0x01, 0x81, 0x80, 0x01,
  0x80, 0x80, 0x80, 0x00, 0x40, 0x40, 0x40, 0x00, 0x20, 0x20, 0x20, 0x00,
  0x18, 0x10, 0x30, 0x00, 0x04, 0x18, 0x18, 0x00, 0x02, 0x0C, 0x0C, 0x00,
  0x01, 0x84, 0x04, 0x00, 0x00, 0x42, 0x02, 0x00, 0x00, 0x21, 0x01, 0x00,
  0x00, 0x18, 0x81, 0x80, 0x00, 0x04, 0xC0, 0xC0, 0x00, 0x03, 0x60, 0x60,
  0x00, 0x01, 0xA0, 0x20, 0x00, 0x00, 0x50, 0x10, 0x00, 0x00, 0x38, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x02, 0x01, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x00, 0x40, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x02, 0x01, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0x00, 0x40, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x08, 0x02, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x10,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x10, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x01, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00,
  0x04, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x20,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x08, 0x60, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x80, 0x10, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x01, 0x00, 0x10, 0x00, 0x03, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x08, 0x00, 0x04, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x04, 0x00, 0x20, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x04,
  0x10, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00,
  0x04, 0x08, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x30, 0x00, 0x81, 0x80, 0x0E, 0x00, 0x30, 0x30,
  0x01, 0x40, 0x06, 0x06, 0x00, 0x68, 0x00, 0x80, 0xC0, 0x09, 0x00, 0x10,
  0x10, 0x03, 0x30, 0x06, 0x02, 0x00, 0x46, 0x00, 0xC0, 0x40, 0x18, 0xC0,
  0x10, 0x08, 0x02, 0x08, 0x02, 0x01, 0x00, 0xC1, 0x00, 0xC0, 0x20, 0x10,
  0x20, 0x10, 0x04, 0x06, 0x04, 0x02, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x10,
  0x10, 0x18, 0x18, 0x02, 0x06, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x20, 0x40,
  0x18, 0x30, 0x04, 0x18, 0x03, 0x04, 0x00, 0x83, 0x00, 0x61, 0x80, 0x10,
  0x40, 0x0C, 0x20, 0x02, 0x08, 0x01, 0x0C, 0x00, 0x63, 0x00, 0x21, 0x00,
  0x0C, 0x60, 0x04, 0x60, 0x01, 0x88, 0x00, 0x88, 0x00, 0x11, 0x00, 0x13,
  0x00, 0x02, 0x60, 0x02, 0x40, 0x00, 0x48, 0x00, 0x58, 0x00, 0x09, 0x00,
  0x0B, 0x00, 0x01, 0x20, 0x01, 0x40, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x02, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x08, 0x00, 0x20, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x01, 0x00, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x03, 0x00, 0x18, 0x00, 0x08, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x04, 0x00, 0x40, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18,
  0x00, 0x0F, 0xF0, 0x18, 0x03, 0x80, 0xE0, 0xC0, 0x30, 0x00, 0x84, 0x06,
  0x00, 0x02, 0x20, 0x60, 0x00, 0x09, 0x06, 0x00, 0x00, 0x28, 0x20, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0E, 0x10, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0A, 0x04, 0x00, 0x00, 0x50, 0x30, 0x00, 0x04,
  0x80, 0x80, 0x00, 0x4C, 0x02, 0x00, 0x06, 0x60, 0x08, 0x00, 0x42, 0x00,
  0x30, 0x1C, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x0F,
  0xF0, 0x00, 0x41, 0xC0, 0xE0, 0x06, 0x10, 0x00, 0x80, 0x33, 0x00, 0x02,
  0x01, 0x90, 0x00, 0x08, 0x09, 0x00, 0x00, 0x60, 0x50, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x23, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x20, 0xA0, 0x00, 0x02, 0x04, 0x80,
  0x00, 0x30, 0x22, 0x00, 0x03, 0x03, 0x08, 0x00, 0x60, 0x18, 0x38, 0x0E,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x09, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x60, 0x00, 0x04, 0x04, 0x00,
  0x01, 0x00, 0x40, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x70, 0x1C, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x03,
  0xFC, 0x06, 0x00, 0x38, 0x0E, 0x0C, 0x00, 0xC0, 0x02, 0x10, 0x06, 0x00,
  0x02, 0x20, 0x18, 0x00, 0x02, 0x40, 0x60, 0x00, 0x02, 0x80, 0x80, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x00, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0E, 0x01, 0x00,
  0x00, 0x14, 0x03, 0x00, 0x00, 0x48, 0x02, 0x00, 0x01, 0x30, 0x02, 0x00,
  0x06, 0x60, 0x02, 0x00, 0x10, 0x80, 0x03, 0x01, 0xC1, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x08, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x22, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0xF0, 0x04, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x04, 0x00, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x06, 0x00, 0x38, 0x0E, 0x0C, 0x00, 0xC0, 0x02, 0x10, 0x06,
  0x00, 0x02, 0x20, 0x18, 0x00, 0x02, 0x40, 0x60, 0x00, 0x02, 0x80, 0x80,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0A, 0x01,
  0x00, 0x00, 0x14, 0x03, 0x00, 0x00, 0x48, 0x02, 0x00, 0x01, 0x30, 0x02,
  0x00, 0x06, 0x60, 0x02, 0x00, 0x10, 0x80, 0x03, 0x01, 0xC1, 0x00, 0x01,
  0xFE, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x3F, 0x80, 0x18, 0x70, 0x18, 0x04, 0x30, 0x03,
  0x01, 0x10, 0x00, 0x60, 0x48, 0x00, 0x08, 0x34, 0x00, 0x01, 0x0F, 0x00,
  0x00, 0x43, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01,
  0x10, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x06, 0x20, 0x00, 0x01, 0x18, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x04, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x30, 0x02, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x08, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x20, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x30, 0x01, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x30, 0x04, 0x00, 0x03, 0x01, 0x80, 0x00, 0x10, 0x30, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x01, 0xFE, 0x00, 0x02, 0x0E, 0x01, 0x80, 0x06, 0x18, 0x00, 0xC0, 0x06,
  0x60, 0x00, 0x60, 0x04, 0xC0, 0x00, 0x20, 0x04, 0x80, 0x00, 0x30, 0x05,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x80, 0x18, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60, 0x00, 0x10,
  0x03, 0x80, 0x00, 0x10, 0x3C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x20,
  0x04, 0x00, 0x03, 0x20, 0x02, 0x00, 0x06, 0x60, 0x03, 0x00, 0x0C, 0x60,
  0x01, 0x00, 0x18, 0x40, 0x01, 0x80, 0x20, 0x40, 0x00, 0x80, 0x40, 0x40,
  0x00, 0xC0, 0x80, 0x40, 0x00, 0x41, 0x00, 0xC0, 0x00, 0x22, 0x00, 0xC0,
  0x00, 0x24, 0x00, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x01, 0x01, 0x00,
  0x02, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x10, 0x03, 0x00, 0x60, 0x02, 0x00,
  0xC0, 0x02, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x08, 0x00, 0x06, 0x30,
  0x00, 0x04, 0x40, 0x00, 0x05, 0x80, 0x00, 0x06, 0x00, 0x00, 0x06, 0x1F,
  0x80, 0x7E, 0x01, 0x08, 0x30, 0x20, 0xC0, 0x4C, 0x06, 0x10, 0x18, 0x12,
  0x00, 0x88, 0x02, 0x05, 0x00, 0x24, 0x00, 0xC3, 0x80, 0x0E, 0x00, 0x30,
  0xC0, 0x03, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00,
  0xC2, 0x00, 0x08, 0x00, 0x20, 0x80, 0x02, 0x00, 0x08, 0x60, 0x00, 0x80,
  0x02, 0x18, 0x00, 0x60, 0x00, 0x86, 0x00, 0x18, 0x00, 0x61, 0x00, 0x04,
  0x00, 0x18, 0x40, 0x01, 0x00, 0x04, 0x10, 0x00, 0x40, 0x01, 0x0C, 0x00,
  0x10, 0x00, 0x43, 0x00, 0x0C, 0x00, 0x10, 0xC0, 0x03, 0x00, 0x0C, 0x20,
  0x00, 0x80, 0x03, 0x08, 0x00, 0x20, 0x00, 0x82, 0x00, 0x08, 0x00, 0x21,
  0x80, 0x02, 0x00, 0x08, 0x60, 0x01, 0x80, 0x02, 0x18, 0x00, 0x60, 0x01,
  0x84, 0x00, 0x10, 0x00, 0x61, 0x00, 0x04, 0x00, 0x10, 0x40, 0x01, 0x00,
  0x04, 0x30, 0x00, 0x40, 0x01, 0x0C, 0x00, 0x30, 0x00, 0x43, 0x00, 0x0C,
  0x00, 0x30, 0x80, 0x02, 0x00, 0x0C, 0x20, 0x00, 0x80, 0x02, 0x00, 0x06,
  0x03, 0xF8, 0x01, 0x07, 0x01, 0x80, 0x43, 0x00, 0x30, 0x11, 0x00, 0x06,
  0x04, 0x80, 0x00, 0x83, 0x40, 0x00, 0x10, 0xF0, 0x00, 0x04, 0x38, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x60,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x02, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x00,
  0x40, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0x81, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x04, 0x00,
  0x18, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x80, 0xFF,
  0x00, 0x01, 0x07, 0x03, 0x80, 0x06, 0x10, 0x00, 0x80, 0x0C, 0xC0, 0x00,
  0x80, 0x11, 0x00, 0x00, 0x80, 0x24, 0x00, 0x01, 0x80, 0x50, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x83, 0x00, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x02, 0x02, 0x80, 0x00, 0x08, 0x04, 0x80, 0x00, 0x30, 0x08, 0x80, 0x00,
  0xC0, 0x30, 0x80, 0x06, 0x00, 0x60, 0xE0, 0x38, 0x00, 0xC0, 0x7F, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x18, 0x03, 0x80, 0xE0, 0xC0, 0x30, 0x00, 0x84, 0x06,
  0x00, 0x02, 0x20, 0x60, 0x00, 0x09, 0x06, 0x00, 0x00, 0x28, 0x20, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x0E, 0x10, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0A, 0x04, 0x00, 0x00, 0x50, 0x30, 0x00, 0x04,
  0x80, 0x80, 0x00, 0x4C, 0x02, 0x00, 0x06, 0x60, 0x08, 0x00, 0x42, 0x00,
  0x30, 0x1C, 0x10, 0x00, 0x7F, 0x80, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x10, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x40, 0x01, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x04, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x60, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x02, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x70, 0x80, 0x00, 0x2C, 0x30, 0x00, 0x12, 0x04, 0x00, 0x04, 0x81,
  0x80, 0x02, 0x20, 0x30, 0x03, 0x08, 0x06, 0x03, 0x86, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x14, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x80, 0x40, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x00, 0x80, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x10, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08, 0x04, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x08, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0x10, 0x01,
  0x00, 0x01, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x30, 0x00, 0x10, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x0C, 0x08, 0x00, 0x20,
  0x04, 0x08, 0x00, 0x60, 0x06, 0x08, 0x00, 0x60, 0x06, 0x18, 0x00, 0x60,
  0x02, 0x18, 0x00, 0x40, 0x02, 0x10, 0x00, 0x40, 0x02, 0x10, 0x00, 0x40,
  0x03, 0x10, 0x00, 0xC0, 0x03, 0x10, 0x00, 0xC0, 0x03, 0x30, 0x00, 0xC0,
  0x03, 0x30, 0x00, 0x80, 0x03, 0x30, 0x00, 0x80, 0x03, 0x20, 0x00, 0x80,
  0x03, 0x20, 0x00, 0x80, 0x03, 0x20, 0x01, 0x80, 0x03, 0x60, 0x01, 0x80,
  0x03, 0x60, 0x01, 0x00, 0x03, 0x60, 0x01, 0x00, 0x02, 0x40, 0x01, 0x00,
  0x02, 0x40, 0x01, 0x00, 0x02, 0x40, 0x03, 0x00, 0x02, 0xC0, 0x03, 0x00,
  0x06, 0xC0, 0x02, 0x00, 0x06, 0xC0, 0x02, 0x00, 0x04, 0x80, 0x02, 0x00,
  0x0C, 0x80, 0x06, 0x00, 0x0C, 0x80, 0x06, 0x00, 0x08, 0x80, 0x0A, 0x00,
  0x18, 0x80, 0x0A, 0x00, 0x10, 0x80, 0x12, 0x00, 0x20, 0xC0, 0x13, 0x00,
  0x60, 0x40, 0x21, 0x00, 0xC0, 0x60, 0xC0, 0x83, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x07, 0x30, 0x06, 0x0C, 0x01, 0xC1,
  0x00, 0x80, 0x60, 0x70, 0x18, 0x10, 0x02, 0x18, 0x00, 0x82, 0x00, 0x36,
  0x00, 0x0C, 0x20, 0x03, 0x00, 0x00, 0x44, 0x00, 0x10, 0x00, 0x04, 0xC0,
  0x01, 0x00, 0x00, 0x48, 0x00, 0x30, 0x00, 0x04, 0x80, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x14, 0x00,
  0x00, 0x80, 0x01, 0x40, 0x00, 0x08, 0x00, 0x14, 0x00, 0x00, 0x80, 0x02,
  0x40, 0x00, 0x08, 0x00, 0x26, 0x00, 0x00, 0x80, 0x04, 0x20, 0x00, 0x48,
  0x00, 0x42, 0x00, 0x18, 0x80, 0x08, 0x30, 0x07, 0x0C, 0x01, 0x81, 0x01,
  0xC0, 0x40, 0x30, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x9C, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x80, 0x80, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x70,
  0x08, 0x00, 0x02, 0xC0, 0x30, 0x00, 0x12, 0x00, 0x40, 0x00, 0x48, 0x01,
  0x80, 0x02, 0x20, 0x03, 0x00, 0x30, 0x80, 0x06, 0x03, 0x86, 0x00, 0x07,
  0xF0, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x01, 0xC0, 0x7C, 0x03, 0x03,
  0x00, 0x0F, 0x83, 0x02, 0x00, 0x01, 0xF3, 0x06, 0x00, 0x00, 0x3E, 0x04,
  0x00, 0x00, 0x0E, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x20, 0x01, 0x80, 0x00, 0x20, 0x03, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x30, 0x78,
  0x00, 0x00, 0x10, 0x47, 0xC0, 0x00, 0x10, 0x40, 0x3E, 0x00, 0x10, 0x40,
  0x03, 0xE0, 0x10, 0xC0, 0x00, 0x1F, 0x18, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0x83, 0x0C, 0x00, 0x00, 0x82, 0x01, 0x00, 0x00, 0xC3, 0x00, 0x40,
  0x00, 0x43, 0x00, 0x10, 0x00, 0x21, 0x00, 0x0C, 0x00, 0x21, 0x80, 0x03,
  0x00, 0x30, 0x80, 0x00, 0x80, 0x10, 0xC0, 0x00, 0x20, 0x10, 0x40, 0x00,
  0x0C, 0x30, 0x20, 0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 10, 45, 39, 15, -45 },
  { 58, 13, 16, 39, 17, -48 },
  { 84, 39, 45, 39, 1, -45 },
  { 304, 35, 61, 39, 2, -53 },
  { 571, 43, 47, 39, -1, -46 },
  { 824, 37, 47, 39, 1, -46 },
  { 1042, 5, 16, 39, 21, -48 },
  { 1052, 20, 58, 39, 15, -49 },
  { 1197, 20, 58, 39, 5, -49 },
  { 1342, 33, 32, 39, 4, -36 },
  { 1474, 32, 31, 39, 4, -35 },
  { 1598, 9, 16, 39, 10, -5 },
  { 1616, 18, 1, 39, 11, -20 },
  { 1619, 4, 4, 39, 15, -4 },
  { 1621, 34, 58, 39, 3, -49 },
  { 1868, 31, 47, 39, 5, -46 },
  { 2051, 30, 45, 39, 3, -45 },
  { 2220, 32, 46, 39, 3, -46 },
  { 2404, 31, 47, 39, 3, -46 },
  { 2587, 33, 45, 39, 2, -45 },
  { 2773, 32, 46, 39, 4, -45 },
  { 2957, 28, 46, 39, 5, -45 },
  { 3118, 30, 45, 39, 8, -45 },
  { 3287, 32, 47, 39, 4, -46 },
  { 3475, 28, 46, 39, 7, -46 },
  { 3636, 9, 34, 39, 15, -34 },
  { 3675, 14, 45, 39, 10, -34 },
  { 3754, 31, 35, 39, 6, -37 },
  { 3890, 34, 12, 39, 3, -26 },
  { 3941, 31, 35, 39, 3, -37 },
  { 4077, 25, 46, 39, 10, -46 },
  { 4221, 30, 53, 39, 5, -46 },
  { 4420, 32, 45, 39, 1, -45 },
  { 4600, 31, 45, 39, 4, -45 },
  { 4775, 30, 47, 39, 6, -46 },
  { 4952, 32, 45, 39, 4, -45 },
  { 5132, 34, 45, 39, 4, -45 },
  { 5324, 34, 45, 39, 4, -45 },
  { 5516, 30, 47, 39, 6, -46 },
  { 5693, 33, 45, 39, 4, -45 },
  { 5879, 35, 45, 39, 3, -45 },
  { 6076, 30, 46, 39, 5, -45 },
  { 6249, 36, 45, 39, 4, -45 },
  { 6452, 25, 45, 39, 7, -45 },
  { 6593, 35, 45, 39, 3, -45 },
  { 6790, 33, 45, 39, 4, -45 },
  { 6976, 31, 47, 39, 5, -46 },
  { 7159, 33, 45, 39, 4, -45 },
  { 7345, 31, 57, 39, 5, -46 },
  { 7566, 33, 45, 39, 4, -45 },
  { 7752, 35, 47, 39, 2, -46 },
  { 7958, 34, 45, 39, 7, -45 },
  { 8150, 31, 46, 39, 6, -45 },
  { 8329, 32, 45, 39, 8, -45 },
  { 8509, 35, 45, 39, 5, -45 },
  { 8706, 39, 45, 39, 1, -45 },
  { 8926, 35, 45, 39, 7, -45 },
  { 9123, 39, 45, 39, 0, -45 },
  { 9343, 25, 58, 39, 13, -49 },
  { 9525, 15, 58, 39, 13, -49 },
  { 9634, 25, 58, 39, 2, -49 },
  { 9816, 30, 25, 39, 5, -45 },
  { 9910, 31, 1, 39, 0, 8 },
  { 9914, 7, 11, 39, 16, -50 },
  { 9924, 29, 35, 39, 5, -34 },
  { 10051, 29, 49, 39, 5, -48 },
  { 10229, 27, 35, 39, 5, -34 },
  { 10348, 31, 49, 39, 5, -48 },
  { 10538, 28, 35, 39, 5, -34 },
  { 10661, 41, 62, 39, -1, -48 },
  { 10979, 31, 48, 39, 3, -34 },
  { 11165, 26, 48, 39, 6, -48 },
  { 11321, 27, 50, 39, 6, -49 },
  { 11490, 27, 63, 39, 7, -49 },
  { 11703, 32, 49, 39, 5, -48 },
  { 11899, 24, 49, 39, 8, -48 },
  { 12046, 34, 34, 39, 3, -34 },
  { 12191, 26, 34, 39, 6, -34 },
  { 12302, 29, 35, 39, 5, -34 },
  { 12429, 31, 47, 39, 3, -34 },
  { 12612, 29, 47, 39, 5, -34 },
  { 12783, 31, 34, 39, 8, -34 },
  { 12915, 30, 35, 39, 4, -34 },
  { 13047, 32, 46, 39, 5, -45 },
  { 13231, 26, 35, 39, 7, -34 },
  { 13345, 29, 34, 39, 5, -34 },
  { 13469, 32, 35, 39, 5, -34 },
  { 13609, 36, 35, 39, 2, -34 },
  { 13767, 30, 48, 39, 3, -34 },
  { 13947, 32, 35, 39, 3, -34 },
  { 14087, 29, 58, 39, 8, -49 },
  { 14298, 11, 58, 39, 15, -49 },
  { 14378, 29, 58, 39, 3, -49 },
  { 14589, 33, 11, 39, 4, -25 },
};

const GFXfont IBMPlexMono_ThinItalic65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_THINITALIC65PT7B_H_
