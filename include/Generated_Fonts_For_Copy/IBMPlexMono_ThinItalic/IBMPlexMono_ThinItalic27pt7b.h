#ifndef _IBMPLEXMONO_THINITALIC27PT7B_H_
#define _IBMPLEXMONO_THINITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x12, 0x22, 0x22, 0x24, 0x44, 0x00, 0x0C, 0xC0, 0x4A,
  0x63, 0x18, 0xCA, 0x40, 0x00, 0x88, 0x01, 0x08, 0x01, 0x10, 0x02, 0x10,
  0x02, 0x10, 0x02, 0x20, 0x7C, 0x1F, 0x04, 0x20, 0x04, 0x40, 0x08, 0x40,
  0x08, 0x40, 0x08, 0x80, 0xF0, 0x7C, 0x10, 0x80, 0x10, 0x80, 0x21, 0x00,
  0x21, 0x00, 0x21, 0x00, 0x42, 0x00, 0x00, 0x40, 0x01, 0x00, 0x08, 0x01,
  0xF8, 0x08, 0x98, 0x42, 0x12, 0x08, 0x08, 0x20, 0x21, 0x00, 0x84, 0x01,
  0x10, 0x03, 0x40, 0x03, 0xC0, 0x08, 0xC0, 0x21, 0x00, 0x82, 0x02, 0x08,
  0x08, 0x28, 0x21, 0x11, 0x04, 0x24, 0x60, 0x7E, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x07, 0x00, 0x8C, 0x40, 0x88, 0x10, 0x44, 0x08, 0x42, 0x04,
  0x41, 0x04, 0x40, 0x82, 0x40, 0x22, 0x20, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x88, 0x80, 0x88, 0x20, 0x88, 0x10, 0x44, 0x08, 0x42, 0x04,
  0x41, 0x04, 0x40, 0x46, 0x20, 0x1C, 0x00, 0x03, 0xE0, 0x04, 0x10, 0x08,
  0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x04, 0x10, 0x04,
  0x20, 0x3B, 0xC0, 0x41, 0x00, 0x41, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80,
  0x41, 0x80, 0x61, 0x40, 0x92, 0x61, 0x14, 0x1E, 0x0C, 0x6A, 0xA8, 0x01,
  0x81, 0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x00, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x10, 0x40, 0x80, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x61, 0x0C, 0xEB, 0x80, 0xE0, 0x0E, 0x00, 0x88, 0x04, 0x40, 0x41,
  0x04, 0x04, 0x00, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x03, 0xFF, 0xE0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x12, 0x24, 0x48, 0x80, 0xFE, 0xF0, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x07, 0xC0, 0x41, 0x84, 0x04, 0x40, 0x14, 0x00, 0xA0,
  0x05, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x10, 0x60, 0x05, 0x00, 0x28, 0x01,
  0x40, 0x0A, 0x00, 0x90, 0x04, 0x40, 0x43, 0x0C, 0x07, 0xC0, 0x00, 0xC0,
  0x0E, 0x00, 0x90, 0x19, 0x01, 0x88, 0x18, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x3F, 0xFE, 0x03, 0xE0, 0x20, 0x82, 0x02, 0x20, 0x12,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x3F, 0xFC,
  0x03, 0xE0, 0x60, 0x84, 0x02, 0x20, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x3E, 0x00, 0x18, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x50, 0x02, 0x40, 0x21, 0x02, 0x07, 0xE0, 0x00, 0x08, 0x00, 0xC0, 0x05,
  0x00, 0x14, 0x00, 0x90, 0x04, 0x40, 0x21, 0x01, 0x08, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x08, 0x40, 0x22, 0x01, 0x0F, 0xFF, 0xC0, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x0F, 0xF8, 0x80, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x09, 0xF0, 0x30, 0x42, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x90, 0x04, 0x80, 0x42, 0x04, 0x0F, 0xC0,
  0x00, 0x60, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x4F, 0x85, 0x06, 0xE0, 0x2C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02,
  0x80, 0x26, 0x0C, 0x1F, 0x00, 0x7F, 0xFC, 0x00, 0xA0, 0x05, 0x00, 0x48,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x07, 0xE0, 0xC1, 0x84, 0x02, 0x40, 0x12, 0x00, 0xA0, 0x05, 0x00, 0x24,
  0x02, 0x10, 0x20, 0x7E, 0x0C, 0x10, 0x80, 0x48, 0x01, 0x40, 0x0A, 0x00,
  0x50, 0x02, 0x80, 0x22, 0x06, 0x0F, 0xC0, 0x0F, 0x83, 0x04, 0x40, 0x28,
  0x02, 0x80, 0x28, 0x03, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x61, 0xC3,
  0xE4, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x08, 0x41, 0x08, 0x20, 0x00,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x00, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x0F, 0x06, 0x19, 0x01,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0xA0, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x03,
  0xC0, 0xC3, 0x18, 0x11, 0x01, 0x20, 0x12, 0x01, 0x41, 0xD4, 0x23, 0x44,
  0x14, 0x81, 0x88, 0x18, 0x82, 0x88, 0x28, 0x82, 0x88, 0x28, 0x4E, 0x83,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x01, 0xF8, 0x00, 0x60, 0x01, 0x80,
  0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x21, 0x00, 0x84, 0x04, 0x10,
  0x10, 0x40, 0x81, 0x02, 0x04, 0x1F, 0xF8, 0x40, 0x22, 0x00, 0x88, 0x02,
  0x40, 0x09, 0x00, 0x28, 0x00, 0x40, 0x1F, 0xE2, 0x03, 0x20, 0x12, 0x01,
  0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40, 0x27, 0xFC, 0x40, 0x68, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0xFF, 0x80, 0x03,
  0xC0, 0x61, 0x84, 0x04, 0x20, 0x12, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x90,
  0x04, 0x40, 0x41, 0x04, 0x07, 0xC0, 0x1F, 0xC1, 0x01, 0x08, 0x04, 0x40,
  0x22, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x80, 0x44, 0x04, 0x3F,
  0xC0, 0x1F, 0xFC, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0xFF, 0xC4, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0xFF, 0xC4, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x61,
  0x84, 0x04, 0x40, 0x12, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x7D, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x40,
  0x61, 0x05, 0x07, 0xC8, 0x10, 0x06, 0x20, 0x08, 0x40, 0x10, 0x80, 0x22,
  0x00, 0x44, 0x00, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0x7F, 0xF0, 0x80,
  0x22, 0x00, 0x44, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x08, 0x40, 0x11,
  0x00, 0x22, 0x00, 0x80, 0x1F, 0xFE, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x48, 0x04, 0x80, 0x84, 0x10, 0x3E, 0x00, 0x20, 0x06, 0x40,
  0x10, 0x80, 0x41, 0x01, 0x02, 0x04, 0x04, 0x10, 0x10, 0x40, 0x21, 0x00,
  0x44, 0x00, 0x94, 0x01, 0x48, 0x03, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x40, 0x20, 0x80, 0x41, 0x00, 0x42, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xFC, 0x10, 0x02, 0x30,
  0x0C, 0xA0, 0x31, 0x40, 0x62, 0x81, 0x44, 0x84, 0x89, 0x09, 0x12, 0x22,
  0x44, 0x88, 0x85, 0x11, 0x0C, 0x22, 0x08, 0x44, 0x00, 0x88, 0x01, 0x20,
  0x02, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x40, 0x08, 0x06, 0x30,
  0x08, 0x60, 0x10, 0xA0, 0x22, 0x40, 0x44, 0x80, 0x88, 0x82, 0x11, 0x04,
  0x22, 0x08, 0x42, 0x11, 0x04, 0x22, 0x04, 0x44, 0x09, 0x08, 0x12, 0x10,
  0x14, 0x20, 0x28, 0x80, 0x51, 0x00, 0x62, 0x00, 0x80, 0x07, 0xC0, 0x41,
  0x84, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90, 0x04, 0x40,
  0x43, 0x0C, 0x07, 0xC0, 0x1F, 0xE1, 0x00, 0x88, 0x02, 0x40, 0x12, 0x00,
  0x90, 0x04, 0x80, 0x28, 0x01, 0x40, 0x12, 0x01, 0x9F, 0xF0, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x07,
  0xC0, 0x41, 0x84, 0x04, 0x40, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x90,
  0x04, 0x40, 0x43, 0x0C, 0x07, 0xC0, 0x08, 0x00, 0x21, 0x01, 0x10, 0x05,
  0x00, 0x10, 0x1F, 0xE1, 0x00, 0x88, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04,
  0x80, 0x28, 0x01, 0x40, 0x12, 0x01, 0x9F, 0xF0, 0x84, 0x04, 0x10, 0x40,
  0x82, 0x02, 0x10, 0x10, 0x80, 0x44, 0x02, 0x20, 0x08, 0x07, 0xE0, 0x20,
  0x61, 0x00, 0x48, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xA0,
  0x04, 0x40, 0x10, 0x81, 0x81, 0xF8, 0x00, 0xFF, 0xFC, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x00, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x88, 0x02,
  0x40, 0x09, 0x00, 0x24, 0x01, 0x10, 0x04, 0x40, 0x11, 0x00, 0x48, 0x01,
  0x20, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x41, 0x02,
  0x03, 0xF0, 0x00, 0x80, 0x0E, 0x00, 0x28, 0x01, 0x10, 0x04, 0x40, 0x21,
  0x00, 0x84, 0x02, 0x10, 0x10, 0x40, 0x40, 0x82, 0x02, 0x08, 0x08, 0x40,
  0x21, 0x00, 0x88, 0x02, 0x20, 0x05, 0x00, 0x14, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x40, 0x06, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x01,
  0x10, 0xC2, 0x21, 0x84, 0x45, 0x11, 0x0A, 0x22, 0x24, 0x44, 0x48, 0x89,
  0x12, 0x12, 0x24, 0x28, 0x28, 0x50, 0x50, 0xC0, 0xC1, 0x81, 0x83, 0x01,
  0x00, 0x10, 0x01, 0x84, 0x01, 0x02, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80,
  0x10, 0x80, 0x08, 0x80, 0x02, 0x40, 0x01, 0x40, 0x00, 0x40, 0x00, 0x50,
  0x00, 0x48, 0x00, 0x42, 0x00, 0x21, 0x00, 0x20, 0x40, 0x20, 0x20, 0x20,
  0x08, 0x20, 0x04, 0x20, 0x01, 0x00, 0x80, 0x06, 0x00, 0x24, 0x01, 0x10,
  0x04, 0x20, 0x20, 0x81, 0x01, 0x08, 0x04, 0x40, 0x0A, 0x00, 0x28, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x00, 0xFF, 0xFC, 0x0F, 0xE1, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x00, 0xFE, 0x00, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x81, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x40,
  0x81, 0x02, 0x06, 0x0F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0xFC, 0x00, 0x01,
  0x80, 0x14, 0x00, 0xA0, 0x08, 0x80, 0x84, 0x08, 0x10, 0x80, 0x84, 0x02,
  0x40, 0x14, 0x00, 0x40, 0xFF, 0xF8, 0xA5, 0x0F, 0x91, 0x05, 0x20, 0x34,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0x48,
  0x0C, 0x41, 0x43, 0xE7, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x27, 0xC2, 0x82, 0x30, 0x12, 0x01, 0x60, 0x14, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x18, 0x01, 0x80, 0x24, 0x04, 0xA0, 0xC9, 0xF0, 0x0F, 0x83,
  0x08, 0x80, 0xA0, 0x14, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x01, 0x20, 0x46, 0x18, 0x3C, 0x00, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x3E, 0x42, 0x0A, 0x20, 0x32, 0x01, 0x20, 0x09,
  0x00, 0x48, 0x02, 0x40, 0x12, 0x00, 0x90, 0x08, 0x80, 0xC4, 0x06, 0x10,
  0x50, 0x7C, 0x80, 0x07, 0xC1, 0x82, 0x20, 0x14, 0x01, 0x40, 0x28, 0x02,
  0x81, 0xCF, 0xE0, 0x80, 0x08, 0x00, 0x80, 0x24, 0x04, 0x60, 0x81, 0xF0,
  0x00, 0x3F, 0x80, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x3F, 0xFC, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x10, 0x40, 0x08, 0x20, 0x03, 0x10, 0x00, 0xC8,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0x07, 0xC8, 0x41, 0x44, 0x06, 0x40,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x01, 0x10, 0x08,
  0x80, 0xC2, 0x0A, 0x0F, 0x90, 0x01, 0x00, 0x08, 0x80, 0x42, 0x0C, 0x0F,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0xF1, 0x61,
  0x30, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40,
  0x50, 0x0A, 0x01, 0x40, 0x20, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x20, 0x83, 0x08, 0xC1, 0x10, 0x16, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x41, 0x0C, 0x20, 0xC4, 0x04, 0x80, 0x50, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x3C, 0x0B, 0x08,
  0x30, 0x10, 0x80, 0x42, 0x02, 0x10, 0x08, 0x40, 0xC1, 0x3C, 0x04, 0x80,
  0x11, 0x02, 0x82, 0x1E, 0x08, 0xC8, 0x14, 0x20, 0x20, 0xFE, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x04, 0x43, 0x21, 0x09, 0x82, 0x80, 0xC0, 0x27, 0x38,
  0xE5, 0x12, 0x18, 0x48, 0x21, 0x41, 0x05, 0x04, 0x14, 0x10, 0x50, 0x41,
  0x41, 0x09, 0x08, 0x28, 0x20, 0xA0, 0x82, 0x82, 0x0A, 0x08, 0x20, 0x23,
  0xC5, 0x84, 0xC0, 0x90, 0x12, 0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x28,
  0x05, 0x01, 0x40, 0x28, 0x05, 0x00, 0x80, 0x0F, 0x81, 0x06, 0x20, 0x24,
  0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x24,
  0x04, 0x60, 0x81, 0xF0, 0x13, 0xE0, 0xA0, 0x86, 0x02, 0x20, 0x13, 0x00,
  0x90, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x50, 0x04, 0x40, 0x45,
  0x06, 0x27, 0xC1, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x0F,
  0x91, 0x05, 0x20, 0x34, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x04, 0x80, 0x48, 0x0C, 0x41, 0x43, 0xE4, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0xFC, 0xF8, 0x38, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x00, 0x0F, 0xC1, 0x02, 0x20, 0x14, 0x00, 0x40, 0x02, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x20, 0x02, 0x00, 0x28, 0x02, 0x40, 0x43, 0xF8,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x7F, 0xFC, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0xC2, 0x18, 0x11, 0x00, 0xB0, 0x06, 0x00, 0x40, 0x28, 0x05, 0x01, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x12, 0x02, 0x40, 0xCC,
  0x28, 0xF9, 0x00, 0xF0, 0x11, 0x01, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01,
  0x20, 0x12, 0x02, 0x20, 0x22, 0x04, 0x20, 0x42, 0x18, 0x46, 0x03, 0xC0,
  0x41, 0x0A, 0x08, 0x50, 0x42, 0x84, 0x14, 0x20, 0xC1, 0x06, 0x08, 0x30,
  0x41, 0x82, 0x0C, 0x20, 0x61, 0x05, 0x08, 0x28, 0xA2, 0x38, 0xE0, 0x04,
  0x3C, 0x34, 0x89, 0x8A, 0x0C, 0x14, 0x10, 0x10, 0x20, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x01, 0x04, 0x02, 0x14, 0x04, 0x28, 0x68, 0x93, 0x0E,
  0x18, 0x00, 0x10, 0x08, 0x80, 0x44, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08,
  0x80, 0x44, 0x02, 0x40, 0x22, 0x01, 0x10, 0x08, 0x40, 0xC3, 0x0A, 0x0F,
  0x90, 0x01, 0x00, 0x08, 0x80, 0xC2, 0x0C, 0x0F, 0x80, 0x0F, 0x84, 0x43,
  0xE2, 0x00, 0x88, 0x04, 0x40, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x82, 0x01, 0x18, 0x04, 0xBF, 0x92, 0x07, 0xC0, 0x03, 0xF0,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x60, 0xF8, 0x00, 0xC0, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x00,
  0x08, 0x84, 0x21, 0x08, 0x44, 0x21, 0x08, 0x42, 0x21, 0x08, 0x42, 0x10,
  0x88, 0x42, 0x10, 0x80, 0x0F, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0xF0,
  0x30, 0x04, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0xFC, 0x00, 0x1C, 0x04, 0x88, 0x14, 0x10, 0x90,
  0x22, 0x80, 0x70,
};

const GFXglyph IBMPlexMono_ThinItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 5, 7, 16, 7, -20 },
  { 16, 16, 19, 16, 1, -19 },
  { 54, 14, 25, 16, 1, -22 },
  { 98, 17, 19, 16, 0, -19 },
  { 139, 16, 19, 16, 0, -19 },
  { 177, 2, 7, 16, 9, -20 },
  { 179, 9, 25, 16, 6, -21 },
  { 208, 8, 25, 16, 2, -21 },
  { 233, 13, 13, 16, 2, -15 },
  { 255, 13, 13, 16, 2, -15 },
  { 277, 4, 7, 16, 4, -2 },
  { 281, 7, 1, 16, 5, -9 },
  { 282, 2, 2, 16, 6, -2 },
  { 283, 14, 25, 16, 1, -21 },
  { 327, 13, 19, 16, 2, -19 },
  { 358, 13, 19, 16, 1, -19 },
  { 389, 13, 19, 16, 1, -19 },
  { 420, 13, 19, 16, 1, -19 },
  { 451, 14, 19, 16, 1, -19 },
  { 485, 13, 19, 16, 2, -19 },
  { 516, 12, 19, 16, 2, -19 },
  { 545, 13, 19, 16, 3, -19 },
  { 576, 13, 19, 16, 2, -19 },
  { 607, 12, 19, 16, 3, -19 },
  { 636, 4, 15, 16, 6, -15 },
  { 644, 6, 20, 16, 4, -15 },
  { 659, 13, 14, 16, 2, -15 },
  { 682, 14, 6, 16, 1, -11 },
  { 693, 13, 14, 16, 1, -15 },
  { 716, 11, 19, 16, 4, -19 },
  { 743, 12, 22, 16, 2, -19 },
  { 776, 14, 19, 16, 0, -19 },
  { 810, 12, 19, 16, 2, -19 },
  { 839, 13, 19, 16, 2, -19 },
  { 870, 13, 19, 16, 2, -19 },
  { 901, 14, 19, 16, 2, -19 },
  { 935, 14, 19, 16, 2, -19 },
  { 969, 13, 19, 16, 2, -19 },
  { 1000, 15, 19, 16, 1, -19 },
  { 1036, 15, 19, 16, 1, -19 },
  { 1072, 12, 19, 16, 2, -19 },
  { 1101, 15, 19, 16, 2, -19 },
  { 1137, 10, 19, 16, 3, -19 },
  { 1161, 15, 19, 16, 1, -19 },
  { 1197, 15, 19, 16, 1, -19 },
  { 1233, 13, 19, 16, 2, -19 },
  { 1264, 13, 19, 16, 2, -19 },
  { 1295, 13, 24, 16, 2, -19 },
  { 1334, 13, 19, 16, 2, -19 },
  { 1365, 14, 19, 16, 1, -19 },
  { 1399, 14, 19, 16, 3, -19 },
  { 1433, 14, 19, 16, 2, -19 },
  { 1467, 14, 19, 16, 3, -19 },
  { 1501, 15, 19, 16, 2, -19 },
  { 1537, 17, 19, 16, 0, -19 },
  { 1578, 14, 19, 16, 3, -19 },
  { 1612, 16, 19, 16, 0, -19 },
  { 1650, 11, 25, 16, 5, -21 },
  { 1685, 7, 25, 16, 5, -21 },
  { 1707, 10, 25, 16, 1, -21 },
  { 1739, 13, 10, 16, 2, -19 },
  { 1756, 13, 1, 16, 0, 3 },
  { 1758, 2, 4, 16, 7, -20 },
  { 1759, 12, 14, 16, 2, -14 },
  { 1780, 12, 20, 16, 2, -20 },
  { 1810, 11, 14, 16, 2, -14 },
  { 1830, 13, 20, 16, 2, -20 },
  { 1863, 12, 14, 16, 2, -14 },
  { 1884, 17, 25, 16, 0, -20 },
  { 1938, 13, 19, 16, 1, -14 },
  { 1969, 11, 20, 16, 2, -20 },
  { 1997, 12, 20, 16, 2, -20 },
  { 2027, 11, 25, 16, 3, -20 },
  { 2062, 14, 20, 16, 2, -20 },
  { 2097, 10, 20, 16, 3, -20 },
  { 2122, 14, 14, 16, 1, -14 },
  { 2147, 11, 14, 16, 2, -14 },
  { 2167, 12, 14, 16, 2, -14 },
  { 2188, 13, 19, 16, 1, -14 },
  { 2219, 12, 19, 16, 2, -14 },
  { 2248, 13, 14, 16, 3, -14 },
  { 2271, 12, 14, 16, 2, -14 },
  { 2292, 13, 19, 16, 2, -19 },
  { 2323, 11, 14, 16, 3, -14 },
  { 2343, 12, 14, 16, 2, -14 },
  { 2364, 13, 14, 16, 2, -14 },
  { 2387, 15, 14, 16, 1, -14 },
  { 2414, 13, 19, 16, 1, -14 },
  { 2445, 14, 14, 16, 1, -14 },
  { 2470, 12, 25, 16, 3, -21 },
  { 2508, 5, 25, 16, 6, -21 },
  { 2524, 12, 25, 16, 1, -21 },
  { 2562, 14, 5, 16, 1, -11 },
};

const GFXfont IBMPlexMono_ThinItalic27pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic27pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic27pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _IBMPLEXMONO_THINITALIC27PT7B_H_
