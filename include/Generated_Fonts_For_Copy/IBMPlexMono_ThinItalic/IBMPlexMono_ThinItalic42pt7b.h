#ifndef _IBMPLEXMONO_THINITALIC42PT7B_H_
#define _IBMPLEXMONO_THINITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x08, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x30, 0xC0, 0x21,
  0x61, 0x41, 0x41, 0x43, 0x42, 0x42, 0xC2, 0x82, 0x82, 0x86, 0x00, 0x04,
  0x08, 0x00, 0x02, 0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0x40, 0x80, 0x00, 0x40, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x10, 0x20, 0x07, 0xF0, 0x1F, 0xE0, 0x08, 0x10, 0x00,
  0x04, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02, 0x04, 0x00, 0x01, 0x02, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x81, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x40, 0x40,
  0x00, 0x20, 0x40, 0x00, 0x10, 0x20, 0x00, 0x10, 0x10, 0x00, 0x08, 0x10,
  0x00, 0x04, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02, 0x04, 0x00, 0x01, 0x02,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x80, 0x0E, 0x11, 0x80, 0x60, 0x41,
  0x02, 0x02, 0x02, 0x08, 0x08, 0x0C, 0x40, 0x20, 0x01, 0x00, 0x80, 0x04,
  0x02, 0x00, 0x10, 0x08, 0x00, 0x40, 0x40, 0x00, 0x81, 0x00, 0x03, 0x04,
  0x00, 0x06, 0x10, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x08, 0xE0,
  0x00, 0x20, 0xC0, 0x00, 0x81, 0x80, 0x02, 0x02, 0x00, 0x08, 0x08, 0x00,
  0x40, 0x20, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00, 0x10, 0x08, 0x80, 0x40,
  0x41, 0x01, 0x01, 0x02, 0x08, 0x18, 0x06, 0x21, 0xC0, 0x07, 0xF8, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x10, 0x18, 0x60, 0x02, 0x02, 0x01, 0x00, 0x40, 0x60, 0x10,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x10, 0x08, 0x01, 0x02, 0x00,
  0x80, 0x10, 0x40, 0x08, 0x01, 0x04, 0x00, 0x80, 0x20, 0x80, 0x08, 0x02,
  0x10, 0x00, 0x40, 0x42, 0x00, 0x02, 0x08, 0x20, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x21, 0x86, 0x00, 0x04,
  0x20, 0x30, 0x00, 0x84, 0x01, 0x00, 0x08, 0x40, 0x10, 0x01, 0x04, 0x01,
  0x00, 0x20, 0x80, 0x10, 0x04, 0x08, 0x01, 0x00, 0x40, 0x80, 0x10, 0x08,
  0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x20, 0x04, 0x04, 0x04, 0x00, 0x20,
  0x80, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x00, 0x80, 0x02, 0x00, 0x40, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x40, 0x02, 0x00, 0x40, 0x02,
  0x00, 0x40, 0x01, 0x00, 0x80, 0x00, 0x81, 0x00, 0x03, 0x82, 0x00, 0x1C,
  0x5C, 0x00, 0x20, 0x60, 0x00, 0x40, 0x20, 0x00, 0x80, 0x10, 0x00, 0x80,
  0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x80, 0x04, 0x00, 0x80,
  0x02, 0x02, 0x80, 0x05, 0x03, 0x80, 0x04, 0x86, 0x80, 0x08, 0x84, 0x40,
  0x10, 0x48, 0x30, 0x60, 0x78, 0x1F, 0x80, 0x30, 0x69, 0x24, 0xA4, 0x92,
  0x00, 0x00, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x60, 0x20, 0x70, 0xE1, 0x1C, 0x00, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x0A, 0x00, 0x00, 0x88, 0x00, 0x08, 0x40, 0x00, 0x81, 0x00, 0x0C,
  0x08, 0x00, 0x40, 0x20, 0x04, 0x00, 0x80, 0x40, 0x04, 0x04, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0xC4, 0x62, 0x31, 0x08, 0x84,
  0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x18, 0x18, 0x02, 0x00, 0x40, 0x40, 0x02, 0x08,
  0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x12,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01,
  0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x84, 0x00,
  0x08, 0x40, 0x01, 0x04, 0x00, 0x20, 0x20, 0x04, 0x01, 0x81, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x03, 0x40, 0x00, 0xC8, 0x00, 0x31, 0x00,
  0x18, 0x40, 0x06, 0x08, 0x01, 0x81, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x0C, 0x0C, 0x03, 0x00, 0x20, 0x60, 0x01, 0x04, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x18, 0x0C, 0x02, 0x00, 0x20, 0x40, 0x03, 0x08, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x80, 0x00, 0x84, 0x00, 0x18, 0x60, 0x03, 0x01, 0x80, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x24,
  0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x42, 0x00, 0x03, 0x08, 0x00,
  0x08, 0x20, 0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x10, 0x10, 0x00, 0x80,
  0x40, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x10, 0x08, 0x00, 0x80,
  0x20, 0x02, 0x01, 0x00, 0x08, 0x08, 0x00, 0x20, 0x40, 0x00, 0x83, 0xFF,
  0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xF8,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x11, 0xFC, 0x00, 0xB0, 0x30, 0x0A, 0x00, 0x40, 0x60, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x80, 0x00, 0xC2, 0x00, 0x04, 0x08, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x11, 0xFC, 0x09, 0x80, 0xC2, 0x80, 0x09,
  0x40, 0x03, 0x60, 0x00, 0x50, 0x00, 0x14, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00,
  0x42, 0x00, 0x20, 0x60, 0x30, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF4, 0x00,
  0x02, 0x40, 0x00, 0x44, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80,
  0x01, 0x08, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x38, 0x0C, 0x06, 0x00, 0x20, 0xC0, 0x01, 0x08, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00,
  0x20, 0x80, 0x0C, 0x06, 0x03, 0x80, 0x1F, 0xC0, 0x0E, 0x03, 0x01, 0x00,
  0x08, 0x60, 0x00, 0x44, 0x00, 0x04, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80,
  0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xCC,
  0x00, 0x18, 0x60, 0x03, 0x03, 0x80, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0xE0, 0x60, 0x20, 0x02, 0x08, 0x00, 0x62, 0x00, 0x04, 0x40, 0x00,
  0x90, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x24, 0x00, 0x0C, 0x80, 0x01, 0x90, 0x00, 0x61, 0x00, 0x14,
  0x18, 0x0D, 0x00, 0xFE, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x03, 0x80, 0x00, 0x18, 0x71, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC3, 0x00,
  0x03, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFD, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x06,
  0x03, 0x04, 0x00, 0xC4, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x0E, 0x80, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x18, 0x18, 0x04, 0x01, 0x01, 0x00, 0x10, 0x40, 0x02, 0x10,
  0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x03, 0xE4, 0x81,
  0x82, 0x90, 0x20, 0x32, 0x08, 0x02, 0x41, 0x00, 0x48, 0x40, 0x12, 0x08,
  0x02, 0x41, 0x00, 0x48, 0x20, 0x09, 0x08, 0x01, 0x21, 0x00, 0x24, 0x20,
  0x09, 0x04, 0x01, 0x20, 0x40, 0x64, 0x08, 0x14, 0x80, 0xFC, 0x90, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x14, 0x00,
  0x00, 0xA0, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x04, 0x40, 0x00, 0x22,
  0x00, 0x02, 0x08, 0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00,
  0x80, 0x80, 0x04, 0x04, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04,
  0x02, 0x00, 0x20, 0x10, 0x01, 0x00, 0xFF, 0xF8, 0x08, 0x00, 0x20, 0x40,
  0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x11,
  0x00, 0x00, 0x48, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x07,
  0xFF, 0x80, 0x40, 0x06, 0x04, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01,
  0x08, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x41, 0x00, 0x18, 0x1F, 0xFE,
  0x01, 0x00, 0x18, 0x10, 0x00, 0x42, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x24, 0x00, 0x04, 0x40, 0x00, 0x84, 0x00, 0x30, 0xFF, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x30, 0x30, 0x08, 0x03, 0x02, 0x00, 0x20, 0x80, 0x02,
  0x20, 0x00, 0x44, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x24, 0x00, 0x08, 0x40, 0x01, 0x08,
  0x00, 0x40, 0x80, 0x10, 0x0C, 0x0C, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00,
  0x80, 0x18, 0x08, 0x00, 0xC0, 0x80, 0x06, 0x08, 0x00, 0x20, 0x80, 0x01,
  0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00,
  0x11, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00,
  0x01, 0x20, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x24, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x08,
  0x00, 0x30, 0x80, 0x06, 0x08, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0xFE, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x18, 0x18, 0x06, 0x00, 0xC0, 0xC0, 0x04,
  0x08, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00, 0x12, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x7F, 0xC8, 0x00, 0x04, 0x80,
  0x00, 0x48, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88,
  0x00, 0x18, 0x80, 0x02, 0x84, 0x00, 0x30, 0x20, 0x05, 0x01, 0x81, 0x90,
  0x07, 0xE1, 0x00, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41,
  0x00, 0x01, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00,
  0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x21, 0x00, 0x01, 0x04, 0x00, 0x04,
  0x10, 0x00, 0x10, 0x40, 0x00, 0x41, 0xFF, 0xFF, 0x04, 0x00, 0x04, 0x20,
  0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00,
  0x20, 0x80, 0x00, 0x84, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x41,
  0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x80, 0x00, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x44, 0x00, 0x10, 0x80, 0x02, 0x08, 0x00, 0x81, 0x00, 0x20, 0x18,
  0x18, 0x00, 0xFC, 0x00, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x10, 0x20, 0x00,
  0x40, 0x40, 0x01, 0x00, 0x80, 0x04, 0x01, 0x00, 0x10, 0x04, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x10, 0x04, 0x00, 0x20, 0x30, 0x00, 0x40, 0xC0, 0x00,
  0x83, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x28, 0x00, 0x08, 0x88, 0x00, 0x12,
  0x10, 0x00, 0x28, 0x10, 0x00, 0x60, 0x20, 0x01, 0x80, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x00, 0x80, 0x20, 0x01,
  0x00, 0x80, 0x01, 0x01, 0x00, 0x02, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x0F, 0xFF, 0xF8, 0x04, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x28, 0x00, 0x30, 0x50, 0x00, 0xA0, 0xA0, 0x02, 0x41, 0x20, 0x04, 0x84,
  0x40, 0x11, 0x08, 0x80, 0x44, 0x11, 0x00, 0x88, 0x21, 0x02, 0x10, 0x42,
  0x04, 0x20, 0x84, 0x10, 0x42, 0x04, 0x40, 0x84, 0x08, 0x82, 0x08, 0x12,
  0x04, 0x10, 0x24, 0x08, 0x20, 0x30, 0x10, 0x40, 0x40, 0x21, 0x00, 0x80,
  0x42, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08,
  0x20, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x82, 0x00, 0x01, 0x04,
  0x00, 0x02, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x04, 0x18, 0x00, 0x10,
  0x60, 0x00, 0x41, 0x40, 0x01, 0x09, 0x00, 0x08, 0x22, 0x00, 0x20, 0x88,
  0x00, 0x82, 0x20, 0x02, 0x08, 0x40, 0x08, 0x41, 0x00, 0x21, 0x04, 0x01,
  0x04, 0x08, 0x04, 0x10, 0x20, 0x10, 0x40, 0x80, 0x41, 0x01, 0x01, 0x08,
  0x04, 0x04, 0x20, 0x10, 0x20, 0x80, 0x20, 0x82, 0x00, 0x82, 0x08, 0x02,
  0x08, 0x20, 0x04, 0x21, 0x00, 0x10, 0x84, 0x00, 0x24, 0x10, 0x00, 0x90,
  0x40, 0x02, 0x41, 0x00, 0x05, 0x04, 0x00, 0x14, 0x20, 0x00, 0x50, 0x80,
  0x00, 0x80, 0x00, 0x7E, 0x00, 0x18, 0x18, 0x02, 0x00, 0x40, 0x40, 0x02,
  0x08, 0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00,
  0x12, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x01, 0x40, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80,
  0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x84,
  0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x20, 0x20, 0x04, 0x01, 0x81, 0x80,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x40, 0x03, 0x02, 0x00, 0x04, 0x10,
  0x00, 0x20, 0x80, 0x00, 0x84, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00, 0x01,
  0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x10, 0x00, 0x30, 0x80, 0x03, 0x07, 0xFF, 0xE0, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x18,
  0x18, 0x02, 0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x21, 0x00, 0x01, 0x10,
  0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x48, 0x00, 0x04, 0x80, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00,
  0x20, 0x20, 0x04, 0x01, 0x81, 0x80, 0x07, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x06, 0x00, 0x20, 0x80, 0x01, 0x10, 0x00, 0x16, 0x00,
  0x00, 0xC0, 0x07, 0xFF, 0x80, 0x40, 0x03, 0x02, 0x00, 0x04, 0x10, 0x00,
  0x20, 0x80, 0x00, 0x84, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00, 0x01, 0x10,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00, 0x02,
  0x10, 0x00, 0x30, 0x80, 0x03, 0x07, 0xFF, 0xE0, 0x20, 0x20, 0x01, 0x01,
  0x00, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x10, 0x08, 0x00, 0x80, 0x80, 0x02, 0x04, 0x00, 0x10, 0x20, 0x00,
  0x41, 0x00, 0x02, 0x08, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x80, 0x0E, 0x01,
  0x80, 0x60, 0x01, 0x02, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x41, 0x00, 0x01, 0x02, 0x00, 0x18, 0x07, 0x01, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x20, 0x00, 0x22,
  0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x02,
  0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00,
  0x48, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00,
  0x08, 0x80, 0x00, 0x88, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x02, 0x08, 0x00, 0x60, 0x40, 0x0C, 0x07, 0x01, 0x80, 0x1F, 0xE0, 0x00,
  0x80, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x04, 0x00, 0x10, 0x20, 0x00, 0x81,
  0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x04, 0x02, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x01, 0x00, 0x10, 0x08, 0x00, 0x80, 0x80, 0x04,
  0x04, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00,
  0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x48, 0x00, 0x01, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x02, 0x40, 0x00, 0x08, 0x80,
  0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x08, 0x00,
  0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x60, 0x20, 0x80, 0xC0,
  0x41, 0x02, 0x80, 0x82, 0x05, 0x01, 0x08, 0x12, 0x04, 0x10, 0x24, 0x08,
  0x20, 0x84, 0x10, 0x41, 0x08, 0x40, 0x84, 0x10, 0x81, 0x08, 0x21, 0x02,
  0x20, 0x42, 0x04, 0x40, 0x88, 0x08, 0x81, 0x10, 0x12, 0x01, 0x20, 0x24,
  0x02, 0x40, 0x50, 0x05, 0x00, 0xA0, 0x0A, 0x01, 0x80, 0x14, 0x05, 0x00,
  0x28, 0x0C, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x60,
  0x10, 0x00, 0x10, 0x04, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x20, 0x20, 0x00, 0x08,
  0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x44, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x28, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x04, 0x10, 0x00, 0x03, 0x02, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x40, 0x10, 0x00, 0x20, 0x04, 0x00, 0x10, 0x00, 0x80, 0x08,
  0x00, 0x20, 0x04, 0x00, 0x04, 0x03, 0x00, 0x01, 0x00, 0x80, 0x00, 0x20,
  0xC0, 0x00, 0x08, 0x00, 0x80, 0x00, 0x02, 0x80, 0x00, 0x09, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x82, 0x00, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x10,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x08, 0x04, 0x00, 0x10, 0x18, 0x00,
  0x10, 0x20, 0x00, 0x20, 0x80, 0x00, 0x22, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x81, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x07, 0xFE, 0x00, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x01, 0xFF, 0x81, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x07, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x01, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x20, 0x00, 0x42, 0x00, 0x08, 0x10, 0x01, 0x01, 0x00, 0x30,
  0x10, 0x02, 0x00, 0x80, 0x40, 0x08, 0x08, 0x00, 0x41, 0x00, 0x04, 0x10,
  0x00, 0x22, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x82, 0x10, 0x42, 0x08, 0x20, 0x01, 0xF8, 0x20, 0xC0, 0xC4, 0x30, 0x05,
  0x08, 0x00, 0x63, 0x00, 0x0C, 0x40, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x61,
  0x00, 0x14, 0x10, 0x04, 0x81, 0x83, 0x20, 0x1F, 0x83, 0xC0, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x0F, 0xC0, 0x26, 0x04,
  0x05, 0x00, 0x41, 0x40, 0x04, 0x30, 0x00, 0x46, 0x00, 0x08, 0x80, 0x01,
  0x10, 0x00, 0x26, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x48, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x11,
  0x80, 0x02, 0x30, 0x00, 0x85, 0x00, 0x21, 0x18, 0x18, 0x20, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0xC0, 0xC0, 0xC0, 0x18, 0x60, 0x02, 0x10, 0x00, 0x48,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02,
  0x40, 0x01, 0x10, 0x00, 0x42, 0x00, 0x20, 0xC0, 0x10, 0x18, 0x18, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x1F, 0x82, 0x06, 0x06, 0x20, 0xC0, 0x14, 0x10, 0x00, 0xC3, 0x00,
  0x0C, 0x20, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x08, 0x80,
  0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x03, 0x04, 0x00, 0x50,
  0x20, 0x09, 0x01, 0x83, 0x20, 0x0F, 0xC2, 0x00, 0x00, 0xFE, 0x00, 0xC0,
  0x60, 0x40, 0x0C, 0x20, 0x01, 0x10, 0x00, 0x48, 0x00, 0x12, 0x00, 0x05,
  0x00, 0x03, 0x40, 0x01, 0x90, 0x01, 0x84, 0x07, 0x81, 0xFE, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x40, 0x00, 0xD0, 0x00,
  0x42, 0x00, 0x30, 0xC0, 0x18, 0x1C, 0x1C, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x20, 0x00, 0x08, 0x08, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x10, 0x30, 0x31, 0x06, 0x00,
  0xA0, 0x80, 0x06, 0x18, 0x00, 0x61, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x20, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84,
  0x00, 0x18, 0x20, 0x02, 0x82, 0x00, 0x28, 0x10, 0x05, 0x00, 0xC1, 0x90,
  0x03, 0xE1, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x80, 0x04,
  0x0C, 0x00, 0xC0, 0x30, 0x30, 0x01, 0xFC, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x08, 0x7E, 0x04, 0x40, 0x82, 0x40, 0x21, 0x40, 0x08,
  0xC0, 0x04, 0xC0, 0x02, 0x60, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40,
  0x02, 0x20, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x03, 0x02, 0x03, 0x02, 0x06, 0x01, 0x06, 0x00,
  0x8C, 0x00, 0x4C, 0x00, 0x38, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x81, 0x00, 0x40, 0x40, 0x20, 0x18, 0x10, 0x06, 0x10, 0x01, 0x88,
  0x00, 0x64, 0x00, 0x0A, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x43, 0xF8, 0x02, 0x60, 0x60,
  0x14, 0x00, 0x81, 0x40, 0x04, 0x0C, 0x00, 0x20, 0x60, 0x01, 0x02, 0x00,
  0x08, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x08, 0x00, 0xC0, 0x40, 0x18, 0x02,
  0x07, 0x00, 0x10, 0xC0, 0x00, 0x84, 0x00, 0x08, 0x10, 0x01, 0x40, 0x40,
  0x1A, 0x02, 0x01, 0x90, 0x08, 0x18, 0x80, 0x41, 0x04, 0x01, 0x10, 0x40,
  0x05, 0x02, 0x00, 0x30, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x03, 0x08, 0x04, 0x08, 0x18, 0x08, 0x20, 0x08,
  0xC0, 0x11, 0x00, 0x16, 0x00, 0x18, 0x00, 0x11, 0xE0, 0xF0, 0x48, 0x4C,
  0x21, 0x41, 0x20, 0x46, 0x03, 0x01, 0x10, 0x08, 0x04, 0xC0, 0x20, 0x12,
  0x01, 0x00, 0x88, 0x04, 0x02, 0x20, 0x10, 0x08, 0x80, 0x40, 0x22, 0x01,
  0x00, 0x90, 0x04, 0x02, 0x40, 0x20, 0x11, 0x00, 0x80, 0x44, 0x02, 0x01,
  0x10, 0x08, 0x04, 0x40, 0x20, 0x12, 0x00, 0x80, 0x48, 0x04, 0x02, 0x20,
  0x10, 0x08, 0x80, 0x40, 0x22, 0x01, 0x00, 0x80, 0x10, 0xFC, 0x08, 0x81,
  0x04, 0x80, 0x42, 0x80, 0x11, 0x80, 0x09, 0x80, 0x04, 0xC0, 0x02, 0x40,
  0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x00,
  0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x60, 0x60,
  0x30, 0x02, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x0A,
  0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x28,
  0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x16, 0x00, 0x04, 0x40, 0x00, 0x88,
  0x00, 0x21, 0x80, 0x0C, 0x18, 0x03, 0x01, 0x81, 0x80, 0x0F, 0xC0, 0x00,
  0x04, 0x3F, 0x00, 0x4C, 0x08, 0x09, 0x00, 0x40, 0xA0, 0x02, 0x0C, 0x00,
  0x10, 0xC0, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00,
  0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x02, 0x20,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x43, 0x00, 0x04, 0x30, 0x00, 0x82,
  0x80, 0x10, 0x46, 0x06, 0x04, 0x1F, 0x80, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xF8, 0x20, 0xC0, 0xC4, 0x30, 0x05, 0x08, 0x00,
  0x63, 0x00, 0x0C, 0x40, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00,
  0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x03, 0x10, 0x00, 0x61, 0x00, 0x14,
  0x10, 0x04, 0x81, 0x83, 0x20, 0x1F, 0x84, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0xFF, 0x8F, 0xF0, 0x13, 0x00, 0x01, 0x40, 0x00, 0x18,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0xC0, 0x30, 0x20, 0x01, 0x08, 0x00, 0x11, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x02, 0x30, 0x00, 0x83, 0x80, 0x60,
  0x0F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x20, 0x08, 0x06, 0x80, 0x40, 0x40, 0x02, 0x0C, 0x00, 0x21, 0x80, 0x01,
  0x10, 0x00, 0x0B, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0xC8, 0x00,
  0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x11,
  0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x0E, 0x20, 0x02,
  0x84, 0x01, 0x41, 0x00, 0x50, 0x30, 0x64, 0x07, 0xE1, 0x00, 0xFC, 0x00,
  0x41, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x10,
  0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x08, 0x40,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x41, 0x00, 0x30, 0x40, 0x08, 0x20, 0x04,
  0x08, 0x02, 0x02, 0x01, 0x00, 0x81, 0x80, 0x21, 0x80, 0x0F, 0x80, 0x00,
  0x10, 0x08, 0x10, 0x80, 0x80, 0x88, 0x04, 0x04, 0x40, 0x20, 0x22, 0x01,
  0x00, 0x90, 0x08, 0x04, 0x80, 0x40, 0x24, 0x04, 0x01, 0x40, 0x20, 0x0A,
  0x01, 0x00, 0x50, 0x08, 0x02, 0x80, 0x40, 0x14, 0x02, 0x01, 0x20, 0x20,
  0x0A, 0x01, 0x00, 0x50, 0x08, 0x02, 0x80, 0x40, 0x24, 0x06, 0x01, 0x20,
  0x30, 0x11, 0x02, 0x81, 0x84, 0x22, 0x18, 0x1E, 0x0F, 0x00, 0x00, 0xC0,
  0x78, 0x06, 0xC1, 0x0C, 0x30, 0x84, 0x0B, 0x80, 0x90, 0x10, 0x01, 0x20,
  0x20, 0x02, 0x80, 0x40, 0x05, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x20, 0x0C, 0x00, 0x40, 0x18, 0x00, 0x80, 0x50, 0x01, 0x00,
  0xA0, 0x0A, 0x02, 0x20, 0x24, 0x0C, 0x41, 0x84, 0x30, 0x4C, 0x07, 0x80,
  0x60, 0x00, 0x04, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00,
  0x41, 0x00, 0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x81, 0x00,
  0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x01, 0x82, 0x00, 0x28, 0x20,
  0x03, 0x01, 0x00, 0x50, 0x10, 0x05, 0x00, 0xC1, 0x90, 0x07, 0xE1, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x80, 0x04, 0x08, 0x00, 0x80,
  0x60, 0x30, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x08, 0x60, 0x78, 0x84, 0x00,
  0x74, 0x20, 0x00, 0xE1, 0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x02, 0x01, 0x00, 0x10, 0x10,
  0x00, 0x41, 0x00, 0x02, 0x1C, 0x00, 0x10, 0xFF, 0x00, 0x88, 0x1F, 0xE4,
  0x40, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x38, 0x03, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x3F, 0x80, 0x3C, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x04, 0x63, 0x00,
  0x23, 0x06, 0x00, 0x88, 0x0C, 0x04, 0x40, 0x10, 0x31, 0x00, 0x31, 0x88,
  0x00, 0x78, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 29, 25, 10, -29 },
  { 23, 8, 11, 25, 11, -31 },
  { 34, 25, 29, 25, 1, -29 },
  { 125, 22, 37, 25, 2, -33 },
  { 227, 28, 29, 25, -1, -29 },
  { 329, 24, 29, 25, 1, -29 },
  { 416, 3, 11, 25, 14, -31 },
  { 421, 13, 38, 25, 10, -32 },
  { 483, 13, 38, 25, 3, -32 },
  { 545, 21, 21, 25, 3, -23 },
  { 601, 20, 21, 25, 3, -23 },
  { 654, 5, 10, 25, 7, -3 },
  { 661, 12, 1, 25, 7, -13 },
  { 663, 2, 3, 25, 10, -3 },
  { 664, 22, 38, 25, 2, -32 },
  { 769, 20, 29, 25, 3, -29 },
  { 842, 19, 29, 25, 2, -29 },
  { 911, 20, 29, 25, 2, -29 },
  { 984, 20, 29, 25, 2, -29 },
  { 1057, 22, 29, 25, 1, -29 },
  { 1137, 21, 29, 25, 2, -29 },
  { 1214, 18, 29, 25, 3, -29 },
  { 1280, 20, 29, 25, 5, -29 },
  { 1353, 20, 29, 25, 3, -29 },
  { 1426, 19, 29, 25, 4, -29 },
  { 1495, 6, 22, 25, 10, -22 },
  { 1512, 9, 29, 25, 7, -22 },
  { 1545, 20, 22, 25, 4, -24 },
  { 1600, 22, 8, 25, 2, -17 },
  { 1622, 20, 22, 25, 2, -24 },
  { 1677, 17, 29, 25, 6, -29 },
  { 1739, 19, 33, 25, 3, -29 },
  { 1818, 21, 29, 25, 0, -29 },
  { 1895, 20, 29, 25, 2, -29 },
  { 1968, 19, 29, 25, 4, -29 },
  { 2037, 20, 29, 25, 3, -29 },
  { 2110, 22, 29, 25, 3, -29 },
  { 2190, 22, 29, 25, 3, -29 },
  { 2270, 20, 29, 25, 4, -29 },
  { 2343, 22, 29, 25, 2, -29 },
  { 2423, 22, 29, 25, 2, -29 },
  { 2503, 19, 29, 25, 3, -29 },
  { 2572, 23, 29, 25, 3, -29 },
  { 2656, 17, 29, 25, 4, -29 },
  { 2718, 23, 29, 25, 2, -29 },
  { 2802, 22, 29, 25, 2, -29 },
  { 2882, 20, 29, 25, 3, -29 },
  { 2955, 21, 29, 25, 3, -29 },
  { 3032, 20, 36, 25, 3, -29 },
  { 3122, 21, 29, 25, 3, -29 },
  { 3199, 22, 29, 25, 2, -29 },
  { 3279, 22, 29, 25, 5, -29 },
  { 3359, 20, 29, 25, 4, -29 },
  { 3432, 21, 29, 25, 5, -29 },
  { 3509, 23, 29, 25, 3, -29 },
  { 3593, 26, 29, 25, 0, -29 },
  { 3688, 23, 29, 25, 4, -29 },
  { 3772, 25, 29, 25, 0, -29 },
  { 3863, 17, 38, 25, 8, -32 },
  { 3944, 10, 38, 25, 8, -32 },
  { 3992, 17, 38, 25, 1, -32 },
  { 4073, 20, 16, 25, 3, -29 },
  { 4113, 20, 1, 25, 0, 5 },
  { 4116, 5, 7, 25, 10, -32 },
  { 4121, 19, 22, 25, 3, -22 },
  { 4174, 19, 31, 25, 3, -31 },
  { 4248, 18, 22, 25, 3, -22 },
  { 4298, 20, 31, 25, 3, -31 },
  { 4376, 18, 22, 25, 3, -22 },
  { 4426, 26, 39, 25, 0, -31 },
  { 4553, 20, 30, 25, 2, -22 },
  { 4628, 17, 31, 25, 4, -31 },
  { 4694, 17, 31, 25, 4, -31 },
  { 4760, 17, 39, 25, 5, -31 },
  { 4843, 21, 31, 25, 3, -31 },
  { 4925, 16, 31, 25, 5, -31 },
  { 4987, 22, 22, 25, 2, -22 },
  { 5048, 17, 22, 25, 4, -22 },
  { 5095, 19, 22, 25, 3, -22 },
  { 5148, 20, 30, 25, 2, -22 },
  { 5223, 19, 30, 25, 3, -22 },
  { 5295, 20, 22, 25, 5, -22 },
  { 5350, 19, 22, 25, 3, -22 },
  { 5403, 21, 29, 25, 3, -29 },
  { 5480, 18, 22, 25, 4, -22 },
  { 5530, 18, 22, 25, 4, -22 },
  { 5580, 21, 22, 25, 3, -22 },
  { 5638, 23, 22, 25, 1, -22 },
  { 5702, 20, 30, 25, 2, -22 },
  { 5777, 21, 22, 25, 2, -22 },
  { 5835, 19, 38, 25, 5, -32 },
  { 5926, 8, 38, 25, 9, -32 },
  { 5964, 19, 38, 25, 2, -32 },
  { 6055, 22, 7, 25, 2, -17 },
};

const GFXfont IBMPlexMono_ThinItalic42pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic42pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _IBMPLEXMONO_THINITALIC42PT7B_H_
