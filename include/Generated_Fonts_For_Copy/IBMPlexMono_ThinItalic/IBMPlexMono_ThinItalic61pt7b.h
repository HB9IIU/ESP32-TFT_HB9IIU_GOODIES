#ifndef _IBMPLEXMONO_THINITALIC61PT7B_H_
#define _IBMPLEXMONO_THINITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x78,
  0x38, 0x00, 0x30, 0x33, 0x03, 0x30, 0x32, 0x02, 0x20, 0x22, 0x02, 0x60,
  0x66, 0x06, 0x60, 0x64, 0x04, 0x40, 0x44, 0x04, 0xC0, 0xCC, 0x0C, 0xC0,
  0xC0, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x00, 0x10, 0x02, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x04, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x08, 0xF0, 0x00,
  0x30, 0x08, 0x1C, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x10, 0x03, 0x01,
  0x00, 0x10, 0x01, 0x03, 0x00, 0x10, 0x00, 0x02, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x30, 0x00, 0x06, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x20, 0x00, 0x02, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x60, 0x00, 0x01, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x70, 0x40, 0x00, 0x00,
  0x1E, 0x40, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x9E, 0x00, 0x00,
  0x00, 0x83, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x02, 0x00, 0x10, 0xC0, 0x02, 0x00, 0x30, 0x60,
  0x02, 0x00, 0x60, 0x30, 0x06, 0x00, 0x40, 0x18, 0x04, 0x01, 0x80, 0x0E,
  0x04, 0x03, 0x00, 0x03, 0xC4, 0x1C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0x00, 0x18, 0x30, 0x00, 0x02, 0x00, 0x60, 0x08,
  0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x08,
  0x01, 0x80, 0x02, 0x00, 0x10, 0x01, 0x00, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x02, 0x00, 0x60, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x02, 0x00, 0x02, 0x00,
  0x80, 0x02, 0x00, 0x06, 0x01, 0x00, 0x02, 0x00, 0x06, 0x03, 0x00, 0x02,
  0x00, 0x04, 0x06, 0x00, 0x02, 0x00, 0x04, 0x04, 0x00, 0x02, 0x00, 0x0C,
  0x08, 0x00, 0x03, 0x00, 0x08, 0x18, 0x00, 0x01, 0x00, 0x10, 0x30, 0x00,
  0x01, 0x80, 0x20, 0x20, 0x00, 0x00, 0xC0, 0xC0, 0x40, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x06, 0x06, 0x01, 0x80, 0x00, 0x04, 0x0C,
  0x00, 0xC0, 0x00, 0x08, 0x08, 0x00, 0x40, 0x00, 0x18, 0x10, 0x00, 0x40,
  0x00, 0x30, 0x10, 0x00, 0x40, 0x00, 0x20, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x20, 0x00, 0x60, 0x00, 0x80, 0x20, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00,
  0x40, 0x01, 0x00, 0x20, 0x00, 0x40, 0x02, 0x00, 0x60, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x18, 0x00, 0x20,
  0x00, 0x80, 0x10, 0x00, 0x20, 0x01, 0x00, 0x20, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x10, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x07,
  0x88, 0x70, 0x00, 0x01, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x04, 0x00, 0x10, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x05, 0x00, 0x28, 0x00, 0x01, 0x30, 0x0D, 0x80, 0x00, 0x23,
  0x01, 0x10, 0x00, 0x0C, 0x20, 0x43, 0x00, 0x01, 0x06, 0x18, 0x20, 0x00,
  0x40, 0x42, 0x03, 0x00, 0x10, 0x04, 0x80, 0x38, 0x1C, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x0C, 0x00, 0x33, 0x32, 0x22, 0x66, 0x64, 0x44, 0xCC, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x73, 0x80, 0x10, 0x07, 0x80, 0xE0, 0x60, 0xF8,
  0x00, 0x3C, 0xCF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x60, 0x01, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x07, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x20, 0x60,
  0x40, 0x40, 0x80, 0x80, 0xFF, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x00, 0x2C, 0x00, 0x70, 0x01, 0x60, 0x07, 0x80, 0x0B, 0x00,
  0x18, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x04, 0x00, 0x01, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x08,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x10, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x80, 0x20, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x60, 0x01, 0x00, 0x00, 0x80, 0x06, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x40, 0x03, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x08, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x41, 0xFE, 0x00, 0x03, 0x18, 0x07, 0x00, 0x09, 0x80, 0x06, 0x00,
  0x28, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x07, 0xF8,
  0x01, 0x8E, 0x03, 0x80, 0x4C, 0x00, 0x18, 0x36, 0x00, 0x03, 0x0B, 0x00,
  0x00, 0x43, 0x80, 0x00, 0x09, 0x40, 0x00, 0x02, 0x60, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x60, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x00, 0x81, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x02,
  0x20, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x1E, 0x03, 0x80, 0x06, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x08, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x02, 0x20, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x38, 0x60, 0x00, 0x0D,
  0x06, 0x00, 0x03, 0x40, 0x60, 0x01, 0xC8, 0x07, 0x00, 0xE2, 0x00, 0x1F,
  0xE0, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0x83, 0xC1, 0xC0,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xC0, 0x70, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x02, 0x30,
  0x00, 0x02, 0x60, 0x00, 0x03, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x30, 0x80, 0x0F, 0xC2, 0x18, 0x03, 0x03, 0x21, 0x00, 0x60,
  0x0A, 0x10, 0x08, 0x00, 0xA1, 0x01, 0x80, 0x06, 0x30, 0x10, 0x00, 0x62,
  0x03, 0x00, 0x04, 0x20, 0x20, 0x00, 0x42, 0x02, 0x00, 0x04, 0x20, 0x20,
  0x00, 0x46, 0x06, 0x00, 0x04, 0x60, 0x60, 0x00, 0xC4, 0x04, 0x00, 0x08,
  0x40, 0x40, 0x00, 0x84, 0x04, 0x00, 0x08, 0x40, 0x40, 0x00, 0x8C, 0x04,
  0x00, 0x18, 0xC0, 0x40, 0x01, 0x8C, 0x04, 0x00, 0x10, 0x80, 0x40, 0x03,
  0x08, 0x06, 0x00, 0x50, 0x80, 0x20, 0x0D, 0x08, 0x03, 0x01, 0x90, 0x80,
  0x1C, 0x63, 0x08, 0x00, 0x3C, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08,
  0x02, 0x00, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x20, 0x03, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x40, 0x00, 0x60, 0x02, 0x00, 0x00, 0x80, 0x08,
  0x00, 0x02, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x04, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x40,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x43, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0xE0, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x18, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x10, 0x10, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x80, 0x08, 0x00, 0x18, 0x00, 0x20, 0x01, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x60, 0x08, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x61, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x10, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x00, 0xC0,
  0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x01, 0xFF, 0xE2, 0x00, 0x10, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04,
  0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x01, 0xC0, 0x80, 0x00, 0x14, 0x02, 0x00, 0x01, 0xA0, 0x18, 0x00,
  0x19, 0x00, 0x60, 0x01, 0x88, 0x00, 0xC0, 0x30, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x18, 0x0F, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x20, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x06, 0x00, 0x08, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x04, 0x00, 0x10, 0x00, 0x01, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x80, 0xE0, 0x00, 0x00, 0x20, 0x68,
  0x00, 0x00, 0x08, 0x33, 0x00, 0x00, 0x06, 0x18, 0x40, 0x00, 0x01, 0x8C,
  0x18, 0x00, 0x00, 0x66, 0x02, 0x00, 0x00, 0x13, 0x00, 0xC0, 0x00, 0x05,
  0x80, 0x30, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x20, 0x00, 0x08, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x18, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xC0, 0x58, 0x00, 0x00, 0xA0, 0x24, 0x00, 0x00, 0xD0, 0x12, 0x00,
  0x00, 0xC8, 0x09, 0x00, 0x00, 0x44, 0x0C, 0xC0, 0x00, 0x66, 0x06, 0x20,
  0x00, 0x22, 0x02, 0x10, 0x00, 0x21, 0x01, 0x08, 0x00, 0x30, 0x80, 0x82,
  0x00, 0x10, 0x40, 0x41, 0x00, 0x18, 0x20, 0x60, 0x80, 0x08, 0x30, 0x30,
  0x60, 0x08, 0x18, 0x10, 0x10, 0x0C, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04,
  0x04, 0x06, 0x02, 0x02, 0x01, 0x06, 0x01, 0x03, 0x00, 0x82, 0x01, 0x81,
  0x80, 0x43, 0x00, 0xC0, 0x80, 0x31, 0x00, 0x40, 0x40, 0x09, 0x00, 0x20,
  0x20, 0x05, 0x80, 0x10, 0x10, 0x02, 0x80, 0x08, 0x18, 0x00, 0xC0, 0x0C,
  0x0C, 0x00, 0x40, 0x06, 0x04, 0x00, 0x40, 0x02, 0x02, 0x00, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x10, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x01, 0x01, 0x40, 0x00, 0x03, 0x01,
  0x60, 0x00, 0x03, 0x01, 0x20, 0x00, 0x02, 0x01, 0x20, 0x00, 0x02, 0x03,
  0x30, 0x00, 0x02, 0x03, 0x10, 0x00, 0x02, 0x02, 0x10, 0x00, 0x06, 0x02,
  0x18, 0x00, 0x06, 0x02, 0x08, 0x00, 0x04, 0x02, 0x08, 0x00, 0x04, 0x06,
  0x0C, 0x00, 0x04, 0x06, 0x04, 0x00, 0x04, 0x04, 0x04, 0x00, 0x0C, 0x04,
  0x06, 0x00, 0x0C, 0x04, 0x02, 0x00, 0x08, 0x04, 0x03, 0x00, 0x08, 0x0C,
  0x01, 0x00, 0x08, 0x0C, 0x01, 0x00, 0x08, 0x08, 0x01, 0x80, 0x18, 0x08,
  0x00, 0x80, 0x18, 0x08, 0x00, 0x80, 0x10, 0x08, 0x00, 0xC0, 0x10, 0x18,
  0x00, 0x40, 0x10, 0x18, 0x00, 0x40, 0x10, 0x10, 0x00, 0x60, 0x30, 0x10,
  0x00, 0x20, 0x30, 0x10, 0x00, 0x20, 0x20, 0x10, 0x00, 0x30, 0x20, 0x30,
  0x00, 0x10, 0x20, 0x30, 0x00, 0x10, 0x20, 0x20, 0x00, 0x18, 0x60, 0x20,
  0x00, 0x08, 0x60, 0x20, 0x00, 0x08, 0x40, 0x20, 0x00, 0x0C, 0x40, 0x60,
  0x00, 0x04, 0x40, 0x60, 0x00, 0x04, 0x40, 0x40, 0x00, 0x06, 0xC0, 0x40,
  0x00, 0x02, 0xC0, 0x40, 0x00, 0x02, 0x80, 0x40, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x04, 0x00, 0x01, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x02,
  0x00, 0x01, 0xC0, 0x04, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x80, 0x80, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x10, 0x18, 0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x30, 0x04, 0x00, 0x01, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x02,
  0x00, 0x01, 0xC0, 0x04, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x40, 0x30,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x80, 0x80, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0x80,
  0x0C, 0x00, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x40, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x03, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x30, 0x01, 0x80, 0x00, 0x20, 0x03, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x00, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x41, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x81, 0x00, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x08, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x40, 0x18, 0x00, 0x02, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x03, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x20, 0x01, 0x00,
  0x01, 0x80, 0x04, 0x00, 0x04, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x80, 0x06, 0x00, 0x02, 0x00, 0x10, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x80, 0x18, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x00, 0x81, 0x00, 0x08, 0x00, 0x40, 0x80, 0x0E, 0x00, 0x60, 0x40,
  0x07, 0x00, 0x20, 0x20, 0x06, 0x80, 0x10, 0x10, 0x02, 0x40, 0x08, 0x08,
  0x03, 0x20, 0x0C, 0x04, 0x01, 0x10, 0x04, 0x02, 0x01, 0x88, 0x02, 0x01,
  0x00, 0x84, 0x01, 0x01, 0x80, 0x43, 0x01, 0x80, 0xC0, 0x41, 0x80, 0x80,
  0x60, 0x20, 0x40, 0x40, 0x30, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x30,
  0x08, 0x18, 0x08, 0x10, 0x04, 0x08, 0x04, 0x08, 0x02, 0x0C, 0x02, 0x04,
  0x01, 0x04, 0x01, 0x86, 0x00, 0x86, 0x00, 0xC2, 0x00, 0x42, 0x00, 0x21,
  0x00, 0x23, 0x00, 0x11, 0x80, 0x11, 0x00, 0x08, 0xC0, 0x09, 0x80, 0x04,
  0x40, 0x0C, 0x80, 0x02, 0x20, 0x06, 0x40, 0x01, 0xB0, 0x03, 0x40, 0x00,
  0xD0, 0x01, 0xA0, 0x00, 0x28, 0x00, 0xF0, 0x00, 0x14, 0x00, 0x50, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x60, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x20, 0x00, 0x06, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C, 0x08,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x04, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x60, 0x02, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x10, 0x00,
  0x10, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x63, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xF8, 0x83, 0x04, 0x18, 0x20, 0x41, 0x82, 0x0C, 0x10, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0x01, 0x83, 0x00, 0x80, 0x06, 0x20, 0x30, 0x00, 0x32, 0x06,
  0x00, 0x01, 0x20, 0x40, 0x00, 0x0A, 0x08, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x43, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0A, 0x02, 0x00, 0x00, 0xA0, 0x30,
  0x00, 0x12, 0x01, 0x00, 0x02, 0x20, 0x0C, 0x00, 0xC6, 0x00, 0x70, 0x38,
  0x3F, 0x01, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x0F, 0xE0, 0x01, 0x06, 0x03, 0x00, 0x23, 0x00, 0x18, 0x04,
  0xC0, 0x01, 0x81, 0xB0, 0x00, 0x10, 0x34, 0x00, 0x01, 0x05, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x44, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18, 0x50, 0x00, 0x06, 0x1A,
  0x00, 0x00, 0x83, 0x20, 0x00, 0x60, 0x42, 0x00, 0x18, 0x08, 0x38, 0x0C,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x10, 0x60, 0x00, 0x0C,
  0x60, 0x00, 0x02, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x04, 0x40, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x84, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0E, 0x07, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x3F, 0x80, 0xC0, 0x07, 0x01, 0x83, 0x00, 0x20, 0x01,
  0x88, 0x03, 0x00, 0x03, 0x20, 0x18, 0x00, 0x04, 0x80, 0x40, 0x00, 0x0A,
  0x02, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x02, 0x80, 0x20, 0x00, 0x0A, 0x00, 0xC0,
  0x00, 0x48, 0x01, 0x00, 0x02, 0x20, 0x03, 0x00, 0x31, 0x80, 0x07, 0x03,
  0x86, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0C, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x06, 0x02, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06, 0x40, 0x00, 0x03,
  0x10, 0x00, 0x01, 0x84, 0x00, 0x01, 0x83, 0x00, 0x03, 0x80, 0xC0, 0x3F,
  0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x01, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x10, 0x30, 0x00, 0x08, 0x06, 0x00, 0x04, 0x00, 0xC0, 0x06, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0,
  0x60, 0xC0, 0x10, 0x00, 0xC4, 0x03, 0x00, 0x03, 0x20, 0x30, 0x00, 0x09,
  0x01, 0x00, 0x00, 0x28, 0x10, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x06, 0x08,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x04, 0x00, 0x00, 0x08, 0x20, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x43, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x40, 0x20, 0x00, 0x0A, 0x01,
  0x80, 0x00, 0x90, 0x04, 0x00, 0x08, 0x80, 0x18, 0x01, 0x8C, 0x00, 0x70,
  0x38, 0x60, 0x00, 0xFE, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10, 0x06, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x07, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x3F, 0x80, 0x18, 0x70,
  0x30, 0x0C, 0x40, 0x04, 0x04, 0x40, 0x01, 0x02, 0x40, 0x00, 0xC1, 0x40,
  0x00, 0x20, 0xA0, 0x00, 0x10, 0xE0, 0x00, 0x08, 0x60, 0x00, 0x04, 0x30,
  0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x31, 0x00, 0x00, 0x18, 0x80, 0x00, 0x08,
  0x40, 0x00, 0x04, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01,
  0x88, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x20, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x20, 0x18, 0x00, 0x60, 0x08, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x02, 0x00,
  0x80, 0x03, 0x01, 0x80, 0x01, 0x81, 0x00, 0x00, 0x83, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x14, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x02, 0x00,
  0x04, 0x00, 0x80, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x40, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x10, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x0F, 0xE0, 0x00, 0x41, 0xC0, 0x60, 0x01, 0x18, 0x00,
  0x40, 0x04, 0xC0, 0x00, 0x80, 0x36, 0x00, 0x02, 0x00, 0xD0, 0x00, 0x0C,
  0x02, 0x80, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x40, 0x30, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x08, 0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x60, 0x04, 0x00, 0x02, 0x00, 0x10, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x08, 0x1C, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x18, 0x02, 0x00, 0x01, 0x60, 0x0C, 0x00, 0x09, 0x00, 0x10, 0x00, 0x44,
  0x00, 0x60, 0x02, 0x10, 0x00, 0x80, 0x30, 0x40, 0x03, 0x01, 0x83, 0x00,
  0x04, 0x0C, 0x0C, 0x00, 0x08, 0x60, 0x20, 0x00, 0x23, 0x00, 0x80, 0x00,
  0x58, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x40, 0x80, 0x06, 0x06, 0x00, 0x30,
  0x18, 0x01, 0x00, 0x40, 0x18, 0x01, 0x00, 0x80, 0x04, 0x0C, 0x00, 0x30,
  0x40, 0x00, 0xC6, 0x00, 0x03, 0x20, 0x00, 0x0B, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1E, 0x01, 0xF8, 0x04, 0x61, 0x83, 0x0C, 0x04, 0x80, 0xC4,
  0x06, 0x0D, 0x00, 0x48, 0x02, 0x0E, 0x00, 0x50, 0x02, 0x0C, 0x00, 0x60,
  0x03, 0x0C, 0x00, 0x60, 0x03, 0x08, 0x00, 0x40, 0x02, 0x08, 0x00, 0x40,
  0x02, 0x18, 0x00, 0x40, 0x02, 0x10, 0x00, 0xC0, 0x02, 0x10, 0x00, 0xC0,
  0x06, 0x10, 0x00, 0x80, 0x06, 0x10, 0x00, 0x80, 0x04, 0x10, 0x00, 0x80,
  0x04, 0x30, 0x00, 0x80, 0x04, 0x20, 0x01, 0x80, 0x04, 0x20, 0x01, 0x80,
  0x0C, 0x20, 0x01, 0x00, 0x0C, 0x20, 0x01, 0x00, 0x08, 0x60, 0x01, 0x00,
  0x08, 0x60, 0x01, 0x00, 0x08, 0x40, 0x03, 0x00, 0x08, 0x40, 0x03, 0x00,
  0x18, 0x40, 0x02, 0x00, 0x18, 0x40, 0x02, 0x00, 0x10, 0xC0, 0x02, 0x00,
  0x10, 0xC0, 0x02, 0x00, 0x10, 0x80, 0x06, 0x00, 0x10, 0x80, 0x06, 0x00,
  0x30, 0x80, 0x04, 0x00, 0x30, 0x80, 0x04, 0x00, 0x20, 0x00, 0x07, 0xF0,
  0x01, 0x0E, 0x06, 0x01, 0x88, 0x00, 0x80, 0x88, 0x00, 0x20, 0x48, 0x00,
  0x18, 0x28, 0x00, 0x04, 0x14, 0x00, 0x02, 0x1C, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x08, 0xC0, 0x00, 0x04, 0x60, 0x00, 0x06, 0x20, 0x00, 0x03, 0x10,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x46, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x18, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04,
  0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x18, 0x00, 0x1F, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x18, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x44, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x08, 0x30, 0x00, 0x02, 0x02,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x03, 0x00, 0x08, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x08, 0x30, 0x18,
  0x00, 0x46, 0x00, 0x30, 0x02, 0x60, 0x00, 0xC0, 0x16, 0x00, 0x02, 0x01,
  0xA0, 0x00, 0x08, 0x0A, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x41, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x20, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x28, 0x00, 0x03, 0x03, 0x40,
  0x00, 0x10, 0x19, 0x00, 0x03, 0x00, 0x84, 0x00, 0x30, 0x04, 0x1C, 0x06,
  0x00, 0x20, 0x3F, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0x01, 0x83, 0x00, 0x80, 0x06, 0x20, 0x30, 0x00, 0x32, 0x06,
  0x00, 0x01, 0x20, 0x40, 0x00, 0x0A, 0x08, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x43, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0A, 0x02, 0x00, 0x00, 0xA0, 0x30,
  0x00, 0x12, 0x01, 0x00, 0x02, 0x20, 0x0C, 0x00, 0xC6, 0x00, 0x70, 0x38,
  0x60, 0x01, 0xFC, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0x43, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x00, 0x70, 0x01,
  0x80, 0x01, 0xC0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x06, 0x00, 0x78, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x40,
  0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x08, 0x00, 0x08,
  0x01, 0x80, 0x00, 0x40, 0x30, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40,
  0x00, 0x04, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x20, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x21, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x28, 0x60, 0x00,
  0x14, 0x10, 0x00, 0x16, 0x08, 0x00, 0x0B, 0x06, 0x00, 0x09, 0x01, 0x80,
  0x18, 0x80, 0x70, 0x30, 0x40, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x5F,
  0xF0, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x40, 0x00, 0x10, 0x18, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x08, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x10, 0x30, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x10, 0x10,
  0x00, 0x02, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x10, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x30, 0x08, 0x00, 0x04, 0x01, 0x00,
  0x01, 0x80, 0x20, 0x00, 0x60, 0x04, 0x00, 0x08, 0x01, 0x80, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x60, 0x00, 0x80, 0x18, 0x00, 0x10, 0x0C,
  0x00, 0x02, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0x10, 0x30, 0x01, 0x80, 0x20, 0x40, 0x02, 0x00, 0x60,
  0x80, 0x04, 0x00, 0x41, 0x00, 0x08, 0x00, 0x82, 0x00, 0x10, 0x01, 0x0C,
  0x00, 0x60, 0x02, 0x18, 0x00, 0xC0, 0x04, 0x20, 0x01, 0x00, 0x08, 0x40,
  0x02, 0x00, 0x18, 0x80, 0x04, 0x00, 0x31, 0x00, 0x08, 0x00, 0x66, 0x00,
  0x30, 0x00, 0x8C, 0x00, 0x60, 0x01, 0x10, 0x00, 0x80, 0x02, 0x20, 0x01,
  0x00, 0x04, 0x40, 0x02, 0x00, 0x08, 0x80, 0x04, 0x00, 0x13, 0x00, 0x18,
  0x00, 0x26, 0x00, 0x30, 0x00, 0xC8, 0x00, 0x40, 0x01, 0x10, 0x00, 0x80,
  0x02, 0x20, 0x01, 0x00, 0x04, 0x40, 0x06, 0x00, 0x18, 0x80, 0x0C, 0x00,
  0x23, 0x00, 0x28, 0x00, 0xC6, 0x00, 0x50, 0x01, 0x04, 0x00, 0xA0, 0x06,
  0x08, 0x02, 0x40, 0x18, 0x18, 0x08, 0x40, 0x60, 0x18, 0x60, 0xC1, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x0E, 0x60, 0x18,
  0x30, 0x07, 0x04, 0x06, 0x03, 0x03, 0x80, 0xC1, 0x80, 0x21, 0x80, 0x08,
  0x20, 0x04, 0x40, 0x01, 0x08, 0x00, 0x80, 0x00, 0x32, 0x00, 0x18, 0x00,
  0x02, 0x40, 0x03, 0x00, 0x00, 0x48, 0x00, 0x40, 0x00, 0x0A, 0x00, 0x08,
  0x00, 0x01, 0x40, 0x01, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x10, 0x00, 0x50, 0x00, 0x02, 0x00, 0x0A, 0x00,
  0x00, 0x40, 0x02, 0x40, 0x00, 0x18, 0x00, 0x48, 0x00, 0x03, 0x00, 0x19,
  0x80, 0x00, 0x20, 0x02, 0x10, 0x00, 0xC4, 0x00, 0x82, 0x00, 0x60, 0x80,
  0x30, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x18, 0x01, 0x83, 0x00, 0xCC, 0x00,
  0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x20, 0x00, 0x02, 0x03, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x02, 0x01, 0x00, 0x00, 0x10, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x40, 0x20, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x02, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x80,
  0x60, 0x00, 0x14, 0x01, 0x00, 0x01, 0x60, 0x08, 0x00, 0x0B, 0x00, 0x60,
  0x00, 0x90, 0x01, 0x80, 0x18, 0x80, 0x07, 0x03, 0x04, 0x00, 0x0F, 0xE0,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x01, 0x80, 0x03,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x06, 0x03, 0x80, 0x10, 0x20, 0x01, 0x80, 0xC1, 0x00, 0x01, 0xC2,
  0x04, 0x00, 0x00, 0xC8, 0x20, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x01, 0x80, 0x20, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x02, 0x00, 0x18, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x20, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0x5F, 0x00, 0x00, 0x41, 0x03, 0xE0,
  0x01, 0x0C, 0x00, 0x7C, 0x04, 0x30, 0x00, 0x1F, 0x98, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x08,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x02, 0x0C, 0x30, 0x00, 0x04, 0x30, 0x10, 0x00, 0x10, 0xC0, 0x10, 0x00,
  0x21, 0x00, 0x10, 0x00, 0xC4, 0x00, 0x30, 0x01, 0x08, 0x00, 0x30, 0x04,
  0x20, 0x00, 0x30, 0x10, 0x40, 0x00, 0x30, 0xC1, 0x80, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 9, 43, 37, 14, -43 },
  { 50, 12, 15, 37, 16, -45 },
  { 73, 36, 43, 37, 1, -43 },
  { 267, 32, 56, 37, 2, -49 },
  { 491, 40, 44, 37, -1, -43 },
  { 711, 35, 44, 37, 1, -43 },
  { 904, 4, 15, 37, 20, -45 },
  { 912, 19, 54, 37, 14, -46 },
  { 1041, 19, 54, 37, 4, -46 },
  { 1170, 31, 30, 37, 4, -33 },
  { 1287, 29, 29, 37, 4, -33 },
  { 1393, 8, 15, 37, 10, -5 },
  { 1408, 16, 1, 37, 11, -19 },
  { 1410, 4, 4, 37, 14, -4 },
  { 1412, 33, 54, 37, 2, -46 },
  { 1635, 29, 44, 37, 5, -43 },
  { 1795, 28, 43, 37, 3, -43 },
  { 1946, 29, 43, 37, 3, -43 },
  { 2102, 29, 44, 37, 3, -43 },
  { 2262, 31, 43, 37, 2, -43 },
  { 2429, 30, 44, 37, 4, -43 },
  { 2594, 26, 44, 37, 5, -43 },
  { 2737, 29, 43, 37, 7, -43 },
  { 2893, 30, 44, 37, 4, -43 },
  { 3058, 27, 43, 37, 6, -43 },
  { 3204, 9, 32, 37, 14, -32 },
  { 3240, 13, 42, 37, 10, -32 },
  { 3309, 29, 33, 37, 6, -35 },
  { 3429, 31, 12, 37, 3, -25 },
  { 3476, 29, 33, 37, 3, -35 },
  { 3596, 24, 43, 37, 9, -43 },
  { 3725, 28, 49, 37, 5, -43 },
  { 3897, 30, 43, 37, 1, -43 },
  { 4059, 29, 43, 37, 4, -43 },
  { 4215, 29, 44, 37, 5, -43 },
  { 4375, 30, 43, 37, 4, -43 },
  { 4537, 32, 43, 37, 4, -43 },
  { 4709, 32, 43, 37, 4, -43 },
  { 4881, 29, 44, 37, 5, -43 },
  { 5041, 32, 43, 37, 3, -43 },
  { 5213, 32, 43, 37, 3, -43 },
  { 5385, 29, 44, 37, 4, -43 },
  { 5545, 34, 43, 37, 4, -43 },
  { 5728, 24, 43, 37, 6, -43 },
  { 5857, 33, 43, 37, 3, -43 },
  { 6035, 32, 43, 37, 3, -43 },
  { 6207, 29, 44, 37, 5, -43 },
  { 6367, 31, 43, 37, 4, -43 },
  { 6534, 29, 53, 37, 5, -43 },
  { 6727, 31, 43, 37, 4, -43 },
  { 6894, 32, 44, 37, 2, -43 },
  { 7070, 32, 43, 37, 7, -43 },
  { 7242, 30, 44, 37, 5, -43 },
  { 7407, 30, 43, 37, 8, -43 },
  { 7569, 33, 43, 37, 5, -43 },
  { 7747, 38, 43, 37, 0, -43 },
  { 7952, 33, 43, 37, 6, -43 },
  { 8130, 37, 43, 37, 0, -43 },
  { 8329, 24, 54, 37, 12, -46 },
  { 8491, 14, 54, 37, 12, -46 },
  { 8586, 24, 54, 37, 2, -46 },
  { 8748, 28, 23, 37, 5, -43 },
  { 8829, 29, 1, 37, 0, 8 },
  { 8833, 6, 10, 37, 15, -46 },
  { 8841, 28, 33, 37, 4, -32 },
  { 8957, 27, 46, 37, 5, -45 },
  { 9113, 25, 33, 37, 5, -32 },
  { 9217, 30, 46, 37, 4, -45 },
  { 9390, 26, 33, 37, 5, -32 },
  { 9498, 38, 58, 37, -1, -45 },
  { 9774, 29, 45, 37, 3, -32 },
  { 9938, 25, 45, 37, 5, -45 },
  { 10079, 25, 46, 37, 6, -45 },
  { 10223, 25, 58, 37, 7, -45 },
  { 10405, 30, 46, 37, 5, -45 },
  { 10578, 22, 46, 37, 8, -45 },
  { 10705, 32, 32, 37, 3, -32 },
  { 10833, 25, 32, 37, 5, -32 },
  { 10933, 27, 33, 37, 5, -32 },
  { 11045, 29, 44, 37, 3, -32 },
  { 11205, 28, 44, 37, 4, -32 },
  { 11359, 30, 31, 37, 7, -31 },
  { 11476, 28, 33, 37, 4, -32 },
  { 11592, 29, 44, 37, 5, -43 },
  { 11752, 25, 32, 37, 6, -31 },
  { 11852, 27, 32, 37, 5, -32 },
  { 11960, 31, 33, 37, 4, -32 },
  { 12088, 35, 33, 37, 1, -32 },
  { 12233, 29, 44, 37, 2, -31 },
  { 12393, 30, 33, 37, 3, -32 },
  { 12517, 28, 54, 37, 7, -46 },
  { 12706, 10, 54, 37, 14, -46 },
  { 12774, 27, 54, 37, 3, -46 },
  { 12957, 31, 10, 37, 3, -24 },
};

const GFXfont IBMPlexMono_ThinItalic61pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic61pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic61pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _IBMPLEXMONO_THINITALIC61PT7B_H_
