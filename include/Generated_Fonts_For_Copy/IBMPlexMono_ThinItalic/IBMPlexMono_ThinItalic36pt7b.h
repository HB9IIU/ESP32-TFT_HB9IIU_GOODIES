#ifndef _IBMPLEXMONO_THINITALIC36PT7B_H_
#define _IBMPLEXMONO_THINITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x23, 0x22, 0x42, 0x42,
  0x42, 0x42, 0x44, 0x44, 0x84, 0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x08,
  0x20, 0x00, 0x41, 0x00, 0x04, 0x08, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00,
  0x10, 0x40, 0x3F, 0x83, 0xF8, 0x04, 0x10, 0x00, 0x40, 0x80, 0x02, 0x08,
  0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00, 0xFC,
  0x0F, 0xE0, 0x20, 0x80, 0x01, 0x04, 0x00, 0x10, 0x20, 0x00, 0x82, 0x00,
  0x04, 0x10, 0x00, 0x40, 0x80, 0x02, 0x08, 0x00, 0x20, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x0F, 0xE0, 0x06,
  0x13, 0x01, 0x04, 0x10, 0x40, 0x81, 0x08, 0x10, 0x02, 0x02, 0x00, 0x40,
  0x40, 0x08, 0x10, 0x01, 0x02, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x08, 0xC0, 0x01, 0x04, 0x00, 0x20, 0x40, 0x04,
  0x08, 0x00, 0x81, 0x00, 0x20, 0x20, 0x04, 0x04, 0x80, 0x80, 0x88, 0x10,
  0x20, 0x82, 0x0C, 0x0C, 0x46, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF0, 0x01, 0x03, 0x08, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x04, 0x04, 0x08, 0x04, 0x08, 0x08, 0x04, 0x10,
  0x08, 0x04, 0x20, 0x08, 0x04, 0x20, 0x08, 0x08, 0x40, 0x08, 0x08, 0x80,
  0x04, 0x31, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xC4, 0x30, 0x00, 0x88, 0x10, 0x01, 0x10, 0x08, 0x02, 0x10, 0x08,
  0x04, 0x10, 0x08, 0x08, 0x20, 0x08, 0x08, 0x20, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x10, 0x10, 0x40, 0x08, 0x60, 0xC0, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x0C, 0x10, 0x00, 0x80, 0x40, 0x04, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x40, 0x20, 0x02, 0x01, 0x00, 0x10, 0x08, 0x00,
  0x40, 0x80, 0x07, 0x08, 0x01, 0xCB, 0x80, 0x10, 0x20, 0x01, 0x00, 0x80,
  0x08, 0x04, 0x00, 0x40, 0x10, 0x04, 0x00, 0x40, 0x20, 0x02, 0x01, 0x00,
  0x18, 0x18, 0x00, 0xA0, 0xA0, 0x09, 0x09, 0x00, 0x44, 0x86, 0x0C, 0x14,
  0x0F, 0x80, 0xC0, 0x55, 0xAA, 0x80, 0x00, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x20, 0x10, 0x13, 0x82, 0x0D, 0x0E, 0x5E, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0x90, 0x00, 0x22, 0x00, 0x08, 0x20, 0x02,
  0x04, 0x00, 0x80, 0x40, 0x20, 0x08, 0x08, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x7F, 0xFF, 0xE0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x88, 0x46, 0x21, 0x10, 0x80, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x03, 0x03, 0x03, 0x00, 0xC2,
  0x00, 0x21, 0x00, 0x11, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x18, 0x14, 0x0C, 0x0A, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x41, 0x00, 0x40, 0x60, 0xC0, 0x1F, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xD0, 0x01, 0x10, 0x06, 0x10, 0x0C, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF,
  0xFF, 0x00, 0xFC, 0x01, 0x81, 0x01, 0x00, 0x41, 0x00, 0x11, 0x00, 0x08,
  0x80, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0x03, 0x02,
  0x00, 0x42, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x7E, 0x00, 0x41, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x48, 0x00, 0x24, 0x00, 0x21, 0x00, 0x30, 0x60, 0x60, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x12, 0x00, 0x09,
  0x00, 0x04, 0x40, 0x02, 0x10, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40,
  0x10, 0x20, 0x08, 0x08, 0x04, 0x02, 0x02, 0x00, 0x81, 0x00, 0x20, 0x80,
  0x08, 0x40, 0x04, 0x10, 0x01, 0x0F, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x07, 0xFF,
  0xC1, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x3F, 0x00, 0x70,
  0x30, 0x10, 0x02, 0x08, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x80, 0x02, 0x20, 0x01, 0x84,
  0x00, 0x40, 0xC0, 0x60, 0x0F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x8F, 0xC2, 0x60, 0x47, 0x00, 0x54, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x50, 0x00,
  0x90, 0x02, 0x18, 0x18, 0x0F, 0xC0, 0x7F, 0xFF, 0xA0, 0x00, 0x90, 0x00,
  0x48, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x08, 0x20, 0x01, 0x10, 0x00, 0x44,
  0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x82, 0x00, 0x40, 0x60,
  0x60, 0x07, 0xC0, 0x0E, 0x0C, 0x0C, 0x00, 0x82, 0x00, 0x11, 0x00, 0x04,
  0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x01, 0x10,
  0x00, 0x86, 0x00, 0x60, 0xC0, 0x60, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x38,
  0x30, 0xC0, 0x13, 0x00, 0x14, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x34, 0x00, 0xC6, 0x06, 0x87,
  0xF2, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x30, 0x06, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x20,
  0x81, 0x06, 0x08, 0x10, 0x40, 0x80, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x07, 0xE0,
  0x10, 0x30, 0xC0, 0x11, 0x00, 0x24, 0x00, 0x50, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x0E, 0x00, 0xE0,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x03,
  0x06, 0x04, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x79, 0x20, 0x85, 0x61, 0x03, 0x42, 0x01, 0x42, 0x01, 0x44, 0x02, 0x44,
  0x02, 0x84, 0x02, 0x84, 0x02, 0x84, 0x02, 0x84, 0x06, 0x84, 0x04, 0x84,
  0x0C, 0x82, 0x14, 0x81, 0xE4, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x40, 0x00, 0x48, 0x00, 0x22, 0x00, 0x08, 0x80, 0x04, 0x20, 0x01,
  0x08, 0x00, 0x82, 0x00, 0x20, 0x40, 0x10, 0x10, 0x04, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x10, 0x10, 0x02, 0x07, 0xFF, 0x82, 0x00, 0x20,
  0x80, 0x08, 0x40, 0x02, 0x10, 0x00, 0x88, 0x00, 0x12, 0x00, 0x05, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x0F, 0xFC, 0x04, 0x01, 0x82, 0x00, 0x61, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88,
  0x00, 0x88, 0x00, 0x44, 0x00, 0xC3, 0xFF, 0x81, 0x00, 0x30, 0x80, 0x04,
  0x40, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x14, 0x00, 0x12, 0x00, 0x09, 0x00, 0x18, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x01, 0x83, 0x01, 0x00, 0x41, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x44, 0x00, 0x42, 0x00, 0x40, 0x80, 0x60, 0x20,
  0x60, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x02, 0x01, 0x80, 0x80, 0x10, 0x20,
  0x02, 0x08, 0x00, 0x84, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x22,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x90, 0x00, 0x44, 0x00, 0x11, 0x00,
  0x04, 0x40, 0x02, 0x10, 0x01, 0x04, 0x00, 0xC2, 0x00, 0xC0, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xF8, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xF0, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0x83, 0x01, 0x00, 0x41, 0x00, 0x21, 0x00, 0x09,
  0x00, 0x04, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x03, 0xFA, 0x02, 0x05, 0x00, 0x04, 0x80,
  0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x62, 0x00, 0x61,
  0x80, 0x50, 0x60, 0x68, 0x0F, 0xC4, 0x00, 0x08, 0x00, 0x21, 0x00, 0x08,
  0x20, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10,
  0x80, 0x04, 0x10, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x43,
  0xFF, 0xF8, 0x40, 0x02, 0x08, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08,
  0x00, 0x21, 0x00, 0x04, 0x20, 0x01, 0x04, 0x00, 0x21, 0x00, 0x04, 0x20,
  0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0xE0, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x80,
  0x10, 0x80, 0x10, 0x80, 0x20, 0x60, 0xC0, 0x1F, 0x00, 0x08, 0x00, 0x10,
  0x80, 0x02, 0x08, 0x00, 0x40, 0x80, 0x18, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x01, 0x01, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00, 0x10, 0x80,
  0x02, 0x18, 0x00, 0x22, 0x40, 0x02, 0x44, 0x00, 0x28, 0x20, 0x03, 0x02,
  0x00, 0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x04, 0x00, 0x80, 0x40,
  0x04, 0x04, 0x00, 0x40, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0x08, 0x00, 0x23, 0x00,
  0x0C, 0x50, 0x02, 0x8A, 0x00, 0x51, 0x40, 0x14, 0x28, 0x04, 0x88, 0x80,
  0x91, 0x10, 0x22, 0x22, 0x04, 0x44, 0x21, 0x08, 0x84, 0x42, 0x10, 0x88,
  0x44, 0x12, 0x08, 0x81, 0x81, 0x10, 0x30, 0x22, 0x04, 0x04, 0x40, 0x01,
  0x08, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02,
  0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x21, 0x80,
  0x08, 0x30, 0x01, 0x09, 0x00, 0x21, 0x20, 0x04, 0x24, 0x00, 0x84, 0x40,
  0x10, 0x88, 0x04, 0x11, 0x00, 0x84, 0x10, 0x10, 0x82, 0x02, 0x10, 0x40,
  0x42, 0x04, 0x08, 0x40, 0x82, 0x08, 0x10, 0x42, 0x01, 0x08, 0x40, 0x21,
  0x08, 0x04, 0x21, 0x00, 0x44, 0x20, 0x09, 0x04, 0x00, 0xA1, 0x00, 0x14,
  0x20, 0x02, 0x84, 0x00, 0x30, 0x80, 0x06, 0x00, 0x01, 0xF8, 0x03, 0x03,
  0x03, 0x00, 0xC2, 0x00, 0x21, 0x00, 0x11, 0x00, 0x04, 0x80, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x14,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0x20, 0x00,
  0x90, 0x00, 0x88, 0x00, 0x44, 0x00, 0x41, 0x00, 0x40, 0x60, 0xC0, 0x1F,
  0x80, 0x00, 0x0F, 0xFE, 0x01, 0x00, 0x30, 0x20, 0x01, 0x04, 0x00, 0x20,
  0x80, 0x04, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x02, 0x10, 0x00, 0x42,
  0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x42, 0x00, 0x30, 0x7F, 0xF8, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0x03, 0x03, 0x00, 0xC2, 0x00, 0x21, 0x00,
  0x11, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x01, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x00, 0x44, 0x00,
  0x41, 0x00, 0x40, 0x60, 0xC0, 0x1F, 0x80, 0x01, 0x00, 0x00, 0x40, 0x80,
  0x10, 0x60, 0x0C, 0xC0, 0x02, 0xC0, 0x00, 0xC0, 0x0F, 0xFE, 0x01, 0x00,
  0x30, 0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00, 0x44, 0x00,
  0x08, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00,
  0x42, 0x00, 0x30, 0x7F, 0xF8, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x20,
  0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x00, 0x80, 0x80, 0x10,
  0x10, 0x01, 0x04, 0x00, 0x20, 0x80, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x60,
  0x30, 0x10, 0x01, 0x04, 0x00, 0x10, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x48, 0x00, 0x08, 0x80, 0x02,
  0x08, 0x00, 0xC0, 0xC0, 0x60, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x44, 0x00,
  0x21, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08,
  0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00,
  0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x04, 0x01, 0x81,
  0x80, 0xC0, 0x1F, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x50,
  0x00, 0x28, 0x00, 0x24, 0x00, 0x12, 0x00, 0x10, 0x80, 0x08, 0x40, 0x08,
  0x20, 0x04, 0x10, 0x04, 0x08, 0x02, 0x04, 0x02, 0x01, 0x01, 0x00, 0x81,
  0x00, 0x40, 0x80, 0x20, 0x80, 0x10, 0x40, 0x08, 0x40, 0x02, 0x20, 0x01,
  0x20, 0x00, 0x90, 0x00, 0x50, 0x00, 0x28, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x24, 0x00, 0x04, 0x80,
  0x00, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40, 0xC0, 0x88, 0x18, 0x11, 0x05,
  0x04, 0x20, 0xA0, 0x84, 0x24, 0x10, 0x84, 0x82, 0x21, 0x08, 0x84, 0x21,
  0x10, 0x88, 0x22, 0x11, 0x04, 0x42, 0x40, 0x90, 0x48, 0x12, 0x0A, 0x02,
  0x41, 0x40, 0x50, 0x28, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x00, 0x04,
  0x00, 0x04, 0x10, 0x00, 0x20, 0x20, 0x01, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x40, 0x04, 0x01, 0x00, 0x08, 0x08, 0x00, 0x20, 0x40, 0x00, 0x42, 0x00,
  0x01, 0x10, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xA0, 0x00, 0x04, 0x80, 0x00, 0x21, 0x00, 0x01, 0x04, 0x00, 0x04, 0x08,
  0x00, 0x20, 0x20, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x02, 0x02,
  0x00, 0x08, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x40, 0x80, 0x00, 0x30, 0x00,
  0x09, 0x00, 0x02, 0x20, 0x00, 0x82, 0x00, 0x10, 0x40, 0x04, 0x04, 0x01,
  0x00, 0x80, 0x40, 0x10, 0x10, 0x01, 0x02, 0x00, 0x20, 0x80, 0x02, 0x20,
  0x00, 0x48, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F,
  0xE0, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04,
  0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x07, 0xFC, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x30, 0x00, 0x24, 0x00,
  0x22, 0x00, 0x20, 0x80, 0x10, 0x40, 0x10, 0x10, 0x10, 0x08, 0x10, 0x02,
  0x08, 0x01, 0x08, 0x00, 0x88, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0C, 0xFF,
  0xFF, 0x80, 0x91, 0x22, 0x40, 0x03, 0xE1, 0x0C, 0x1A, 0x10, 0x06, 0x20,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x08, 0x80,
  0x18, 0x40, 0x28, 0x20, 0xC8, 0x1F, 0x0F, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x11,
  0xF0, 0x12, 0x0C, 0x24, 0x02, 0x28, 0x02, 0x30, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x04, 0xC0, 0x04, 0xA0, 0x08, 0x90, 0x30, 0x8F,
  0xC0, 0x03, 0xF0, 0x18, 0x30, 0x40, 0x11, 0x00, 0x24, 0x00, 0x28, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0xA0, 0x02, 0x20, 0x04, 0x40, 0x10, 0x60, 0xC0, 0x3E,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x03, 0xE1, 0x06, 0x0D, 0x04, 0x01,
  0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x12, 0x00, 0x09, 0x00, 0x08, 0x80,
  0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x62,
  0x00, 0x21, 0x00, 0x30, 0x40, 0x28, 0x10, 0x64, 0x07, 0xC2, 0x00, 0x03,
  0xF0, 0x08, 0x18, 0x60, 0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x60, 0x01,
  0x40, 0x04, 0x80, 0xF1, 0xFE, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0xE0, 0x01, 0x20, 0x04, 0x60, 0x10, 0x60, 0xC0, 0x3F, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x20, 0x20, 0x00, 0x40, 0x80, 0x00, 0x82, 0x00, 0x01, 0x88, 0x00,
  0x03, 0x20, 0x00, 0x06, 0x80, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF0, 0x83,
  0x06, 0x82, 0x00, 0xC2, 0x00, 0x22, 0x00, 0x11, 0x00, 0x09, 0x00, 0x04,
  0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x20, 0x14, 0x08, 0x32, 0x03,
  0xE1, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x41, 0x00, 0x60,
  0x60, 0xE0, 0x0F, 0xC0, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x11, 0xF0, 0x24, 0x18,
  0x50, 0x10, 0xC0, 0x13, 0x00, 0x26, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20,
  0x02, 0x40, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01,
  0x20, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x20,
  0x81, 0x81, 0x04, 0x02, 0x30, 0x08, 0x80, 0x16, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x04, 0x02, 0x06, 0x04, 0x06, 0x10, 0x06, 0x20, 0x02, 0x40, 0x02,
  0x80, 0x03, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0xF8, 0x04,
  0xC1, 0x02, 0x40, 0x20, 0xA0, 0x08, 0x30, 0x02, 0x08, 0x00, 0x82, 0x00,
  0x20, 0x80, 0x10, 0x40, 0x18, 0x10, 0x38, 0x04, 0x70, 0x01, 0x08, 0x00,
  0x42, 0x00, 0x90, 0x40, 0x38, 0x08, 0x12, 0x02, 0x08, 0x80, 0x44, 0x20,
  0x16, 0x08, 0x03, 0x00, 0x7F, 0x82, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x0C, 0x20, 0x41, 0x06, 0x04, 0x20, 0x13, 0x00,
  0x50, 0x01, 0x80, 0x00, 0x23, 0x87, 0x8B, 0x12, 0x13, 0x05, 0x04, 0xC1,
  0x81, 0x20, 0x20, 0x48, 0x10, 0x14, 0x04, 0x05, 0x01, 0x01, 0x40, 0x40,
  0x50, 0x10, 0x24, 0x04, 0x09, 0x02, 0x02, 0x80, 0x80, 0xA0, 0x20, 0x28,
  0x08, 0x0A, 0x02, 0x04, 0x80, 0x81, 0x20, 0x40, 0x48, 0x10, 0x10, 0x11,
  0xF0, 0x24, 0x18, 0x50, 0x10, 0xC0, 0x13, 0x00, 0x26, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x20, 0x02, 0x40, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x20, 0x03,
  0xF0, 0x0C, 0x0C, 0x10, 0x04, 0x20, 0x02, 0x20, 0x02, 0x40, 0x01, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x40, 0x08, 0x40, 0x18, 0x30, 0x20, 0x0F,
  0xC0, 0x08, 0xF8, 0x04, 0x83, 0x04, 0x80, 0x42, 0x80, 0x21, 0x80, 0x08,
  0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x08, 0xC0, 0x04, 0x50,
  0x04, 0x24, 0x0C, 0x11, 0xF8, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x00, 0x03, 0xE1, 0x0C,
  0x1A, 0x10, 0x06, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x80, 0x08, 0x80, 0x18, 0x40, 0x28, 0x20, 0xC8, 0x1F, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0xFF, 0x1F, 0xC0, 0x98, 0x00, 0x28, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x02, 0x03,
  0x02, 0x00, 0x62, 0x00, 0x21, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x05, 0x00, 0x04, 0x40, 0x02, 0x1C, 0x06, 0x01, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x03, 0xFF, 0xFE, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x80, 0x81, 0x80, 0x81, 0x00, 0x43, 0x00,
  0x26, 0x00, 0x14, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x05, 0x00, 0x14, 0x00,
  0x50, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48, 0x03, 0x20, 0x14, 0x80,
  0x51, 0x06, 0x43, 0xE2, 0x00, 0xF8, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08,
  0x01, 0x08, 0x01, 0x08, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10,
  0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x04, 0x20, 0x08, 0x20, 0x10, 0x20,
  0x20, 0x20, 0x40, 0x23, 0x80, 0x3E, 0x00, 0x20, 0x41, 0x10, 0x20, 0x50,
  0x10, 0x28, 0x08, 0x14, 0x04, 0x0A, 0x02, 0x05, 0x02, 0x02, 0x81, 0x01,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x20, 0x18, 0x10, 0x0C, 0x08,
  0x0A, 0x04, 0x05, 0x06, 0x02, 0x83, 0x02, 0x42, 0x42, 0x1E, 0x1E, 0x00,
  0x03, 0x01, 0xC0, 0xC8, 0x62, 0x30, 0x48, 0x14, 0x04, 0x81, 0x00, 0x50,
  0x10, 0x05, 0x01, 0x00, 0x60, 0x10, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x80, 0x40, 0x08, 0x0C, 0x00, 0x80,
  0xC0, 0x08, 0x12, 0x06, 0x82, 0x21, 0x84, 0x61, 0x60, 0x38, 0x18, 0x00,
  0x04, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x08, 0x40,
  0x04, 0x20, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00, 0x84, 0x00, 0x42,
  0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x20, 0x14, 0x10, 0x0A,
  0x04, 0x19, 0x01, 0xF1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x21, 0x80, 0x20, 0x20, 0x60, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x88, 0x1E,
  0x48, 0x01, 0xE4, 0x00, 0x32, 0x00, 0x21, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x20,
  0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0xFE, 0x02, 0x43, 0xF9, 0x20, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x01, 0x80, 0xFE, 0x00, 0x07, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x1F, 0xE0, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08,
  0x21, 0x04, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x07, 0xF8, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0x01, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x4C,
  0x40, 0x12, 0x08, 0x09, 0x01, 0x02, 0x40, 0x41, 0x20, 0x08, 0xC8, 0x01,
  0xE0,
};

const GFXglyph IBMPlexMono_ThinItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 25, 22, 8, -25 },
  { 20, 8, 9, 22, 9, -27 },
  { 29, 21, 25, 22, 1, -25 },
  { 95, 19, 33, 22, 1, -29 },
  { 174, 24, 25, 22, -1, -25 },
  { 249, 21, 25, 22, 0, -25 },
  { 315, 2, 9, 22, 12, -27 },
  { 318, 12, 32, 22, 8, -27 },
  { 366, 11, 32, 22, 3, -27 },
  { 410, 19, 18, 22, 2, -20 },
  { 453, 18, 17, 22, 2, -20 },
  { 492, 5, 9, 22, 6, -3 },
  { 498, 10, 1, 22, 6, -11 },
  { 500, 3, 2, 22, 8, -2 },
  { 501, 20, 32, 22, 1, -27 },
  { 581, 17, 25, 22, 3, -25 },
  { 635, 16, 25, 22, 2, -25 },
  { 685, 17, 25, 22, 2, -25 },
  { 739, 17, 25, 22, 2, -25 },
  { 793, 18, 25, 22, 1, -25 },
  { 850, 18, 25, 22, 2, -25 },
  { 907, 15, 25, 22, 3, -25 },
  { 954, 17, 25, 22, 4, -25 },
  { 1008, 18, 25, 22, 2, -25 },
  { 1065, 15, 25, 22, 4, -25 },
  { 1112, 5, 19, 22, 8, -19 },
  { 1124, 7, 25, 22, 6, -19 },
  { 1146, 17, 19, 22, 3, -20 },
  { 1187, 18, 8, 22, 2, -15 },
  { 1205, 17, 19, 22, 2, -20 },
  { 1246, 15, 25, 22, 5, -25 },
  { 1293, 16, 29, 22, 3, -25 },
  { 1351, 18, 25, 22, 0, -25 },
  { 1408, 17, 25, 22, 2, -25 },
  { 1462, 17, 25, 22, 3, -25 },
  { 1516, 18, 25, 22, 2, -25 },
  { 1573, 19, 25, 22, 2, -25 },
  { 1633, 19, 25, 22, 2, -25 },
  { 1693, 17, 25, 22, 3, -25 },
  { 1747, 19, 25, 22, 2, -25 },
  { 1807, 19, 25, 22, 2, -25 },
  { 1867, 16, 25, 22, 3, -25 },
  { 1917, 20, 25, 22, 2, -25 },
  { 1980, 14, 25, 22, 4, -25 },
  { 2024, 19, 25, 22, 2, -25 },
  { 2084, 19, 25, 22, 2, -25 },
  { 2144, 17, 25, 22, 3, -25 },
  { 2198, 19, 25, 22, 2, -25 },
  { 2258, 17, 31, 22, 3, -25 },
  { 2324, 19, 25, 22, 2, -25 },
  { 2384, 19, 25, 22, 1, -25 },
  { 2444, 19, 25, 22, 4, -25 },
  { 2504, 18, 25, 22, 3, -25 },
  { 2561, 17, 25, 22, 5, -25 },
  { 2615, 19, 25, 22, 3, -25 },
  { 2675, 22, 25, 22, 0, -25 },
  { 2744, 19, 25, 22, 4, -25 },
  { 2804, 22, 25, 22, 0, -25 },
  { 2873, 14, 32, 22, 7, -27 },
  { 2929, 8, 32, 22, 7, -27 },
  { 2961, 14, 32, 22, 1, -27 },
  { 3017, 17, 14, 22, 3, -25 },
  { 3047, 17, 1, 22, 0, 4 },
  { 3050, 3, 6, 22, 9, -27 },
  { 3053, 16, 19, 22, 3, -19 },
  { 3091, 16, 27, 22, 3, -27 },
  { 3145, 15, 19, 22, 3, -19 },
  { 3181, 17, 27, 22, 3, -27 },
  { 3239, 15, 19, 22, 3, -19 },
  { 3275, 22, 34, 22, 0, -27 },
  { 3369, 17, 26, 22, 2, -19 },
  { 3425, 15, 27, 22, 3, -27 },
  { 3476, 15, 27, 22, 3, -27 },
  { 3527, 15, 34, 22, 4, -27 },
  { 3591, 18, 27, 22, 3, -27 },
  { 3652, 14, 27, 22, 4, -27 },
  { 3700, 18, 19, 22, 2, -19 },
  { 3743, 15, 19, 22, 3, -19 },
  { 3779, 16, 19, 22, 3, -19 },
  { 3817, 17, 26, 22, 2, -19 },
  { 3873, 16, 26, 22, 3, -19 },
  { 3925, 18, 19, 22, 4, -19 },
  { 3968, 17, 19, 22, 2, -19 },
  { 4009, 17, 25, 22, 3, -25 },
  { 4063, 14, 19, 22, 4, -19 },
  { 4097, 16, 19, 22, 3, -19 },
  { 4135, 17, 19, 22, 3, -19 },
  { 4176, 20, 19, 22, 1, -19 },
  { 4224, 17, 26, 22, 1, -19 },
  { 4280, 17, 19, 22, 2, -19 },
  { 4321, 16, 32, 22, 4, -27 },
  { 4385, 6, 32, 22, 8, -27 },
  { 4409, 16, 32, 22, 2, -27 },
  { 4473, 18, 7, 22, 2, -14 },
};

const GFXfont IBMPlexMono_ThinItalic36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_THINITALIC36PT7B_H_
