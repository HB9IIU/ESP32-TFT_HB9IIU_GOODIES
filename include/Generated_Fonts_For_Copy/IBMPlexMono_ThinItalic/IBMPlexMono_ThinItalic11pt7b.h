#ifndef _IBMPLEXMONO_THINITALIC11PT7B_H_
#define _IBMPLEXMONO_THINITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0xA2, 0xFC, 0x14, 0x51, 0x99, 0x45, 0x19, 0x94, 0x50, 0x10,
  0xE5, 0x54, 0x30, 0x62, 0x6A, 0x78, 0x80, 0x33, 0xAA, 0x63, 0x00, 0xCE,
  0xA9, 0x4C, 0x39, 0x24, 0x9A, 0xB2, 0x49, 0xD9, 0xE0, 0x72, 0x49, 0x24,
  0x90, 0x44, 0x92, 0x4A, 0x50, 0x21, 0x2E, 0xCB, 0x00, 0x21, 0x09, 0xF4,
  0x21, 0x00, 0xE0, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x82,
  0x00, 0x36, 0x63, 0x1A, 0xC6, 0x5C, 0x23, 0x39, 0x42, 0x11, 0x1F, 0x19,
  0x94, 0x42, 0x08, 0xC4, 0x3E, 0x74, 0x42, 0xE1, 0x0A, 0x4C, 0x0C, 0x62,
  0x92, 0x89, 0xF8, 0x84, 0x7C, 0x1D, 0x21, 0x0A, 0x4C, 0x32, 0x21, 0xE8,
  0xC6, 0x5E, 0x7C, 0x64, 0x22, 0x21, 0x10, 0x7C, 0x62, 0xED, 0x46, 0x3E,
  0x74, 0x63, 0x17, 0x08, 0x88, 0x40, 0x20, 0x40, 0x2A, 0x09, 0xB1, 0x04,
  0x18, 0xF8, 0x3E, 0x83, 0x04, 0x36, 0x40, 0x79, 0x92, 0xC8, 0x08, 0x32,
  0x6F, 0x9C, 0xEA, 0xD0, 0xF0, 0x10, 0xA2, 0x92, 0x49, 0xE8, 0xA3, 0x7C,
  0x63, 0xE8, 0xC6, 0x5E, 0x32, 0x61, 0x08, 0x4A, 0x4C, 0x74, 0x63, 0x18,
  0xC6, 0x5C, 0x7C, 0x21, 0xF8, 0x42, 0x1E, 0x7E, 0x08, 0x3E, 0x82, 0x08,
  0x20, 0x32, 0x61, 0x09, 0xC6, 0x4E, 0x8C, 0x63, 0xF8, 0xCA, 0x52, 0x79,
  0x08, 0x44, 0x21, 0x1E, 0x3A, 0x44, 0x21, 0x0A, 0x5C, 0x8E, 0x4A, 0x30,
  0xA2, 0x89, 0x26, 0x48, 0x88, 0x88, 0x8F, 0x45, 0x16, 0xEB, 0xB6, 0x98,
  0xA2, 0x8E, 0x73, 0x9A, 0xDA, 0xD2, 0x36, 0x63, 0x18, 0xC6, 0x5C, 0x7C,
  0x63, 0x1F, 0x42, 0x10, 0x36, 0x63, 0x18, 0xC6, 0x5C, 0x28, 0x80, 0x7C,
  0x63, 0x1F, 0x52, 0x92, 0x39, 0x14, 0x0C, 0x08, 0x18, 0x9E, 0xFC, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x8C, 0x63, 0x18, 0xCA, 0x5C, 0x86, 0x28, 0xA4,
  0x91, 0x86, 0x10, 0x86, 0x28, 0xBA, 0xEA, 0xCB, 0x2C, 0x46, 0x88, 0xA1,
  0x83, 0x0A, 0x12, 0x46, 0x86, 0x25, 0x18, 0x41, 0x04, 0x10, 0x3E, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x7E, 0x34, 0x44, 0x88, 0x88, 0x8E, 0x92, 0x48,
  0x92, 0x44, 0x38, 0x84, 0x21, 0x08, 0x44, 0x27, 0x00, 0x22, 0xA5, 0x10,
  0xF8, 0xC0, 0x7C, 0xA5, 0x29, 0x74, 0x84, 0x2D, 0x98, 0xC6, 0x5E, 0x79,
  0x89, 0x96, 0x08, 0x5F, 0x19, 0x4A, 0xDE, 0x74, 0x7D, 0x09, 0x30, 0x0E,
  0x21, 0xF0, 0x81, 0x04, 0x08, 0x50, 0xE0, 0x40, 0x7C, 0xA5, 0x29, 0x7A,
  0x5C, 0xC8, 0xB5, 0x99, 0x99, 0x20, 0x38, 0x84, 0x28, 0xE8, 0x08, 0x1D,
  0x21, 0x08, 0x94, 0x61, 0x00, 0x84, 0x2C, 0x99, 0x56, 0xB2, 0xE2, 0x44,
  0x45, 0xB4, 0x7D, 0x59, 0x65, 0xA6, 0x90, 0xB5, 0x99, 0x99, 0x74, 0x63,
  0x19, 0x30, 0xB6, 0x63, 0x19, 0x7A, 0x10, 0x7C, 0xA5, 0x29, 0x78, 0x44,
  0xFD, 0x84, 0x10, 0x41, 0x00, 0x74, 0x58, 0x29, 0x78, 0x22, 0x3E, 0x84,
  0x26, 0xC8, 0x8C, 0xA5, 0x2B, 0x78, 0xCC, 0x63, 0x29, 0x30, 0xAD, 0x6B,
  0x9C, 0xF8, 0x2F, 0xD1, 0x68, 0xB5, 0x60, 0x45, 0x24, 0xA2, 0x49, 0xE9,
  0x1C, 0x7C, 0x4C, 0x89, 0x78, 0x19, 0x08, 0x4C, 0x10, 0x88, 0x43, 0x80,
  0x55, 0x6A, 0xA0, 0x72, 0x24, 0x34, 0x44, 0x4C, 0xCD, 0x64,
};

const GFXglyph IBMPlexMono_ThinItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 2, 3, 7, 3, -8 },
  { 4, 7, 8, 7, 0, -8 },
  { 11, 6, 10, 7, 0, -9 },
  { 19, 7, 8, 7, 0, -8 },
  { 26, 6, 8, 7, 0, -8 },
  { 32, 1, 3, 7, 3, -8 },
  { 33, 3, 10, 7, 3, -8 },
  { 37, 3, 10, 7, 1, -8 },
  { 41, 5, 5, 7, 1, -6 },
  { 45, 5, 7, 7, 1, -7 },
  { 50, 1, 3, 7, 2, -1 },
  { 51, 3, 1, 7, 2, -4 },
  { 52, 1, 1, 7, 2, -1 },
  { 53, 6, 10, 7, 0, -8 },
  { 61, 5, 8, 7, 1, -8 },
  { 66, 5, 8, 7, 1, -8 },
  { 71, 6, 8, 7, 0, -8 },
  { 77, 5, 8, 7, 1, -8 },
  { 82, 6, 8, 7, 0, -8 },
  { 88, 5, 8, 7, 1, -8 },
  { 93, 5, 8, 7, 1, -8 },
  { 98, 5, 8, 7, 1, -8 },
  { 103, 5, 8, 7, 1, -8 },
  { 108, 5, 8, 7, 1, -8 },
  { 113, 2, 6, 7, 2, -6 },
  { 115, 2, 8, 7, 2, -6 },
  { 117, 5, 6, 7, 1, -6 },
  { 121, 5, 3, 7, 1, -5 },
  { 123, 5, 6, 7, 1, -6 },
  { 127, 4, 8, 7, 2, -8 },
  { 131, 5, 9, 7, 1, -8 },
  { 137, 6, 8, 7, 0, -8 },
  { 143, 5, 8, 7, 1, -8 },
  { 148, 5, 8, 7, 1, -8 },
  { 153, 5, 8, 7, 1, -8 },
  { 158, 5, 8, 7, 1, -8 },
  { 163, 6, 8, 7, 1, -8 },
  { 169, 5, 8, 7, 1, -8 },
  { 174, 5, 8, 7, 1, -8 },
  { 179, 5, 8, 7, 1, -8 },
  { 184, 5, 8, 7, 1, -8 },
  { 189, 6, 8, 7, 1, -8 },
  { 195, 4, 8, 7, 1, -8 },
  { 199, 6, 8, 7, 0, -8 },
  { 205, 5, 8, 7, 1, -8 },
  { 210, 5, 8, 7, 1, -8 },
  { 215, 5, 8, 7, 1, -8 },
  { 220, 5, 10, 7, 1, -8 },
  { 227, 5, 8, 7, 1, -8 },
  { 232, 6, 8, 7, 0, -8 },
  { 238, 6, 8, 7, 1, -8 },
  { 244, 5, 8, 7, 1, -8 },
  { 249, 6, 8, 7, 1, -8 },
  { 255, 6, 8, 7, 1, -8 },
  { 261, 7, 8, 7, 0, -8 },
  { 268, 6, 8, 7, 1, -8 },
  { 274, 7, 8, 7, 0, -8 },
  { 281, 4, 10, 7, 2, -8 },
  { 286, 3, 10, 7, 2, -8 },
  { 290, 5, 10, 7, 0, -8 },
  { 297, 5, 4, 7, 1, -8 },
  { 300, 5, 1, 7, 0, 1 },
  { 301, 1, 2, 7, 3, -10 },
  { 302, 5, 6, 7, 1, -6 },
  { 306, 5, 8, 7, 1, -8 },
  { 311, 4, 6, 7, 1, -6 },
  { 314, 5, 8, 7, 1, -8 },
  { 319, 5, 6, 7, 1, -6 },
  { 323, 7, 10, 7, 0, -8 },
  { 332, 5, 8, 7, 1, -6 },
  { 337, 4, 8, 7, 1, -8 },
  { 341, 5, 8, 7, 1, -8 },
  { 346, 5, 10, 7, 1, -8 },
  { 353, 5, 8, 7, 1, -8 },
  { 358, 4, 8, 7, 1, -8 },
  { 362, 6, 6, 7, 0, -6 },
  { 367, 4, 6, 7, 1, -6 },
  { 370, 5, 6, 7, 1, -6 },
  { 374, 5, 8, 7, 1, -6 },
  { 379, 5, 8, 7, 1, -6 },
  { 384, 6, 6, 7, 1, -6 },
  { 389, 5, 6, 7, 1, -6 },
  { 393, 5, 8, 7, 1, -8 },
  { 398, 5, 6, 7, 1, -6 },
  { 402, 5, 6, 7, 1, -6 },
  { 406, 5, 6, 7, 1, -6 },
  { 410, 6, 6, 7, 0, -6 },
  { 415, 6, 8, 7, 0, -6 },
  { 421, 5, 6, 7, 1, -6 },
  { 425, 5, 10, 7, 1, -8 },
  { 432, 2, 10, 7, 2, -8 },
  { 435, 4, 10, 7, 1, -8 },
  { 440, 5, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_ThinItalic11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_THINITALIC11PT7B_H_
