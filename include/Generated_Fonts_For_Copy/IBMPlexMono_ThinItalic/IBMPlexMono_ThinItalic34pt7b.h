#ifndef _IBMPLEXMONO_THINITALIC34PT7B_H_
#define _IBMPLEXMONO_THINITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42,
  0x00, 0x00, 0x03, 0x18, 0x42, 0x89, 0x12, 0x28, 0x50, 0xA1, 0x44, 0x88,
  0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x41,
  0x00, 0x08, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x3F, 0x07, 0xF0, 0x10,
  0x40, 0x01, 0x04, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x04,
  0x10, 0x0F, 0xC1, 0xF8, 0x04, 0x10, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00,
  0x82, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x07, 0xF0, 0x06, 0x13, 0x03,
  0x04, 0x20, 0x82, 0x04, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02,
  0x00, 0x41, 0x00, 0x08, 0x40, 0x01, 0x90, 0x00, 0x1E, 0x00, 0x01, 0x70,
  0x00, 0x42, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00,
  0x20, 0x48, 0x08, 0x11, 0x04, 0x08, 0x21, 0x06, 0x06, 0x43, 0x00, 0x7F,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x02, 0x04,
  0x20, 0x08, 0x10, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80, 0x81, 0x01, 0x01,
  0x04, 0x04, 0x02, 0x10, 0x08, 0x04, 0x40, 0x08, 0x11, 0x00, 0x18, 0x42,
  0x00, 0x0F, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x22, 0x08, 0x00, 0x88, 0x10, 0x02, 0x10, 0x10, 0x08, 0x40, 0x20,
  0x20, 0x80, 0x40, 0x41, 0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x10,
  0x04, 0x30, 0x60, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x10, 0x40, 0x02, 0x02,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x01, 0x04, 0x00, 0xF9, 0x80, 0x10,
  0xE0, 0x02, 0x04, 0x00, 0x40, 0x40, 0x04, 0x02, 0x00, 0x80, 0x10, 0x08,
  0x01, 0x00, 0x80, 0x08, 0x18, 0x01, 0x41, 0x40, 0x14, 0x24, 0x02, 0x24,
  0x30, 0x41, 0x41, 0xF8, 0x18, 0x55, 0x6A, 0x80, 0x00, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x03, 0x02,
  0x02, 0x71, 0x1E, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x42, 0x00, 0x41, 0x00, 0x40, 0x40, 0x40, 0x20, 0x40, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x84, 0x42, 0x11, 0x08, 0x80, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x06, 0x0C, 0x08,
  0x06, 0x10, 0x02, 0x20, 0x02, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x81, 0x82, 0x81, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80,
  0x10, 0x40, 0x30, 0x20, 0xC0, 0x1F, 0x80, 0x00, 0x30, 0x00, 0xA0, 0x06,
  0x80, 0x19, 0x00, 0x42, 0x03, 0x04, 0x0C, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x7F, 0xFF, 0x00, 0xFC, 0x01, 0x81, 0x81, 0x80, 0x40, 0x80,
  0x10, 0x80, 0x08, 0xC0, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x06, 0x04, 0x08,
  0x02, 0x10, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x80,
  0x04, 0x40, 0x08, 0x20, 0x30, 0x1F, 0xC0, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x40, 0x01, 0x20, 0x01, 0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x04,
  0x00, 0x82, 0x00, 0x81, 0x00, 0x81, 0x00, 0x80, 0x80, 0x80, 0x40, 0x80,
  0x20, 0x80, 0x10, 0x80, 0x08, 0x80, 0x08, 0x7F, 0xFF, 0xC0, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x07, 0xFF,
  0x82, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x09, 0xF8, 0x0B, 0x06, 0x06, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x88, 0x00, 0x42, 0x00, 0x40, 0xC0, 0xC0, 0x1F,
  0x80, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x7E, 0x16, 0x06, 0x60, 0x0B,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x09, 0x00, 0x42, 0x06, 0x07, 0xE0, 0x7F, 0xFF, 0x40, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x01, 0xFC, 0x03, 0x03, 0x03,
  0x00, 0x41, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x02,
  0x10, 0x01, 0x04, 0x01, 0x01, 0x03, 0x00, 0x7E, 0x01, 0xC0, 0x81, 0x00,
  0x21, 0x00, 0x09, 0x00, 0x04, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x90,
  0x00, 0x48, 0x00, 0x62, 0x00, 0x60, 0xC0, 0xE0, 0x1F, 0x80, 0x07, 0xE0,
  0x60, 0x42, 0x00, 0x90, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x02, 0x40, 0x19, 0x81, 0xA1, 0xF9,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x18, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x40, 0x40, 0x80, 0x00, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x60, 0xC2, 0x00,
  0x90, 0x02, 0x80, 0x0A, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x07, 0x80, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x01, 0xF0, 0x0C, 0x18, 0x30, 0x08, 0x40, 0x11, 0x00, 0x26, 0x00,
  0x48, 0x00, 0x90, 0x79, 0x41, 0x0A, 0x84, 0x0D, 0x08, 0x0A, 0x20, 0x28,
  0x40, 0x50, 0x80, 0xA2, 0x01, 0x44, 0x02, 0x88, 0x05, 0x10, 0x12, 0x10,
  0x64, 0x31, 0x48, 0x3C, 0x90, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x05,
  0x00, 0x04, 0x80, 0x02, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x08, 0x00,
  0x82, 0x00, 0x81, 0x00, 0x40, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x04, 0x0F, 0xFE, 0x08, 0x01, 0x08, 0x00, 0x84, 0x00, 0x44, 0x00,
  0x22, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x00, 0x01, 0x0F, 0xFC, 0x08,
  0x06, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20,
  0x01, 0x20, 0x02, 0x20, 0x02, 0x20, 0x0C, 0x3F, 0xF0, 0x20, 0x0C, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x18, 0xFF, 0xE0, 0x01, 0xF8, 0x06,
  0x0C, 0x0C, 0x02, 0x18, 0x02, 0x10, 0x01, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x04, 0x80,
  0x08, 0x40, 0x08, 0x40, 0x10, 0x30, 0x60, 0x0F, 0x80, 0x0F, 0xF8, 0x04,
  0x06, 0x02, 0x00, 0x82, 0x00, 0x21, 0x00, 0x10, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x10,
  0x00, 0x88, 0x00, 0x84, 0x00, 0x44, 0x00, 0xC2, 0x00, 0xC1, 0xFF, 0x80,
  0x0F, 0xFF, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFC, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC2, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF8, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x01, 0xF0, 0x06, 0x0C, 0x08, 0x02, 0x10, 0x02, 0x10, 0x01, 0x20, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0xFE, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x40, 0x1C, 0x40, 0x18, 0x30, 0x68, 0x0F, 0x88,
  0x18, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00, 0x84,
  0x00, 0x22, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42, 0x00,
  0x10, 0xFF, 0xFC, 0x40, 0x01, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08,
  0x40, 0x02, 0x10, 0x00, 0x84, 0x00, 0x22, 0x00, 0x10, 0x80, 0x04, 0x20,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x10, 0x0F, 0xFF, 0xC0, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x80, 0x08, 0x80, 0x10, 0x40, 0x30, 0x20, 0x60, 0x1F, 0x80,
  0x08, 0x00, 0x61, 0x00, 0x10, 0x20, 0x04, 0x08, 0x01, 0x01, 0x00, 0x40,
  0x20, 0x10, 0x04, 0x04, 0x00, 0x81, 0x00, 0x10, 0x40, 0x04, 0x10, 0x00,
  0x84, 0x00, 0x11, 0x40, 0x02, 0x48, 0x00, 0x50, 0x80, 0x0C, 0x10, 0x01,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x04, 0x04,
  0x00, 0x81, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x3F, 0xFF, 0x0C, 0x00, 0x21, 0x80, 0x0C, 0x30, 0x02, 0x86, 0x00,
  0xA1, 0x20, 0x14, 0x24, 0x04, 0x84, 0x80, 0x90, 0x88, 0x22, 0x11, 0x08,
  0x42, 0x21, 0x10, 0x84, 0x42, 0x10, 0x48, 0x42, 0x0A, 0x08, 0x40, 0x81,
  0x08, 0x10, 0x21, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x04, 0x20, 0x00, 0x84, 0x00, 0x10,
  0x08, 0x00, 0xC6, 0x00, 0x21, 0x40, 0x08, 0x50, 0x02, 0x14, 0x00, 0x84,
  0x80, 0x22, 0x20, 0x10, 0x84, 0x04, 0x21, 0x01, 0x08, 0x40, 0x42, 0x08,
  0x10, 0x82, 0x04, 0x40, 0x81, 0x10, 0x10, 0x84, 0x04, 0x21, 0x01, 0x08,
  0x40, 0x22, 0x10, 0x08, 0x84, 0x02, 0x22, 0x00, 0x50, 0x80, 0x14, 0x20,
  0x05, 0x08, 0x00, 0xC2, 0x00, 0x30, 0x01, 0xF0, 0x06, 0x0C, 0x08, 0x06,
  0x10, 0x02, 0x20, 0x02, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x80, 0x10,
  0x40, 0x30, 0x20, 0xC0, 0x1F, 0x80, 0x0F, 0xFE, 0x04, 0x01, 0x82, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10,
  0x00, 0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0xC3, 0xFF, 0x81, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF0, 0x06,
  0x0C, 0x08, 0x06, 0x10, 0x02, 0x20, 0x02, 0x20, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x80, 0x10, 0x40, 0x30, 0x20, 0xC0, 0x1F, 0x80, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x04, 0x00, 0x88, 0x00, 0xB0, 0x00, 0x60, 0x0F, 0xFE, 0x04,
  0x01, 0x82, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x01, 0x10, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0xC3, 0xFF,
  0x81, 0x04, 0x00, 0x81, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x04, 0x08, 0x02, 0x04, 0x00, 0x84, 0x00, 0x42, 0x00, 0x11, 0x00, 0x08,
  0x01, 0xFC, 0x01, 0x80, 0xC0, 0xC0, 0x08, 0x20, 0x01, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x12, 0x00, 0x04, 0x40, 0x02, 0x08,
  0x01, 0x81, 0x80, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x30, 0x01, 0x90,
  0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x09, 0x00, 0x08,
  0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00,
  0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20,
  0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x00, 0x81, 0x81, 0x80, 0x3F, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x90, 0x00, 0x48, 0x00, 0x44, 0x00, 0x22, 0x00,
  0x21, 0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x02, 0x02, 0x01, 0x02, 0x00, 0x81, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x08, 0x80, 0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0x90, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x81, 0x10,
  0x60, 0x88, 0x28, 0x22, 0x0A, 0x08, 0x84, 0x42, 0x21, 0x11, 0x08, 0x44,
  0x42, 0x21, 0x10, 0x88, 0x44, 0x24, 0x12, 0x09, 0x04, 0x82, 0x81, 0x20,
  0xA0, 0x28, 0x30, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0xC0, 0x04, 0x00, 0x08,
  0x20, 0x00, 0x80, 0x80, 0x08, 0x04, 0x00, 0x80, 0x10, 0x08, 0x00, 0x80,
  0x80, 0x02, 0x04, 0x00, 0x10, 0x40, 0x00, 0x44, 0x00, 0x02, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x28, 0x00, 0x02, 0x20,
  0x00, 0x21, 0x00, 0x02, 0x04, 0x00, 0x10, 0x20, 0x01, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x10, 0x10, 0x00, 0x81, 0x00, 0x02, 0x18, 0x00, 0x10,
  0x80, 0x00, 0x28, 0x00, 0x09, 0x00, 0x02, 0x10, 0x00, 0x82, 0x00, 0x20,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x40, 0x08, 0x10, 0x00, 0x84, 0x00,
  0x11, 0x00, 0x01, 0x20, 0x00, 0x28, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xF8, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x03, 0xFC, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x03, 0x07, 0xF8,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x83, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0xA0, 0x01, 0x20, 0x02, 0x10, 0x02, 0x10, 0x04,
  0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x40, 0x02, 0x80,
  0x02, 0x80, 0x01, 0xFF, 0xFF, 0x84, 0x42, 0x21, 0x03, 0xE1, 0x0C, 0x1A,
  0x10, 0x06, 0x30, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08,
  0x40, 0x18, 0x40, 0x28, 0x30, 0x48, 0x0F, 0x8F, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x11, 0xF8, 0x26,
  0x18, 0x50, 0x08, 0xC0, 0x11, 0x00, 0x12, 0x00, 0x28, 0x00, 0x50, 0x00,
  0xA0, 0x01, 0x40, 0x02, 0x80, 0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x98,
  0x01, 0x30, 0x04, 0x58, 0x30, 0x8F, 0x80, 0x03, 0xE0, 0x30, 0x41, 0x00,
  0x88, 0x01, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x10, 0x08, 0x20,
  0xC0, 0x7C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x07, 0xC2, 0x0C, 0x19, 0x08, 0x03,
  0x0C, 0x00, 0x84, 0x00, 0x44, 0x00, 0x22, 0x00, 0x11, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x82,
  0x00, 0xC1, 0x00, 0xE0, 0x60, 0xD0, 0x0F, 0x88, 0x00, 0x03, 0xF0, 0x30,
  0x21, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x18, 0x00, 0xA0, 0x04, 0x81,
  0xC3, 0xF0, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x38, 0x00, 0x90,
  0x04, 0x30, 0x60, 0x7E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x04, 0x04,
  0x00, 0x10, 0x20, 0x00, 0x41, 0x00, 0x01, 0x10, 0x00, 0x04, 0x80, 0x00,
  0x14, 0x00, 0x00, 0x60, 0x00, 0x03, 0xE1, 0x0C, 0x1A, 0x10, 0x06, 0x30,
  0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x40, 0x18, 0x40,
  0x28, 0x30, 0x48, 0x0F, 0x88, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x80, 0x20, 0x40, 0xC0, 0x3F, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x7C, 0x16, 0x18, 0xA0,
  0x13, 0x00, 0x4C, 0x01, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x02, 0x40,
  0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x01, 0x04, 0x08, 0x20, 0xC0, 0x84, 0x02, 0x60, 0x0A, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x08, 0x08,
  0x10, 0x20, 0x20, 0x80, 0x44, 0x00, 0x90, 0x01, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x43, 0xE0, 0x26, 0x08, 0x14, 0x02, 0x0C, 0x01, 0x04, 0x00,
  0x82, 0x00, 0x42, 0x00, 0x41, 0x00, 0x40, 0x80, 0xC0, 0x43, 0x80, 0x22,
  0x00, 0x10, 0x80, 0x10, 0x40, 0x38, 0x10, 0x24, 0x08, 0x22, 0x02, 0x21,
  0x00, 0xA0, 0x80, 0x60, 0x00, 0xFF, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x02,
  0x20, 0x61, 0x06, 0x08, 0xC0, 0x48, 0x05, 0x80, 0x10, 0x00, 0x13, 0xC7,
  0x85, 0x12, 0x11, 0x83, 0x04, 0x40, 0x81, 0x10, 0x20, 0x48, 0x08, 0x12,
  0x04, 0x04, 0x81, 0x01, 0x20, 0x40, 0x88, 0x10, 0x24, 0x04, 0x09, 0x01,
  0x02, 0x40, 0x80, 0x90, 0x20, 0x24, 0x08, 0x11, 0x02, 0x04, 0x80, 0x81,
  0x20, 0x20, 0x40, 0x11, 0xF0, 0x98, 0x62, 0x80, 0x4C, 0x01, 0x30, 0x04,
  0x80, 0x12, 0x00, 0x50, 0x01, 0x40, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02,
  0x40, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x40, 0x07,
  0xE0, 0x10, 0x30, 0x40, 0x31, 0x00, 0x24, 0x00, 0x48, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50,
  0x01, 0x20, 0x02, 0x20, 0x08, 0x20, 0x60, 0x3F, 0x00, 0x11, 0xF8, 0x13,
  0x0C, 0x14, 0x02, 0x18, 0x02, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x04, 0x60, 0x04, 0x60, 0x08, 0x58, 0x30, 0x87, 0xC0, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03,
  0xE1, 0x0C, 0x1A, 0x10, 0x06, 0x30, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x08, 0x40, 0x18, 0x40, 0x28, 0x30, 0x48, 0x0F, 0x88, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0xFE, 0x3F, 0x02, 0xC0, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x03, 0xF8, 0x0C, 0x06, 0x10, 0x03, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x80, 0x02, 0x40, 0x04, 0x30, 0x18, 0x0F,
  0xE0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x04, 0x08, 0x0C, 0x08, 0x30, 0x08, 0x40, 0x09, 0x80, 0x16, 0x00, 0x08,
  0x00, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x14,
  0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12,
  0x00, 0x48, 0x03, 0x10, 0x14, 0x60, 0x90, 0x7C, 0x40, 0xF8, 0x02, 0x10,
  0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88, 0x01,
  0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x42, 0x01, 0x04, 0x02, 0x08,
  0x08, 0x10, 0x60, 0x23, 0x00, 0x78, 0x00, 0x30, 0x21, 0x10, 0x20, 0x48,
  0x10, 0x24, 0x08, 0x12, 0x04, 0x09, 0x02, 0x05, 0x01, 0x02, 0x81, 0x01,
  0x40, 0x80, 0xA0, 0x40, 0x50, 0x20, 0x28, 0x10, 0x18, 0x08, 0x14, 0x0C,
  0x0A, 0x04, 0x05, 0x05, 0x04, 0x46, 0x84, 0x1C, 0x3C, 0x00, 0x03, 0x03,
  0x81, 0x91, 0x88, 0xC2, 0x60, 0xE0, 0x48, 0x10, 0x06, 0x02, 0x00, 0xC0,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x40, 0x60, 0x08, 0x14, 0x01, 0x02, 0x80, 0x20, 0x50, 0x14, 0x12, 0x0C,
  0xC4, 0x26, 0x0F, 0x03, 0x00, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x10,
  0x14, 0x18, 0x24, 0x07, 0xC4, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x80, 0x30, 0x60, 0x60, 0x1F, 0x80, 0x0F, 0xC1, 0x10, 0x79, 0x20,
  0x0F, 0x20, 0x02, 0x40, 0x04, 0x40, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x04, 0x10, 0x04, 0x20, 0x04, 0x40,
  0x04, 0xFC, 0x04, 0x8F, 0xE4, 0x80, 0x7C, 0x00, 0xFE, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0xC0, 0x7E,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x07, 0xF0, 0x00, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10,
  0x84, 0x22, 0x10, 0x84, 0x21, 0x10, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08,
  0x42, 0x00, 0x07, 0xF0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x3F, 0x01, 0xC0, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x3F, 0x80,
  0x00, 0x1E, 0x00, 0x91, 0x80, 0x50, 0x60, 0x48, 0x10, 0x28, 0x06, 0x24,
  0x01, 0xE0,
};

const GFXglyph IBMPlexMono_ThinItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 24, 20, 8, -24 },
  { 16, 7, 9, 20, 9, -25 },
  { 24, 20, 24, 20, 1, -24 },
  { 84, 18, 30, 20, 1, -27 },
  { 152, 23, 24, 20, -1, -24 },
  { 221, 20, 24, 20, 0, -24 },
  { 281, 2, 9, 20, 11, -25 },
  { 284, 11, 31, 20, 8, -26 },
  { 327, 11, 31, 20, 2, -26 },
  { 370, 17, 17, 20, 2, -19 },
  { 407, 17, 17, 20, 2, -19 },
  { 444, 5, 9, 20, 5, -3 },
  { 450, 9, 1, 20, 6, -11 },
  { 452, 2, 2, 20, 8, -2 },
  { 453, 18, 31, 20, 1, -26 },
  { 523, 16, 24, 20, 3, -24 },
  { 571, 15, 24, 20, 2, -24 },
  { 616, 17, 24, 20, 1, -24 },
  { 667, 16, 24, 20, 2, -24 },
  { 715, 17, 24, 20, 1, -24 },
  { 766, 17, 24, 20, 2, -24 },
  { 817, 14, 24, 20, 3, -24 },
  { 859, 16, 24, 20, 4, -24 },
  { 907, 17, 24, 20, 2, -24 },
  { 958, 14, 24, 20, 4, -24 },
  { 1000, 5, 18, 20, 8, -18 },
  { 1012, 8, 24, 20, 5, -18 },
  { 1036, 16, 18, 20, 3, -19 },
  { 1072, 17, 7, 20, 2, -14 },
  { 1087, 16, 18, 20, 2, -19 },
  { 1123, 14, 24, 20, 5, -24 },
  { 1165, 15, 28, 20, 3, -24 },
  { 1218, 17, 24, 20, 0, -24 },
  { 1269, 16, 24, 20, 2, -24 },
  { 1317, 16, 24, 20, 3, -24 },
  { 1365, 17, 24, 20, 2, -24 },
  { 1416, 18, 24, 20, 2, -24 },
  { 1470, 18, 24, 20, 2, -24 },
  { 1524, 16, 24, 20, 3, -24 },
  { 1572, 18, 24, 20, 2, -24 },
  { 1626, 18, 24, 20, 2, -24 },
  { 1680, 16, 24, 20, 2, -24 },
  { 1728, 19, 24, 20, 2, -24 },
  { 1785, 14, 24, 20, 3, -24 },
  { 1827, 19, 24, 20, 1, -24 },
  { 1884, 18, 24, 20, 2, -24 },
  { 1938, 16, 24, 20, 3, -24 },
  { 1986, 17, 24, 20, 2, -24 },
  { 2037, 16, 30, 20, 3, -24 },
  { 2097, 17, 24, 20, 2, -24 },
  { 2148, 18, 24, 20, 1, -24 },
  { 2202, 17, 24, 20, 4, -24 },
  { 2253, 17, 24, 20, 3, -24 },
  { 2304, 17, 24, 20, 4, -24 },
  { 2355, 18, 24, 20, 3, -24 },
  { 2409, 21, 24, 20, 0, -24 },
  { 2472, 19, 24, 20, 3, -24 },
  { 2529, 21, 24, 20, 0, -24 },
  { 2592, 13, 31, 20, 7, -26 },
  { 2643, 8, 31, 20, 7, -26 },
  { 2674, 13, 31, 20, 1, -26 },
  { 2725, 16, 13, 20, 3, -24 },
  { 2751, 16, 1, 20, 0, 4 },
  { 2753, 4, 6, 20, 8, -26 },
  { 2756, 16, 18, 20, 2, -18 },
  { 2792, 15, 25, 20, 3, -25 },
  { 2839, 14, 18, 20, 3, -18 },
  { 2871, 17, 25, 20, 2, -25 },
  { 2925, 14, 18, 20, 3, -18 },
  { 2957, 21, 32, 20, 0, -25 },
  { 3041, 16, 25, 20, 2, -18 },
  { 3091, 14, 25, 20, 3, -25 },
  { 3135, 14, 26, 20, 3, -26 },
  { 3181, 14, 33, 20, 4, -26 },
  { 3239, 17, 25, 20, 3, -25 },
  { 3293, 13, 25, 20, 4, -25 },
  { 3334, 18, 18, 20, 1, -18 },
  { 3375, 14, 18, 20, 3, -18 },
  { 3407, 15, 18, 20, 3, -18 },
  { 3441, 16, 25, 20, 2, -18 },
  { 3491, 16, 25, 20, 2, -18 },
  { 3541, 16, 18, 20, 4, -18 },
  { 3577, 16, 18, 20, 2, -18 },
  { 3613, 16, 24, 20, 3, -24 },
  { 3661, 14, 18, 20, 3, -18 },
  { 3693, 15, 18, 20, 3, -18 },
  { 3727, 17, 18, 20, 2, -18 },
  { 3766, 19, 18, 20, 1, -18 },
  { 3809, 16, 25, 20, 1, -18 },
  { 3859, 16, 18, 20, 2, -18 },
  { 3895, 15, 31, 20, 4, -26 },
  { 3954, 5, 31, 20, 8, -26 },
  { 3974, 15, 31, 20, 2, -26 },
  { 4033, 17, 6, 20, 2, -13 },
};

const GFXfont IBMPlexMono_ThinItalic34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_THINITALIC34PT7B_H_
