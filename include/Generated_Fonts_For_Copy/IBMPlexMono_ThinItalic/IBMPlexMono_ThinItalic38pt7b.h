#ifndef _IBMPLEXMONO_THINITALIC38PT7B_H_
#define _IBMPLEXMONO_THINITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x84, 0x10, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x42, 0x85,
  0x0A, 0x14, 0x28, 0x61, 0x42, 0x85, 0x08, 0x00, 0x18, 0x20, 0x00, 0x40,
  0x80, 0x01, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x00, 0x82, 0x00,
  0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x41, 0x00, 0xFE, 0x07, 0xF0, 0x08,
  0x10, 0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x40,
  0x00, 0x81, 0x00, 0x02, 0x04, 0x03, 0xF8, 0x1F, 0xC0, 0x40, 0x80, 0x01,
  0x02, 0x00, 0x04, 0x10, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00, 0x02, 0x08,
  0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x01, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x00, 0x38,
  0x8C, 0x06, 0x08, 0x20, 0x40, 0x81, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08,
  0x10, 0x01, 0x01, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x0C, 0x10, 0x00,
  0x61, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x23, 0x00, 0x02, 0x08,
  0x00, 0x20, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x40,
  0x40, 0x04, 0x04, 0x80, 0x40, 0x44, 0x08, 0x08, 0x20, 0x81, 0x01, 0x88,
  0x60, 0x07, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0xC3, 0x00, 0x40, 0x20, 0x40, 0x10,
  0x10, 0x08, 0x08, 0x08, 0x02, 0x04, 0x02, 0x00, 0x82, 0x00, 0x80, 0x20,
  0x80, 0x20, 0x10, 0x40, 0x08, 0x04, 0x20, 0x02, 0x01, 0x10, 0x00, 0x80,
  0x84, 0x00, 0x10, 0x42, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x08, 0x60, 0x00, 0xC4, 0x08, 0x00, 0x22, 0x01,
  0x00, 0x10, 0x80, 0x40, 0x08, 0x40, 0x10, 0x04, 0x10, 0x04, 0x02, 0x04,
  0x01, 0x00, 0x81, 0x00, 0x80, 0x40, 0x40, 0x20, 0x20, 0x08, 0x10, 0x10,
  0x03, 0x0C, 0x0C, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x06, 0x0C, 0x00,
  0x10, 0x08, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x02, 0x00, 0x80, 0x08, 0x02, 0x00, 0x10, 0x10,
  0x00, 0x20, 0x40, 0x03, 0x86, 0x00, 0x31, 0xE0, 0x03, 0x04, 0x00, 0x08,
  0x08, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40, 0x04, 0x00, 0x80, 0x20, 0x01,
  0x00, 0x80, 0x04, 0x02, 0x00, 0x18, 0x14, 0x00, 0x90, 0xD0, 0x02, 0x42,
  0x20, 0x10, 0x90, 0xC0, 0x81, 0xC0, 0xFC, 0x06, 0x00, 0x24, 0xA4, 0x92,
  0x50, 0x00, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x0E, 0x04, 0x07, 0x1C, 0x43, 0x80, 0x3F, 0xC0, 0x00, 0x40, 0x00, 0x0A,
  0x00, 0x01, 0x20, 0x00, 0x21, 0x00, 0x04, 0x08, 0x00, 0x80, 0x80, 0x10,
  0x04, 0x02, 0x00, 0x40, 0x20, 0x02, 0x00, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x18, 0xC4, 0x62, 0x11, 0x08, 0x84, 0x00, 0xFF, 0xC0, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x40,
  0x10, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01,
  0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x18, 0x0C, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00, 0x21, 0x00, 0x10,
  0x60, 0x08, 0x0C, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x12, 0x00, 0x31, 0x00, 0x30, 0x80, 0x30, 0x40, 0x20, 0x40, 0x20, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x3F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x60, 0xC0, 0x60, 0x08,
  0x10, 0x01, 0x08, 0x00, 0x44, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0xC0,
  0x08, 0x20, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x03, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08,
  0x40, 0x04, 0x0C, 0x06, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x05, 0x00, 0x01, 0x20, 0x00, 0x44, 0x00, 0x11, 0x00, 0x02, 0x20,
  0x00, 0x84, 0x00, 0x20, 0x80, 0x08, 0x10, 0x02, 0x02, 0x00, 0x80, 0x80,
  0x10, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x40, 0x08, 0x10, 0x01, 0x04,
  0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x0F, 0xFF, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x03, 0xFF, 0xE0, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x08, 0xFC, 0x01, 0x60, 0x60, 0x30, 0x02, 0x04, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x02, 0x20, 0x00, 0x42, 0x00, 0x10, 0x60, 0x06, 0x03,
  0x03, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x23, 0xF0, 0x2C, 0x0C, 0x50, 0x02, 0x60, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x40, 0x06, 0x60, 0x0C, 0x30, 0x30, 0x0F, 0xC0, 0x7F,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x22,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x70, 0x30, 0x18, 0x01, 0x04, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x41, 0x00, 0x08, 0x20, 0x02, 0x03,
  0x01, 0x80, 0x1F, 0xC0, 0x1C, 0x0C, 0x04, 0x00, 0x41, 0x00, 0x04, 0x40,
  0x00, 0x88, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00,
  0x01, 0x20, 0x00, 0x22, 0x00, 0x08, 0x20, 0x02, 0x03, 0x03, 0x80, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x0C, 0x0C, 0x10, 0x02, 0x20, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x40, 0x06, 0x60, 0x0A, 0x30, 0x34, 0x0F, 0xC4,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0x80, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x10, 0x30, 0x20, 0x20, 0x40, 0x40, 0x80, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xE0, 0x30, 0x30, 0x80, 0x12, 0x00, 0x28, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x03, 0x00, 0x78, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xC1, 0x81, 0x80, 0x40,
  0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x01, 0x20, 0x3C,
  0x90, 0x61, 0x48, 0x60, 0x68, 0x20, 0x14, 0x20, 0x0A, 0x10, 0x09, 0x08,
  0x04, 0x84, 0x02, 0x44, 0x01, 0x42, 0x00, 0xA1, 0x00, 0x50, 0x80, 0x48,
  0x20, 0x24, 0x10, 0x32, 0x06, 0x69, 0x00, 0xC0, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0x20, 0x00,
  0x22, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x02,
  0x04, 0x00, 0x40, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x04, 0x00, 0x80, 0xFF, 0xF8, 0x20, 0x01, 0x04, 0x00, 0x21, 0x00,
  0x04, 0x20, 0x00, 0x88, 0x00, 0x11, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00,
  0x07, 0x00, 0x00, 0x80, 0x07, 0xFE, 0x02, 0x00, 0x60, 0x80, 0x0C, 0x20,
  0x01, 0x08, 0x00, 0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x08, 0x40, 0x04, 0x20, 0x02, 0x0F, 0xFF, 0x02,
  0x00, 0x30, 0x80, 0x06, 0x20, 0x00, 0x88, 0x00, 0x24, 0x00, 0x09, 0x00,
  0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x80, 0x03,
  0x20, 0x01, 0x8F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x60, 0xC0, 0x60, 0x08,
  0x10, 0x02, 0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x44, 0x00, 0x21, 0x00, 0x10, 0x20,
  0x08, 0x06, 0x0C, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x80, 0x60, 0x20,
  0x02, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40,
  0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00,
  0x02, 0x20, 0x00, 0x48, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00,
  0x08, 0x80, 0x01, 0x10, 0x00, 0x44, 0x00, 0x08, 0x80, 0x02, 0x10, 0x00,
  0x42, 0x00, 0x10, 0x40, 0x04, 0x08, 0x03, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xFC, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0xFF, 0xF8, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xE0, 0xC0, 0x60, 0x08, 0x30, 0x02,
  0x08, 0x00, 0x44, 0x00, 0x11, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x01, 0xFE, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x01, 0x10, 0x00, 0x44, 0x00, 0x31, 0x00, 0x18, 0x20, 0x0A, 0x06,
  0x04, 0x80, 0x7E, 0x20, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x20,
  0x80, 0x02, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02,
  0x10, 0x00, 0x41, 0x00, 0x04, 0x10, 0x00, 0x41, 0x00, 0x04, 0x20, 0x00,
  0x43, 0xFF, 0xFC, 0x20, 0x00, 0x82, 0x00, 0x08, 0x20, 0x00, 0x82, 0x00,
  0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x10, 0x40,
  0x01, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x22, 0x00, 0x21, 0x00, 0x30, 0x40,
  0x30, 0x30, 0x30, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x08, 0x40, 0x00, 0x82,
  0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x08, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x01, 0x80, 0x10, 0x18, 0x00, 0x81, 0x80, 0x04, 0x10, 0x00, 0x21,
  0x00, 0x01, 0x14, 0x00, 0x09, 0x20, 0x00, 0x90, 0x80, 0x05, 0x04, 0x00,
  0x30, 0x10, 0x01, 0x00, 0x80, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x40, 0x20, 0x02, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40, 0x01, 0x02,
  0x00, 0x08, 0x20, 0x00, 0x20, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFF, 0xF8, 0x08, 0x00, 0x10, 0xC0,
  0x03, 0x14, 0x00, 0x31, 0x40, 0x05, 0x14, 0x00, 0xD1, 0x20, 0x0A, 0x12,
  0x01, 0x21, 0x20, 0x12, 0x22, 0x02, 0x22, 0x10, 0x22, 0x21, 0x04, 0x22,
  0x10, 0x84, 0x20, 0x88, 0x42, 0x09, 0x04, 0x40, 0x90, 0x44, 0x0A, 0x04,
  0x40, 0x40, 0x44, 0x04, 0x04, 0x40, 0x00, 0x84, 0x00, 0x08, 0x80, 0x00,
  0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x0A, 0x00, 0x20,
  0xA0, 0x02, 0x0A, 0x00, 0x21, 0x10, 0x02, 0x11, 0x00, 0x21, 0x10, 0x02,
  0x10, 0x80, 0x41, 0x08, 0x04, 0x10, 0x80, 0x42, 0x04, 0x04, 0x20, 0x40,
  0x42, 0x04, 0x04, 0x20, 0x20, 0x82, 0x02, 0x08, 0x20, 0x20, 0x84, 0x01,
  0x08, 0x40, 0x10, 0x84, 0x01, 0x08, 0x40, 0x08, 0x84, 0x00, 0x90, 0x40,
  0x09, 0x08, 0x00, 0x50, 0x80, 0x05, 0x08, 0x00, 0x30, 0x80, 0x03, 0x00,
  0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x10, 0x20, 0x02, 0x10, 0x00, 0x84,
  0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0x88, 0x00, 0x21, 0x00, 0x10, 0x60, 0x08, 0x0C, 0x0C, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x40, 0x0C, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x11,
  0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x04, 0x10, 0x00, 0x41, 0x00, 0x18,
  0x3F, 0xFE, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xC0, 0xC0, 0x40, 0x10, 0x20, 0x02, 0x10, 0x00, 0x84, 0x00, 0x12, 0x00,
  0x04, 0x80, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x28, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00,
  0x21, 0x00, 0x10, 0x60, 0x08, 0x0C, 0x0C, 0x00, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x40, 0x04, 0x38, 0x01, 0x18, 0x00, 0x28, 0x00,
  0x04, 0x00, 0x07, 0xFF, 0x00, 0x40, 0x0C, 0x08, 0x00, 0x20, 0x80, 0x02,
  0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00,
  0x11, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x04, 0x10, 0x00, 0x41, 0x00,
  0x18, 0x3F, 0xFE, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x01, 0x00, 0x20,
  0x10, 0x02, 0x00, 0x80, 0x40, 0x08, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04,
  0x00, 0x40, 0x40, 0x02, 0x04, 0x00, 0x20, 0x80, 0x01, 0x00, 0x00, 0x7F,
  0x00, 0x38, 0x0C, 0x06, 0x00, 0x20, 0x40, 0x01, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x80, 0x00, 0x44, 0x00, 0x08, 0x20, 0x01,
  0x01, 0xC0, 0x60, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x84,
  0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x10,
  0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x01, 0x88, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x20, 0x40,
  0x08, 0x06, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x10, 0x00, 0x44, 0x00, 0x21, 0x00,
  0x08, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x80, 0x80, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x00, 0x80, 0x80, 0x20, 0x40, 0x0C, 0x10, 0x01,
  0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x48,
  0x00, 0x0A, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x12, 0x00,
  0x01, 0x20, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x24, 0x00, 0x04, 0x40, 0x00, 0x44, 0x04, 0x04, 0x40, 0xA0, 0x44,
  0x0A, 0x08, 0x41, 0x20, 0x84, 0x12, 0x08, 0x42, 0x20, 0x84, 0x22, 0x10,
  0x44, 0x21, 0x04, 0x43, 0x10, 0x44, 0x11, 0x08, 0x81, 0x20, 0x88, 0x12,
  0x09, 0x01, 0x20, 0x90, 0x12, 0x0A, 0x01, 0x40, 0xA0, 0x14, 0x0C, 0x00,
  0xC0, 0xC0, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x04, 0x00, 0x08, 0x08, 0x00,
  0x20, 0x08, 0x00, 0x40, 0x10, 0x01, 0x00, 0x10, 0x04, 0x00, 0x20, 0x10,
  0x00, 0x20, 0x40, 0x00, 0x41, 0x80, 0x00, 0x42, 0x00, 0x00, 0x88, 0x00,
  0x00, 0xA0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x44, 0x00, 0x01, 0x04, 0x00, 0x04, 0x08, 0x00, 0x18,
  0x08, 0x00, 0x20, 0x10, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x08, 0x00,
  0x20, 0x20, 0x00, 0x40, 0x40, 0x00, 0x43, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x82, 0x00, 0x08, 0x10,
  0x00, 0x80, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x04, 0x00, 0x40, 0x40,
  0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x22, 0x00, 0x01, 0x20, 0x00, 0x0A,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0xFE, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01,
  0x01, 0x03, 0xFE, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x81, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x80,
  0x02, 0x20, 0x01, 0x04, 0x00, 0x41, 0x00, 0x20, 0x40, 0x10, 0x08, 0x08,
  0x02, 0x04, 0x00, 0x41, 0x00, 0x10, 0x80, 0x02, 0x40, 0x00, 0xA0, 0x00,
  0x10, 0xFF, 0xFF, 0xC0, 0x84, 0x42, 0x11, 0x03, 0xF0, 0x86, 0x06, 0x84,
  0x01, 0x44, 0x00, 0x62, 0x00, 0x12, 0x00, 0x09, 0x00, 0x05, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24, 0x00,
  0x22, 0x00, 0x11, 0x00, 0x18, 0x80, 0x14, 0x20, 0x0A, 0x0C, 0x19, 0x03,
  0xF0, 0xF0, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0xF8, 0x09, 0x83, 0x05,
  0x00, 0x43, 0x00, 0x23, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x00, 0x90, 0x00, 0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x12, 0x00,
  0x09, 0x00, 0x04, 0x80, 0x04, 0xC0, 0x04, 0x50, 0x06, 0x26, 0x0E, 0x10,
  0xFC, 0x00, 0x01, 0xF0, 0x06, 0x0C, 0x18, 0x02, 0x10, 0x02, 0x20, 0x01,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x02, 0x40, 0x04, 0x40, 0x08,
  0x20, 0x18, 0x10, 0x20, 0x0F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x03, 0xF0, 0x83, 0x03, 0x21, 0x00, 0x50, 0x80, 0x0C, 0x20, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x42, 0x00, 0x30,
  0x80, 0x14, 0x10, 0x05, 0x03, 0x06, 0x40, 0x7E, 0x10, 0x01, 0xF8, 0x06,
  0x06, 0x08, 0x01, 0x10, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x02, 0x80, 0x0C, 0x80, 0xF0, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x03, 0x40, 0x02, 0x40, 0x04, 0x20, 0x08, 0x18, 0x30, 0x0F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x08, 0x04, 0x00,
  0x18, 0x08, 0x00, 0x18, 0x10, 0x00, 0x18, 0x40, 0x00, 0x08, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x41,
  0x81, 0xA0, 0x80, 0x28, 0x40, 0x06, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00,
  0x09, 0x00, 0x02, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0x44, 0x00, 0x21, 0x00, 0x18, 0x40, 0x0A, 0x08,
  0x02, 0x81, 0x83, 0x20, 0x3F, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x08, 0x20, 0x04, 0x06, 0x06, 0x00, 0x7E, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0xF8, 0x13, 0x06, 0x14, 0x02, 0x18, 0x01,
  0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02,
  0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04,
  0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x00, 0x20, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x80, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x01, 0x02, 0x03, 0x04, 0x04, 0x04, 0x18, 0x04, 0x20,
  0x04, 0xC0, 0x05, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x80, 0x20, 0x40, 0x40, 0x20, 0x40, 0x10, 0x40,
  0x0C, 0x40, 0x06, 0x40, 0x03, 0x40, 0x01, 0x80, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0xFC, 0x02, 0x60, 0x40, 0x50, 0x04, 0x0C, 0x00,
  0x83, 0x00, 0x10, 0x60, 0x02, 0x08, 0x00, 0x41, 0x00, 0x10, 0x20, 0x04,
  0x04, 0x03, 0x01, 0x07, 0x80, 0x21, 0x00, 0x04, 0x20, 0x00, 0x82, 0x00,
  0x50, 0x20, 0x12, 0x04, 0x04, 0x80, 0x43, 0x10, 0x04, 0xC2, 0x00, 0xB0,
  0x40, 0x0C, 0x00, 0xFF, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x04, 0x40, 0x21, 0x03, 0x04, 0x10, 0x11, 0x80, 0x48,
  0x02, 0xC0, 0x0C, 0x00, 0x13, 0xC3, 0xC2, 0x42, 0x42, 0x28, 0x28, 0x23,
  0x03, 0x01, 0x20, 0x30, 0x22, 0x02, 0x02, 0x20, 0x20, 0x22, 0x02, 0x02,
  0x40, 0x20, 0x24, 0x04, 0x02, 0x40, 0x40, 0x44, 0x04, 0x04, 0x40, 0x40,
  0x44, 0x04, 0x04, 0x80, 0x40, 0x48, 0x08, 0x04, 0x80, 0x80, 0x88, 0x08,
  0x08, 0x80, 0x80, 0x88, 0x08, 0x08, 0x10, 0xF8, 0x13, 0x06, 0x14, 0x02,
  0x18, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x20, 0x02, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x04, 0x40, 0x04, 0x40, 0x04, 0x80, 0x04, 0x80, 0x04, 0x01, 0xF8,
  0x03, 0x06, 0x06, 0x00, 0x82, 0x00, 0x22, 0x00, 0x12, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x14, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x04, 0x40, 0x04, 0x10, 0x04,
  0x0C, 0x0C, 0x01, 0xF8, 0x00, 0x08, 0x7C, 0x02, 0x60, 0xC0, 0xA0, 0x08,
  0x30, 0x02, 0x18, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x88, 0x00,
  0x22, 0x00, 0x08, 0x80, 0x04, 0x60, 0x02, 0x14, 0x01, 0x84, 0xC1, 0xC1,
  0x0F, 0xC0, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x86, 0x06,
  0x84, 0x01, 0x44, 0x00, 0x62, 0x00, 0x12, 0x00, 0x09, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x12, 0x00, 0x11, 0x00, 0x18, 0x80, 0x14, 0x20, 0x0A, 0x0C, 0x19,
  0x03, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0xFE, 0x3F, 0xC0, 0x90,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFC, 0x01, 0x80, 0xC0, 0x80, 0x08,
  0x40, 0x01, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0xC0, 0x01, 0x18, 0x00, 0xC1, 0x80, 0xE0,
  0x1F, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x04, 0x04,
  0x03, 0x01, 0x01, 0x80, 0x41, 0x80, 0x11, 0x80, 0x08, 0xC0, 0x02, 0xC0,
  0x00, 0xC0, 0x00, 0x20, 0x02, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14, 0x00,
  0x28, 0x00, 0x50, 0x01, 0x20, 0x02, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x0C, 0x80, 0x29, 0x80,
  0x91, 0x82, 0x40, 0xF8, 0x80, 0xFC, 0x00, 0x82, 0x00, 0x41, 0x00, 0x21,
  0x00, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01, 0x08, 0x00,
  0x84, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00, 0x20, 0x80, 0x20, 0x40,
  0x10, 0x20, 0x10, 0x10, 0x10, 0x10, 0x30, 0x08, 0x60, 0x03, 0xC0, 0x00,
  0x20, 0x20, 0x84, 0x04, 0x08, 0x80, 0x81, 0x10, 0x10, 0x24, 0x04, 0x04,
  0x80, 0x80, 0x90, 0x10, 0x0A, 0x02, 0x01, 0x40, 0x40, 0x48, 0x08, 0x0A,
  0x02, 0x01, 0x40, 0x40, 0x28, 0x08, 0x05, 0x01, 0x00, 0xA0, 0x20, 0x24,
  0x0C, 0x04, 0x82, 0x81, 0x90, 0x50, 0x23, 0x11, 0x18, 0x3C, 0x1E, 0x00,
  0x01, 0x81, 0xE0, 0x32, 0x18, 0x86, 0x11, 0x02, 0xC0, 0x50, 0x10, 0x02,
  0x80, 0x80, 0x18, 0x04, 0x00, 0xC0, 0x20, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x40, 0x30,
  0x02, 0x02, 0x80, 0x10, 0x14, 0x00, 0x80, 0xA0, 0x34, 0x08, 0x86, 0x11,
  0x86, 0xC0, 0x78, 0x18, 0x00, 0x08, 0x00, 0x84, 0x00, 0x42, 0x00, 0x22,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x04, 0x40, 0x04, 0x20, 0x02, 0x10, 0x01,
  0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x08, 0x40, 0x0C, 0x20, 0x0A, 0x18, 0x09, 0x06, 0x09, 0x00, 0xF8, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x40, 0x08,
  0x18, 0x18, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x63, 0x07, 0xC8, 0x40, 0x0F,
  0x10, 0x00, 0x62, 0x00, 0x18, 0x40, 0x04, 0x08, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x20,
  0x10, 0x02, 0x04, 0x00, 0x41, 0x00, 0x08, 0x40, 0x01, 0x1F, 0xE0, 0x22,
  0x0F, 0xE4, 0x40, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x02, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x07, 0xFC, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x80, 0x70, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x22,
  0x30, 0x04, 0x83, 0x00, 0xA0, 0x20, 0x24, 0x02, 0x09, 0x00, 0x23, 0x20,
  0x03, 0x80,
};

const GFXglyph IBMPlexMono_ThinItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 27, 23, 9, -27 },
  { 22, 7, 10, 23, 10, -28 },
  { 31, 22, 27, 23, 1, -27 },
  { 106, 20, 35, 23, 1, -31 },
  { 194, 26, 27, 23, -1, -27 },
  { 282, 22, 27, 23, 0, -27 },
  { 357, 3, 10, 23, 12, -28 },
  { 361, 12, 34, 23, 9, -29 },
  { 412, 12, 34, 23, 3, -29 },
  { 463, 20, 19, 23, 2, -21 },
  { 511, 18, 19, 23, 3, -21 },
  { 554, 5, 10, 23, 6, -3 },
  { 561, 10, 1, 23, 7, -12 },
  { 563, 2, 2, 23, 9, -2 },
  { 564, 21, 34, 23, 1, -29 },
  { 654, 18, 27, 23, 3, -27 },
  { 715, 17, 27, 23, 2, -27 },
  { 773, 18, 27, 23, 2, -27 },
  { 834, 18, 27, 23, 2, -27 },
  { 895, 19, 27, 23, 1, -27 },
  { 960, 19, 27, 23, 2, -27 },
  { 1025, 16, 27, 23, 3, -27 },
  { 1079, 17, 27, 23, 5, -27 },
  { 1137, 19, 27, 23, 2, -27 },
  { 1202, 16, 27, 23, 4, -27 },
  { 1256, 5, 20, 23, 9, -20 },
  { 1269, 8, 27, 23, 6, -20 },
  { 1296, 19, 20, 23, 3, -22 },
  { 1344, 19, 7, 23, 2, -15 },
  { 1361, 18, 20, 23, 2, -22 },
  { 1406, 15, 27, 23, 6, -27 },
  { 1457, 17, 31, 23, 3, -27 },
  { 1523, 19, 27, 23, 0, -27 },
  { 1588, 18, 27, 23, 2, -27 },
  { 1649, 18, 27, 23, 3, -27 },
  { 1710, 19, 27, 23, 2, -27 },
  { 1775, 20, 27, 23, 2, -27 },
  { 1843, 20, 27, 23, 2, -27 },
  { 1911, 18, 27, 23, 3, -27 },
  { 1972, 20, 27, 23, 2, -27 },
  { 2040, 20, 27, 23, 2, -27 },
  { 2108, 17, 27, 23, 3, -27 },
  { 2166, 21, 27, 23, 2, -27 },
  { 2237, 15, 27, 23, 4, -27 },
  { 2288, 20, 27, 23, 2, -27 },
  { 2356, 20, 27, 23, 2, -27 },
  { 2424, 18, 27, 23, 3, -27 },
  { 2485, 20, 27, 23, 2, -27 },
  { 2553, 18, 34, 23, 3, -27 },
  { 2630, 20, 27, 23, 2, -27 },
  { 2698, 20, 27, 23, 1, -27 },
  { 2766, 20, 27, 23, 4, -27 },
  { 2834, 19, 27, 23, 3, -27 },
  { 2899, 18, 27, 23, 5, -27 },
  { 2960, 20, 27, 23, 3, -27 },
  { 3028, 23, 27, 23, 0, -27 },
  { 3106, 21, 27, 23, 4, -27 },
  { 3177, 23, 27, 23, 0, -27 },
  { 3255, 14, 34, 23, 8, -29 },
  { 3315, 8, 34, 23, 8, -29 },
  { 3349, 15, 34, 23, 1, -29 },
  { 3413, 18, 14, 23, 3, -27 },
  { 3445, 18, 1, 23, 0, 4 },
  { 3448, 4, 6, 23, 9, -29 },
  { 3451, 17, 20, 23, 3, -20 },
  { 3494, 17, 28, 23, 3, -28 },
  { 3554, 16, 20, 23, 3, -20 },
  { 3594, 18, 28, 23, 3, -28 },
  { 3657, 16, 20, 23, 3, -20 },
  { 3697, 23, 36, 23, 0, -28 },
  { 3801, 18, 28, 23, 2, -20 },
  { 3864, 16, 28, 23, 3, -28 },
  { 3920, 16, 29, 23, 3, -29 },
  { 3978, 16, 37, 23, 4, -29 },
  { 4052, 19, 28, 23, 3, -28 },
  { 4119, 14, 28, 23, 5, -28 },
  { 4168, 20, 20, 23, 2, -20 },
  { 4218, 16, 20, 23, 3, -20 },
  { 4258, 17, 20, 23, 3, -20 },
  { 4301, 18, 28, 23, 2, -20 },
  { 4364, 17, 28, 23, 3, -20 },
  { 4424, 18, 20, 23, 5, -20 },
  { 4469, 18, 20, 23, 2, -20 },
  { 4514, 18, 27, 23, 3, -27 },
  { 4575, 15, 20, 23, 4, -20 },
  { 4613, 17, 20, 23, 3, -20 },
  { 4656, 19, 20, 23, 3, -20 },
  { 4704, 21, 20, 23, 1, -20 },
  { 4757, 17, 28, 23, 2, -20 },
  { 4817, 19, 20, 23, 2, -20 },
  { 4865, 17, 34, 23, 5, -29 },
  { 4938, 6, 34, 23, 9, -29 },
  { 4964, 17, 34, 23, 2, -29 },
  { 5037, 19, 7, 23, 2, -15 },
};

const GFXfont IBMPlexMono_ThinItalic38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_THINITALIC38PT7B_H_
