#ifndef _IBMPLEXMONO_THINITALIC44PT7B_H_
#define _IBMPLEXMONO_THINITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x1C, 0x38, 0x00, 0x41, 0x41, 0x41, 0x41, 0x42, 0xC2, 0x82,
  0x82, 0x82, 0x82, 0x84, 0x00, 0x02, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x08, 0x00, 0x02, 0x04, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x40, 0x40, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x08,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x10,
  0x10, 0x00, 0x04, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x20, 0x20, 0x00, 0x10, 0x10, 0x00, 0x04, 0x04, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x80, 0x80, 0x00, 0x20, 0x20, 0x00, 0x08, 0x18, 0x00, 0x04, 0x04,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x20, 0x20, 0x00, 0x08,
  0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00,
  0x30, 0x46, 0x00, 0x81, 0x02, 0x02, 0x02, 0x02, 0x08, 0x04, 0x02, 0x10,
  0x08, 0x00, 0x20, 0x10, 0x00, 0x80, 0x20, 0x01, 0x00, 0x80, 0x02, 0x01,
  0x00, 0x02, 0x02, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x10,
  0x00, 0x07, 0x40, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x70, 0x00, 0x02, 0x18,
  0x00, 0x04, 0x08, 0x00, 0x08, 0x18, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20,
  0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02, 0x20,
  0x10, 0x04, 0x40, 0x20, 0x10, 0x40, 0x40, 0x60, 0x40, 0x81, 0x80, 0x71,
  0x0C, 0x00, 0x1F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x00, 0x08, 0x0C, 0x10, 0x00, 0x80,
  0x40, 0x40, 0x08, 0x04, 0x01, 0x00, 0x40, 0x40, 0x08, 0x04, 0x02, 0x00,
  0x40, 0x40, 0x10, 0x02, 0x04, 0x00, 0x80, 0x10, 0x20, 0x08, 0x00, 0x82,
  0x00, 0x40, 0x08, 0x20, 0x02, 0x00, 0x42, 0x00, 0x08, 0x04, 0x10, 0x00,
  0x40, 0x21, 0x00, 0x01, 0x06, 0x10, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x30,
  0xC0, 0x00, 0x82, 0x03, 0x00, 0x08, 0x20, 0x08, 0x00, 0x41, 0x00, 0x40,
  0x04, 0x10, 0x02, 0x00, 0x40, 0x80, 0x10, 0x04, 0x04, 0x00, 0x80, 0x20,
  0x20, 0x04, 0x02, 0x01, 0x00, 0x20, 0x20, 0x08, 0x02, 0x02, 0x00, 0x40,
  0x10, 0x20, 0x01, 0x01, 0x01, 0x00, 0x0C, 0x30, 0x10, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x40, 0x10, 0x00, 0x60, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x20,
  0x08, 0x00, 0x10, 0x04, 0x00, 0x04, 0x04, 0x00, 0x02, 0x04, 0x00, 0x1E,
  0x8C, 0x00, 0x10, 0x38, 0x00, 0x10, 0x10, 0x00, 0x10, 0x04, 0x00, 0x10,
  0x03, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x04, 0x00, 0x80, 0x03, 0x00, 0x40, 0x01, 0x80, 0x60, 0x01, 0x20,
  0x50, 0x00, 0x98, 0x4C, 0x00, 0x44, 0x22, 0x00, 0x41, 0x20, 0xC0, 0xC0,
  0xE0, 0x1F, 0x80, 0x30, 0x24, 0x96, 0x92, 0x4B, 0x00, 0x00, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0xC0, 0x20, 0x0C, 0xE0, 0x83, 0xC0, 0x72, 0x70, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x02, 0x40, 0x00, 0x10, 0x80, 0x00, 0xC2, 0x00, 0x06,
  0x04, 0x00, 0x10, 0x10, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x01,
  0x01, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x21, 0x84, 0x30, 0x82, 0x10, 0x42, 0x08, 0x00, 0xFF, 0xE0, 0xFF,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x06, 0x00,
  0xC0, 0x08, 0x04, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x04, 0x60, 0x00,
  0x22, 0x00, 0x01, 0x10, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40,
  0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x06, 0x01,
  0x40, 0x30, 0x0A, 0x00, 0x00, 0x60, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00,
  0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x62,
  0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x10, 0x18, 0x03,
  0x00, 0x60, 0x30, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0xD0, 0x00,
  0x19, 0x00, 0x02, 0x20, 0x00, 0xC2, 0x00, 0x18, 0x20, 0x02, 0x02, 0x00,
  0xC0, 0x20, 0x18, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0x80, 0x06, 0x03, 0x00, 0x40, 0x04, 0x04, 0x00, 0x30, 0x40,
  0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x0E, 0x06, 0x00, 0x80, 0x0C, 0x08, 0x00, 0x20, 0xC0, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x19, 0x00, 0x00, 0x84,
  0x00, 0x08, 0x10, 0x00, 0xC0, 0x60, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x40, 0x00, 0x08,
  0x80, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x08, 0x00, 0x04, 0x10,
  0x00, 0x10, 0x20, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x06, 0x02, 0x00,
  0x08, 0x04, 0x00, 0x20, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x08,
  0x00, 0x80, 0x20, 0x01, 0x00, 0x40, 0x02, 0x01, 0x00, 0x04, 0x04, 0x00,
  0x08, 0x10, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xF8, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x08, 0xFE, 0x00, 0x58, 0x0C, 0x03, 0x00, 0x10, 0x10, 0x00,
  0x41, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x11, 0x00, 0x01, 0x0C, 0x00, 0x18, 0x30, 0x01, 0x80, 0x60,
  0x30, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x7F, 0x02,
  0x60, 0x71, 0x60, 0x06, 0x60, 0x00, 0xA8, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x06, 0x40, 0x03, 0x18, 0x01, 0x83,
  0x81, 0x80, 0x1F, 0x80, 0x7F, 0xFF, 0xFA, 0x00, 0x00, 0x90, 0x00, 0x04,
  0x80, 0x00, 0x44, 0x00, 0x04, 0x20, 0x00, 0x22, 0x00, 0x02, 0x10, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x07, 0x00, 0x80, 0x0C, 0x08, 0x00,
  0x30, 0x80, 0x00, 0x84, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00, 0x01, 0x10,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x03,
  0x02, 0x00, 0x30, 0x0C, 0x06, 0x00, 0x1F, 0xC0, 0x07, 0x03, 0x00, 0xC0,
  0x06, 0x08, 0x00, 0x18, 0x80, 0x00, 0x44, 0x00, 0x01, 0x40, 0x00, 0x0A,
  0x00, 0x00, 0x50, 0x00, 0x02, 0x80, 0x00, 0x34, 0x00, 0x01, 0x20, 0x00,
  0x09, 0x00, 0x00, 0x84, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x60, 0x38, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0x60, 0x60, 0x06, 0x18, 0x00, 0x62,
  0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x01, 0xA0,
  0x00, 0x32, 0x00, 0x0C, 0x60, 0x06, 0x83, 0x03, 0xA0, 0x3F, 0x84, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x70, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8E, 0x00, 0x01, 0x81,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x06, 0x06, 0x0C, 0x00, 0xC4,
  0x00, 0x24, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x07, 0xC0, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x18, 0x18, 0x03, 0x00, 0x40, 0x60, 0x02, 0x04, 0x00, 0x20,
  0x80, 0x02, 0x08, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x22, 0x01, 0xF2,
  0x20, 0x60, 0xA2, 0x0C, 0x06, 0x20, 0x80, 0x64, 0x10, 0x02, 0x41, 0x00,
  0x24, 0x10, 0x04, 0x42, 0x00, 0x44, 0x20, 0x04, 0x82, 0x00, 0x48, 0x20,
  0x04, 0x82, 0x00, 0x48, 0x20, 0x08, 0x82, 0x00, 0x88, 0x20, 0x18, 0x82,
  0x02, 0x88, 0x10, 0x68, 0x80, 0xF8, 0x88, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44,
  0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00,
  0x08, 0x08, 0x00, 0x20, 0x20, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x80, 0x04,
  0x03, 0xFF, 0xF0, 0x10, 0x00, 0x20, 0x40, 0x00, 0x82, 0x00, 0x02, 0x08,
  0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0x88, 0x00, 0x01, 0x20, 0x00,
  0x05, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x80, 0x80, 0x04,
  0x08, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00,
  0x03, 0x10, 0x00, 0x23, 0x00, 0x04, 0x20, 0x01, 0x83, 0xFF, 0xE0, 0x20,
  0x01, 0x82, 0x00, 0x04, 0x20, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x30, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x06, 0x06, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x40,
  0x40, 0x01, 0x04, 0x00, 0x08, 0x40, 0x00, 0x62, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x02, 0x10, 0x00, 0x20,
  0x80, 0x02, 0x06, 0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x60, 0x00, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x18, 0x10, 0x00, 0x40,
  0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00,
  0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88,
  0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00,
  0x48, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00,
  0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x21,
  0x00, 0x02, 0x08, 0x00, 0x20, 0x40, 0x06, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFE, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x0E, 0x06, 0x00, 0xC0, 0x18, 0x08, 0x00, 0x40, 0x80, 0x01,
  0x04, 0x00, 0x08, 0x40, 0x00, 0x62, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x01, 0xFF, 0x20, 0x00,
  0x09, 0x00, 0x00, 0x48, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x20, 0x80, 0x03,
  0x06, 0x00, 0x28, 0x10, 0x02, 0x40, 0x60, 0x62, 0x00, 0xFC, 0x00, 0x04,
  0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40,
  0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x00,
  0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x0F, 0xFF, 0xFC, 0x10, 0x00, 0x08,
  0x20, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x01, 0x04,
  0x00, 0x02, 0x08, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80,
  0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00,
  0x08, 0x20, 0x00, 0x10, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x20, 0x00,
  0x41, 0x00, 0x04, 0x04, 0x00, 0x60, 0x30, 0x06, 0x00, 0xC0, 0xE0, 0x01,
  0xF8, 0x00, 0x04, 0x00, 0x03, 0x04, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x08,
  0x00, 0x10, 0x08, 0x00, 0x20, 0x08, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x08, 0x02, 0x00, 0x10, 0x04, 0x00, 0x10, 0x08, 0x00, 0x10,
  0x10, 0x00, 0x10, 0x20, 0x00, 0x10, 0x40, 0x00, 0x10, 0xA0, 0x00, 0x23,
  0x20, 0x00, 0x26, 0x10, 0x00, 0x2C, 0x10, 0x00, 0x38, 0x08, 0x00, 0x30,
  0x08, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x40,
  0x02, 0x00, 0x40, 0x01, 0x00, 0x40, 0x01, 0x00, 0x40, 0x00, 0x80, 0x80,
  0x00, 0x80, 0x80, 0x00, 0x40, 0x80, 0x00, 0x40, 0x80, 0x00, 0x20, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0x04, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0A, 0x00, 0x06, 0x0A, 0x00,
  0x0E, 0x09, 0x00, 0x0A, 0x09, 0x00, 0x12, 0x09, 0x00, 0x12, 0x09, 0x00,
  0x22, 0x08, 0x80, 0x64, 0x10, 0x80, 0x44, 0x10, 0x80, 0x84, 0x10, 0x80,
  0x84, 0x10, 0x41, 0x04, 0x10, 0x42, 0x04, 0x10, 0x42, 0x04, 0x20, 0x24,
  0x08, 0x20, 0x24, 0x08, 0x20, 0x28, 0x08, 0x20, 0x10, 0x08, 0x20, 0x10,
  0x08, 0x20, 0x20, 0x08, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x80, 0x00,
  0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x06, 0x00,
  0x02, 0x0C, 0x00, 0x04, 0x14, 0x00, 0x08, 0x28, 0x00, 0x10, 0x48, 0x00,
  0x20, 0x90, 0x00, 0x82, 0x20, 0x01, 0x04, 0x20, 0x02, 0x08, 0x40, 0x04,
  0x10, 0x80, 0x08, 0x20, 0x80, 0x10, 0x41, 0x00, 0x41, 0x02, 0x00, 0x82,
  0x02, 0x01, 0x04, 0x04, 0x02, 0x08, 0x08, 0x04, 0x10, 0x08, 0x08, 0x20,
  0x10, 0x20, 0x80, 0x20, 0x41, 0x00, 0x20, 0x82, 0x00, 0x41, 0x04, 0x00,
  0x82, 0x08, 0x00, 0x84, 0x10, 0x01, 0x10, 0x40, 0x02, 0x20, 0x80, 0x02,
  0x41, 0x00, 0x04, 0x82, 0x00, 0x0D, 0x04, 0x00, 0x0A, 0x08, 0x00, 0x18,
  0x20, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x06, 0x00, 0xC0, 0x08,
  0x04, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x04, 0x60, 0x00, 0x22, 0x00,
  0x01, 0x10, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x14,
  0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00,
  0x0A, 0x00, 0x00, 0x60, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40,
  0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x62, 0x00, 0x02,
  0x10, 0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x10, 0x18, 0x03, 0x00, 0x60,
  0x30, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x10, 0x00, 0xC0, 0x40, 0x01,
  0x82, 0x00, 0x02, 0x08, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42,
  0x00, 0x01, 0x08, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00,
  0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x41, 0x00, 0x03, 0x08, 0x00, 0x38,
  0x3F, 0xFF, 0x80, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x06, 0x00,
  0xC0, 0x08, 0x04, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x04, 0x60, 0x00,
  0x22, 0x00, 0x01, 0x10, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x02, 0x40,
  0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x01,
  0x40, 0x00, 0x0A, 0x00, 0x00, 0x60, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00,
  0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x62,
  0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x10, 0x18, 0x03,
  0x00, 0x60, 0x30, 0x00, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x02, 0x01, 0x00,
  0x08, 0x0C, 0x00, 0x20, 0x80, 0x01, 0x18, 0x00, 0x05, 0x80, 0x00, 0x18,
  0x00, 0x07, 0xFF, 0xC0, 0x10, 0x00, 0xC0, 0x40, 0x01, 0x82, 0x00, 0x02,
  0x08, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x02, 0x10, 0x00,
  0x08, 0x40, 0x00, 0x41, 0x00, 0x03, 0x08, 0x00, 0x38, 0x3F, 0xFF, 0x80,
  0x80, 0x40, 0x02, 0x01, 0x00, 0x08, 0x06, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40, 0x02, 0x01, 0x00, 0x08,
  0x04, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x00, 0x82, 0x00, 0x02, 0x08,
  0x00, 0x04, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0x00, 0x60, 0x08, 0x00, 0x20,
  0x20, 0x00, 0x20, 0x80, 0x00, 0x21, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x04,
  0x00, 0x06, 0x04, 0x00, 0x18, 0x07, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x44,
  0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00,
  0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40,
  0x00, 0x22, 0x00, 0x02, 0x10, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04,
  0x40, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00,
  0x04, 0x20, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x20, 0x20, 0x03, 0x00,
  0xC0, 0x60, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xA0, 0x00,
  0x05, 0x00, 0x00, 0x48, 0x00, 0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08,
  0x00, 0x18, 0x40, 0x00, 0x82, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x80, 0x06,
  0x02, 0x00, 0x20, 0x10, 0x01, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x04, 0x04, 0x00, 0x20, 0x20, 0x01, 0x02, 0x00,
  0x08, 0x10, 0x00, 0x41, 0x00, 0x02, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44,
  0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x02, 0x40, 0x00, 0x05, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x02, 0x20,
  0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0xC0, 0x42, 0x02,
  0x80, 0x84, 0x05, 0x01, 0x08, 0x12, 0x02, 0x10, 0x24, 0x08, 0x20, 0x48,
  0x10, 0x41, 0x10, 0x21, 0x02, 0x20, 0x42, 0x08, 0x21, 0x04, 0x10, 0x42,
  0x08, 0x40, 0x84, 0x10, 0x81, 0x10, 0x22, 0x02, 0x20, 0x44, 0x04, 0x40,
  0x90, 0x08, 0x81, 0x20, 0x12, 0x02, 0x80, 0x14, 0x05, 0x00, 0x28, 0x0C,
  0x00, 0x50, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x08, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x80, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x0C, 0x00, 0x10, 0x01, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x20, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x88, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x60, 0x10, 0x00, 0x08, 0x01, 0x00, 0x02, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x20, 0x00, 0x40, 0x08, 0x00, 0x04, 0x03, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x08, 0x30, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x02,
  0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x10,
  0x08, 0x00, 0x20, 0x08, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x80,
  0x04, 0x01, 0x00, 0x02, 0x02, 0x00, 0x02, 0x04, 0x00, 0x01, 0x0C, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x90, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0x81, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x04,
  0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x03, 0xFF, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x04, 0x40, 0x00, 0xC2, 0x00,
  0x08, 0x20, 0x01, 0x01, 0x00, 0x20, 0x10, 0x06, 0x00, 0x80, 0x40, 0x08,
  0x08, 0x00, 0x41, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x02, 0x40, 0x00,
  0x28, 0x00, 0x01, 0x80, 0x00, 0x20, 0xFF, 0xFF, 0xF8, 0x88, 0x42, 0x21,
  0x10, 0x00, 0xFC, 0x10, 0x30, 0x31, 0x04, 0x00, 0xA0, 0x80, 0x06, 0x10,
  0x00, 0x62, 0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x44,
  0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0xC0, 0x01,
  0x84, 0x00, 0x28, 0x40, 0x05, 0x02, 0x00, 0xD0, 0x18, 0x19, 0xF0, 0x7E,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x41, 0xF8, 0x08, 0xC1, 0x81, 0x20, 0x08, 0x28, 0x00, 0x86, 0x00,
  0x11, 0x80, 0x01, 0x30, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00,
  0x12, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00,
  0x28, 0x00, 0x09, 0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x02,
  0x28, 0x00, 0xC5, 0x80, 0x30, 0x98, 0x1C, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x01, 0xC1, 0x80, 0xC0, 0x10, 0x40, 0x02, 0x20, 0x00, 0x48, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x28, 0x00, 0x11, 0x00, 0x0C, 0x40, 0x06, 0x08, 0x03, 0x01,
  0x81, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x3F, 0x04, 0x06, 0x06, 0x20,
  0x40, 0x0A, 0x04, 0x00, 0x30, 0x40, 0x01, 0x84, 0x00, 0x04, 0x20, 0x00,
  0x22, 0x00, 0x01, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x04, 0x40,
  0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x84, 0x00, 0x04,
  0x20, 0x00, 0x21, 0x00, 0x01, 0x0C, 0x00, 0x18, 0x20, 0x01, 0x41, 0x00,
  0x14, 0x04, 0x01, 0x20, 0x18, 0x11, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xC0, 0xC0, 0xC0, 0x08, 0x60, 0x01, 0x10, 0x00, 0x48, 0x00, 0x14,
  0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0xE2, 0x03,
  0xC0, 0xFF, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x28, 0x00, 0x09, 0x00, 0x04, 0x40, 0x02, 0x08, 0x01, 0x01,
  0x81, 0x80, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x10, 0x02, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x30, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x7E, 0x08, 0x0C, 0x0C, 0x40, 0x80, 0x14, 0x08, 0x00,
  0x60, 0x80, 0x03, 0x08, 0x00, 0x08, 0x40, 0x00, 0x44, 0x00, 0x02, 0x20,
  0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02,
  0x20, 0x00, 0x11, 0x00, 0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00,
  0x02, 0x18, 0x00, 0x30, 0x40, 0x02, 0x82, 0x00, 0x28, 0x08, 0x03, 0x40,
  0x30, 0x32, 0x00, 0x7E, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x08, 0x00, 0x20, 0x20, 0x02, 0x00, 0xC0, 0x60, 0x01,
  0xFC, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x87, 0xE0, 0x46, 0x0C, 0x12, 0x00, 0x85, 0x00, 0x31, 0x80, 0x04,
  0x60, 0x01, 0x10, 0x00, 0x4C, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0x88, 0x00, 0x22, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00,
  0x24, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x04, 0x80, 0x02, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x10, 0x20, 0x18, 0x08, 0x0C, 0x02, 0x04, 0x00, 0x86,
  0x00, 0x42, 0x00, 0x13, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x20, 0x04, 0x04, 0x01, 0x00, 0x80, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00,
  0x62, 0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x83, 0xF0, 0x02, 0x30, 0x30, 0x09, 0x00, 0x60, 0x28, 0x00, 0x81,
  0xC0, 0x02, 0x06, 0x00, 0x08, 0x18, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00,
  0x04, 0x04, 0x00, 0x20, 0x10, 0x01, 0x00, 0x80, 0x18, 0x02, 0x03, 0x80,
  0x08, 0x70, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x02, 0x04, 0x00, 0x50,
  0x08, 0x02, 0x40, 0x20, 0x11, 0x00, 0x40, 0x84, 0x01, 0x04, 0x10, 0x02,
  0x20, 0x40, 0x09, 0x02, 0x00, 0x18, 0x00, 0x7F, 0xE0, 0x40, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x41, 0x00, 0xC0, 0x80, 0x80, 0x81, 0x80, 0x41, 0x00, 0x23,
  0x00, 0x12, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x19, 0xF0, 0x78, 0x24,
  0x31, 0x08, 0x50, 0x2C, 0x08, 0xC0, 0x50, 0x11, 0x80, 0xC0, 0x22, 0x01,
  0x80, 0x44, 0x02, 0x00, 0x90, 0x04, 0x01, 0x20, 0x08, 0x04, 0x40, 0x10,
  0x08, 0x80, 0x40, 0x11, 0x00, 0x80, 0x22, 0x01, 0x00, 0x48, 0x02, 0x01,
  0x10, 0x04, 0x02, 0x20, 0x08, 0x04, 0x40, 0x20, 0x08, 0x80, 0x40, 0x11,
  0x00, 0x80, 0x24, 0x01, 0x00, 0x88, 0x02, 0x01, 0x10, 0x04, 0x02, 0x20,
  0x10, 0x04, 0x00, 0x08, 0x7E, 0x04, 0x60, 0xC1, 0x20, 0x08, 0x50, 0x03,
  0x18, 0x00, 0x46, 0x00, 0x11, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0x48,
  0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x90, 0x00, 0x24, 0x00,
  0x09, 0x00, 0x02, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x20, 0x01, 0xFC, 0x00, 0xE0, 0x60,
  0x20, 0x06, 0x08, 0x00, 0x42, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x0A,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50,
  0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x84, 0x00, 0x20, 0x40, 0x08, 0x06,
  0x06, 0x00, 0x3F, 0x00, 0x04, 0x1F, 0x80, 0x23, 0x06, 0x01, 0x20, 0x08,
  0x0A, 0x00, 0x20, 0x60, 0x01, 0x06, 0x00, 0x04, 0x30, 0x00, 0x21, 0x00,
  0x01, 0x08, 0x00, 0x08, 0x40, 0x00, 0x42, 0x00, 0x02, 0x20, 0x00, 0x11,
  0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x02, 0x10, 0x00,
  0x11, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x60, 0x00, 0x82, 0x80, 0x0C, 0x16,
  0x00, 0xC0, 0x98, 0x1C, 0x08, 0x3F, 0x80, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x10, 0x30, 0x31, 0x04, 0x00, 0xA0,
  0x80, 0x06, 0x10, 0x00, 0x62, 0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x02,
  0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00,
  0x48, 0x00, 0x04, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00,
  0x08, 0xC0, 0x01, 0x84, 0x00, 0x28, 0x40, 0x05, 0x02, 0x00, 0xD0, 0x18,
  0x19, 0x00, 0x7E, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0xFF, 0x87, 0xF8, 0x04, 0xC0, 0x00, 0x28, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x30, 0x1C, 0x0C, 0x00, 0x20, 0x80, 0x01, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x28, 0x00, 0x04, 0x40, 0x00, 0x42, 0x00, 0x08, 0x1C, 0x07, 0x00, 0x7F,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x08, 0x01, 0x00, 0x70, 0x08, 0x06,
  0x00, 0x20, 0x20, 0x00, 0x83, 0x00, 0x02, 0x10, 0x00, 0x09, 0x80, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x62, 0x00, 0x08, 0x40, 0x01,
  0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x21, 0x00, 0x04,
  0x20, 0x00, 0x84, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x10,
  0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x62,
  0x00, 0x14, 0x20, 0x03, 0x04, 0x00, 0xA0, 0xC0, 0x24, 0x0C, 0x18, 0x80,
  0x7C, 0x00, 0xFC, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x82, 0x00, 0x10,
  0x40, 0x02, 0x08, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x20, 0x80, 0x04, 0x20, 0x01, 0x04,
  0x00, 0x20, 0x80, 0x08, 0x10, 0x03, 0x02, 0x00, 0x40, 0x40, 0x10, 0x08,
  0x0C, 0x02, 0x03, 0x00, 0x43, 0x80, 0x0F, 0x80, 0x00, 0x10, 0x08, 0x08,
  0x40, 0x20, 0x21, 0x00, 0x80, 0x84, 0x02, 0x02, 0x20, 0x08, 0x04, 0x80,
  0x20, 0x12, 0x01, 0x00, 0x48, 0x04, 0x01, 0x20, 0x10, 0x04, 0x80, 0x40,
  0x14, 0x01, 0x00, 0x50, 0x04, 0x01, 0x40, 0x20, 0x05, 0x00, 0x80, 0x14,
  0x02, 0x00, 0x90, 0x08, 0x02, 0x80, 0x20, 0x0A, 0x01, 0x80, 0x28, 0x06,
  0x01, 0x20, 0x18, 0x04, 0x80, 0xA0, 0x23, 0x06, 0x81, 0x04, 0x31, 0x0C,
  0x0F, 0x03, 0xC0, 0x00, 0xC0, 0x3C, 0x01, 0x90, 0x21, 0x83, 0x04, 0x20,
  0x46, 0x02, 0x20, 0x24, 0x01, 0x20, 0x08, 0x00, 0x50, 0x04, 0x00, 0x30,
  0x02, 0x00, 0x18, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x80, 0x28, 0x00, 0x40, 0x14, 0x00, 0x20,
  0x0A, 0x00, 0x10, 0x09, 0x00, 0x48, 0x04, 0x40, 0xC2, 0x04, 0x21, 0x81,
  0x8C, 0x1B, 0x00, 0x78, 0x07, 0x00, 0x04, 0x00, 0x18, 0x20, 0x00, 0x81,
  0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00,
  0x81, 0x00, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x08, 0x20,
  0x00, 0x41, 0x00, 0x04, 0x08, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08,
  0x20, 0x00, 0x41, 0x00, 0x06, 0x08, 0x00, 0x60, 0x20, 0x03, 0x01, 0x00,
  0x28, 0x0C, 0x02, 0x40, 0x30, 0x62, 0x00, 0x7C, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x08, 0x00, 0x60, 0x60, 0x06,
  0x00, 0x80, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x04, 0x10, 0x3C, 0x10,
  0x80, 0x1E, 0x84, 0x00, 0x0E, 0x10, 0x00, 0x10, 0x40, 0x00, 0x81, 0x00,
  0x04, 0x04, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x10, 0x04, 0x00, 0x40, 0x20, 0x00, 0x81, 0x00, 0x02, 0x18, 0x00,
  0x08, 0x5C, 0x00, 0x21, 0x0F, 0x80, 0x88, 0x01, 0xF2, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xF0, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x0F,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x02, 0x10, 0x80, 0x08, 0x40, 0x80, 0x11,
  0x00, 0x80, 0x22, 0x01, 0x80, 0x88, 0x01, 0x02, 0x10, 0x01, 0x88, 0x40,
  0x01, 0xE0,
};

const GFXglyph IBMPlexMono_ThinItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 31, 26, 10, -31 },
  { 29, 8, 11, 26, 12, -33 },
  { 40, 26, 31, 26, 1, -31 },
  { 141, 23, 40, 26, 2, -35 },
  { 256, 29, 32, 26, -1, -31 },
  { 372, 25, 32, 26, 1, -31 },
  { 472, 3, 11, 26, 14, -33 },
  { 477, 14, 39, 26, 10, -33 },
  { 546, 14, 39, 26, 3, -33 },
  { 615, 22, 22, 26, 3, -24 },
  { 676, 21, 21, 26, 3, -24 },
  { 732, 6, 11, 26, 7, -3 },
  { 741, 11, 1, 26, 8, -14 },
  { 743, 3, 3, 26, 10, -3 },
  { 745, 23, 39, 26, 2, -33 },
  { 858, 21, 32, 26, 3, -31 },
  { 942, 20, 31, 26, 2, -31 },
  { 1020, 21, 31, 26, 2, -31 },
  { 1102, 21, 32, 26, 2, -31 },
  { 1186, 23, 31, 26, 1, -31 },
  { 1276, 21, 32, 26, 3, -31 },
  { 1360, 18, 32, 26, 4, -31 },
  { 1432, 21, 31, 26, 5, -31 },
  { 1514, 21, 32, 26, 3, -31 },
  { 1598, 19, 31, 26, 5, -31 },
  { 1672, 6, 23, 26, 10, -23 },
  { 1690, 9, 31, 26, 7, -23 },
  { 1725, 21, 24, 26, 4, -25 },
  { 1788, 23, 9, 26, 2, -18 },
  { 1814, 21, 24, 26, 2, -25 },
  { 1877, 17, 31, 26, 7, -31 },
  { 1943, 20, 36, 26, 4, -31 },
  { 2033, 22, 31, 26, 0, -31 },
  { 2119, 20, 31, 26, 3, -31 },
  { 2197, 21, 32, 26, 4, -31 },
  { 2281, 21, 31, 26, 3, -31 },
  { 2363, 23, 31, 26, 3, -31 },
  { 2453, 23, 31, 26, 3, -31 },
  { 2543, 21, 32, 26, 4, -31 },
  { 2627, 23, 31, 26, 2, -31 },
  { 2717, 24, 31, 26, 2, -31 },
  { 2810, 21, 32, 26, 3, -31 },
  { 2894, 24, 31, 26, 3, -31 },
  { 2987, 16, 31, 26, 5, -31 },
  { 3049, 24, 31, 26, 2, -31 },
  { 3142, 23, 31, 26, 2, -31 },
  { 3232, 21, 32, 26, 3, -31 },
  { 3316, 22, 31, 26, 3, -31 },
  { 3402, 21, 39, 26, 3, -31 },
  { 3505, 22, 31, 26, 3, -31 },
  { 3591, 23, 32, 26, 2, -31 },
  { 3683, 23, 31, 26, 5, -31 },
  { 3773, 21, 32, 26, 4, -31 },
  { 3857, 21, 31, 26, 6, -31 },
  { 3939, 23, 31, 26, 4, -31 },
  { 4029, 27, 31, 26, 0, -31 },
  { 4134, 24, 31, 26, 4, -31 },
  { 4227, 27, 31, 26, 0, -31 },
  { 4332, 17, 39, 26, 9, -33 },
  { 4415, 10, 39, 26, 9, -33 },
  { 4464, 17, 39, 26, 1, -33 },
  { 4547, 20, 17, 26, 4, -31 },
  { 4590, 21, 1, 26, 0, 5 },
  { 4593, 4, 7, 26, 11, -33 },
  { 4597, 20, 24, 26, 3, -23 },
  { 4657, 19, 34, 26, 4, -33 },
  { 4738, 18, 24, 26, 4, -23 },
  { 4792, 21, 34, 26, 3, -33 },
  { 4882, 18, 24, 26, 4, -23 },
  { 4936, 27, 42, 26, 0, -33 },
  { 5078, 21, 32, 26, 2, -23 },
  { 5162, 18, 33, 26, 4, -33 },
  { 5237, 18, 34, 26, 4, -33 },
  { 5314, 18, 42, 26, 5, -33 },
  { 5409, 22, 34, 26, 3, -33 },
  { 5503, 17, 34, 26, 5, -33 },
  { 5576, 23, 23, 26, 2, -23 },
  { 5643, 18, 23, 26, 4, -23 },
  { 5695, 19, 24, 26, 4, -23 },
  { 5752, 21, 32, 26, 2, -23 },
  { 5836, 20, 32, 26, 3, -23 },
  { 5916, 21, 23, 26, 5, -23 },
  { 5977, 20, 24, 26, 3, -23 },
  { 6037, 22, 32, 26, 3, -31 },
  { 6125, 19, 24, 26, 4, -23 },
  { 6182, 19, 23, 26, 4, -23 },
  { 6237, 22, 24, 26, 3, -23 },
  { 6303, 25, 24, 26, 1, -23 },
  { 6378, 21, 32, 26, 2, -23 },
  { 6462, 22, 24, 26, 2, -23 },
  { 6528, 20, 39, 26, 5, -33 },
  { 6626, 7, 39, 26, 10, -33 },
  { 6661, 20, 39, 26, 2, -33 },
  { 6759, 23, 8, 26, 2, -17 },
};

const GFXfont IBMPlexMono_ThinItalic44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_THINITALIC44PT7B_H_
