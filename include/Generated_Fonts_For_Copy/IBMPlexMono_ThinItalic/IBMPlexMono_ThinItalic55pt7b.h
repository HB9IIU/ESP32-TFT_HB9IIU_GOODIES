#ifndef _IBMPLEXMONO_THINITALIC55PT7B_H_
#define _IBMPLEXMONO_THINITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x07, 0x80, 0x10, 0x26, 0x04, 0xC1,
  0x90, 0x32, 0x06, 0x40, 0x88, 0x13, 0x02, 0x60, 0xC8, 0x19, 0x03, 0x20,
  0x44, 0x09, 0x81, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x20, 0x08,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x08, 0x02,
  0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x40, 0x10, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x00, 0x30, 0x08, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x00, 0xC0, 0x20, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x20, 0x18, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x04, 0x70, 0x00, 0xC0,
  0x60, 0x60, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x10, 0x06, 0x04, 0x00, 0x80,
  0x10, 0x60, 0x04, 0x00, 0x02, 0x00, 0x20, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x04, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00, 0x01, 0x00,
  0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x39, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x9E, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x01, 0x00, 0x80, 0x00, 0x08, 0x02, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x20, 0x02, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x30, 0x02, 0x10, 0x01, 0x00, 0x10, 0xC0, 0x08, 0x01, 0x03, 0x00, 0x40,
  0x18, 0x0C, 0x02, 0x01, 0x80, 0x30, 0x10, 0x18, 0x00, 0x71, 0x87, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0x06, 0x00, 0x01, 0x00,
  0xC0, 0x30, 0x00, 0x20, 0x08, 0x01, 0x00, 0x06, 0x01, 0x00, 0x18, 0x00,
  0x40, 0x30, 0x00, 0x80, 0x08, 0x02, 0x00, 0x08, 0x01, 0x00, 0x20, 0x00,
  0x80, 0x30, 0x02, 0x00, 0x08, 0x02, 0x00, 0x60, 0x01, 0x80, 0x40, 0x04,
  0x00, 0x10, 0x08, 0x00, 0x40, 0x01, 0x01, 0x00, 0x06, 0x00, 0x10, 0x30,
  0x00, 0x20, 0x02, 0x02, 0x00, 0x02, 0x00, 0x60, 0x40, 0x00, 0x10, 0x0C,
  0x08, 0x00, 0x01, 0x81, 0x81, 0x80, 0x00, 0x07, 0xE0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x03, 0xE0, 0x00, 0x00, 0x80,
  0xC1, 0x80, 0x00, 0x10, 0x10, 0x04, 0x00, 0x03, 0x02, 0x00, 0x60, 0x00,
  0x20, 0x60, 0x02, 0x00, 0x04, 0x04, 0x00, 0x20, 0x00, 0x80, 0xC0, 0x02,
  0x00, 0x18, 0x08, 0x00, 0x20, 0x01, 0x00, 0x80, 0x02, 0x00, 0x20, 0x08,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x02, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x08,
  0x00, 0x80, 0x04, 0x01, 0x00, 0x08, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x08,
  0x06, 0x00, 0x04, 0x01, 0x00, 0x40, 0x00, 0x30, 0x60, 0x08, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x80,
  0x10, 0x00, 0x02, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x18, 0x00, 0x60, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x20, 0x01, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x01, 0xC0, 0x40, 0x00, 0x1C, 0x47, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x20, 0x01, 0x00, 0x00, 0x40,
  0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x06, 0x00, 0x10, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0x18, 0x01, 0x80, 0x00, 0x28, 0x07, 0x00, 0x00,
  0x98, 0x0B, 0x00, 0x01, 0x10, 0x22, 0x00, 0x04, 0x10, 0x46, 0x00, 0x18,
  0x31, 0x06, 0x00, 0x60, 0x26, 0x07, 0x03, 0x00, 0x68, 0x03, 0xF8, 0x00,
  0x60, 0x32, 0x22, 0x26, 0x64, 0x44, 0x4C, 0xC8, 0x00, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x03, 0x00, 0x10, 0x01, 0x9C, 0x02, 0x03, 0xC0, 0x70,
  0x43, 0xC0, 0x01, 0xDF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x10, 0x08, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x20, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x18, 0x30, 0xC1, 0x82, 0x0C,
  0x10, 0x60, 0x81, 0x04, 0x08, 0x00, 0xFF, 0xFC, 0x77, 0xF0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x04, 0x01, 0x00, 0x01, 0x80, 0x80, 0x00, 0x20, 0x40, 0x00, 0x08, 0x30,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04,
  0x40, 0x00, 0x01, 0x30, 0x00, 0x00, 0x48, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x50, 0x00, 0x00, 0x14, 0x00,
  0xE0, 0x05, 0x00, 0x38, 0x01, 0x40, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x12, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18, 0x40, 0x00, 0x04, 0x10,
  0x00, 0x02, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x00, 0x60, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x84, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x82, 0x00, 0x03, 0x01, 0x00, 0x03, 0x00, 0x80, 0x03,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0x60, 0x08,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x06, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x20, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x18,
  0x00, 0xE0, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x08, 0x10, 0x00, 0x01, 0x81, 0x00, 0x00, 0x30,
  0x10, 0x00, 0x06, 0x01, 0x00, 0x00, 0x40, 0x30, 0x00, 0x08, 0x02, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x20, 0x02, 0x00, 0x04, 0x00, 0x20, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x04, 0x00, 0x60, 0x00, 0x40,
  0x04, 0x00, 0x04, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x04, 0x02, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x3F, 0xC0, 0x00, 0x98, 0x07, 0x00, 0x24, 0x00, 0x30,
  0x05, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x30, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x03,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x3F, 0xC0, 0x19, 0xC0, 0x70, 0x13,
  0x00, 0x18, 0x14, 0x00, 0x04, 0x28, 0x00, 0x06, 0x30, 0x00, 0x02, 0x50,
  0x00, 0x03, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40,
  0x00, 0x0C, 0x20, 0x00, 0x18, 0x30, 0x00, 0x30, 0x18, 0x00, 0x60, 0x06,
  0x03, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xA0, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x10, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x00, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x40, 0x00, 0x60, 0x10, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x10, 0x10, 0x00, 0x04, 0x03, 0x00,
  0x01, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x1F, 0xF0, 0x00,
  0x1C, 0x03, 0x80, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x08, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x88, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x70,
  0x01, 0xC0, 0x38, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xC0,
  0x60, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x30, 0x00,
  0x02, 0x20, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x40, 0x00,
  0x0C, 0x40, 0x00, 0x14, 0x20, 0x00, 0x34, 0x10, 0x00, 0xC8, 0x0E, 0x03,
  0x88, 0x03, 0xFC, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x70, 0xF0, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x03, 0x06,
  0x00, 0x04, 0x30, 0x00, 0x08, 0x80, 0x00, 0x24, 0x00, 0x00, 0xD0, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x01, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x04,
  0x01, 0x80, 0x02, 0x01, 0x00, 0x03, 0x02, 0x00, 0x01, 0x06, 0x00, 0x01,
  0x04, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01,
  0x10, 0x00, 0x01, 0x10, 0x03, 0xE1, 0x10, 0x0C, 0x19, 0x20, 0x10, 0x05,
  0x20, 0x20, 0x05, 0x20, 0x20, 0x03, 0x60, 0x40, 0x02, 0x40, 0x40, 0x02,
  0x40, 0xC0, 0x02, 0x40, 0x80, 0x02, 0x40, 0x80, 0x02, 0x40, 0x80, 0x06,
  0xC0, 0x80, 0x04, 0x81, 0x80, 0x04, 0x81, 0x80, 0x04, 0x81, 0x00, 0x04,
  0x81, 0x00, 0x0C, 0x81, 0x80, 0x0C, 0x80, 0x80, 0x18, 0x80, 0x80, 0x38,
  0x80, 0xC0, 0x28, 0x80, 0x60, 0xC8, 0x80, 0x3F, 0x88, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x64, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x10, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x80, 0x10, 0x00, 0x18, 0x01, 0x00, 0x01, 0x00, 0x10, 0x00, 0x30, 0x01,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x04, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x80, 0x08, 0x00, 0x08, 0x01, 0xFF, 0xFF, 0x80, 0x10, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x06, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x22, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x01, 0xFF, 0xF8, 0x00, 0xC0,
  0x01, 0x80, 0x20, 0x00, 0x18, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00, 0x01, 0x04, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x04, 0x08,
  0x00, 0x06, 0x02, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x70,
  0x10, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x22, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x66, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x04, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x00, 0x60, 0x02, 0x00, 0x0C,
  0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x20, 0x40, 0x00, 0x08, 0x30, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00,
  0x02, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x00, 0x60, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x80, 0x0E, 0x00, 0x20, 0x00, 0x40, 0x18, 0x00, 0x08, 0x04, 0x00,
  0x01, 0x01, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x11, 0x80, 0x00, 0x04, 0x60, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x44, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x01, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x04, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x04, 0x08,
  0x00, 0x02, 0x02, 0x00, 0x03, 0x00, 0x80, 0x03, 0x80, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0C, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x20, 0x40, 0x00, 0x08, 0x20, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xF2, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x04, 0x00,
  0x01, 0xC0, 0x80, 0x00, 0xA0, 0x30, 0x00, 0x68, 0x06, 0x00, 0x32, 0x00,
  0xE0, 0x30, 0x80, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x07,
  0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x40, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x20, 0x40, 0x00, 0x10, 0x10, 0x00, 0x10, 0x08, 0x00, 0x10, 0x03, 0x00,
  0x10, 0x00, 0xE0, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x40, 0x20, 0x00, 0x02, 0x01, 0x80, 0x00, 0x10, 0x04,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x60, 0x01, 0x00,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x06,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x08, 0x01, 0x80, 0x00, 0x20, 0x08, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x06, 0x02, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x41, 0xA0, 0x00, 0x01, 0x0C, 0xC0, 0x00, 0x04, 0x61, 0x00, 0x00, 0x33,
  0x06, 0x00, 0x00, 0xD8, 0x08, 0x00, 0x02, 0xC0, 0x10, 0x00, 0x0E, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x80, 0x00, 0x80, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x40, 0x00, 0x20, 0x01, 0x00, 0x00, 0x80,
  0x04, 0x00, 0x01, 0x00, 0x10, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x08, 0x03,
  0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x50, 0x28, 0x00, 0x01, 0x40, 0xA0,
  0x00, 0x09, 0x02, 0x40, 0x00, 0x2C, 0x09, 0x00, 0x01, 0x20, 0x24, 0x00,
  0x08, 0x81, 0x98, 0x00, 0x22, 0x04, 0x20, 0x01, 0x08, 0x10, 0x80, 0x0C,
  0x20, 0x42, 0x00, 0x21, 0x81, 0x04, 0x01, 0x04, 0x04, 0x10, 0x04, 0x10,
  0x30, 0x40, 0x20, 0x40, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x20, 0x30, 0x20, 0x31, 0x80, 0x80, 0x80, 0x44, 0x02, 0x06, 0x01,
  0x20, 0x08, 0x10, 0x05, 0x80, 0x20, 0x40, 0x0C, 0x00, 0x81, 0x00, 0x20,
  0x06, 0x04, 0x00, 0x80, 0x10, 0x10, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x14, 0x00, 0x00, 0x80, 0xA0, 0x00, 0x04, 0x05, 0x00, 0x00,
  0x20, 0x24, 0x00, 0x01, 0x03, 0x20, 0x00, 0x08, 0x19, 0x80, 0x00, 0xC0,
  0x84, 0x00, 0x04, 0x04, 0x20, 0x00, 0x20, 0x21, 0x80, 0x01, 0x01, 0x04,
  0x00, 0x08, 0x18, 0x20, 0x00, 0x40, 0x81, 0x80, 0x06, 0x04, 0x04, 0x00,
  0x20, 0x20, 0x20, 0x01, 0x01, 0x01, 0x80, 0x08, 0x08, 0x04, 0x00, 0x40,
  0xC0, 0x20, 0x02, 0x04, 0x00, 0x80, 0x30, 0x20, 0x04, 0x01, 0x01, 0x00,
  0x20, 0x08, 0x08, 0x00, 0x80, 0x40, 0x40, 0x04, 0x02, 0x06, 0x00, 0x30,
  0x10, 0x20, 0x00, 0x81, 0x81, 0x00, 0x04, 0x08, 0x08, 0x00, 0x30, 0x40,
  0x40, 0x00, 0x82, 0x02, 0x00, 0x04, 0x10, 0x30, 0x00, 0x31, 0x81, 0x00,
  0x00, 0x8C, 0x08, 0x00, 0x04, 0x40, 0x40, 0x00, 0x32, 0x02, 0x00, 0x00,
  0x90, 0x10, 0x00, 0x04, 0x81, 0x80, 0x00, 0x1C, 0x08, 0x00, 0x00, 0xE0,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x04, 0x01, 0x00, 0x01, 0x80, 0x80, 0x00, 0x20,
  0x40, 0x00, 0x08, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x04, 0x40, 0x00, 0x01, 0x30, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x12, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x04, 0x10, 0x00, 0x02, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x60, 0x30, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x02,
  0x03, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x10, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x30, 0x0F, 0xFF, 0xF8, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x04,
  0x01, 0x00, 0x01, 0x80, 0x80, 0x00, 0x20, 0x40, 0x00, 0x08, 0x30, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x48, 0x00, 0x00, 0x12, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x50, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x05, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00,
  0x02, 0x06, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x00, 0x60, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x40, 0x00, 0x80, 0x30, 0x00, 0x10, 0x10, 0x00, 0x06,
  0x08, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x16, 0x00, 0x00, 0x03, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x30, 0x0F, 0xFF, 0xF8, 0x03, 0x00, 0x40, 0x00, 0x60, 0x0C,
  0x00, 0x08, 0x00, 0x80, 0x01, 0x00, 0x18, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0x40, 0x04, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x80, 0x10, 0x00, 0x08, 0x02, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x02, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04,
  0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x06, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x00, 0x08, 0x20, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x30, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x86, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x02, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x20, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x44, 0x00, 0x00, 0x18, 0x80, 0x00, 0x02, 0x10,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x60, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x30, 0x10, 0x00, 0x04, 0x02, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x20, 0x0C, 0x00, 0x0C, 0x00, 0x80, 0x01, 0x00, 0x10, 0x00, 0x60,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01, 0x80,
  0x18, 0x00, 0x10, 0x02, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x40, 0x10, 0x00,
  0x08, 0x06, 0x00, 0x01, 0x00, 0x80, 0x00, 0x30, 0x30, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x48, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x61, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x10, 0xC0, 0x08, 0x00, 0x84, 0x00, 0xC0, 0x0C, 0x20,
  0x07, 0x00, 0x41, 0x00, 0x68, 0x02, 0x08, 0x02, 0x40, 0x10, 0x40, 0x32,
  0x01, 0x02, 0x01, 0x10, 0x08, 0x10, 0x18, 0x80, 0x40, 0x80, 0x84, 0x06,
  0x04, 0x04, 0x20, 0x20, 0x20, 0x41, 0x81, 0x01, 0x02, 0x04, 0x08, 0x08,
  0x20, 0x20, 0xC0, 0xC1, 0x01, 0x04, 0x06, 0x10, 0x08, 0x20, 0x30, 0x80,
  0x41, 0x01, 0x0C, 0x02, 0x18, 0x08, 0x40, 0x18, 0x80, 0x46, 0x00, 0x44,
  0x02, 0x20, 0x02, 0x20, 0x13, 0x00, 0x12, 0x00, 0x90, 0x00, 0x90, 0x04,
  0x80, 0x04, 0x80, 0x28, 0x00, 0x2C, 0x01, 0x40, 0x01, 0x40, 0x0C, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x60, 0x00, 0x02, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x04,
  0x60, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x03, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x40, 0x08, 0x00, 0x06, 0x00, 0x40, 0x00, 0x60,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x20, 0x02, 0x00, 0x01,
  0x00, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0x98, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x83, 0x00, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x40, 0x00,
  0xC0, 0x10, 0x00, 0x40, 0x08, 0x00, 0x40, 0x02, 0x00, 0x40, 0x01, 0x00,
  0x60, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x20, 0x00, 0x10, 0x20, 0x00, 0x04,
  0x30, 0x00, 0x02, 0x10, 0x00, 0x00, 0x90, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0x06, 0x08, 0x10,
  0x40, 0x83, 0x04, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x30, 0xC0, 0xC0, 0x04,
  0x40, 0xC0, 0x01, 0x20, 0xC0, 0x00, 0x50, 0xC0, 0x00, 0x28, 0x40, 0x00,
  0x0C, 0x60, 0x00, 0x04, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x66, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20,
  0x00, 0x03, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x50, 0x40, 0x00, 0x38, 0x30, 0x00, 0x28,
  0x08, 0x00, 0x24, 0x02, 0x00, 0x22, 0x00, 0xC0, 0x61, 0xF8, 0x1F, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0xFE, 0x00, 0x21, 0x80, 0xC0, 0x11, 0x00, 0x30,
  0x09, 0x00, 0x04, 0x0D, 0x00, 0x03, 0x07, 0x00, 0x00, 0x82, 0x80, 0x00,
  0x41, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x60, 0x00,
  0x02, 0x30, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x18,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x85, 0x00, 0x00, 0x82, 0x80, 0x00, 0xC1,
  0x20, 0x00, 0xC0, 0x88, 0x00, 0xC0, 0xC3, 0x01, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0x03, 0x80, 0x30, 0x03, 0x01, 0x00, 0x02,
  0x08, 0x00, 0x0C, 0x40, 0x00, 0x13, 0x00, 0x00, 0x88, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xB0, 0x00, 0x04, 0x40, 0x00, 0x31, 0x80, 0x01,
  0x82, 0x00, 0x0C, 0x04, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x03, 0xF8, 0x18, 0x01, 0x80, 0xC2, 0x00,
  0xC0, 0x04, 0x40, 0x30, 0x00, 0x48, 0x0C, 0x00, 0x05, 0x03, 0x00, 0x00,
  0xA0, 0x40, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x08, 0x20, 0x00, 0x03, 0x04, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x08, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x14, 0x04, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xA0, 0x08, 0x00, 0x24, 0x00,
  0x80, 0x08, 0x80, 0x0C, 0x06, 0x10, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x20, 0x80, 0x00,
  0x43, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x90, 0x00, 0x03, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x09, 0x00, 0x00, 0x34, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x10,
  0x00, 0x70, 0x20, 0x1F, 0x00, 0x7F, 0x80, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x01, 0xA0, 0x00, 0x02, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x10, 0xC0, 0x00,
  0x40, 0xC0, 0x01, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x70, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x08, 0x00, 0x00, 0x70, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x0C, 0x30,
  0x18, 0x00, 0x88, 0x0C, 0x00, 0x12, 0x06, 0x00, 0x02, 0x83, 0x00, 0x00,
  0xA0, 0x80, 0x00, 0x18, 0x60, 0x00, 0x04, 0x10, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x04, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x50, 0x20,
  0x00, 0x1C, 0x0C, 0x00, 0x0A, 0x01, 0x00, 0x04, 0x80, 0x20, 0x02, 0x20,
  0x06, 0x03, 0x08, 0x00, 0x7F, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x20, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x1F, 0xC0, 0x31, 0xC0, 0xC0, 0x88, 0x01,
  0x82, 0x40, 0x02, 0x0A, 0x00, 0x04, 0x28, 0x00, 0x10, 0xC0, 0x00, 0x46,
  0x00, 0x01, 0x18, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00,
  0x01, 0x10, 0x00, 0x04, 0xC0, 0x00, 0x12, 0x00, 0x00, 0xC8, 0x00, 0x02,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x98, 0x00, 0x02, 0x40,
  0x00, 0x19, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00,
  0x13, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x20,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x01, 0x00, 0x80, 0x0C, 0x01,
  0x00, 0x20, 0x06, 0x01, 0x80, 0x08, 0x04, 0x00, 0x10, 0x30, 0x00, 0x20,
  0x80, 0x00, 0x46, 0x00, 0x01, 0x98, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x02, 0x00, 0x08, 0x02, 0x00, 0x10, 0x03, 0x00, 0x60, 0x03, 0x00,
  0x80, 0x03, 0x01, 0x00, 0x03, 0x02, 0x00, 0x03, 0x04, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x30, 0x00, 0x01, 0x40, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x07, 0xF0, 0x00, 0x43, 0x81, 0xC0, 0x04,
  0x40, 0x06, 0x00, 0x48, 0x00, 0x20, 0x0D, 0x00, 0x03, 0x00, 0xA0, 0x00,
  0x10, 0x0C, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x08, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x20, 0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x18, 0x01, 0x00, 0x02, 0x00, 0x10, 0x01, 0xC0, 0x01, 0x00, 0x60, 0x00,
  0x30, 0x78, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x32, 0x01, 0x80, 0x06, 0x60, 0x08, 0x00,
  0xC4, 0x00, 0x40, 0x10, 0x40, 0x04, 0x02, 0x04, 0x00, 0x20, 0x40, 0x40,
  0x03, 0x08, 0x04, 0x00, 0x11, 0x00, 0xC0, 0x01, 0xA0, 0x00, 0x00, 0x0C,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x01, 0x06, 0x00, 0x20,
  0x40, 0x0C, 0x04, 0x01, 0x00, 0x40, 0x60, 0x04, 0x08, 0x00, 0xC3, 0x00,
  0x08, 0x40, 0x00, 0x98, 0x00, 0x0B, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x26, 0x18, 0x61, 0x81, 0x40, 0x64, 0x04, 0x0C, 0x01, 0x40,
  0x10, 0xE0, 0x0E, 0x00, 0x86, 0x00, 0x60, 0x04, 0x30, 0x02, 0x00, 0x21,
  0x00, 0x10, 0x01, 0x08, 0x00, 0x80, 0x08, 0x40, 0x0C, 0x00, 0xC6, 0x00,
  0x40, 0x04, 0x20, 0x02, 0x00, 0x21, 0x00, 0x10, 0x01, 0x08, 0x00, 0x80,
  0x08, 0x40, 0x04, 0x00, 0x42, 0x00, 0x60, 0x06, 0x30, 0x02, 0x00, 0x21,
  0x00, 0x10, 0x01, 0x08, 0x00, 0x80, 0x08, 0x40, 0x04, 0x00, 0x42, 0x00,
  0x20, 0x02, 0x10, 0x03, 0x00, 0x31, 0x80, 0x10, 0x01, 0x08, 0x00, 0x80,
  0x08, 0x40, 0x04, 0x00, 0x42, 0x00, 0x20, 0x02, 0x10, 0x01, 0x00, 0x10,
  0x80, 0x18, 0x01, 0x8C, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x1F, 0xC0, 0x31,
  0xC0, 0xC0, 0x88, 0x01, 0x82, 0x40, 0x02, 0x0A, 0x00, 0x04, 0x28, 0x00,
  0x10, 0xC0, 0x00, 0x46, 0x00, 0x01, 0x18, 0x00, 0x04, 0x40, 0x00, 0x11,
  0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0xC0, 0x00, 0x12, 0x00,
  0x00, 0xC8, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00,
  0x98, 0x00, 0x02, 0x40, 0x00, 0x19, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10,
  0x00, 0x04, 0x40, 0x00, 0x13, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00,
  0x08, 0x80, 0x00, 0x20, 0x00, 0x3F, 0x80, 0x03, 0x80, 0xC0, 0x0C, 0x00,
  0x40, 0x20, 0x00, 0x40, 0x80, 0x00, 0x42, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x90, 0x00, 0x01, 0x60, 0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x40, 0x00,
  0x0C, 0x40, 0x00, 0x10, 0x80, 0x00, 0x40, 0x80, 0x01, 0x00, 0x80, 0x04,
  0x00, 0xC0, 0x70, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x86,
  0x03, 0x00, 0x22, 0x00, 0x60, 0x09, 0x00, 0x04, 0x02, 0x80, 0x01, 0x81,
  0xC0, 0x00, 0x20, 0x50, 0x00, 0x08, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x30, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03, 0x08,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x08, 0x28, 0x00, 0x04, 0x0A, 0x00, 0x03, 0x02, 0x40, 0x01, 0x80, 0x88,
  0x00, 0xC0, 0x61, 0x80, 0xC0, 0x18, 0x1F, 0xC0, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x30, 0xC0,
  0xC0, 0x04, 0x40, 0xC0, 0x01, 0x20, 0xC0, 0x00, 0x50, 0xC0, 0x00, 0x28,
  0x40, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x20, 0x00, 0x02, 0x30, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x11, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04, 0x40, 0x00,
  0x02, 0x20, 0x00, 0x03, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x60, 0x80, 0x00, 0x50, 0x40, 0x00, 0x38, 0x30,
  0x00, 0x28, 0x08, 0x00, 0x24, 0x02, 0x00, 0x22, 0x00, 0xC0, 0x61, 0x00,
  0x1F, 0xC0, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xE0,
  0xFF, 0xC0, 0x11, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x38, 0x07, 0x00,
  0x18, 0x00, 0x30, 0x08, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x40, 0x60, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x10, 0x01, 0x00, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x04, 0x00, 0x80, 0x00, 0x80, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x04, 0x40, 0x00,
  0x13, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22,
  0x00, 0x00, 0x88, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x64, 0x00,
  0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x4C, 0x00, 0x01,
  0x20, 0x00, 0x0C, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20,
  0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x20, 0x00,
  0x50, 0x80, 0x01, 0x43, 0x00, 0x09, 0x06, 0x00, 0x44, 0x0C, 0x0E, 0x30,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x02, 0xFF, 0x00, 0x03, 0x01, 0x00, 0x01,
  0x03, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01,
  0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x06, 0x00, 0x01, 0x04, 0x00, 0x01,
  0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02,
  0x04, 0x00, 0x04, 0x0C, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x08,
  0x08, 0x00, 0x10, 0x08, 0x00, 0x30, 0x08, 0x00, 0x20, 0x08, 0x00, 0x40,
  0x18, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x06, 0x00, 0x10, 0x18, 0x00,
  0x10, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x30,
  0x08, 0x60, 0x04, 0x01, 0x0C, 0x00, 0x80, 0x21, 0x00, 0x10, 0x06, 0x20,
  0x02, 0x00, 0x44, 0x00, 0xC0, 0x08, 0x80, 0x10, 0x01, 0x30, 0x02, 0x00,
  0x26, 0x00, 0x40, 0x04, 0x80, 0x08, 0x00, 0x90, 0x01, 0x00, 0x12, 0x00,
  0x60, 0x02, 0x40, 0x08, 0x00, 0x58, 0x01, 0x00, 0x0A, 0x00, 0x20, 0x01,
  0x40, 0x04, 0x00, 0x28, 0x00, 0x80, 0x0D, 0x00, 0x30, 0x01, 0x20, 0x04,
  0x00, 0x2C, 0x00, 0x80, 0x05, 0x00, 0x10, 0x01, 0xA0, 0x02, 0x00, 0x24,
  0x00, 0xC0, 0x04, 0x80, 0x28, 0x01, 0x10, 0x05, 0x00, 0x62, 0x01, 0x20,
  0x08, 0x20, 0x22, 0x02, 0x06, 0x18, 0x61, 0x80, 0x7C, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x01, 0xF0, 0x01, 0xC8, 0x04, 0x18, 0x0E, 0x18, 0x10, 0x10,
  0x60, 0x10, 0x40, 0x33, 0x00, 0x21, 0x00, 0x20, 0x00, 0x26, 0x00, 0x40,
  0x00, 0x48, 0x00, 0x80, 0x00, 0x90, 0x01, 0x00, 0x01, 0x40, 0x02, 0x00,
  0x02, 0x80, 0x04, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x04, 0x00, 0x50, 0x00, 0x18, 0x00, 0xA0,
  0x00, 0x30, 0x01, 0x40, 0x00, 0x40, 0x04, 0x80, 0x00, 0x80, 0x08, 0x80,
  0x09, 0x80, 0x21, 0x00, 0x69, 0x00, 0xC3, 0x03, 0x82, 0x03, 0x02, 0x1C,
  0x03, 0x0C, 0x06, 0x60, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x10, 0x30, 0x00, 0x04, 0x08, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x20, 0x20, 0x00, 0x08, 0x08, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x10, 0x10, 0x00, 0x04,
  0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x20, 0x00,
  0x0C, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x20,
  0x00, 0x08, 0x08, 0x00, 0x06, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC0,
  0x20, 0x00, 0x50, 0x08, 0x00, 0x14, 0x03, 0x00, 0x09, 0x00, 0x60, 0x04,
  0x40, 0x0C, 0x0E, 0x30, 0x00, 0xFE, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x60,
  0x70, 0x0C, 0x10, 0x01, 0x81, 0x04, 0x00, 0x0E, 0x20, 0x80, 0x00, 0x34,
  0x30, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x10, 0x00,
  0x0C, 0x02, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x30, 0x00, 0x40, 0x0C, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x10, 0x60, 0x00, 0x02, 0x0F, 0x00, 0x00, 0x43, 0x1F,
  0x00, 0x08, 0x40, 0x0F, 0x01, 0x88, 0x00, 0x1F, 0x10, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x10, 0xC3, 0x00, 0x03, 0x18,
  0x18, 0x00, 0x23, 0x00, 0xC0, 0x06, 0x20, 0x06, 0x00, 0x46, 0x00, 0x20,
  0x08, 0x40, 0x01, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x80, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 9, 38, 33, 12, -38 },
  { 44, 11, 14, 33, 14, -41 },
  { 64, 33, 38, 33, 1, -38 },
  { 221, 29, 52, 33, 2, -45 },
  { 410, 36, 40, 33, -1, -39 },
  { 590, 31, 40, 33, 1, -39 },
  { 745, 4, 14, 33, 18, -41 },
  { 752, 17, 50, 33, 13, -42 },
  { 859, 17, 50, 33, 4, -42 },
  { 966, 27, 27, 33, 4, -30 },
  { 1058, 26, 27, 33, 4, -30 },
  { 1146, 7, 13, 33, 9, -4 },
  { 1158, 14, 1, 33, 10, -17 },
  { 1160, 4, 3, 33, 12, -3 },
  { 1162, 29, 50, 33, 2, -42 },
  { 1344, 26, 40, 33, 4, -39 },
  { 1474, 25, 38, 33, 3, -38 },
  { 1593, 27, 39, 33, 2, -39 },
  { 1725, 26, 40, 33, 3, -39 },
  { 1855, 28, 38, 33, 2, -38 },
  { 1988, 27, 39, 33, 3, -38 },
  { 2120, 24, 39, 33, 4, -38 },
  { 2237, 25, 38, 33, 7, -38 },
  { 2356, 27, 40, 33, 3, -39 },
  { 2491, 24, 39, 33, 6, -39 },
  { 2608, 8, 29, 33, 12, -29 },
  { 2637, 11, 38, 33, 9, -29 },
  { 2690, 26, 29, 33, 5, -31 },
  { 2785, 28, 11, 33, 3, -22 },
  { 2824, 26, 29, 33, 3, -31 },
  { 2919, 22, 39, 33, 8, -39 },
  { 3027, 24, 45, 33, 5, -39 },
  { 3162, 28, 38, 33, 0, -38 },
  { 3295, 26, 38, 33, 3, -38 },
  { 3419, 26, 40, 33, 5, -39 },
  { 3549, 26, 38, 33, 4, -38 },
  { 3673, 28, 38, 33, 4, -38 },
  { 3806, 29, 38, 33, 4, -38 },
  { 3944, 26, 40, 33, 5, -39 },
  { 4074, 29, 38, 33, 3, -38 },
  { 4212, 29, 38, 33, 3, -38 },
  { 4350, 25, 39, 33, 4, -38 },
  { 4472, 30, 38, 33, 4, -38 },
  { 4615, 21, 38, 33, 6, -38 },
  { 4715, 30, 38, 33, 2, -38 },
  { 4858, 29, 38, 33, 3, -38 },
  { 4996, 26, 40, 33, 4, -39 },
  { 5126, 27, 38, 33, 4, -38 },
  { 5255, 26, 48, 33, 4, -39 },
  { 5411, 27, 38, 33, 4, -38 },
  { 5540, 29, 40, 33, 2, -39 },
  { 5685, 29, 38, 33, 6, -38 },
  { 5823, 27, 39, 33, 5, -38 },
  { 5955, 27, 38, 33, 7, -38 },
  { 6084, 29, 38, 33, 5, -38 },
  { 6222, 34, 38, 33, 0, -38 },
  { 6384, 29, 38, 33, 6, -38 },
  { 6522, 33, 38, 33, 0, -38 },
  { 6679, 21, 50, 33, 11, -42 },
  { 6811, 12, 50, 33, 11, -42 },
  { 6886, 21, 50, 33, 2, -42 },
  { 7018, 25, 21, 33, 5, -38 },
  { 7084, 26, 1, 33, 0, 7 },
  { 7088, 6, 9, 33, 13, -42 },
  { 7095, 25, 30, 33, 4, -29 },
  { 7189, 25, 42, 33, 4, -41 },
  { 7321, 22, 30, 33, 5, -29 },
  { 7404, 27, 42, 33, 4, -41 },
  { 7546, 23, 30, 33, 5, -29 },
  { 7633, 35, 53, 33, -1, -41 },
  { 7865, 26, 41, 33, 3, -29 },
  { 7999, 22, 41, 33, 5, -41 },
  { 8112, 23, 42, 33, 5, -41 },
  { 8233, 23, 53, 33, 6, -41 },
  { 8386, 28, 42, 33, 4, -41 },
  { 8533, 20, 42, 33, 7, -41 },
  { 8638, 29, 29, 33, 2, -29 },
  { 8744, 22, 29, 33, 5, -29 },
  { 8824, 23, 30, 33, 5, -29 },
  { 8911, 26, 40, 33, 3, -29 },
  { 9041, 25, 40, 33, 4, -29 },
  { 9166, 26, 28, 33, 7, -28 },
  { 9257, 26, 30, 33, 3, -29 },
  { 9355, 27, 39, 33, 4, -38 },
  { 9487, 22, 29, 33, 6, -28 },
  { 9567, 24, 29, 33, 5, -29 },
  { 9654, 27, 30, 33, 4, -29 },
  { 9756, 31, 30, 33, 1, -29 },
  { 9873, 26, 40, 33, 2, -28 },
  { 10003, 27, 30, 33, 3, -29 },
  { 10105, 24, 50, 33, 7, -42 },
  { 10255, 10, 50, 33, 12, -42 },
  { 10318, 24, 50, 33, 3, -42 },
  { 10468, 28, 9, 33, 3, -21 },
};

const GFXfont IBMPlexMono_ThinItalic55pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic55pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic55pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _IBMPLEXMONO_THINITALIC55PT7B_H_
