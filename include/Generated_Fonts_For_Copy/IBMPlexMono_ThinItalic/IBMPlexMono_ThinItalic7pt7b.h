#ifndef _IBMPLEXMONO_THINITALIC7PT7B_H_
#define _IBMPLEXMONO_THINITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x76, 0x7B, 0xC0, 0x2F, 0xC2, 0x5E, 0x40, 0xDF, 0x01,
  0xEF, 0x00, 0xEA, 0xCC, 0xF0, 0xC0, 0xEA, 0xA0, 0x95, 0xA0, 0x6D, 0x2E,
  0x64, 0xF4, 0xC0, 0xC0, 0x00, 0x12, 0x44, 0x88, 0xF6, 0xDC, 0x6A, 0x44,
  0xF0, 0x71, 0x24, 0xE0, 0xF1, 0x62, 0xE0, 0x36, 0xAA, 0x70, 0x78, 0xE2,
  0xE0, 0x53, 0x5C, 0xE9, 0x48, 0x79, 0x69, 0xE0, 0xF6, 0xA8, 0x80, 0x42,
  0x80, 0x72, 0x20, 0x7F, 0x42, 0x3C, 0xE5, 0x48, 0xFE, 0xE9, 0x80, 0x66,
  0xAE, 0xB0, 0xF9, 0x69, 0xE0, 0xF2, 0x4C, 0xE9, 0x99, 0xE0, 0xF8, 0x78,
  0xE0, 0xF8, 0x78, 0x80, 0xF2, 0x7C, 0x99, 0x7A, 0xA0, 0x74, 0x44, 0xE0,
  0x65, 0x2C, 0x9A, 0xCA, 0xB0, 0xAA, 0xC0, 0x9F, 0xB9, 0xA0, 0x5D, 0xDA,
  0xA0, 0xF6, 0xDC, 0xF9, 0xAC, 0x80, 0xF6, 0xDD, 0xC0, 0xF9, 0xAE, 0xA0,
  0xF8, 0x61, 0xE0, 0xF2, 0x48, 0xB6, 0xEC, 0xB7, 0x68, 0xB7, 0xEC, 0x96,
  0x4A, 0xB0, 0xBC, 0x48, 0x80, 0x72, 0x48, 0xF0, 0xF2, 0x49, 0x80, 0xAA,
  0x50, 0x65, 0x25, 0x80, 0xDA, 0x80, 0xE0, 0x80, 0x7A, 0xAF, 0x9A, 0xDC,
  0xEB, 0x17, 0xAA, 0xE0, 0xDE, 0x60, 0x37, 0x44, 0x4C, 0x7A, 0xAA, 0xE0,
  0xBF, 0xC0, 0x52, 0x4E, 0x39, 0x25, 0x80, 0x9B, 0xCE, 0xEA, 0xC0, 0x7D,
  0xDD, 0xFF, 0xD6, 0xE0, 0xE9, 0x9A, 0xC0, 0x7A, 0xAA, 0x60, 0xBA, 0x40,
  0x69, 0x6F, 0x9E, 0x4E, 0xBB, 0x60, 0xB7, 0x60, 0xF6, 0xF0, 0xF5, 0x4F,
  0x9A, 0xAA, 0xE0, 0xFA, 0x4E, 0xE9, 0x69, 0x80, 0xFC, 0x69, 0x35, 0x80,
  0xF0,
};

const GFXglyph IBMPlexMono_ThinItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 1, 2, 4, 2, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 5, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 2, 4, 2, -5 },
  { 18, 2, 6, 4, 2, -5 },
  { 20, 2, 6, 4, 1, -5 },
  { 22, 4, 4, 4, 0, -4 },
  { 24, 4, 4, 4, 0, -4 },
  { 26, 1, 2, 4, 1, -1 },
  { 27, 2, 1, 4, 1, -3 },
  { 28, 1, 1, 4, 1, -1 },
  { 29, 4, 6, 4, 0, -5 },
  { 32, 3, 5, 4, 1, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 3, 5, 4, 1, -5 },
  { 51, 3, 5, 4, 1, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 3, 5, 4, 1, -5 },
  { 58, 1, 4, 4, 2, -4 },
  { 59, 2, 5, 4, 1, -4 },
  { 61, 3, 4, 4, 1, -4 },
  { 63, 4, 2, 4, 0, -3 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 3, 5, 4, 1, -5 },
  { 68, 3, 6, 4, 1, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 3, 5, 4, 1, -5 },
  { 79, 4, 5, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -5 },
  { 85, 4, 5, 4, 0, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 3, 5, 4, 1, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 2, 5, 4, 1, -5 },
  { 103, 4, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 3, 5, 4, 1, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 3, 6, 4, 1, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 3, 5, 4, 1, -5 },
  { 125, 3, 5, 4, 1, -5 },
  { 127, 3, 5, 4, 1, -5 },
  { 129, 3, 5, 4, 1, -5 },
  { 131, 4, 5, 4, 0, -5 },
  { 134, 4, 5, 4, 1, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 3, 6, 4, 1, -5 },
  { 143, 2, 6, 4, 1, -5 },
  { 145, 3, 6, 4, 0, -5 },
  { 148, 3, 3, 4, 1, -5 },
  { 150, 3, 1, 4, 0, 0 },
  { 151, 1, 1, 4, 2, -5 },
  { 152, 4, 4, 4, 0, -4 },
  { 154, 3, 5, 4, 1, -5 },
  { 156, 2, 4, 4, 1, -4 },
  { 157, 4, 5, 4, 0, -5 },
  { 160, 3, 4, 4, 1, -4 },
  { 162, 4, 6, 4, 0, -5 },
  { 165, 4, 5, 4, 0, -4 },
  { 168, 2, 5, 4, 1, -5 },
  { 170, 3, 5, 4, 1, -5 },
  { 172, 3, 6, 4, 1, -5 },
  { 175, 3, 5, 4, 1, -5 },
  { 177, 2, 5, 4, 1, -5 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 2, 4, 4, 1, -4 },
  { 182, 3, 4, 4, 1, -4 },
  { 184, 4, 5, 4, 0, -4 },
  { 187, 4, 5, 4, 0, -4 },
  { 190, 3, 4, 4, 1, -4 },
  { 192, 4, 4, 4, 0, -4 },
  { 194, 3, 5, 4, 1, -5 },
  { 196, 3, 4, 4, 1, -4 },
  { 198, 3, 4, 4, 1, -4 },
  { 200, 3, 4, 4, 1, -4 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 4, 5, 4, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 3, 6, 4, 1, -5 },
  { 212, 1, 6, 4, 2, -5 },
  { 213, 3, 6, 4, 0, -5 },
  { 216, 4, 1, 4, 0, -3 },
};

const GFXfont IBMPlexMono_ThinItalic7pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic7pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _IBMPLEXMONO_THINITALIC7PT7B_H_
