#ifndef _IBMPLEXMONO_THINITALIC58PT7B_H_
#define _IBMPLEXMONO_THINITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0x10, 0x33,
  0x02, 0x30, 0x22, 0x02, 0x20, 0x62, 0x06, 0x20, 0x66, 0x04, 0x60, 0x44,
  0x04, 0x40, 0xC4, 0x0C, 0x40, 0xCC, 0x08, 0xC0, 0x80, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x20, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x10, 0x06, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x20, 0x08, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x06, 0x00, 0x80,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0E, 0x08, 0xF0, 0x00, 0x60, 0x30, 0x30, 0x01, 0x80,
  0x40, 0x30, 0x06, 0x00, 0x80, 0x30, 0x18, 0x01, 0x00, 0x30, 0x20, 0x02,
  0x00, 0x00, 0x40, 0x04, 0x00, 0x01, 0x80, 0x18, 0x00, 0x02, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x08, 0x00, 0x80, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x00, 0x39, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x09, 0xE0, 0x00,
  0x00, 0x10, 0x70, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x03, 0x00, 0x60, 0x00, 0x04, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x10, 0x01, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00,
  0x40, 0x04, 0x00, 0x01, 0x80, 0x08, 0x00, 0x02, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x61, 0x80, 0x08, 0x00, 0x81, 0x00, 0x10, 0x03, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0xC0, 0x30, 0x01, 0x81, 0x80, 0xC0, 0x01, 0xE2, 0x0E,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x10, 0x04, 0x01, 0x80, 0x00, 0x80, 0x20, 0x02, 0x00, 0x06,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x10, 0x00, 0x80, 0x30, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x01, 0x00, 0x20, 0x02, 0x00, 0x04, 0x01, 0x80,
  0x08, 0x00, 0x30, 0x04, 0x00, 0x20, 0x00, 0xC0, 0x20, 0x00, 0x80, 0x02,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x00, 0x60, 0x20, 0x00,
  0x20, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x08, 0x00, 0x01, 0x00, 0x60,
  0x60, 0x00, 0x03, 0x06, 0x01, 0x00, 0x00, 0x03, 0xE0, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x06, 0x06, 0x0E, 0x00, 0x00, 0x20, 0x20, 0x0C, 0x00, 0x01, 0x01, 0x00,
  0x10, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x00, 0x20, 0x20, 0x00, 0x80, 0x01,
  0x01, 0x80, 0x02, 0x00, 0x08, 0x04, 0x00, 0x08, 0x00, 0x60, 0x10, 0x00,
  0x20, 0x01, 0x00, 0x40, 0x01, 0x80, 0x08, 0x01, 0x00, 0x06, 0x00, 0x40,
  0x04, 0x00, 0x10, 0x03, 0x00, 0x10, 0x00, 0x40, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x02, 0x00, 0x06, 0x00, 0x60, 0x18, 0x00,
  0x08, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x20, 0x00, 0x04, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x02, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00,
  0x18, 0x01, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x0F, 0x03, 0x00, 0x00,
  0x38, 0xC7, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00,
  0x40, 0x06, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x02, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x80, 0x00, 0x18, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x09,
  0x00, 0x50, 0x00, 0x04, 0x40, 0x4C, 0x00, 0x02, 0x30, 0x22, 0x00, 0x02,
  0x08, 0x20, 0x80, 0x02, 0x02, 0x30, 0x60, 0x02, 0x01, 0x90, 0x0C, 0x06,
  0x00, 0x50, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x33, 0x22, 0x26, 0x66, 0x44,
  0x4C, 0xCC, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80,
  0x03, 0xE0, 0x04, 0x00, 0xF1, 0xE0, 0x20, 0x78, 0x01, 0xE3, 0x1E, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x04, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x10, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x40, 0x40, 0x80, 0xFF, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x00, 0x40,
  0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x36, 0x00, 0x70, 0x03, 0x40, 0x07, 0x00, 0x24, 0x00, 0x60, 0x02, 0x40,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x10, 0x00, 0x30, 0x00, 0x80,
  0x06, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x0C,
  0x10, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x03, 0x00, 0x80, 0x01,
  0x80, 0x20, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x60, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x60, 0x01, 0x80, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x01, 0x01, 0x00, 0x00, 0x10, 0x08, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x18, 0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x80, 0x08, 0x00, 0x08, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x40, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x10, 0x04, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0xFF, 0x00, 0x01, 0x18, 0x07, 0x00, 0x0B, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x40, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x3F, 0xC0, 0x08, 0xE0, 0x38,
  0x09, 0x80, 0x02, 0x05, 0x80, 0x00, 0x87, 0x80, 0x00, 0x22, 0x80, 0x00,
  0x19, 0x80, 0x00, 0x05, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x02, 0x40,
  0x00, 0x01, 0x30, 0x00, 0x01, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x81,
  0x00, 0x01, 0x80, 0x60, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x18, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x10, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x0C, 0x00, 0x10, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x03, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x06, 0x01, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x02, 0x20, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x18, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x80,
  0x00, 0xC0, 0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x40,
  0x00, 0x01, 0x60, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x90, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0xA2, 0x00, 0x00, 0xA1, 0x80, 0x00, 0x90, 0x60, 0x01,
  0x90, 0x0C, 0x03, 0x88, 0x01, 0xFE, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x03,
  0xC1, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0x07, 0x83, 0x80, 0x00, 0x70, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x06,
  0x01, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0xC3, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x90, 0x00, 0x01, 0x60, 0x00, 0x02, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x06, 0x03,
  0x80, 0x06, 0x00, 0x30, 0x03, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x40,
  0x00, 0x20, 0x20, 0x00, 0x04, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x18, 0x01, 0xF8,
  0x44, 0x01, 0x81, 0x11, 0x00, 0x80, 0x2C, 0x40, 0x40, 0x06, 0x20, 0x30,
  0x01, 0x88, 0x08, 0x00, 0x22, 0x02, 0x00, 0x08, 0x81, 0x80, 0x06, 0x60,
  0x40, 0x01, 0x90, 0x10, 0x00, 0x44, 0x04, 0x00, 0x11, 0x03, 0x00, 0x04,
  0x40, 0xC0, 0x01, 0x10, 0x20, 0x00, 0x4C, 0x08, 0x00, 0x33, 0x02, 0x00,
  0x08, 0x80, 0x80, 0x02, 0x20, 0x20, 0x01, 0x88, 0x08, 0x00, 0x62, 0x03,
  0x00, 0x28, 0x80, 0x40, 0x16, 0x20, 0x18, 0x0D, 0x08, 0x03, 0x06, 0x42,
  0x00, 0x3E, 0x10, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x64, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x18, 0x01, 0x00, 0x01, 0x00, 0x10, 0x00, 0x30, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x80, 0x04, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x80,
  0x08, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFC, 0x02, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x60, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x22, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x01,
  0xFF, 0xFE, 0x00, 0x10, 0x00, 0x38, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x10, 0x08, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x10, 0x18, 0x00, 0x00, 0x81, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x18, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x00, 0x40, 0x18, 0x00, 0x0C,
  0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x20, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x08, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x31, 0x00, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x10, 0x08, 0x00, 0x06, 0x00, 0x80, 0x01, 0xC0, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x01, 0xC0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x08, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFC, 0xC0, 0x04,
  0x00, 0x90, 0x00, 0x00, 0x12, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x03, 0x02, 0x00, 0x00, 0xA0, 0x40, 0x00, 0x24, 0x04, 0x00, 0x0D,
  0x80, 0x40, 0x03, 0x30, 0x07, 0x01, 0x84, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x01, 0x81, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x80, 0x80, 0x00, 0x02, 0x03, 0xFF,
  0xFF, 0xF8, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x01, 0x01, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x10, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x08, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x00, 0x60, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x18, 0x02,
  0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x04, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x18, 0x00, 0x04, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x08, 0x1C, 0x00, 0x00, 0x18,
  0x34, 0x00, 0x00, 0x18, 0x66, 0x00, 0x00, 0x10, 0xC2, 0x00, 0x00, 0x11,
  0x03, 0x00, 0x00, 0x12, 0x01, 0x00, 0x00, 0x14, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x18, 0x00, 0x40, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x04, 0x00, 0x40, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x01, 0x00, 0x80, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x05, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x40, 0x00, 0x0B, 0x03, 0x40, 0x00,
  0x12, 0x02, 0x60, 0x00, 0x12, 0x02, 0x20, 0x00, 0x22, 0x02, 0x20, 0x00,
  0x42, 0x02, 0x20, 0x00, 0x46, 0x02, 0x10, 0x00, 0x86, 0x06, 0x10, 0x01,
  0x84, 0x04, 0x10, 0x01, 0x04, 0x04, 0x18, 0x02, 0x04, 0x04, 0x08, 0x02,
  0x04, 0x04, 0x08, 0x04, 0x0C, 0x04, 0x0C, 0x08, 0x0C, 0x0C, 0x04, 0x08,
  0x08, 0x08, 0x04, 0x10, 0x08, 0x08, 0x04, 0x30, 0x08, 0x08, 0x02, 0x20,
  0x08, 0x08, 0x02, 0x40, 0x18, 0x08, 0x02, 0xC0, 0x18, 0x18, 0x03, 0x80,
  0x10, 0x10, 0x01, 0x80, 0x10, 0x10, 0x01, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x10, 0x10, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x10, 0x3C, 0x00, 0x00, 0x40, 0xD0, 0x00, 0x01,
  0x02, 0x40, 0x00, 0x0C, 0x09, 0x80, 0x00, 0x20, 0x22, 0x00, 0x00, 0x80,
  0x88, 0x00, 0x02, 0x06, 0x10, 0x00, 0x08, 0x18, 0x40, 0x00, 0x20, 0x41,
  0x80, 0x01, 0x81, 0x02, 0x00, 0x04, 0x04, 0x08, 0x00, 0x10, 0x10, 0x30,
  0x00, 0x40, 0xC0, 0x40, 0x01, 0x03, 0x01, 0x00, 0x04, 0x08, 0x06, 0x00,
  0x30, 0x20, 0x08, 0x00, 0x80, 0x80, 0x20, 0x02, 0x02, 0x00, 0xC0, 0x08,
  0x18, 0x01, 0x00, 0x20, 0x60, 0x04, 0x01, 0x81, 0x00, 0x08, 0x06, 0x04,
  0x00, 0x20, 0x10, 0x10, 0x00, 0xC0, 0x40, 0x40, 0x01, 0x01, 0x03, 0x00,
  0x04, 0x04, 0x0C, 0x00, 0x18, 0x30, 0x20, 0x00, 0x20, 0xC0, 0x80, 0x00,
  0x82, 0x02, 0x00, 0x03, 0x08, 0x08, 0x00, 0x04, 0x20, 0x60, 0x00, 0x10,
  0x81, 0x80, 0x00, 0x66, 0x04, 0x00, 0x00, 0x98, 0x10, 0x00, 0x02, 0x40,
  0x40, 0x00, 0x0D, 0x01, 0x00, 0x00, 0x14, 0x0C, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x00, 0x40, 0x30, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x08,
  0xC0, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x80, 0x10, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0xC0, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x40, 0x30, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x80, 0x10, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x07, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x0E, 0x01, 0xFF, 0xFF, 0xC0, 0x08, 0x01,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x02, 0x00, 0x20, 0x00, 0x30, 0x01, 0x00,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x10, 0x01, 0x80, 0x00, 0x80, 0x08, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x10, 0x02, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x61, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x82, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x80, 0x40, 0x00, 0x10, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x02, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x06, 0x00, 0x04, 0x00, 0x20, 0x00, 0x20, 0x03, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x08, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x41, 0x00, 0x00, 0x01,
  0x82, 0x00, 0x60, 0x02, 0x04, 0x00, 0xE0, 0x04, 0x08, 0x01, 0xC0, 0x08,
  0x30, 0x04, 0x80, 0x30, 0x60, 0x09, 0x00, 0x40, 0xC0, 0x22, 0x00, 0x81,
  0x80, 0x44, 0x01, 0x02, 0x01, 0x88, 0x04, 0x04, 0x02, 0x10, 0x08, 0x08,
  0x0C, 0x30, 0x10, 0x10, 0x10, 0x20, 0x60, 0x20, 0x60, 0x40, 0x80, 0x40,
  0x80, 0x81, 0x00, 0x83, 0x01, 0x02, 0x01, 0x04, 0x02, 0x0C, 0x02, 0x18,
  0x04, 0x10, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x40, 0x18, 0x40, 0x31, 0x00,
  0x11, 0x80, 0x62, 0x00, 0x22, 0x00, 0xC8, 0x00, 0x44, 0x01, 0x10, 0x00,
  0x98, 0x02, 0x60, 0x01, 0x20, 0x04, 0x80, 0x02, 0x40, 0x0B, 0x00, 0x06,
  0x80, 0x14, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x18, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x10, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x08,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x40, 0x08, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x10, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x60, 0x02, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x81, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0x60, 0x00, 0x04, 0x04,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x08, 0x01, 0x00, 0x02,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x00, 0x60, 0x04, 0x00, 0x04,
  0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x08, 0x18, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x83, 0x04, 0x18, 0x20,
  0x41, 0x82, 0x0C, 0x10, 0x00, 0x1F, 0xC0, 0x00, 0x38, 0x0C, 0x10, 0x18,
  0x00, 0x84, 0x08, 0x00, 0x13, 0x04, 0x00, 0x02, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x40, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x22, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02,
  0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x0C, 0x10, 0x00, 0x05, 0x06, 0x00, 0x01, 0x40, 0x80, 0x00, 0xB0, 0x10,
  0x00, 0x4C, 0x06, 0x00, 0x22, 0x00, 0x60, 0x70, 0xFC, 0x07, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x0F, 0xE0, 0x01, 0x0C, 0x06, 0x00, 0xC4, 0x00,
  0x40, 0x22, 0x00, 0x08, 0x09, 0x00, 0x01, 0x02, 0x80, 0x00, 0x40, 0xC0,
  0x00, 0x08, 0x30, 0x00, 0x02, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x31, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02,
  0x18, 0x00, 0x01, 0x0E, 0x00, 0x00, 0xC2, 0x40, 0x00, 0x60, 0x98, 0x00,
  0x30, 0x23, 0x00, 0x18, 0x08, 0x70, 0x18, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xE0, 0x30, 0x01, 0x00, 0x08, 0x06, 0x00, 0x04, 0x0C,
  0x00, 0x02, 0x08, 0x00, 0x02, 0x10, 0x00, 0x03, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x04, 0x40, 0x00, 0x08, 0x60, 0x00, 0x18, 0x20, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0x40, 0x0E, 0x03, 0x04,
  0x01, 0x80, 0x08, 0x40, 0x20, 0x00, 0x4C, 0x04, 0x00, 0x02, 0xC0, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x86, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x14, 0x02, 0x00, 0x02, 0x40, 0x10, 0x00, 0x4C, 0x01, 0x80,
  0x08, 0x80, 0x06, 0x07, 0x08, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x60, 0x18, 0x01, 0x80, 0x04, 0x03, 0x00, 0x02, 0x04, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x30, 0x00, 0x01,
  0x20, 0x00, 0x01, 0x60, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x04,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x70, 0x80, 0x01, 0xC0, 0x80, 0x7E, 0x00,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x02, 0x40, 0x00, 0x06,
  0x40, 0x00, 0x04, 0x40, 0x00, 0x08, 0x20, 0x00, 0x10, 0x30, 0x00, 0x20,
  0x18, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0E, 0x03, 0x04, 0x03, 0x00, 0x10, 0x80, 0x80,
  0x01, 0x30, 0x20, 0x00, 0x16, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x10, 0x20, 0x00, 0x06,
  0x04, 0x00, 0x01, 0x40, 0xC0, 0x00, 0x28, 0x08, 0x00, 0x0B, 0x00, 0x80,
  0x02, 0x60, 0x18, 0x00, 0x88, 0x00, 0xC0, 0xE1, 0x00, 0x07, 0xF0, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x20, 0x00, 0x08, 0x06,
  0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x0F, 0xE0, 0x04, 0x38, 0x18, 0x04, 0x40, 0x04, 0x04,
  0x80, 0x06, 0x0D, 0x00, 0x02, 0x0E, 0x00, 0x03, 0x0A, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x18,
  0x00, 0x03, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x60,
  0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40,
  0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x01, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x18, 0x00,
  0x80, 0x20, 0x00, 0x80, 0xC0, 0x00, 0x81, 0x80, 0x01, 0x86, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0x10, 0x00, 0x01, 0x60, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0xC0,
  0x01, 0x00, 0x20, 0x01, 0x00, 0x10, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x02, 0x00, 0x03, 0x02, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x07, 0xF0, 0x00, 0xC3, 0x80, 0xC0, 0x0C, 0x40, 0x06,
  0x00, 0x88, 0x00, 0x30, 0x09, 0x00, 0x01, 0x00, 0xA0, 0x00, 0x10, 0x0C,
  0x00, 0x01, 0x01, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x10, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x20, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x06,
  0x00, 0x02, 0x07, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x04, 0x01, 0x00, 0x01, 0x40, 0x10, 0x00, 0x34, 0x00,
  0x80, 0x06, 0x40, 0x0C, 0x00, 0xCC, 0x00, 0x40, 0x18, 0xC0, 0x06, 0x03,
  0x08, 0x00, 0x20, 0x60, 0x80, 0x03, 0x08, 0x08, 0x00, 0x11, 0x00, 0x80,
  0x00, 0xA0, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x08, 0x08, 0x00, 0x30, 0x20, 0x03, 0x00, 0x80, 0x10, 0x06, 0x01, 0x80,
  0x18, 0x08, 0x00, 0x40, 0xC0, 0x01, 0x06, 0x00, 0x04, 0x20, 0x00, 0x13,
  0x00, 0x00, 0xD0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x0C,
  0xC3, 0x04, 0x10, 0x12, 0x03, 0x10, 0x10, 0x28, 0x02, 0x40, 0x30, 0x60,
  0x05, 0x00, 0x20, 0xC0, 0x0C, 0x00, 0x43, 0x00, 0x18, 0x00, 0x86, 0x00,
  0x20, 0x03, 0x08, 0x00, 0x40, 0x06, 0x10, 0x00, 0x80, 0x08, 0x20, 0x03,
  0x00, 0x10, 0x40, 0x04, 0x00, 0x21, 0x80, 0x08, 0x00, 0x43, 0x00, 0x10,
  0x01, 0x84, 0x00, 0x20, 0x03, 0x08, 0x00, 0x40, 0x04, 0x10, 0x01, 0x80,
  0x08, 0x20, 0x02, 0x00, 0x10, 0xC0, 0x04, 0x00, 0x21, 0x80, 0x08, 0x00,
  0xC2, 0x00, 0x10, 0x01, 0x84, 0x00, 0x20, 0x02, 0x08, 0x00, 0xC0, 0x04,
  0x10, 0x01, 0x00, 0x08, 0x60, 0x02, 0x00, 0x10, 0xC0, 0x04, 0x00, 0x61,
  0x00, 0x08, 0x00, 0xC2, 0x00, 0x10, 0x01, 0x04, 0x00, 0x60, 0x02, 0x08,
  0x00, 0x80, 0x04, 0x30, 0x01, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xE0, 0x04,
  0x38, 0x18, 0x04, 0x40, 0x04, 0x04, 0x80, 0x06, 0x0D, 0x00, 0x02, 0x0E,
  0x00, 0x03, 0x0A, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x18, 0x00, 0x01, 0x18, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40,
  0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0xC0,
  0x00, 0x18, 0x80, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x40, 0x03, 0x00, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x08,
  0x40, 0x00, 0x04, 0x60, 0x00, 0x03, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0x80, 0x00, 0x04, 0x20,
  0x00, 0x06, 0x10, 0x00, 0x02, 0x04, 0x00, 0x02, 0x03, 0x00, 0x02, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x0E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x10, 0xC0, 0x60, 0x03, 0x10, 0x01, 0x00, 0x22, 0x00, 0x08, 0x02,
  0x40, 0x00, 0x40, 0x28, 0x00, 0x04, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x04, 0x10, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x10, 0x38, 0x00, 0x03, 0x02, 0x40, 0x00, 0x60, 0x26,
  0x00, 0x0C, 0x02, 0x30, 0x01, 0x80, 0x21, 0xC0, 0x60, 0x02, 0x03, 0xF8,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x38, 0x0C, 0x10, 0x18,
  0x00, 0x84, 0x08, 0x00, 0x13, 0x04, 0x00, 0x02, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x18, 0x40, 0x00, 0x06, 0x30, 0x00, 0x01, 0x88, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x40, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x22, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02,
  0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x63, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x0C, 0x10, 0x00, 0x05, 0x06, 0x00, 0x01, 0x40, 0x80, 0x00, 0xB0, 0x10,
  0x00, 0x4C, 0x06, 0x00, 0x22, 0x00, 0x60, 0x70, 0x80, 0x07, 0xF0, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0xFF, 0xF0, 0x7F, 0xF0, 0x02, 0x38, 0x00, 0x00, 0x26, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1C, 0x03, 0xC0, 0x0C, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x04, 0x18, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x10, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x20, 0x08, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x34, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x06, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60,
  0x00, 0x04, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40,
  0x00, 0x08, 0x40, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x18, 0x80,
  0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x70, 0x80, 0x00, 0xA0, 0x40, 0x01, 0x20, 0x40,
  0x01, 0x20, 0x20, 0x06, 0x20, 0x18, 0x18, 0x20, 0x07, 0xE0, 0x40, 0xFF,
  0x80, 0x00, 0x80, 0x40, 0x00, 0x20, 0x10, 0x00, 0x08, 0x04, 0x00, 0x03,
  0x01, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x10, 0x30, 0x00, 0x04, 0x0C, 0x00,
  0x01, 0x02, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x20, 0x00, 0x08, 0x08,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x81, 0x80, 0x00, 0x20, 0x60, 0x00, 0x10,
  0x10, 0x00, 0x04, 0x04, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x60, 0x10, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x00, 0x80,
  0x01, 0x00, 0x20, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x60, 0x00,
  0x80, 0x30, 0x00, 0x60, 0x30, 0x00, 0x10, 0x70, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x20, 0x40, 0x04, 0x01, 0x82, 0x00, 0x20, 0x04,
  0x10, 0x01, 0x00, 0x21, 0x80, 0x08, 0x01, 0x0C, 0x00, 0xC0, 0x08, 0x40,
  0x06, 0x00, 0x62, 0x00, 0x20, 0x03, 0x10, 0x01, 0x00, 0x08, 0x80, 0x08,
  0x00, 0x4C, 0x00, 0x40, 0x02, 0x60, 0x02, 0x00, 0x12, 0x00, 0x30, 0x00,
  0x90, 0x01, 0x00, 0x0C, 0x80, 0x08, 0x00, 0x64, 0x00, 0x40, 0x03, 0x60,
  0x02, 0x00, 0x13, 0x00, 0x10, 0x00, 0x90, 0x01, 0x80, 0x04, 0x80, 0x08,
  0x00, 0x24, 0x00, 0x40, 0x03, 0x20, 0x02, 0x00, 0x1B, 0x00, 0x10, 0x00,
  0x98, 0x01, 0x80, 0x0C, 0x80, 0x0C, 0x00, 0x44, 0x00, 0xA0, 0x06, 0x20,
  0x05, 0x00, 0x21, 0x80, 0x48, 0x03, 0x04, 0x04, 0x20, 0x30, 0x10, 0x41,
  0x87, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x33,
  0x00, 0xC3, 0x00, 0x60, 0x80, 0x80, 0xC1, 0xC0, 0x20, 0x80, 0x23, 0x80,
  0x10, 0xC0, 0x19, 0x00, 0x0C, 0x40, 0x04, 0x00, 0x02, 0x40, 0x02, 0x00,
  0x01, 0x20, 0x01, 0x00, 0x00, 0xA0, 0x01, 0x80, 0x00, 0x50, 0x00, 0xC0,
  0x00, 0x28, 0x00, 0x40, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x02, 0x00, 0x14, 0x00,
  0x01, 0x00, 0x0A, 0x00, 0x01, 0x80, 0x05, 0x00, 0x00, 0xC0, 0x04, 0x80,
  0x00, 0x60, 0x02, 0x60, 0x00, 0x30, 0x02, 0x10, 0x01, 0x88, 0x01, 0x08,
  0x03, 0x84, 0x01, 0x06, 0x03, 0x03, 0x01, 0x01, 0x06, 0x00, 0xC3, 0x00,
  0xCC, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x30, 0x10, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x20, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x20, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00, 0x04,
  0x06, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x08, 0x04, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x08, 0x0C, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x10, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10, 0x08,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x08, 0x00, 0x07, 0x00, 0x80, 0x00,
  0xA0, 0x04, 0x00, 0x12, 0x00, 0x40, 0x01, 0x20, 0x02, 0x00, 0x62, 0x00,
  0x18, 0x18, 0x20, 0x00, 0x7E, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x30, 0x1C, 0x01, 0x06, 0x00, 0x30, 0x10, 0x40, 0x00, 0xE1, 0x08,
  0x00, 0x01, 0xB0, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x02, 0x01, 0x00, 0x00, 0x40, 0x10, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x10, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0x10, 0x08, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x87, 0xE0, 0x00, 0x08, 0xC1,
  0xF0, 0x00, 0x8C, 0x00, 0xF0, 0x08, 0x80, 0x00, 0xF8, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0C,
  0x18, 0x60, 0x00, 0x20, 0x80, 0xC0, 0x00, 0x84, 0x01, 0x00, 0x04, 0x30,
  0x02, 0x00, 0x10, 0x80, 0x04, 0x00, 0x86, 0x00, 0x18, 0x06, 0x10, 0x00,
  0x30, 0x30, 0x40, 0x00, 0x61, 0x82, 0x00, 0x00, 0x78, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 40, 35, 13, -40 },
  { 46, 12, 15, 35, 15, -43 },
  { 69, 34, 40, 35, 1, -40 },
  { 239, 31, 54, 35, 2, -47 },
  { 449, 38, 42, 35, -1, -41 },
  { 649, 33, 42, 35, 1, -41 },
  { 823, 4, 15, 35, 19, -43 },
  { 831, 18, 52, 35, 14, -44 },
  { 948, 18, 52, 35, 4, -44 },
  { 1065, 29, 29, 35, 4, -32 },
  { 1171, 28, 29, 35, 4, -32 },
  { 1273, 8, 15, 35, 9, -5 },
  { 1288, 16, 1, 35, 10, -18 },
  { 1290, 4, 4, 35, 13, -4 },
  { 1292, 31, 52, 35, 2, -44 },
  { 1494, 28, 42, 35, 4, -41 },
  { 1641, 26, 40, 35, 3, -40 },
  { 1771, 28, 41, 35, 3, -41 },
  { 1915, 28, 42, 35, 3, -41 },
  { 2062, 29, 40, 35, 2, -40 },
  { 2207, 29, 41, 35, 3, -40 },
  { 2356, 25, 41, 35, 5, -40 },
  { 2485, 27, 40, 35, 7, -40 },
  { 2620, 29, 42, 35, 3, -41 },
  { 2773, 25, 41, 35, 6, -41 },
  { 2902, 9, 31, 35, 13, -31 },
  { 2937, 13, 41, 35, 9, -31 },
  { 3004, 28, 31, 35, 5, -33 },
  { 3113, 30, 11, 35, 3, -23 },
  { 3155, 27, 31, 35, 3, -33 },
  { 3260, 23, 41, 35, 9, -41 },
  { 3378, 26, 47, 35, 5, -41 },
  { 3531, 28, 40, 35, 1, -40 },
  { 3671, 28, 40, 35, 3, -40 },
  { 3811, 27, 42, 35, 5, -41 },
  { 3953, 28, 40, 35, 4, -40 },
  { 4093, 30, 40, 35, 4, -40 },
  { 4243, 30, 40, 35, 4, -40 },
  { 4393, 27, 42, 35, 5, -41 },
  { 4535, 30, 40, 35, 3, -40 },
  { 4685, 31, 40, 35, 3, -40 },
  { 4840, 27, 41, 35, 4, -40 },
  { 4979, 32, 40, 35, 4, -40 },
  { 5139, 22, 40, 35, 6, -40 },
  { 5249, 32, 40, 35, 2, -40 },
  { 5409, 30, 40, 35, 3, -40 },
  { 5559, 28, 42, 35, 4, -41 },
  { 5706, 29, 40, 35, 4, -40 },
  { 5851, 28, 51, 35, 4, -41 },
  { 6030, 29, 40, 35, 4, -40 },
  { 6175, 31, 42, 35, 2, -41 },
  { 6338, 31, 40, 35, 6, -40 },
  { 6493, 28, 41, 35, 5, -40 },
  { 6637, 29, 40, 35, 7, -40 },
  { 6782, 31, 40, 35, 5, -40 },
  { 6937, 36, 40, 35, 0, -40 },
  { 7117, 31, 40, 35, 6, -40 },
  { 7272, 35, 40, 35, 0, -40 },
  { 7447, 23, 52, 35, 11, -44 },
  { 7597, 13, 52, 35, 12, -44 },
  { 7682, 22, 52, 35, 2, -44 },
  { 7825, 27, 22, 35, 5, -40 },
  { 7900, 28, 1, 35, 0, 7 },
  { 7904, 6, 10, 35, 14, -45 },
  { 7912, 26, 32, 35, 4, -31 },
  { 8016, 26, 44, 35, 5, -43 },
  { 8159, 24, 32, 35, 5, -31 },
  { 8255, 28, 44, 35, 4, -43 },
  { 8409, 24, 32, 35, 5, -31 },
  { 8505, 37, 55, 35, -1, -43 },
  { 8760, 27, 43, 35, 3, -31 },
  { 8906, 24, 43, 35, 5, -43 },
  { 9035, 24, 44, 35, 5, -43 },
  { 9167, 24, 55, 35, 6, -43 },
  { 9332, 28, 44, 35, 5, -43 },
  { 9486, 22, 44, 35, 7, -43 },
  { 9607, 31, 31, 35, 2, -31 },
  { 9728, 24, 31, 35, 5, -31 },
  { 9821, 25, 32, 35, 5, -31 },
  { 9921, 28, 43, 35, 3, -31 },
  { 10072, 26, 43, 35, 4, -31 },
  { 10212, 28, 30, 35, 7, -30 },
  { 10317, 27, 32, 35, 4, -31 },
  { 10425, 29, 41, 35, 4, -40 },
  { 10574, 24, 31, 35, 6, -30 },
  { 10667, 26, 30, 35, 5, -30 },
  { 10765, 29, 31, 35, 4, -30 },
  { 10878, 33, 32, 35, 1, -31 },
  { 11010, 28, 42, 35, 2, -30 },
  { 11157, 28, 32, 35, 3, -31 },
  { 11269, 26, 52, 35, 7, -44 },
  { 11438, 10, 52, 35, 13, -44 },
  { 11503, 26, 52, 35, 3, -44 },
  { 11672, 30, 10, 35, 3, -23 },
};

const GFXfont IBMPlexMono_ThinItalic58pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic58pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic58pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _IBMPLEXMONO_THINITALIC58PT7B_H_
