#ifndef _IBMPLEXMONO_THINITALIC60PT7B_H_
#define _IBMPLEXMONO_THINITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xE0, 0xF0, 0x70,
  0x00, 0x30, 0x32, 0x02, 0x20, 0x22, 0x06, 0x60, 0x66, 0x06, 0x60, 0x44,
  0x04, 0x40, 0x44, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0x88, 0x08, 0x80, 0x80,
  0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x10, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1C, 0x18, 0xE0, 0x00, 0x30, 0x10, 0x18, 0x00, 0xC0, 0x10,
  0x0C, 0x00, 0x80, 0x10, 0x06, 0x01, 0x00, 0x10, 0x03, 0x03, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x30, 0x00, 0x02, 0x00, 0x20, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0x20, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x02, 0x00, 0x40, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x9C, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x10, 0x00, 0x01, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x10, 0x00, 0x02, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x10, 0x00, 0x02, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x20, 0xC0, 0x06, 0x00, 0x20, 0x60, 0x06, 0x00, 0x60, 0x20, 0x04, 0x00,
  0xC0, 0x18, 0x04, 0x01, 0x80, 0x0C, 0x04, 0x07, 0x00, 0x03, 0x84, 0x1C,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x03, 0x00, 0x60, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0x80, 0x04, 0x00, 0x08, 0x01, 0x00, 0x04, 0x00, 0x10, 0x01,
  0x00, 0x06, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00, 0x06,
  0x00, 0x40, 0x02, 0x00, 0x06, 0x00, 0x80, 0x02, 0x00, 0x04, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x03, 0x00, 0x02, 0x00, 0x04, 0x02, 0x00, 0x02, 0x00,
  0x0C, 0x04, 0x00, 0x02, 0x00, 0x08, 0x08, 0x00, 0x02, 0x00, 0x18, 0x18,
  0x00, 0x01, 0x00, 0x10, 0x10, 0x00, 0x01, 0x80, 0x20, 0x20, 0x00, 0x00,
  0xC0, 0xC0, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x06,
  0x03, 0x06, 0x00, 0x00, 0x04, 0x04, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x80, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x40, 0x00,
  0x20, 0x20, 0x00, 0x40, 0x00, 0x40, 0x20, 0x00, 0x40, 0x00, 0x80, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x60, 0x00, 0x40, 0x01, 0x00, 0x60, 0x00, 0xC0,
  0x02, 0x00, 0x40, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x00, 0x80, 0x08, 0x00, 0x60, 0x01, 0x80, 0x10, 0x00, 0x20, 0x01,
  0x00, 0x20, 0x00, 0x20, 0x02, 0x00, 0x60, 0x00, 0x10, 0x06, 0x00, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x02, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x10, 0x00, 0x10, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x7C,
  0x0C, 0x00, 0x00, 0xE1, 0x0C, 0x00, 0x00, 0xC0, 0x7C, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x08, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x58, 0x03, 0x80, 0x00, 0x12, 0x00, 0xB0, 0x00,
  0x04, 0x40, 0x44, 0x00, 0x02, 0x18, 0x11, 0x80, 0x01, 0x82, 0x08, 0x20,
  0x00, 0x40, 0xC6, 0x06, 0x00, 0x60, 0x19, 0x00, 0xC0, 0x70, 0x02, 0x80,
  0x0F, 0xE0, 0x00, 0xE0, 0x32, 0x22, 0x66, 0x64, 0x44, 0xCC, 0xC8, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x3C, 0x03, 0x00, 0xF0, 0x1E, 0x08, 0x3C, 0x00, 0x0F,
  0x27, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x40, 0x08, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x06,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x04, 0x00, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x81, 0x81,
  0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02,
  0x03, 0x00, 0xFF, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x08, 0x01, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x28, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x02, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x04, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x01, 0x80, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x83, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xC0,
  0x38, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x62, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x10, 0x18, 0x00, 0x00, 0x80, 0x40, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x20,
  0x02, 0x00, 0x01, 0x00, 0x08, 0x00, 0x08, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x40,
  0x06, 0x00, 0x01, 0x00, 0x10, 0x00, 0x04, 0x00, 0x80, 0x00, 0x10, 0x06,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0xFF,
  0x00, 0x03, 0x38, 0x06, 0x00, 0x12, 0x00, 0x0C, 0x00, 0xA0, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x80, 0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x07, 0xF0, 0x01, 0x0E, 0x03, 0x80, 0x4C, 0x00,
  0x30, 0x24, 0x00, 0x02, 0x0A, 0x00, 0x00, 0x47, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x02, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x10, 0x00, 0x01, 0x82,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x60, 0x01, 0x80, 0x70,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF2, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x01, 0x84, 0x00, 0x00, 0x10, 0x40, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x81, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x64, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x18, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x58, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x02, 0x88, 0x00, 0x01, 0x41, 0x00,
  0x00, 0x90, 0x30, 0x00, 0xC8, 0x07, 0x01, 0xC2, 0x00, 0x7F, 0x81, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x0F, 0x0F, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0xF0, 0xF0, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0x80, 0x60, 0x06, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x10,
  0x00, 0x04, 0x20, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x00, 0x40, 0x08, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x08, 0x10, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x02, 0x10, 0x01, 0xF8, 0x44, 0x00, 0xC0, 0x88, 0x80,
  0x20, 0x0B, 0x10, 0x08, 0x00, 0xC6, 0x02, 0x00, 0x18, 0x80, 0x40, 0x03,
  0x10, 0x10, 0x00, 0x22, 0x02, 0x00, 0x0C, 0x40, 0x40, 0x01, 0x98, 0x18,
  0x00, 0x23, 0x02, 0x00, 0x04, 0x40, 0x40, 0x00, 0x88, 0x08, 0x00, 0x11,
  0x01, 0x00, 0x02, 0x20, 0x20, 0x00, 0xCC, 0x0C, 0x00, 0x11, 0x81, 0x80,
  0x02, 0x30, 0x10, 0x00, 0x44, 0x02, 0x00, 0x18, 0x80, 0x40, 0x03, 0x10,
  0x08, 0x00, 0xE2, 0x01, 0x80, 0x28, 0x40, 0x18, 0x09, 0x08, 0x01, 0xC6,
  0x21, 0x00, 0x0F, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x60, 0x40, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x40, 0x04, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x20, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x01, 0x80, 0x01, 0x00, 0x08, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0x40, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0xFF, 0xFF, 0xC0,
  0x30, 0x00, 0x02, 0x01, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x03, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x38, 0x02, 0x00,
  0x00, 0xC0, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x08,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x08, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x46, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x04, 0x40, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x10, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x38, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x04, 0x00, 0x80, 0x00, 0x60,
  0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x06, 0x01, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x20, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x08,
  0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x80, 0x00, 0x80, 0x08, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x10, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xC6, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x43, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x14,
  0x06, 0x00, 0x01, 0x60, 0x18, 0x00, 0x13, 0x00, 0x60, 0x01, 0x10, 0x01,
  0xC0, 0x70, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x08, 0x04, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x02,
  0x00, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x01, 0x00, 0x20, 0x00, 0x01, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x08, 0x00, 0x03, 0x00, 0x04, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x02, 0xC0, 0x00,
  0x01, 0x86, 0x20, 0x00, 0x00, 0xC6, 0x18, 0x00, 0x00, 0x46, 0x04, 0x00,
  0x00, 0x26, 0x03, 0x00, 0x00, 0x16, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x10, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x08, 0x00, 0x30, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x07, 0x02, 0x80, 0x00, 0x05, 0x02, 0x80, 0x00,
  0x0F, 0x02, 0xC0, 0x00, 0x0B, 0x02, 0x40, 0x00, 0x12, 0x06, 0x40, 0x00,
  0x32, 0x06, 0x40, 0x00, 0x22, 0x04, 0x20, 0x00, 0x62, 0x04, 0x20, 0x00,
  0xC6, 0x04, 0x20, 0x00, 0x86, 0x04, 0x30, 0x01, 0x84, 0x0C, 0x10, 0x01,
  0x04, 0x0C, 0x10, 0x02, 0x04, 0x08, 0x10, 0x06, 0x04, 0x08, 0x08, 0x04,
  0x0C, 0x08, 0x08, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x0C, 0x10,
  0x08, 0x18, 0x04, 0x30, 0x08, 0x10, 0x04, 0x20, 0x08, 0x10, 0x04, 0x40,
  0x18, 0x10, 0x06, 0xC0, 0x18, 0x10, 0x02, 0x80, 0x10, 0x30, 0x03, 0x80,
  0x10, 0x30, 0x03, 0x00, 0x10, 0x20, 0x02, 0x00, 0x10, 0x20, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x02, 0x01, 0x40, 0x00, 0x02, 0x01, 0x40, 0x00,
  0x02, 0x03, 0x60, 0x00, 0x06, 0x03, 0x20, 0x00, 0x06, 0x02, 0x20, 0x00,
  0x04, 0x02, 0x10, 0x00, 0x04, 0x02, 0x10, 0x00, 0x04, 0x02, 0x18, 0x00,
  0x04, 0x02, 0x08, 0x00, 0x0C, 0x06, 0x08, 0x00, 0x0C, 0x04, 0x0C, 0x00,
  0x08, 0x04, 0x04, 0x00, 0x08, 0x04, 0x04, 0x00, 0x08, 0x04, 0x06, 0x00,
  0x08, 0x04, 0x02, 0x00, 0x18, 0x0C, 0x02, 0x00, 0x18, 0x08, 0x03, 0x00,
  0x10, 0x08, 0x01, 0x00, 0x10, 0x08, 0x01, 0x00, 0x10, 0x08, 0x01, 0x80,
  0x10, 0x08, 0x00, 0x80, 0x30, 0x18, 0x00, 0x80, 0x30, 0x10, 0x00, 0xC0,
  0x20, 0x10, 0x00, 0x40, 0x20, 0x10, 0x00, 0x40, 0x20, 0x10, 0x00, 0x60,
  0x20, 0x10, 0x00, 0x20, 0x60, 0x30, 0x00, 0x30, 0x60, 0x20, 0x00, 0x10,
  0x40, 0x20, 0x00, 0x10, 0x40, 0x20, 0x00, 0x18, 0x40, 0x20, 0x00, 0x08,
  0x40, 0x20, 0x00, 0x08, 0xC0, 0x60, 0x00, 0x0C, 0xC0, 0x40, 0x00, 0x04,
  0x80, 0x40, 0x00, 0x04, 0x80, 0x40, 0x00, 0x06, 0x80, 0x40, 0x00, 0x02,
  0x80, 0x40, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x0C, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x00, 0x88, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x08, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x18, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x41, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x80, 0x7F, 0xFF,
  0xF0, 0x01, 0x00, 0x30, 0x00, 0x04, 0x00, 0x40, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x40, 0x02, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x02, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x10, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00,
  0x00, 0x80, 0x10, 0x00, 0x03, 0x00, 0x40, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x06, 0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x81, 0x00, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x04, 0x08, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x02, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x81, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x08, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x02, 0x00, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x80, 0x00, 0x80, 0x04, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x60, 0x01,
  0x00, 0x01, 0x00, 0x10, 0x00, 0x08, 0x00, 0x80, 0x00, 0x40, 0x08, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x10, 0x04, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x08, 0x20,
  0x00, 0x00, 0x18, 0x20, 0x03, 0x00, 0x10, 0x20, 0x03, 0x00, 0x10, 0x20,
  0x07, 0x00, 0x10, 0x20, 0x05, 0x80, 0x30, 0x20, 0x0D, 0x80, 0x20, 0x20,
  0x08, 0x80, 0x20, 0x20, 0x18, 0x80, 0x20, 0x60, 0x10, 0x80, 0x60, 0x60,
  0x30, 0x80, 0x40, 0x60, 0x20, 0x80, 0x40, 0x40, 0x60, 0x80, 0xC0, 0x40,
  0x40, 0xC0, 0x80, 0x40, 0x40, 0xC0, 0x80, 0x40, 0x80, 0x40, 0x80, 0x40,
  0x80, 0x41, 0x80, 0x41, 0x80, 0x41, 0x00, 0x41, 0x00, 0x41, 0x00, 0x43,
  0x00, 0x41, 0x00, 0x42, 0x00, 0x43, 0x00, 0x46, 0x00, 0x62, 0x00, 0x44,
  0x00, 0x62, 0x00, 0xCC, 0x00, 0x22, 0x00, 0xC8, 0x00, 0x26, 0x00, 0xD8,
  0x00, 0x24, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x90, 0x00, 0x2C, 0x00, 0xA0,
  0x00, 0x3C, 0x00, 0xA0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x60, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x01, 0x00, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x40, 0x06, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80,
  0x03, 0x00, 0x30, 0x00, 0x10, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xF8, 0x82, 0x0C, 0x18, 0x20, 0xC1, 0x06, 0x08,
  0x10, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x07, 0x04, 0x06, 0x00, 0x10, 0x81,
  0x80, 0x01, 0x30, 0x60, 0x00, 0x16, 0x08, 0x00, 0x02, 0x82, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x46, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x88, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x06, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x28, 0x10, 0x00, 0x0B, 0x02,
  0x00, 0x03, 0x60, 0x20, 0x00, 0xC8, 0x02, 0x00, 0x31, 0x00, 0x30, 0x18,
  0x3F, 0x01, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x7F,
  0x00, 0x08, 0x30, 0x38, 0x01, 0x18, 0x01, 0x80, 0x26, 0x00, 0x08, 0x0D,
  0x00, 0x01, 0x81, 0x20, 0x00, 0x10, 0x28, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x04, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x33, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00, 0x20, 0xD0, 0x00, 0x0C, 0x11,
  0x00, 0x03, 0x02, 0x10, 0x00, 0xC0, 0x41, 0x80, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x00, 0x40, 0x40, 0x00, 0x30, 0x40, 0x00, 0x08, 0x60, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x03, 0x10, 0x00,
  0x01, 0x04, 0x00, 0x01, 0x03, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFE, 0x02, 0x00, 0x38, 0x1C, 0x10,
  0x06, 0x00, 0x10, 0x80, 0x60, 0x00, 0x4C, 0x06, 0x00, 0x01, 0x60, 0x20,
  0x00, 0x0A, 0x02, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x05, 0x01, 0x00, 0x00, 0x28, 0x04, 0x00, 0x02, 0xC0, 0x20, 0x00,
  0x26, 0x00, 0x80, 0x03, 0x20, 0x02, 0x00, 0x31, 0x00, 0x0C, 0x06, 0x08,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x0E, 0x00,
  0x30, 0x00, 0x80, 0x60, 0x00, 0x20, 0x60, 0x00, 0x18, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x63, 0x00, 0x00, 0xE1, 0x80, 0x03, 0x80, 0x80, 0x3E, 0x00, 0x7F, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x20,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x84, 0x00, 0x01, 0x83, 0x00, 0x00, 0x80,
  0x80, 0x01, 0x80, 0x30, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0x81, 0xC1, 0x00, 0xC0, 0x02, 0x10, 0x18, 0x00, 0x13, 0x03, 0x00,
  0x00, 0xB0, 0x20, 0x00, 0x0A, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06,
  0x08, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x10, 0x20, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x05, 0x01, 0x00, 0x00, 0xB0, 0x10, 0x00,
  0x1B, 0x00, 0x80, 0x03, 0x20, 0x04, 0x00, 0x62, 0x00, 0x30, 0x18, 0x20,
  0x00, 0xFE, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x7F, 0x00, 0x30, 0xC0, 0x60, 0x18, 0x80, 0x18, 0x08, 0x80, 0x06,
  0x04, 0x80, 0x01, 0x02, 0x80, 0x00, 0x81, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x10, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x04, 0x20, 0x00, 0x06, 0x10, 0x00,
  0x03, 0x08, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x18, 0x40, 0x00, 0x0C, 0x60,
  0x00, 0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x06, 0x10, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x20, 0x08, 0x00, 0x20, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x40, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x80, 0x00, 0x81, 0x80,
  0x00, 0x41, 0x80, 0x00, 0x23, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x80, 0x01,
  0x00, 0xC0, 0x03, 0x00, 0x20, 0x03, 0x00, 0x10, 0x02, 0x00, 0x08, 0x02,
  0x00, 0x04, 0x02, 0x00, 0x03, 0x02, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x7F, 0x80, 0x02, 0x0C, 0x07,
  0x00, 0x11, 0x80, 0x0C, 0x00, 0x98, 0x00, 0x20, 0x0D, 0x00, 0x00, 0x80,
  0x50, 0x00, 0x04, 0x02, 0x80, 0x00, 0x20, 0x18, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x08, 0x0C, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x02, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x02, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00, 0x06, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x10, 0x07, 0x00, 0x00, 0x81,
  0xC0, 0x00, 0x04, 0x04, 0x00, 0x00, 0x20, 0x30, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x18, 0x06, 0x00, 0x02, 0x80, 0x10, 0x00, 0x24, 0x00, 0xC0, 0x02,
  0x20, 0x02, 0x00, 0x21, 0x00, 0x18, 0x02, 0x18, 0x00, 0x40, 0x20, 0xC0,
  0x01, 0x02, 0x04, 0x00, 0x08, 0x20, 0x20, 0x00, 0x22, 0x01, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x80, 0x20, 0x06, 0x00, 0x40, 0x10, 0x00, 0x80, 0xC0, 0x03, 0x03,
  0x00, 0x06, 0x18, 0x00, 0x08, 0x60, 0x00, 0x11, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x08, 0x83, 0x0C, 0x10,
  0x32, 0x02, 0x20, 0x10, 0x68, 0x06, 0x80, 0x30, 0xA0, 0x05, 0x00, 0x21,
  0x80, 0x0C, 0x00, 0x43, 0x00, 0x10, 0x00, 0x84, 0x00, 0x20, 0x01, 0x18,
  0x00, 0xC0, 0x06, 0x20, 0x01, 0x80, 0x0C, 0x40, 0x02, 0x00, 0x10, 0x80,
  0x04, 0x00, 0x21, 0x00, 0x08, 0x00, 0x42, 0x00, 0x10, 0x00, 0x8C, 0x00,
  0x60, 0x03, 0x18, 0x00, 0xC0, 0x06, 0x20, 0x01, 0x00, 0x08, 0x40, 0x02,
  0x00, 0x10, 0x80, 0x04, 0x00, 0x21, 0x00, 0x08, 0x00, 0x46, 0x00, 0x30,
  0x01, 0x8C, 0x00, 0x60, 0x03, 0x10, 0x00, 0x80, 0x04, 0x20, 0x01, 0x00,
  0x08, 0x40, 0x02, 0x00, 0x10, 0x80, 0x04, 0x00, 0x23, 0x00, 0x18, 0x00,
  0xC6, 0x00, 0x30, 0x01, 0x88, 0x00, 0x40, 0x02, 0x10, 0x00, 0x80, 0x04,
  0x20, 0x01, 0x00, 0x08, 0x40, 0x02, 0x00, 0x10, 0x00, 0x07, 0xF0, 0x03,
  0x0C, 0x06, 0x01, 0x08, 0x01, 0x80, 0x88, 0x00, 0x60, 0x48, 0x00, 0x10,
  0x28, 0x00, 0x08, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10, 0x00,
  0x01, 0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x20,
  0x00, 0x06, 0x30, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10,
  0x00, 0x1F, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x00, 0x40, 0x08, 0x00,
  0x08, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0x61, 0x80, 0x00, 0x08, 0x40,
  0x00, 0x02, 0x30, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x12, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x04, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x61, 0x80, 0x00, 0x10, 0x20, 0x00, 0x08, 0x04, 0x00,
  0x04, 0x00, 0x80, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x08, 0x30, 0x38, 0x00, 0x46, 0x00, 0x60, 0x02,
  0x60, 0x00, 0x80, 0x34, 0x00, 0x06, 0x01, 0x20, 0x00, 0x10, 0x0A, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x02, 0x03, 0x40, 0x00, 0x30, 0x11, 0x00, 0x03,
  0x00, 0x84, 0x00, 0x30, 0x04, 0x18, 0x0E, 0x00, 0x20, 0x3F, 0xC0, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x07, 0x04, 0x06,
  0x00, 0x10, 0x81, 0x80, 0x01, 0x30, 0x60, 0x00, 0x16, 0x08, 0x00, 0x02,
  0x82, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x46, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x23, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x28, 0x10,
  0x00, 0x0B, 0x02, 0x00, 0x03, 0x60, 0x20, 0x00, 0xC8, 0x02, 0x00, 0x31,
  0x00, 0x30, 0x18, 0x20, 0x01, 0xFC, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0x86, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x01,
  0x80, 0x20, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01, 0x03, 0x00, 0x00, 0x20, 0x18,
  0x00, 0x0C, 0x00, 0x70, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x10, 0x00, 0xC0, 0x01, 0xC0, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x03, 0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x30,
  0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0x80, 0x00, 0x08,
  0x40, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x38, 0x60, 0x00, 0x38, 0x30, 0x00, 0x14, 0x08, 0x00,
  0x12, 0x06, 0x00, 0x11, 0x01, 0x80, 0x10, 0x80, 0x60, 0x30, 0xC0, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x10, 0x00, 0x08, 0x06, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x08, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00, 0x04, 0x06, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x30, 0x10, 0x00, 0x04, 0x02, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x20, 0x08, 0x00, 0x08, 0x01, 0x00, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x0C,
  0x00, 0x30, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x10, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x40, 0x10, 0x20, 0x01, 0x00, 0x60, 0x80, 0x04, 0x00, 0x82, 0x00,
  0x10, 0x02, 0x08, 0x00, 0xC0, 0x08, 0x20, 0x02, 0x00, 0x31, 0x80, 0x08,
  0x00, 0xC6, 0x00, 0x20, 0x01, 0x10, 0x00, 0x80, 0x04, 0x40, 0x02, 0x00,
  0x11, 0x00, 0x18, 0x00, 0x44, 0x00, 0x60, 0x01, 0x30, 0x01, 0x00, 0x04,
  0xC0, 0x04, 0x00, 0x12, 0x00, 0x10, 0x00, 0x48, 0x00, 0x40, 0x03, 0x20,
  0x03, 0x00, 0x0C, 0x80, 0x0C, 0x00, 0x36, 0x00, 0x20, 0x00, 0x98, 0x00,
  0x80, 0x02, 0x40, 0x02, 0x00, 0x09, 0x00, 0x08, 0x00, 0x64, 0x00, 0x60,
  0x01, 0x10, 0x01, 0x80, 0x04, 0xC0, 0x06, 0x00, 0x33, 0x00, 0x30, 0x00,
  0x8C, 0x00, 0xE0, 0x06, 0x30, 0x04, 0x80, 0x10, 0x40, 0x12, 0x00, 0x81,
  0x00, 0x8C, 0x06, 0x03, 0x0C, 0x18, 0x60, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x1C, 0x00, 0x3E, 0x00, 0x1C, 0x80, 0x30, 0xC0, 0x1C, 0x30, 0x10, 0x18,
  0x18, 0x04, 0x08, 0x02, 0x18, 0x01, 0x84, 0x00, 0xC8, 0x00, 0x21, 0x00,
  0x10, 0x00, 0x08, 0x80, 0x04, 0x00, 0x03, 0x20, 0x01, 0x00, 0x00, 0x50,
  0x00, 0x40, 0x00, 0x14, 0x00, 0x10, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x1C, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x00, 0x40, 0x02, 0x40, 0x00, 0x30, 0x00, 0x90,
  0x00, 0x0C, 0x00, 0x44, 0x00, 0x03, 0x00, 0x11, 0x80, 0x0C, 0x40, 0x08,
  0x20, 0x0E, 0x10, 0x06, 0x08, 0x0E, 0x06, 0x03, 0x01, 0x0E, 0x00, 0xC1,
  0x00, 0x6E, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x80, 0x60, 0x00, 0x04, 0x02, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x00, 0x80, 0x00, 0x08,
  0x04, 0x00, 0x00, 0x40, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x08,
  0x04, 0x00, 0x00, 0x40, 0x20, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x08,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x3C, 0x03, 0x00, 0x01, 0x40, 0x08, 0x00,
  0x12, 0x00, 0x60, 0x01, 0x10, 0x01, 0x80, 0x10, 0x80, 0x06, 0x03, 0x0C,
  0x00, 0x0F, 0xE0, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x08, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x40, 0x80, 0x0E, 0x02, 0x08,
  0x00, 0x0C, 0x10, 0xC0, 0x00, 0x1D, 0x84, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0x40, 0x00, 0x18,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x10, 0x06, 0x00, 0x00, 0x80, 0x40, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x01, 0x85, 0xF0, 0x00, 0x0C, 0x20, 0x78, 0x00,
  0x23, 0x00, 0x3E, 0x01, 0x10, 0x00, 0x0F, 0x88, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x02, 0x0C, 0x30, 0x00, 0x08, 0x30, 0x10, 0x00, 0x10, 0xC0, 0x10, 0x00,
  0x41, 0x00, 0x30, 0x00, 0x84, 0x00, 0x30, 0x02, 0x18, 0x00, 0x20, 0x0C,
  0x20, 0x00, 0x20, 0x30, 0x40, 0x00, 0x30, 0xC1, 0x80, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 9, 42, 36, 14, -42 },
  { 49, 12, 15, 36, 16, -44 },
  { 72, 36, 42, 36, 1, -42 },
  { 261, 32, 56, 36, 2, -49 },
  { 485, 40, 44, 36, -1, -43 },
  { 705, 34, 44, 36, 1, -43 },
  { 892, 4, 15, 36, 20, -44 },
  { 900, 19, 54, 36, 14, -46 },
  { 1029, 19, 54, 36, 4, -46 },
  { 1158, 30, 30, 36, 4, -33 },
  { 1271, 29, 29, 36, 4, -33 },
  { 1377, 9, 15, 36, 9, -5 },
  { 1394, 16, 1, 36, 10, -19 },
  { 1396, 4, 4, 36, 14, -4 },
  { 1398, 32, 54, 36, 2, -46 },
  { 1614, 28, 44, 36, 5, -43 },
  { 1768, 27, 42, 36, 3, -42 },
  { 1910, 29, 43, 36, 3, -43 },
  { 2066, 29, 44, 36, 3, -43 },
  { 2226, 30, 42, 36, 2, -42 },
  { 2384, 29, 43, 36, 4, -42 },
  { 2540, 26, 43, 36, 5, -42 },
  { 2680, 28, 42, 36, 7, -42 },
  { 2827, 29, 44, 36, 4, -43 },
  { 2987, 26, 43, 36, 6, -43 },
  { 3127, 8, 32, 36, 14, -32 },
  { 3159, 13, 42, 36, 9, -32 },
  { 3228, 29, 32, 36, 5, -34 },
  { 3344, 31, 12, 36, 3, -24 },
  { 3391, 28, 32, 36, 3, -34 },
  { 3503, 24, 43, 36, 9, -43 },
  { 3632, 27, 49, 36, 5, -43 },
  { 3798, 29, 42, 36, 1, -42 },
  { 3951, 28, 42, 36, 4, -42 },
  { 4098, 28, 44, 36, 5, -43 },
  { 4252, 29, 42, 36, 4, -42 },
  { 4405, 31, 42, 36, 4, -42 },
  { 4568, 31, 42, 36, 4, -42 },
  { 4731, 29, 44, 36, 5, -43 },
  { 4891, 32, 42, 36, 3, -42 },
  { 5059, 32, 42, 36, 3, -42 },
  { 5227, 28, 43, 36, 4, -42 },
  { 5378, 33, 42, 36, 4, -42 },
  { 5552, 23, 42, 36, 6, -42 },
  { 5673, 32, 42, 36, 3, -42 },
  { 5841, 32, 42, 36, 3, -42 },
  { 6009, 28, 44, 36, 5, -43 },
  { 6163, 30, 42, 36, 4, -42 },
  { 6321, 28, 53, 36, 5, -43 },
  { 6507, 30, 42, 36, 4, -42 },
  { 6665, 32, 44, 36, 2, -43 },
  { 6841, 31, 42, 36, 7, -42 },
  { 7004, 30, 43, 36, 5, -42 },
  { 7166, 29, 42, 36, 8, -42 },
  { 7319, 32, 42, 36, 5, -42 },
  { 7487, 37, 42, 36, 0, -42 },
  { 7682, 33, 42, 36, 6, -42 },
  { 7856, 36, 42, 36, 0, -42 },
  { 8045, 23, 54, 36, 12, -46 },
  { 8201, 14, 54, 36, 12, -46 },
  { 8296, 23, 54, 36, 2, -46 },
  { 8452, 28, 23, 36, 5, -42 },
  { 8533, 29, 1, 36, 0, 7 },
  { 8537, 6, 10, 36, 15, -46 },
  { 8545, 27, 33, 36, 4, -32 },
  { 8657, 27, 45, 36, 5, -44 },
  { 8809, 25, 33, 36, 5, -32 },
  { 8913, 29, 45, 36, 4, -44 },
  { 9077, 25, 33, 36, 5, -32 },
  { 9181, 38, 57, 36, -1, -44 },
  { 9452, 28, 45, 36, 3, -32 },
  { 9610, 25, 44, 36, 5, -44 },
  { 9748, 25, 46, 36, 5, -45 },
  { 9892, 24, 58, 36, 7, -45 },
  { 10066, 29, 45, 36, 5, -44 },
  { 10230, 23, 45, 36, 7, -44 },
  { 10360, 31, 32, 36, 3, -32 },
  { 10484, 25, 32, 36, 5, -32 },
  { 10584, 26, 33, 36, 5, -32 },
  { 10692, 29, 44, 36, 3, -32 },
  { 10852, 27, 44, 36, 4, -32 },
  { 11001, 29, 31, 36, 7, -31 },
  { 11114, 28, 33, 36, 4, -32 },
  { 11230, 29, 43, 36, 5, -42 },
  { 11386, 25, 32, 36, 6, -31 },
  { 11486, 27, 31, 36, 5, -31 },
  { 11591, 30, 32, 36, 4, -31 },
  { 11711, 34, 33, 36, 1, -32 },
  { 11852, 29, 44, 36, 2, -31 },
  { 12012, 29, 33, 36, 3, -32 },
  { 12132, 27, 54, 36, 7, -46 },
  { 12315, 11, 54, 36, 13, -46 },
  { 12390, 27, 54, 36, 3, -46 },
  { 12573, 31, 10, 36, 3, -23 },
};

const GFXfont IBMPlexMono_ThinItalic60pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic60pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic60pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _IBMPLEXMONO_THINITALIC60PT7B_H_
