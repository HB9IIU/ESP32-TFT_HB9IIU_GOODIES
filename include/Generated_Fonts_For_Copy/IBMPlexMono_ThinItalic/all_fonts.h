#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/IBMPlexMono_ThinItalic
// Headers: 67

#include "IBMPlexMono_ThinItalic6pt7b.h"
#include "IBMPlexMono_ThinItalic7pt7b.h"
#include "IBMPlexMono_ThinItalic8pt7b.h"
#include "IBMPlexMono_ThinItalic9pt7b.h"
#include "IBMPlexMono_ThinItalic10pt7b.h"
#include "IBMPlexMono_ThinItalic11pt7b.h"
#include "IBMPlexMono_ThinItalic12pt7b.h"
#include "IBMPlexMono_ThinItalic13pt7b.h"
#include "IBMPlexMono_ThinItalic14pt7b.h"
#include "IBMPlexMono_ThinItalic15pt7b.h"
#include "IBMPlexMono_ThinItalic16pt7b.h"
#include "IBMPlexMono_ThinItalic17pt7b.h"
#include "IBMPlexMono_ThinItalic18pt7b.h"
#include "IBMPlexMono_ThinItalic19pt7b.h"
#include "IBMPlexMono_ThinItalic20pt7b.h"
#include "IBMPlexMono_ThinItalic21pt7b.h"
#include "IBMPlexMono_ThinItalic22pt7b.h"
#include "IBMPlexMono_ThinItalic23pt7b.h"
#include "IBMPlexMono_ThinItalic24pt7b.h"
#include "IBMPlexMono_ThinItalic25pt7b.h"
#include "IBMPlexMono_ThinItalic26pt7b.h"
#include "IBMPlexMono_ThinItalic27pt7b.h"
#include "IBMPlexMono_ThinItalic28pt7b.h"
#include "IBMPlexMono_ThinItalic29pt7b.h"
#include "IBMPlexMono_ThinItalic30pt7b.h"
#include "IBMPlexMono_ThinItalic31pt7b.h"
#include "IBMPlexMono_ThinItalic32pt7b.h"
#include "IBMPlexMono_ThinItalic33pt7b.h"
#include "IBMPlexMono_ThinItalic34pt7b.h"
#include "IBMPlexMono_ThinItalic35pt7b.h"
#include "IBMPlexMono_ThinItalic36pt7b.h"
#include "IBMPlexMono_ThinItalic37pt7b.h"
#include "IBMPlexMono_ThinItalic38pt7b.h"
#include "IBMPlexMono_ThinItalic39pt7b.h"
#include "IBMPlexMono_ThinItalic40pt7b.h"
#include "IBMPlexMono_ThinItalic41pt7b.h"
#include "IBMPlexMono_ThinItalic42pt7b.h"
#include "IBMPlexMono_ThinItalic43pt7b.h"
#include "IBMPlexMono_ThinItalic44pt7b.h"
#include "IBMPlexMono_ThinItalic45pt7b.h"
#include "IBMPlexMono_ThinItalic46pt7b.h"
#include "IBMPlexMono_ThinItalic47pt7b.h"
#include "IBMPlexMono_ThinItalic48pt7b.h"
#include "IBMPlexMono_ThinItalic49pt7b.h"
#include "IBMPlexMono_ThinItalic50pt7b.h"
#include "IBMPlexMono_ThinItalic51pt7b.h"
#include "IBMPlexMono_ThinItalic52pt7b.h"
#include "IBMPlexMono_ThinItalic53pt7b.h"
#include "IBMPlexMono_ThinItalic54pt7b.h"
#include "IBMPlexMono_ThinItalic55pt7b.h"
#include "IBMPlexMono_ThinItalic56pt7b.h"
#include "IBMPlexMono_ThinItalic57pt7b.h"
#include "IBMPlexMono_ThinItalic58pt7b.h"
#include "IBMPlexMono_ThinItalic59pt7b.h"
#include "IBMPlexMono_ThinItalic60pt7b.h"
#include "IBMPlexMono_ThinItalic61pt7b.h"
#include "IBMPlexMono_ThinItalic62pt7b.h"
#include "IBMPlexMono_ThinItalic63pt7b.h"
#include "IBMPlexMono_ThinItalic64pt7b.h"
#include "IBMPlexMono_ThinItalic65pt7b.h"
#include "IBMPlexMono_ThinItalic66pt7b.h"
#include "IBMPlexMono_ThinItalic67pt7b.h"
#include "IBMPlexMono_ThinItalic68pt7b.h"
#include "IBMPlexMono_ThinItalic69pt7b.h"
#include "IBMPlexMono_ThinItalic70pt7b.h"
#include "IBMPlexMono_ThinItalic71pt7b.h"
#include "IBMPlexMono_ThinItalic72pt7b.h"
