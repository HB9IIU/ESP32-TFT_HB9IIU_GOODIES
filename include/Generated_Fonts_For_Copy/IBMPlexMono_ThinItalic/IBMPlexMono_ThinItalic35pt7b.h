#ifndef _IBMPLEXMONO_THINITALIC35PT7B_H_
#define _IBMPLEXMONO_THINITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x42, 0x10, 0x84, 0x22,
  0x00, 0x00, 0x03, 0x18, 0x42, 0x85, 0x0A, 0x24, 0x48, 0xA1, 0x42, 0x84,
  0x00, 0x30, 0xC0, 0x02, 0x08, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x41,
  0x00, 0x04, 0x10, 0x00, 0x82, 0x00, 0x08, 0x20, 0x3F, 0x83, 0xF0, 0x10,
  0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80, 0x04,
  0x08, 0x0F, 0xC1, 0xFC, 0x04, 0x10, 0x00, 0x81, 0x00, 0x08, 0x20, 0x00,
  0x82, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x0F, 0xE0,
  0x06, 0x23, 0x01, 0x04, 0x10, 0x40, 0x81, 0x10, 0x10, 0x02, 0x04, 0x00,
  0x40, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x10, 0x40, 0x01, 0x90, 0x00,
  0x0F, 0x00, 0x00, 0x5C, 0x00, 0x08, 0x40, 0x01, 0x04, 0x00, 0x20, 0x40,
  0x08, 0x08, 0x01, 0x01, 0x00, 0x20, 0x24, 0x04, 0x08, 0x40, 0x81, 0x04,
  0x20, 0x40, 0x64, 0x30, 0x03, 0xF8, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0xF0, 0x03, 0x02, 0x18, 0x04, 0x04, 0x08,
  0x04, 0x08, 0x04, 0x08, 0x08, 0x04, 0x10, 0x08, 0x04, 0x20, 0x10, 0x08,
  0x20, 0x08, 0x08, 0x40, 0x08, 0x10, 0x80, 0x04, 0x31, 0x00, 0x03, 0xC1,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x83, 0xC0, 0x00, 0x8C,
  0x20, 0x01, 0x10, 0x10, 0x02, 0x10, 0x10, 0x04, 0x20, 0x10, 0x08, 0x20,
  0x10, 0x08, 0x20, 0x10, 0x10, 0x20, 0x10, 0x20, 0x10, 0x20, 0x40, 0x18,
  0x40, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x08, 0x30, 0x00, 0x80, 0x40,
  0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x02, 0x01, 0x00, 0x10, 0x10, 0x00, 0x41, 0x00, 0x1F, 0x30, 0x01,
  0x0E, 0x00, 0x10, 0x20, 0x01, 0x00, 0x80, 0x08, 0x04, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x40, 0x20, 0x02, 0x05, 0x00, 0x28, 0x34, 0x01, 0x23, 0x20,
  0x10, 0x90, 0xC1, 0x85, 0x01, 0xF0, 0x10, 0x25, 0x24, 0x92, 0x80, 0x00,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x08, 0x04, 0x05, 0xC2, 0x1E, 0x0E, 0xB8, 0x00, 0x70, 0x00, 0x14, 0x00,
  0x09, 0x00, 0x04, 0x20, 0x02, 0x04, 0x01, 0x01, 0x00, 0x40, 0x20, 0x60,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x13, 0x22, 0x44, 0x88, 0x80, 0xFF, 0x80, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x01, 0xF8, 0x06, 0x0C, 0x08, 0x02, 0x10, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x81, 0x81, 0x81, 0x81, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x40, 0x10, 0x20,
  0x60, 0x1F, 0x80, 0x00, 0x30, 0x00, 0x70, 0x00, 0x90, 0x03, 0x10, 0x06,
  0x20, 0x08, 0x20, 0x30, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x01, 0x83, 0x01, 0x00, 0x41, 0x00, 0x21,
  0x00, 0x08, 0x80, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x06, 0x06, 0x08, 0x01,
  0x10, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x80, 0x04,
  0x40, 0x08, 0x30, 0x30, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x50, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x40, 0x02, 0x10, 0x01, 0x08,
  0x00, 0x82, 0x00, 0x40, 0x80, 0x20, 0x20, 0x10, 0x08, 0x08, 0x02, 0x04,
  0x01, 0x02, 0x00, 0x41, 0x00, 0x10, 0x40, 0x04, 0x3F, 0xFF, 0xF0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x07, 0xFF, 0x82, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x09, 0xF8, 0x0B, 0x03, 0x02,
  0x00, 0x82, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x48, 0x00, 0x42, 0x00, 0x40, 0xC0,
  0xC0, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x9F, 0x82,
  0xC0, 0xC6, 0x00, 0x58, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x88, 0x03, 0x08, 0x1C, 0x0F, 0xC0,
  0x7F, 0xFF, 0x40, 0x01, 0x40, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x08,
  0x80, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x00, 0xFC, 0x01, 0x81, 0x83, 0x00, 0x21, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x00, 0x84, 0x00, 0x81, 0x01, 0x80,
  0x7F, 0x00, 0xC0, 0xC1, 0x80, 0x11, 0x00, 0x04, 0x80, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x22, 0x00, 0x20, 0xC0,
  0x60, 0x1F, 0xC0, 0x07, 0xE0, 0x30, 0x30, 0x80, 0x12, 0x00, 0x24, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x64, 0x01, 0x84, 0x0D, 0x07, 0xE4, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x38, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x30, 0x40, 0x82, 0x04, 0x10, 0x20, 0x40, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x60, 0x42,
  0x00, 0x90, 0x01, 0x40, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x07, 0x80, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x01, 0xF8, 0x02, 0x04, 0x04, 0x02, 0x08, 0x02, 0x10, 0x01,
  0x10, 0x01, 0x20, 0x01, 0x20, 0xF9, 0x21, 0x86, 0x42, 0x06, 0x42, 0x02,
  0x44, 0x02, 0x44, 0x02, 0x84, 0x02, 0x84, 0x04, 0x84, 0x04, 0x84, 0x04,
  0x84, 0x04, 0x84, 0x0C, 0x82, 0x14, 0x81, 0xE8, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x24, 0x00, 0x10, 0x80,
  0x04, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x40, 0x40, 0x10, 0x1F, 0xFC, 0x08, 0x01,
  0x02, 0x00, 0x21, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x90, 0x00, 0x24,
  0x00, 0x0A, 0x00, 0x01, 0x0F, 0xFC, 0x04, 0x01, 0x02, 0x00, 0x42, 0x00,
  0x21, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x20, 0x02, 0x20, 0x01, 0x10,
  0x01, 0x08, 0x01, 0x07, 0xFF, 0x02, 0x00, 0xC1, 0x00, 0x11, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x48, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x22, 0x00, 0x21, 0xFF, 0xE0, 0x00, 0xF8, 0x01, 0x82, 0x01,
  0x00, 0x81, 0x00, 0x21, 0x00, 0x11, 0x00, 0x04, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x01, 0x10,
  0x00, 0x84, 0x00, 0x83, 0x00, 0x80, 0xC1, 0x80, 0x1F, 0x00, 0x0F, 0xF8,
  0x04, 0x03, 0x02, 0x00, 0xC1, 0x00, 0x21, 0x00, 0x08, 0x80, 0x04, 0x40,
  0x02, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00,
  0x90, 0x00, 0x88, 0x00, 0x44, 0x00, 0x44, 0x00, 0x42, 0x00, 0xC1, 0xFF,
  0x80, 0x0F, 0xFF, 0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x1F, 0xFF, 0x82, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE1, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x1F, 0xFF, 0x82, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x03, 0x02, 0x03,
  0x00, 0x83, 0x00, 0x21, 0x00, 0x11, 0x00, 0x04, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x07,
  0xF2, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x01, 0x10,
  0x00, 0x84, 0x00, 0xC2, 0x00, 0xA0, 0xC0, 0x90, 0x1F, 0x88, 0x08, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x84, 0x00, 0x21,
  0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00, 0x22, 0x00, 0x10, 0xFF,
  0xFC, 0x20, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x02,
  0x10, 0x00, 0x84, 0x00, 0x22, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x88,
  0x00, 0x42, 0x00, 0x10, 0x0F, 0xFF, 0xC0, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10,
  0x80, 0x10, 0x80, 0x10, 0x80, 0x20, 0x60, 0xC0, 0x1F, 0x00, 0x08, 0x00,
  0x30, 0x80, 0x04, 0x08, 0x00, 0x80, 0x80, 0x10, 0x10, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x01, 0x03, 0x00, 0x10, 0x40, 0x01, 0x08, 0x00, 0x21,
  0x80, 0x02, 0x28, 0x00, 0x24, 0x40, 0x02, 0x84, 0x00, 0x30, 0x20, 0x02,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x04, 0x00, 0x80,
  0x40, 0x04, 0x08, 0x00, 0x40, 0x80, 0x02, 0x08, 0x00, 0x30, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F,
  0xFF, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xA0, 0x0A, 0x0A,
  0x01, 0x21, 0x20, 0x12, 0x12, 0x02, 0x41, 0x10, 0x24, 0x11, 0x04, 0x41,
  0x10, 0x84, 0x10, 0x88, 0x42, 0x09, 0x04, 0x20, 0xA0, 0x82, 0x0A, 0x08,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x01,
  0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x10, 0x08, 0x00, 0x45, 0x00, 0x11, 0x40, 0x04, 0x50, 0x01, 0x12, 0x00,
  0x84, 0x80, 0x21, 0x20, 0x08, 0x84, 0x02, 0x21, 0x00, 0x88, 0x20, 0x22,
  0x08, 0x10, 0x82, 0x04, 0x20, 0x41, 0x10, 0x10, 0x44, 0x04, 0x11, 0x00,
  0x84, 0x40, 0x22, 0x10, 0x08, 0x84, 0x01, 0x22, 0x00, 0x48, 0x80, 0x12,
  0x20, 0x02, 0x88, 0x00, 0xC2, 0x00, 0x10, 0x01, 0xF8, 0x06, 0x0C, 0x08,
  0x02, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x08, 0x40, 0x10, 0x20, 0x60, 0x1F, 0x80, 0x0F, 0xFE, 0x02, 0x00, 0x60,
  0x80, 0x08, 0x20, 0x01, 0x10, 0x00, 0x44, 0x00, 0x11, 0x00, 0x04, 0x40,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x22, 0x00, 0x18, 0x80, 0x0C, 0x3F, 0xFC,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xF8, 0x06, 0x0C, 0x08, 0x02, 0x10, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x08, 0x40, 0x10, 0x20, 0x60, 0x1F,
  0x80, 0x02, 0x00, 0x01, 0x00, 0x01, 0x06, 0x00, 0x8C, 0x00, 0x50, 0x00,
  0x60, 0x0F, 0xFE, 0x02, 0x00, 0x60, 0x80, 0x08, 0x20, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x22,
  0x00, 0x18, 0x80, 0x0C, 0x3F, 0xFC, 0x08, 0x10, 0x02, 0x04, 0x00, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x20, 0x40, 0x08,
  0x20, 0x01, 0x08, 0x00, 0x42, 0x00, 0x18, 0x00, 0xFE, 0x00, 0x60, 0x30,
  0x10, 0x01, 0x04, 0x00, 0x11, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x40, 0x00, 0x84, 0x00, 0x10, 0x40, 0x04, 0x06,
  0x03, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x90, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x04, 0x80, 0x02, 0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x88, 0x00, 0x44,
  0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x08, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x01, 0x10, 0x01, 0x08, 0x00, 0x82, 0x00, 0x81, 0x81, 0x80, 0x3F,
  0x80, 0x80, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x11, 0x00, 0x04, 0x40, 0x02,
  0x10, 0x00, 0x84, 0x00, 0x40, 0x80, 0x10, 0x20, 0x08, 0x08, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x08, 0x08, 0x01, 0x04, 0x00, 0x41,
  0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x10, 0x00, 0x44, 0x00, 0x0A, 0x00,
  0x02, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x40, 0x00, 0x68, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22,
  0x04, 0x04, 0x41, 0x81, 0x08, 0x28, 0x21, 0x09, 0x04, 0x21, 0x21, 0x08,
  0x24, 0x21, 0x08, 0x84, 0x21, 0x10, 0x84, 0x42, 0x20, 0x88, 0x24, 0x12,
  0x04, 0x82, 0x40, 0x90, 0x50, 0x14, 0x0A, 0x02, 0x81, 0x80, 0x50, 0x30,
  0x0C, 0x04, 0x00, 0x80, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x40, 0x20, 0x02,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x40, 0x04, 0x02, 0x00, 0x08, 0x10, 0x00,
  0x20, 0x80, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x02, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x40, 0x00, 0x08, 0x80, 0x00, 0x41, 0x00,
  0x01, 0x04, 0x00, 0x08, 0x08, 0x00, 0x40, 0x20, 0x02, 0x00, 0x40, 0x10,
  0x01, 0x00, 0x80, 0x02, 0x02, 0x00, 0x08, 0x30, 0x00, 0x10, 0x80, 0x00,
  0x70, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x82, 0x00, 0x20, 0x40, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x80, 0x08, 0x10, 0x01, 0x04, 0x00, 0x11, 0x00,
  0x02, 0x40, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFC,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x10, 0x08,
  0x08, 0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02,
  0x01, 0x01, 0x07, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x3F, 0xE0, 0x00, 0x60,
  0x00, 0xA0, 0x00, 0x90, 0x01, 0x10, 0x02, 0x10, 0x04, 0x08, 0x04, 0x08,
  0x08, 0x04, 0x10, 0x04, 0x20, 0x02, 0x20, 0x02, 0x40, 0x02, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x84, 0x42, 0x31, 0x03, 0xF1, 0x0C, 0x09, 0x18, 0x05,
  0x10, 0x03, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x40, 0x14,
  0x20, 0x14, 0x30, 0x68, 0x0F, 0x87, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x11, 0xF0, 0x4C,
  0x18, 0xA0, 0x11, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x18, 0x00, 0x50, 0x00, 0xB0,
  0x02, 0x50, 0x0C, 0x90, 0x21, 0x1F, 0x80, 0x03, 0xE0, 0x30, 0x61, 0x00,
  0x88, 0x01, 0x40, 0x05, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x28, 0x01, 0x10, 0x08, 0x30,
  0x40, 0x3E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x03, 0xF1, 0x06, 0x04,
  0x86, 0x01, 0x42, 0x00, 0x62, 0x00, 0x22, 0x00, 0x11, 0x00, 0x08, 0x80,
  0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x44,
  0x00, 0x61, 0x00, 0x30, 0x40, 0x28, 0x30, 0x68, 0x07, 0xC4, 0x00, 0x03,
  0xF0, 0x18, 0x18, 0x40, 0x11, 0x00, 0x14, 0x00, 0x28, 0x00, 0xA0, 0x01,
  0x40, 0x0C, 0x81, 0xE1, 0xFC, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0xA0, 0x02, 0x20, 0x08, 0x30, 0x60, 0x1F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x20, 0x20, 0x00, 0x81, 0x00, 0x02, 0x08,
  0x00, 0x08, 0x40, 0x00, 0x24, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xF1, 0x0C, 0x09, 0x18, 0x05, 0x10, 0x03, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x04, 0x80, 0x0C, 0x40, 0x14, 0x20, 0x14, 0x30, 0x68, 0x0F, 0x88,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x80, 0x20, 0x40, 0xC0,
  0x3F, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x11, 0xF0, 0x48, 0x21, 0xC0, 0x4A, 0x01, 0x30,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50,
  0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x40,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x10, 0x40, 0xC0, 0x86, 0x02, 0x18, 0x04, 0xC0, 0x0A, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x08, 0x08,
  0x10, 0x20, 0x20, 0x80, 0x62, 0x00, 0xC8, 0x01, 0xC0, 0x01, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x21, 0xF8, 0x13, 0x06, 0x0A, 0x01, 0x06, 0x00,
  0x42, 0x00, 0x21, 0x00, 0x20, 0x80, 0x10, 0x80, 0x10, 0x40, 0x30, 0x21,
  0xE0, 0x11, 0x00, 0x08, 0x40, 0x08, 0x20, 0x0C, 0x08, 0x0A, 0x02, 0x19,
  0x01, 0x18, 0x80, 0x58, 0x40, 0x10, 0x00, 0xFF, 0x80, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x11, 0x01, 0x08, 0x30, 0x42, 0x02, 0x60, 0x14, 0x00,
  0xC0, 0x00, 0x13, 0xC3, 0xC2, 0x84, 0x88, 0x60, 0xA0, 0x88, 0x18, 0x11,
  0x02, 0x02, 0x40, 0x40, 0x48, 0x08, 0x11, 0x01, 0x02, 0x20, 0x40, 0x44,
  0x08, 0x08, 0x81, 0x01, 0x20, 0x20, 0x24, 0x04, 0x08, 0x80, 0x81, 0x10,
  0x20, 0x22, 0x04, 0x04, 0x80, 0x80, 0x90, 0x10, 0x20, 0x11, 0xF0, 0x48,
  0x21, 0xC0, 0x4A, 0x01, 0x30, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x40,
  0x05, 0x00, 0x14, 0x00, 0x50, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0,
  0x02, 0x80, 0x0A, 0x00, 0x40, 0x03, 0xF0, 0x18, 0x30, 0x40, 0x11, 0x00,
  0x14, 0x00, 0x28, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x20, 0x08, 0x30,
  0x60, 0x3F, 0x00, 0x18, 0xF8, 0x13, 0x06, 0x14, 0x02, 0x18, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x40, 0x02, 0x40, 0x02, 0x60, 0x04, 0x50, 0x0C, 0x48,
  0x10, 0x47, 0xE0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xF1, 0x0C, 0x09, 0x18, 0x05, 0x10,
  0x03, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80,
  0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x40, 0x14, 0x20,
  0x14, 0x30, 0x68, 0x0F, 0x88, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0xFE, 0x3F, 0x81, 0x20, 0x00,
  0xE0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8,
  0x0C, 0x06, 0x10, 0x01, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x07, 0xF0, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x80, 0x02, 0x40, 0x04, 0x30, 0x18, 0x0F, 0xF0, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x03, 0xFF,
  0xFE, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01,
  0x02, 0x03, 0x01, 0x02, 0x00, 0x86, 0x00, 0x4C, 0x00, 0x28, 0x00, 0x18,
  0x00, 0x40, 0x05, 0x00, 0x14, 0x00, 0x50, 0x02, 0x40, 0x0A, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12,
  0x01, 0x48, 0x05, 0x20, 0x28, 0x41, 0x20, 0xF8, 0x80, 0xF8, 0x02, 0x08,
  0x02, 0x08, 0x02, 0x08, 0x01, 0x08, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10,
  0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x20, 0x04, 0x20, 0x08, 0x20,
  0x10, 0x20, 0x20, 0x20, 0xC0, 0x23, 0x80, 0x3C, 0x00, 0x20, 0x41, 0x20,
  0x20, 0x90, 0x10, 0x48, 0x10, 0x14, 0x08, 0x0A, 0x04, 0x05, 0x02, 0x03,
  0x01, 0x01, 0x80, 0x80, 0xC0, 0x80, 0x60, 0x40, 0x50, 0x20, 0x28, 0x10,
  0x14, 0x08, 0x0A, 0x0C, 0x09, 0x0A, 0x0C, 0x8C, 0x8C, 0x3C, 0x38, 0x00,
  0x03, 0x03, 0xC1, 0x90, 0x84, 0xC2, 0x20, 0xA0, 0x28, 0x10, 0x05, 0x02,
  0x00, 0xC0, 0x40, 0x18, 0x08, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x0C, 0x01, 0x02, 0x80, 0x20, 0x50, 0x14,
  0x11, 0x0C, 0x46, 0x26, 0x0F, 0x03, 0x00, 0x08, 0x00, 0x84, 0x00, 0x42,
  0x00, 0x21, 0x00, 0x20, 0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02,
  0x10, 0x01, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x42, 0x00, 0x21, 0x00,
  0x50, 0x40, 0x30, 0x20, 0x28, 0x08, 0x24, 0x03, 0xE2, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x43, 0x00, 0x40, 0x40, 0xC0, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x88, 0x1C, 0x48, 0x01, 0xE4, 0x00, 0x22, 0x00, 0x21,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x81, 0x80, 0x41, 0x00, 0x21, 0x00, 0x09, 0xF8, 0x04, 0x8F,
  0xE2, 0x40, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0xFE, 0x00,
  0x07, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1F, 0xE0, 0x04, 0x10, 0x82, 0x08,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x41,
  0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x07, 0xF0, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x3F, 0x01, 0xC0, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x7F, 0x00, 0x1E, 0x00, 0x4C, 0x40,
  0x24, 0x08, 0x09, 0x01, 0x04, 0x80, 0x62, 0x20, 0x07, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 24, 21, 8, -24 },
  { 16, 7, 9, 21, 9, -26 },
  { 24, 20, 24, 21, 1, -24 },
  { 84, 19, 32, 21, 1, -28 },
  { 160, 24, 24, 21, -1, -24 },
  { 232, 21, 24, 21, 0, -24 },
  { 295, 3, 9, 21, 11, -26 },
  { 299, 11, 32, 21, 8, -27 },
  { 343, 10, 32, 21, 3, -27 },
  { 383, 18, 17, 21, 2, -19 },
  { 422, 17, 17, 21, 2, -19 },
  { 459, 4, 9, 21, 6, -3 },
  { 464, 9, 1, 21, 6, -11 },
  { 466, 2, 2, 21, 8, -2 },
  { 467, 19, 32, 21, 1, -27 },
  { 543, 16, 24, 21, 3, -24 },
  { 591, 16, 24, 21, 2, -24 },
  { 639, 17, 24, 21, 2, -24 },
  { 690, 16, 24, 21, 2, -24 },
  { 738, 18, 24, 21, 1, -24 },
  { 792, 17, 24, 21, 2, -24 },
  { 843, 15, 24, 21, 3, -24 },
  { 888, 16, 24, 21, 4, -24 },
  { 936, 17, 24, 21, 2, -24 },
  { 987, 15, 24, 21, 4, -24 },
  { 1032, 5, 18, 21, 8, -18 },
  { 1044, 7, 24, 21, 6, -18 },
  { 1065, 17, 19, 21, 3, -20 },
  { 1106, 18, 7, 21, 2, -14 },
  { 1122, 16, 19, 21, 2, -20 },
  { 1160, 14, 24, 21, 5, -24 },
  { 1202, 16, 28, 21, 3, -24 },
  { 1258, 18, 24, 21, 0, -24 },
  { 1312, 17, 24, 21, 2, -24 },
  { 1363, 17, 24, 21, 3, -24 },
  { 1414, 17, 24, 21, 2, -24 },
  { 1465, 19, 24, 21, 2, -24 },
  { 1522, 19, 24, 21, 2, -24 },
  { 1579, 17, 24, 21, 3, -24 },
  { 1630, 18, 24, 21, 2, -24 },
  { 1684, 18, 24, 21, 2, -24 },
  { 1738, 16, 24, 21, 3, -24 },
  { 1786, 20, 24, 21, 2, -24 },
  { 1846, 13, 24, 21, 4, -24 },
  { 1885, 20, 24, 21, 1, -24 },
  { 1945, 18, 24, 21, 2, -24 },
  { 1999, 16, 24, 21, 3, -24 },
  { 2047, 18, 24, 21, 2, -24 },
  { 2101, 16, 30, 21, 3, -24 },
  { 2161, 18, 24, 21, 2, -24 },
  { 2215, 19, 24, 21, 1, -24 },
  { 2272, 18, 24, 21, 4, -24 },
  { 2326, 17, 24, 21, 3, -24 },
  { 2377, 18, 24, 21, 4, -24 },
  { 2431, 19, 24, 21, 3, -24 },
  { 2488, 22, 24, 21, 0, -24 },
  { 2554, 19, 24, 21, 4, -24 },
  { 2611, 21, 24, 21, 0, -24 },
  { 2674, 14, 32, 21, 7, -27 },
  { 2730, 8, 32, 21, 7, -27 },
  { 2762, 14, 32, 21, 1, -27 },
  { 2818, 16, 13, 21, 3, -24 },
  { 2844, 17, 1, 21, 0, 4 },
  { 2847, 4, 6, 21, 8, -27 },
  { 2850, 16, 18, 21, 2, -18 },
  { 2886, 15, 26, 21, 3, -26 },
  { 2935, 14, 18, 21, 3, -18 },
  { 2967, 17, 26, 21, 2, -26 },
  { 3023, 15, 18, 21, 3, -18 },
  { 3057, 21, 33, 21, 0, -26 },
  { 3144, 16, 25, 21, 2, -18 },
  { 3194, 14, 26, 21, 3, -26 },
  { 3240, 15, 26, 21, 3, -26 },
  { 3289, 14, 33, 21, 4, -26 },
  { 3347, 17, 26, 21, 3, -26 },
  { 3403, 13, 26, 21, 4, -26 },
  { 3446, 19, 18, 21, 1, -18 },
  { 3489, 14, 18, 21, 3, -18 },
  { 3521, 15, 18, 21, 3, -18 },
  { 3555, 16, 25, 21, 2, -18 },
  { 3605, 16, 25, 21, 2, -18 },
  { 3655, 17, 18, 21, 4, -18 },
  { 3694, 16, 18, 21, 2, -18 },
  { 3730, 17, 24, 21, 3, -24 },
  { 3781, 14, 18, 21, 4, -18 },
  { 3813, 16, 18, 21, 3, -18 },
  { 3849, 17, 18, 21, 3, -18 },
  { 3888, 19, 18, 21, 1, -18 },
  { 3931, 17, 25, 21, 1, -18 },
  { 3985, 17, 18, 21, 2, -18 },
  { 4024, 16, 32, 21, 4, -27 },
  { 4088, 6, 32, 21, 8, -27 },
  { 4112, 15, 32, 21, 2, -27 },
  { 4172, 18, 6, 21, 2, -14 },
};

const GFXfont IBMPlexMono_ThinItalic35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_THINITALIC35PT7B_H_
