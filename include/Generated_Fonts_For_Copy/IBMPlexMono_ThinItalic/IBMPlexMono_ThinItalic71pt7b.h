#ifndef _IBMPLEXMONO_THINITALIC71PT7B_H_
#define _IBMPLEXMONO_THINITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x00, 0x30, 0x0C,
  0xC0, 0x23, 0x01, 0x8C, 0x06, 0x30, 0x18, 0x80, 0x66, 0x01, 0x98, 0x04,
  0x60, 0x31, 0x80, 0xC6, 0x03, 0x10, 0x0C, 0xC0, 0x33, 0x00, 0x8C, 0x06,
  0x30, 0x18, 0xC0, 0x62, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x02, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x83, 0x1E, 0x00, 0x00,
  0xE0, 0x18, 0x0C, 0x00, 0x0C, 0x00, 0x80, 0x38, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x0C, 0x00, 0x20, 0x01, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x04, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x00, 0x80, 0x01, 0x00, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x00,
  0x00, 0x3C, 0x40, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x01, 0x80, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x01, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0x00,
  0x81, 0x80, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x70, 0x04, 0x00, 0xC0, 0x00, 0xE0, 0x60, 0x1C, 0x00,
  0x01, 0xE3, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x04, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x00, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x01, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x01, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x30, 0x00, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x02, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x18, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x20, 0x01, 0x80, 0x00, 0x01, 0x80, 0x80,
  0x01, 0x00, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x08, 0x00, 0x20, 0x00, 0x60, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x00, 0x00, 0x80, 0x01, 0x80,
  0x04, 0x00, 0x01, 0x00, 0x02, 0x00, 0x10, 0x00, 0x01, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x20, 0x01, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x00, 0x00, 0x79, 0x81,
  0x80, 0x00, 0x00, 0xC0, 0x47, 0x00, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x00,
  0x01, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x01, 0x60, 0x01,
  0xE0, 0x00, 0x00, 0x90, 0x01, 0xB0, 0x00, 0x00, 0x4C, 0x00, 0x88, 0x00,
  0x00, 0x43, 0x00, 0xC4, 0x00, 0x00, 0x20, 0x80, 0xC3, 0x00, 0x00, 0x20,
  0x60, 0x40, 0xC0, 0x00, 0x30, 0x18, 0x60, 0x30, 0x00, 0x30, 0x04, 0x60,
  0x0C, 0x00, 0x30, 0x03, 0x20, 0x03, 0x80, 0xE0, 0x00, 0xB0, 0x00, 0x3F,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0x21, 0x18, 0xC6,
  0x31, 0x08, 0xC6, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x0E, 0x7C,
  0x00, 0x40, 0x07, 0xD0, 0xF8, 0x0C, 0x07, 0xC0, 0x00, 0xF0, 0xC3, 0xE0,
  0x00, 0x01, 0xED, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x10, 0x06, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x03, 0x80, 0x03, 0x60, 0x01,
  0xE0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x26, 0x00, 0x0E, 0x00, 0x09, 0x00,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x71, 0x00, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x02, 0x00, 0x00, 0xC0, 0x02,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x18, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x0E, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x07,
  0xFC, 0x00, 0x00, 0x87, 0x00, 0x70, 0x00, 0x13, 0x00, 0x03, 0x00, 0x06,
  0x80, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x07, 0xF8, 0x00, 0x20, 0xE0, 0x1C, 0x01, 0x8C, 0x00, 0x0C,
  0x04, 0xC0, 0x00, 0x18, 0x36, 0x00, 0x00, 0x30, 0xB0, 0x00, 0x00, 0x42,
  0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x02, 0x70, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xCC, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x10,
  0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x03, 0x90, 0x00, 0x00, 0x14, 0x60, 0x00, 0x00,
  0xD0, 0xC0, 0x00, 0x06, 0xC1, 0x80, 0x00, 0x32, 0x03, 0x00, 0x03, 0x18,
  0x03, 0x80, 0x70, 0x40, 0x03, 0xFE, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x1F, 0x83, 0x08, 0x00, 0xE0, 0x63,
  0x08, 0x01, 0x80, 0x12, 0x18, 0x03, 0x00, 0x0A, 0x18, 0x02, 0x00, 0x0A,
  0x10, 0x04, 0x00, 0x06, 0x10, 0x0C, 0x00, 0x06, 0x30, 0x08, 0x00, 0x06,
  0x30, 0x08, 0x00, 0x04, 0x30, 0x18, 0x00, 0x04, 0x20, 0x18, 0x00, 0x04,
  0x20, 0x10, 0x00, 0x0C, 0x60, 0x10, 0x00, 0x0C, 0x60, 0x30, 0x00, 0x0C,
  0x60, 0x30, 0x00, 0x08, 0x60, 0x30, 0x00, 0x08, 0x40, 0x30, 0x00, 0x08,
  0x40, 0x20, 0x00, 0x08, 0x40, 0x20, 0x00, 0x18, 0xC0, 0x20, 0x00, 0x18,
  0xC0, 0x20, 0x00, 0x10, 0xC0, 0x30, 0x00, 0x30, 0xC0, 0x30, 0x00, 0x30,
  0x80, 0x10, 0x00, 0x50, 0x80, 0x10, 0x00, 0xB0, 0x80, 0x18, 0x01, 0xB0,
  0x80, 0x0C, 0x03, 0x20, 0x80, 0x07, 0x0E, 0x20, 0x80, 0x01, 0xF0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0x10, 0x01, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x80, 0x06, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x08, 0x00, 0x01, 0x80, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x0C, 0x04, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x30, 0x08, 0x00,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x06, 0x04, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x10, 0x02, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x20, 0x00, 0x70, 0x00, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x01, 0x80, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x38, 0x00, 0x80, 0x00, 0x78,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x7F, 0xFE, 0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x80, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0x50, 0x04, 0x00, 0x00, 0x24, 0x01, 0x80, 0x00, 0x13, 0x00, 0x30, 0x00,
  0x08, 0xC0, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x70, 0x0E, 0x08, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x40,
  0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x02, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0E, 0x01, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x03,
  0x01, 0xE0, 0x00, 0x00, 0x06, 0x06, 0x60, 0x00, 0x00, 0x08, 0x18, 0xC0,
  0x00, 0x00, 0x10, 0x60, 0xC0, 0x00, 0x00, 0x61, 0x81, 0x80, 0x00, 0x00,
  0xC6, 0x01, 0x80, 0x00, 0x01, 0x98, 0x03, 0x00, 0x00, 0x03, 0x60, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x02, 0x80, 0x00,
  0x00, 0x70, 0x05, 0x00, 0x00, 0x01, 0xA0, 0x1B, 0x00, 0x00, 0x03, 0x40,
  0x36, 0x00, 0x00, 0x0D, 0x80, 0x64, 0x00, 0x00, 0x3B, 0x00, 0xC8, 0x00,
  0x00, 0x66, 0x01, 0x18, 0x00, 0x01, 0x88, 0x02, 0x10, 0x00, 0x03, 0x10,
  0x0C, 0x20, 0x00, 0x0C, 0x20, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x30, 0xC0,
  0x00, 0x61, 0x80, 0x60, 0x80, 0x01, 0x83, 0x00, 0x81, 0x00, 0x03, 0x04,
  0x01, 0x03, 0x00, 0x0C, 0x08, 0x06, 0x02, 0x00, 0x30, 0x10, 0x0C, 0x04,
  0x00, 0x60, 0x60, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x02, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x30, 0x04, 0x03, 0x00,
  0x60, 0x60, 0x08, 0x06, 0x00, 0x41, 0x80, 0x30, 0x0C, 0x00, 0x82, 0x00,
  0x60, 0x18, 0x01, 0x0C, 0x00, 0xC0, 0x20, 0x03, 0x30, 0x01, 0x00, 0x40,
  0x02, 0x60, 0x02, 0x00, 0x80, 0x05, 0x80, 0x04, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x10,
  0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x08, 0x00, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x28, 0x00, 0x00, 0x04, 0x01, 0x60, 0x00, 0x00, 0x20, 0x1B, 0x00,
  0x00, 0x01, 0x00, 0xC8, 0x00, 0x00, 0x18, 0x06, 0x60, 0x00, 0x00, 0xC0,
  0x21, 0x00, 0x00, 0x06, 0x01, 0x08, 0x00, 0x00, 0x20, 0x08, 0x60, 0x00,
  0x01, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x06, 0x08, 0x00, 0x00, 0xC0, 0x30,
  0x60, 0x00, 0x06, 0x01, 0x01, 0x00, 0x00, 0x30, 0x08, 0x0C, 0x00, 0x01,
  0x00, 0x40, 0x60, 0x00, 0x08, 0x06, 0x01, 0x00, 0x00, 0x40, 0x30, 0x0C,
  0x00, 0x06, 0x01, 0x80, 0x60, 0x00, 0x30, 0x08, 0x01, 0x00, 0x01, 0x80,
  0x40, 0x0C, 0x00, 0x08, 0x02, 0x00, 0x60, 0x00, 0x40, 0x30, 0x01, 0x00,
  0x02, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x40,
  0x01, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x00, 0x40, 0x10, 0x00, 0x60, 0x02,
  0x01, 0x80, 0x01, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x0C, 0x02, 0x00, 0x01, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x02, 0x00,
  0x80, 0x00, 0x20, 0x10, 0x0C, 0x00, 0x01, 0x00, 0x80, 0x60, 0x00, 0x0C,
  0x0C, 0x03, 0x00, 0x00, 0x20, 0x60, 0x10, 0x00, 0x01, 0x03, 0x00, 0x80,
  0x00, 0x0C, 0x18, 0x04, 0x00, 0x00, 0x20, 0x80, 0x60, 0x00, 0x01, 0x84,
  0x03, 0x00, 0x00, 0x0C, 0x60, 0x18, 0x00, 0x00, 0x23, 0x00, 0x80, 0x00,
  0x01, 0x98, 0x04, 0x00, 0x00, 0x0C, 0xC0, 0x20, 0x00, 0x00, 0x24, 0x03,
  0x00, 0x00, 0x01, 0xA0, 0x18, 0x00, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x10, 0x06, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x00, 0x20, 0x60, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x04, 0x60,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x10, 0x06,
  0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x30, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0xE0, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x20, 0x30, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x18, 0x00, 0x40, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x20,
  0x30, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x00, 0x20, 0x04, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x01, 0x80, 0x00, 0x18, 0x00, 0x10, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x08, 0x00, 0x20, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x08, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x60, 0x00, 0x80, 0xC0, 0x03,
  0x80, 0x02, 0x02, 0x00, 0x0A, 0x00, 0x18, 0x08, 0x00, 0x68, 0x00, 0x60,
  0x20, 0x01, 0x30, 0x01, 0x00, 0x80, 0x0C, 0xC0, 0x04, 0x02, 0x00, 0x23,
  0x00, 0x30, 0x08, 0x01, 0x8C, 0x00, 0xC0, 0x20, 0x04, 0x10, 0x02, 0x00,
  0x80, 0x30, 0x40, 0x08, 0x06, 0x00, 0x81, 0x00, 0x60, 0x18, 0x06, 0x04,
  0x01, 0x80, 0x60, 0x18, 0x18, 0x04, 0x01, 0x80, 0x40, 0x60, 0x30, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x18, 0x08, 0x02, 0x02, 0x00, 0x60, 0x60, 0x08,
  0x08, 0x01, 0x01, 0x00, 0x20, 0x60, 0x04, 0x0C, 0x00, 0x81, 0x80, 0x10,
  0x20, 0x03, 0x04, 0x00, 0x41, 0x80, 0x0C, 0x10, 0x01, 0x04, 0x00, 0x30,
  0xC0, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x46,
  0x00, 0x04, 0x20, 0x03, 0x18, 0x00, 0x11, 0x80, 0x0C, 0xC0, 0x00, 0x46,
  0x00, 0x33, 0x00, 0x01, 0x90, 0x00, 0xC8, 0x00, 0x06, 0xC0, 0x03, 0x60,
  0x00, 0x1B, 0x00, 0x0D, 0x00, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x00, 0xA0,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x40, 0x00, 0x02, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x20, 0x01, 0x80, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0xC0,
  0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x02, 0x03, 0x00, 0x07,
  0xFC, 0x03, 0x00, 0x1C, 0x07, 0x03, 0x00, 0x60, 0x00, 0xC2, 0x00, 0xC0,
  0x00, 0x62, 0x01, 0x00, 0x00, 0x32, 0x02, 0x00, 0x00, 0x12, 0x06, 0x00,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xA0, 0x60, 0x00,
  0x01, 0xE0, 0x20, 0x00, 0x01, 0x60, 0x30, 0x00, 0x02, 0x60, 0x10, 0x00,
  0x04, 0x40, 0x08, 0x00, 0x08, 0x40, 0x06, 0x00, 0x30, 0x40, 0x03, 0x80,
  0xE0, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x01, 0xFE, 0x00,
  0x04, 0x0E, 0x03, 0x00, 0x18, 0x60, 0x01, 0x80, 0x31, 0x80, 0x01, 0x80,
  0x66, 0x00, 0x01, 0x80, 0x98, 0x00, 0x01, 0x01, 0x20, 0x00, 0x01, 0x02,
  0x80, 0x00, 0x02, 0x0E, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x08, 0x28, 0x00, 0x00, 0x30,
  0xD0, 0x00, 0x00, 0xC1, 0x90, 0x00, 0x03, 0x03, 0x10, 0x00, 0x0C, 0x04,
  0x18, 0x00, 0x60, 0x08, 0x1C, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x00, 0x30, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10, 0x30, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x07, 0xFC, 0x03, 0x00, 0x07, 0x01, 0xC0, 0xC0, 0x06,
  0x00, 0x0C, 0x20, 0x03, 0x00, 0x01, 0x88, 0x01, 0x00, 0x00, 0x32, 0x00,
  0x80, 0x00, 0x04, 0x80, 0x60, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x38,
  0x08, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x16, 0x00, 0x80, 0x00, 0x05, 0x80, 0x30, 0x00, 0x02, 0x60, 0x04, 0x00,
  0x01, 0x10, 0x00, 0x80, 0x00, 0x84, 0x00, 0x18, 0x00, 0xC3, 0x00, 0x03,
  0x80, 0xE0, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xC0, 0x01,
  0xC0, 0x70, 0x30, 0x01, 0x80, 0x03, 0x08, 0x00, 0xC0, 0x00, 0x62, 0x00,
  0x40, 0x00, 0x0C, 0x80, 0x20, 0x00, 0x01, 0x20, 0x18, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x08, 0x10, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x04, 0x0C,
  0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x0A, 0x01, 0x80, 0x00, 0x07, 0x80, 0x20, 0x00, 0x01, 0x60, 0x0C, 0x00,
  0x00, 0x90, 0x01, 0x00, 0x00, 0x44, 0x00, 0x20, 0x00, 0x21, 0x00, 0x06,
  0x00, 0x30, 0x40, 0x00, 0xE0, 0x38, 0x30, 0x00, 0x0F, 0xF0, 0x0C, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x01, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0xFE,
  0x00, 0x18, 0x38, 0x0C, 0x00, 0xC2, 0x00, 0x18, 0x04, 0x20, 0x00, 0x60,
  0x22, 0x00, 0x01, 0x03, 0x20, 0x00, 0x0C, 0x1A, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x01, 0x07, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x02, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x01,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x02, 0x00, 0x80, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x02, 0x00, 0x00, 0x80, 0x08, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x04, 0x18, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0xE0, 0x1C,
  0x00, 0x18, 0x60, 0x00, 0xC0, 0x03, 0x18, 0x00, 0x0C, 0x00, 0x64, 0x00,
  0x00, 0x80, 0x09, 0x00, 0x00, 0x18, 0x01, 0x60, 0x00, 0x03, 0x00, 0x68,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x70, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x09, 0x80, 0x08,
  0x00, 0x01, 0xB0, 0x01, 0x80, 0x00, 0x46, 0x00, 0x10, 0x00, 0x10, 0x80,
  0x03, 0x00, 0x04, 0x10, 0x00, 0x20, 0x03, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0x30, 0x18, 0x00, 0x04, 0x0C, 0x03, 0x00, 0x00, 0xC3,
  0x00, 0x40, 0x00, 0x08, 0xC0, 0x08, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x60, 0x00, 0x60, 0x10, 0x00, 0x30, 0x04,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x08, 0x00, 0x30, 0x0C, 0x00,
  0x08, 0x04, 0x00, 0x02, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x05, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x07, 0xC0, 0x0F, 0xC0, 0x10, 0xC1, 0x81, 0x83, 0x00, 0x88, 0x06, 0x10,
  0x0C, 0x0C, 0x80, 0x11, 0x00, 0x30, 0x68, 0x00, 0x90, 0x01, 0x83, 0x80,
  0x07, 0x00, 0x04, 0x1C, 0x00, 0x38, 0x00, 0x20, 0xC0, 0x01, 0x80, 0x01,
  0x06, 0x00, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x60, 0x00, 0xC3, 0x00, 0x02,
  0x00, 0x06, 0x18, 0x00, 0x10, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x01, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x60, 0x00, 0x41, 0x00, 0x03, 0x00,
  0x06, 0x18, 0x00, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x80, 0x01, 0x86, 0x00,
  0x0C, 0x00, 0x08, 0x20, 0x00, 0x60, 0x00, 0x41, 0x00, 0x03, 0x00, 0x02,
  0x08, 0x00, 0x10, 0x00, 0x30, 0xC0, 0x00, 0x80, 0x01, 0x86, 0x00, 0x04,
  0x00, 0x0C, 0x30, 0x00, 0x60, 0x00, 0x41, 0x00, 0x03, 0x00, 0x02, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x40, 0x00, 0x80, 0x01, 0x86, 0x00, 0x04, 0x00,
  0x0C, 0x30, 0x00, 0x20, 0x00, 0x61, 0x80, 0x03, 0x00, 0x02, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x40, 0x00, 0xC0, 0x00, 0x82, 0x00, 0x04, 0x00, 0x0C,
  0x30, 0x00, 0x20, 0x00, 0x61, 0x80, 0x01, 0x00, 0x03, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x03, 0x00, 0xFE, 0x00, 0x18, 0x38, 0x0C, 0x00, 0x82,
  0x00, 0x18, 0x04, 0x20, 0x00, 0x60, 0x22, 0x00, 0x01, 0x03, 0x20, 0x00,
  0x0C, 0x1A, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0x07, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x02, 0x00, 0x20, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x40,
  0x3F, 0xC0, 0x00, 0x10, 0x38, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x03,
  0x18, 0x00, 0x18, 0x00, 0xCC, 0x00, 0x03, 0x00, 0x26, 0x00, 0x00, 0x40,
  0x09, 0x00, 0x00, 0x08, 0x02, 0x80, 0x00, 0x02, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x00, 0x04, 0x0C, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x28, 0x00,
  0x00, 0x30, 0x1A, 0x00, 0x00, 0x18, 0x06, 0x40, 0x00, 0x0C, 0x01, 0x88,
  0x00, 0x06, 0x00, 0x41, 0x80, 0x06, 0x00, 0x10, 0x38, 0x07, 0x00, 0x04,
  0x01, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x03, 0x00, 0x1C, 0x07, 0x03, 0x00, 0x60, 0x00, 0xC2, 0x00,
  0xC0, 0x00, 0x62, 0x01, 0x00, 0x00, 0x32, 0x02, 0x00, 0x00, 0x12, 0x06,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x08, 0x60,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xA0, 0x60,
  0x00, 0x01, 0xE0, 0x20, 0x00, 0x01, 0x60, 0x30, 0x00, 0x02, 0x40, 0x10,
  0x00, 0x04, 0x40, 0x08, 0x00, 0x08, 0x40, 0x06, 0x00, 0x30, 0x40, 0x03,
  0x80, 0xE0, 0xC0, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x08, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x43, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x01, 0x84, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0x80, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x43, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x61,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x14, 0x08, 0x00, 0x01, 0x20, 0x40, 0x00, 0x0B, 0x03, 0x00, 0x00,
  0x98, 0x0C, 0x00, 0x08, 0xC0, 0x30, 0x01, 0x86, 0x00, 0xE0, 0x38, 0x20,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x40, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x02, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x10,
  0x02, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x08, 0x01,
  0x80, 0x80, 0x01, 0x00, 0x10, 0x10, 0x00, 0x20, 0x03, 0x06, 0x00, 0x0C,
  0x00, 0x20, 0xC0, 0x01, 0x80, 0x04, 0x18, 0x00, 0x30, 0x00, 0xC2, 0x00,
  0x04, 0x00, 0x18, 0x40, 0x00, 0x80, 0x03, 0x08, 0x00, 0x10, 0x00, 0x63,
  0x00, 0x06, 0x00, 0x04, 0x60, 0x00, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0x00,
  0x11, 0x00, 0x02, 0x00, 0x02, 0x20, 0x00, 0x40, 0x00, 0x44, 0x00, 0x08,
  0x00, 0x09, 0x80, 0x03, 0x00, 0x01, 0x30, 0x00, 0x60, 0x00, 0x26, 0x00,
  0x0C, 0x00, 0x0C, 0x80, 0x01, 0x00, 0x01, 0x90, 0x00, 0x20, 0x00, 0x32,
  0x00, 0x04, 0x00, 0x06, 0xC0, 0x01, 0x80, 0x00, 0xD8, 0x00, 0x30, 0x00,
  0x13, 0x00, 0x06, 0x00, 0x02, 0x60, 0x00, 0x80, 0x00, 0xC8, 0x00, 0x10,
  0x00, 0x19, 0x00, 0x02, 0x00, 0x03, 0x20, 0x00, 0xC0, 0x00, 0x4C, 0x00,
  0x18, 0x00, 0x19, 0x80, 0x03, 0x00, 0x02, 0x30, 0x00, 0xA0, 0x00, 0xC6,
  0x00, 0x14, 0x00, 0x10, 0xC0, 0x04, 0x80, 0x06, 0x18, 0x00, 0x90, 0x00,
  0x81, 0x00, 0x23, 0x00, 0x20, 0x30, 0x08, 0x20, 0x08, 0x03, 0x06, 0x03,
  0x06, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xE0,
  0x00, 0x73, 0x00, 0x18, 0x30, 0x03, 0x83, 0x00, 0x40, 0x30, 0x1C, 0x02,
  0x01, 0x00, 0x30, 0xE0, 0x06, 0x04, 0x00, 0x67, 0x00, 0x04, 0x10, 0x00,
  0x50, 0x00, 0x0C, 0x60, 0x00, 0x80, 0x00, 0x18, 0x80, 0x01, 0x00, 0x00,
  0x13, 0x00, 0x02, 0x00, 0x00, 0x24, 0x00, 0x04, 0x00, 0x00, 0x48, 0x00,
  0x08, 0x00, 0x00, 0xA0, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0xA0,
  0x00, 0x02, 0x00, 0x01, 0x40, 0x00, 0x04, 0x00, 0x04, 0x80, 0x00, 0x08,
  0x00, 0x09, 0x00, 0x00, 0x10, 0x00, 0x32, 0x00, 0x00, 0x20, 0x00, 0x46,
  0x00, 0x00, 0x40, 0x01, 0x84, 0x00, 0x0C, 0x80, 0x02, 0x08, 0x00, 0x71,
  0x80, 0x08, 0x18, 0x03, 0x83, 0x00, 0x30, 0x10, 0x1C, 0x03, 0x00, 0xC0,
  0x30, 0xE0, 0x03, 0x06, 0x00, 0x37, 0x00, 0x01, 0xF0, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x40, 0x08, 0x00, 0x01,
  0x20, 0x04, 0x00, 0x00, 0x90, 0x03, 0x00, 0x00, 0x98, 0x00, 0xC0, 0x00,
  0x8C, 0x00, 0x30, 0x01, 0x84, 0x00, 0x0E, 0x03, 0x82, 0x00, 0x01, 0xFE,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x40, 0x30, 0x1F, 0x80, 0x10, 0x30, 0x00, 0x7C,
  0x0C, 0x08, 0x00, 0x03, 0xE3, 0x06, 0x00, 0x00, 0x3E, 0xC1, 0x00, 0x00,
  0x01, 0xE0, 0x40, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x20, 0x06,
  0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x00, 0x30, 0x7C, 0x00, 0x00, 0x0C, 0x30, 0xF8, 0x00, 0x01,
  0x0C, 0x01, 0xF0, 0x00, 0x42, 0x00, 0x03, 0xE0, 0x10, 0x80, 0x00, 0x07,
  0xC4, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x30,
  0x60, 0x00, 0x03, 0x06, 0x03, 0x00, 0x00, 0x20, 0xC0, 0x18, 0x00, 0x06,
  0x18, 0x00, 0xC0, 0x00, 0x41, 0x00, 0x04, 0x00, 0x0C, 0x20, 0x00, 0x60,
  0x00, 0x86, 0x00, 0x03, 0x00, 0x18, 0x40, 0x00, 0x18, 0x03, 0x04, 0x00,
  0x00, 0xC0, 0x60, 0xC0, 0x00, 0x06, 0x0C, 0x08, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 11, 50, 43, 16, -50 },
  { 70, 14, 18, 43, 19, -53 },
  { 102, 42, 50, 43, 1, -50 },
  { 365, 37, 65, 43, 3, -57 },
  { 666, 47, 51, 43, -1, -50 },
  { 966, 41, 51, 43, 1, -50 },
  { 1228, 5, 18, 43, 23, -53 },
  { 1240, 22, 64, 43, 17, -54 },
  { 1416, 22, 64, 43, 5, -54 },
  { 1592, 36, 35, 43, 5, -39 },
  { 1750, 34, 35, 43, 5, -39 },
  { 1899, 10, 18, 43, 11, -6 },
  { 1922, 19, 1, 43, 12, -22 },
  { 1925, 5, 4, 43, 16, -4 },
  { 1928, 37, 64, 43, 3, -54 },
  { 2224, 34, 51, 43, 5, -50 },
  { 2441, 32, 50, 43, 4, -50 },
  { 2641, 35, 50, 43, 3, -50 },
  { 2860, 34, 51, 43, 3, -50 },
  { 3077, 36, 50, 43, 2, -50 },
  { 3302, 35, 51, 43, 4, -50 },
  { 3526, 30, 51, 43, 6, -50 },
  { 3718, 34, 50, 43, 8, -50 },
  { 3931, 35, 51, 43, 4, -50 },
  { 4155, 30, 50, 43, 8, -50 },
  { 4343, 10, 37, 43, 16, -37 },
  { 4390, 15, 49, 43, 11, -37 },
  { 4482, 34, 38, 43, 6, -41 },
  { 4644, 36, 14, 43, 4, -29 },
  { 4707, 34, 38, 43, 3, -41 },
  { 4869, 28, 50, 43, 11, -50 },
  { 5044, 32, 58, 43, 6, -50 },
  { 5276, 35, 50, 43, 1, -50 },
  { 5495, 34, 50, 43, 4, -50 },
  { 5708, 34, 51, 43, 6, -50 },
  { 5925, 34, 50, 43, 5, -50 },
  { 6138, 37, 50, 43, 5, -50 },
  { 6370, 37, 50, 43, 5, -50 },
  { 6602, 34, 51, 43, 6, -50 },
  { 6819, 37, 50, 43, 4, -50 },
  { 7051, 38, 50, 43, 3, -50 },
  { 7289, 33, 51, 43, 5, -50 },
  { 7500, 39, 50, 43, 5, -50 },
  { 7744, 28, 50, 43, 7, -50 },
  { 7919, 39, 50, 43, 3, -50 },
  { 8163, 37, 50, 43, 4, -50 },
  { 8395, 34, 51, 43, 5, -50 },
  { 8612, 36, 50, 43, 5, -50 },
  { 8837, 34, 62, 43, 5, -50 },
  { 9101, 36, 50, 43, 5, -50 },
  { 9326, 37, 51, 43, 3, -50 },
  { 9562, 37, 50, 43, 8, -50 },
  { 9794, 35, 51, 43, 6, -50 },
  { 10018, 35, 50, 43, 9, -50 },
  { 10237, 38, 50, 43, 6, -50 },
  { 10475, 43, 50, 43, 1, -50 },
  { 10744, 39, 50, 43, 7, -50 },
  { 10988, 43, 50, 43, 0, -50 },
  { 11257, 28, 64, 43, 14, -54 },
  { 11481, 16, 64, 43, 14, -54 },
  { 11609, 28, 64, 43, 2, -54 },
  { 11833, 33, 27, 43, 6, -50 },
  { 11945, 34, 1, 43, 0, 9 },
  { 11950, 8, 12, 43, 17, -54 },
  { 11962, 32, 38, 43, 5, -37 },
  { 12114, 31, 54, 43, 6, -53 },
  { 12324, 29, 38, 43, 6, -37 },
  { 12462, 34, 54, 43, 5, -53 },
  { 12692, 30, 38, 43, 6, -37 },
  { 12835, 45, 68, 43, -1, -53 },
  { 13218, 34, 52, 43, 3, -37 },
  { 13439, 29, 53, 43, 6, -53 },
  { 13632, 30, 54, 43, 6, -53 },
  { 13835, 29, 68, 43, 8, -53 },
  { 14082, 35, 54, 43, 6, -53 },
  { 14319, 26, 54, 43, 9, -53 },
  { 14495, 37, 37, 43, 3, -37 },
  { 14667, 29, 37, 43, 6, -37 },
  { 14802, 31, 38, 43, 6, -37 },
  { 14950, 34, 51, 43, 3, -37 },
  { 15167, 32, 51, 43, 5, -37 },
  { 15371, 34, 37, 43, 9, -37 },
  { 15529, 33, 38, 43, 4, -37 },
  { 15686, 35, 51, 43, 5, -50 },
  { 15910, 29, 38, 43, 7, -37 },
  { 16048, 32, 37, 43, 6, -37 },
  { 16196, 35, 38, 43, 5, -37 },
  { 16363, 39, 38, 43, 2, -37 },
  { 16549, 33, 52, 43, 3, -37 },
  { 16764, 34, 38, 43, 4, -37 },
  { 16926, 31, 64, 43, 9, -54 },
  { 17174, 12, 64, 43, 16, -54 },
  { 17270, 32, 64, 43, 3, -54 },
  { 17526, 36, 12, 43, 4, -28 },
};

const GFXfont IBMPlexMono_ThinItalic71pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic71pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic71pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _IBMPLEXMONO_THINITALIC71PT7B_H_
