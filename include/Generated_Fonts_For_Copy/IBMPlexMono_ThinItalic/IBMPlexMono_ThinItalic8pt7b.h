#ifndef _IBMPLEXMONO_THINITALIC8PT7B_H_
#define _IBMPLEXMONO_THINITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xE0, 0x32, 0x96, 0xCB, 0x50, 0x75, 0x68, 0xE5, 0x69, 0x80,
  0x6D, 0xAC, 0xAF, 0x78, 0x64, 0x99, 0x8A, 0x7C, 0xC0, 0x6A, 0xA8, 0x95,
  0x68, 0x4F, 0xCA, 0x5E, 0x40, 0xC0, 0xE0, 0x00, 0x18, 0x88, 0x44, 0x42,
  0x00, 0x76, 0xFB, 0x80, 0x26, 0x22, 0x2F, 0x3D, 0x12, 0x4F, 0x35, 0x13,
  0x1E, 0x13, 0x59, 0xA7, 0x34, 0x87, 0x1F, 0x3A, 0x7B, 0xC0, 0xFA, 0x44,
  0x88, 0x3D, 0x9F, 0x9F, 0x76, 0xF5, 0x00, 0x80, 0x42, 0x80, 0x16, 0x88,
  0x60, 0xF8, 0x86, 0x12, 0xC0, 0x74, 0xE8, 0x00, 0x77, 0xDB, 0xB0, 0x26,
  0x69, 0xF9, 0x79, 0x9F, 0x9F, 0x76, 0x49, 0xC0, 0xD6, 0xDB, 0x80, 0xF8,
  0x8E, 0x8E, 0xF8, 0x8E, 0x88, 0x76, 0x5B, 0xC0, 0x4C, 0xA5, 0xE9, 0x48,
  0x79, 0x08, 0x44, 0x78, 0x64, 0x93, 0x80, 0x9A, 0xCC, 0xCA, 0x92, 0x49,
  0xC0, 0x4E, 0x7D, 0xE9, 0x48, 0x4E, 0xB5, 0x6B, 0x58, 0x76, 0xDB, 0x80,
  0xE9, 0xAC, 0x88, 0x76, 0xDB, 0x98, 0xE9, 0xAC, 0xCA, 0x74, 0x60, 0xE1,
  0x78, 0xF4, 0x44, 0x88, 0x9A, 0xAA, 0xAC, 0x9A, 0xAC, 0xC8, 0x99, 0xEE,
  0xEA, 0x8A, 0x98, 0xC6, 0x48, 0x9A, 0xC4, 0x88, 0x78, 0x88, 0x88, 0x78,
  0xF2, 0x49, 0x30, 0xFE, 0x64, 0x92, 0xB0, 0x56, 0x80, 0xF0, 0x80, 0xF6,
  0xF0, 0x93, 0xDB, 0xC0, 0xF2, 0x70, 0x27, 0xDB, 0xC0, 0xF7, 0x70, 0x39,
  0x1E, 0x44, 0x23, 0x08, 0xF9, 0x99, 0x6E, 0x93, 0xDB, 0x40, 0x03, 0x4A,
  0x80, 0x03, 0xA4, 0xB2, 0x88, 0xEA, 0xCF, 0xCA, 0x4A, 0x80, 0xFD, 0xB5,
  0xA0, 0xF6, 0xD0, 0xF6, 0xE0, 0xF9, 0x99, 0xE8, 0xF6, 0xD4, 0x80, 0xF8,
  0x88, 0xF8, 0x7F, 0x48, 0xF8, 0x86, 0xB6, 0xE0, 0xB6, 0xE0, 0xED, 0xEE,
  0xF9, 0x11, 0xE0, 0x99, 0x9A, 0x6E, 0xF2, 0x5F, 0x74, 0x48, 0x48, 0xC0,
  0xFE, 0x22, 0x43, 0x64, 0xC0, 0xF8,
};

const GFXglyph IBMPlexMono_ThinItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 5, 7, 5, 0, -6 },
  { 12, 5, 6, 5, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 5, 2, -6 },
  { 21, 2, 7, 5, 2, -6 },
  { 23, 2, 7, 5, 1, -6 },
  { 25, 4, 4, 5, 1, -4 },
  { 27, 3, 4, 5, 1, -4 },
  { 29, 1, 2, 5, 1, -1 },
  { 30, 3, 1, 5, 1, -3 },
  { 31, 1, 1, 5, 2, -1 },
  { 32, 5, 7, 5, 0, -6 },
  { 37, 3, 6, 5, 1, -6 },
  { 40, 4, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 0, -6 },
  { 55, 3, 6, 5, 1, -6 },
  { 58, 4, 6, 5, 1, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 3, 6, 5, 1, -6 },
  { 67, 1, 4, 5, 2, -4 },
  { 68, 2, 5, 5, 1, -4 },
  { 70, 4, 5, 5, 1, -5 },
  { 73, 5, 1, 5, 0, -3 },
  { 74, 4, 5, 5, 0, -5 },
  { 77, 3, 6, 5, 1, -6 },
  { 80, 3, 7, 5, 1, -6 },
  { 83, 4, 6, 5, 0, -6 },
  { 86, 4, 6, 5, 0, -6 },
  { 89, 3, 6, 5, 1, -6 },
  { 92, 3, 6, 5, 1, -6 },
  { 95, 4, 6, 5, 1, -6 },
  { 98, 4, 6, 5, 1, -6 },
  { 101, 3, 6, 5, 1, -6 },
  { 104, 5, 6, 5, 0, -6 },
  { 108, 5, 6, 5, 0, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 4, 6, 5, 1, -6 },
  { 118, 3, 6, 5, 1, -6 },
  { 121, 5, 6, 5, 0, -6 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 3, 6, 5, 1, -6 },
  { 132, 4, 6, 5, 1, -6 },
  { 135, 3, 7, 5, 1, -6 },
  { 138, 4, 6, 5, 1, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 4, 6, 5, 1, -6 },
  { 148, 4, 6, 5, 1, -6 },
  { 151, 4, 6, 5, 1, -6 },
  { 154, 4, 6, 5, 1, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 4, 6, 5, 1, -6 },
  { 164, 5, 6, 5, 0, -6 },
  { 168, 3, 7, 5, 2, -6 },
  { 171, 1, 7, 5, 2, -6 },
  { 172, 3, 7, 5, 0, -6 },
  { 175, 3, 3, 5, 1, -6 },
  { 177, 4, 1, 5, 0, 1 },
  { 178, 1, 1, 5, 2, -6 },
  { 179, 3, 4, 5, 1, -4 },
  { 181, 3, 6, 5, 1, -6 },
  { 184, 3, 4, 5, 1, -4 },
  { 186, 3, 6, 5, 1, -6 },
  { 189, 3, 4, 5, 1, -4 },
  { 191, 5, 8, 5, 0, -6 },
  { 196, 4, 6, 5, 0, -4 },
  { 199, 3, 6, 5, 1, -6 },
  { 202, 3, 6, 5, 1, -6 },
  { 205, 3, 8, 5, 1, -6 },
  { 208, 4, 6, 5, 1, -6 },
  { 211, 3, 6, 5, 1, -6 },
  { 214, 5, 4, 5, 0, -4 },
  { 217, 3, 4, 5, 1, -4 },
  { 219, 3, 4, 5, 1, -4 },
  { 221, 4, 6, 5, 0, -4 },
  { 224, 3, 6, 5, 1, -4 },
  { 227, 4, 4, 5, 1, -4 },
  { 229, 4, 4, 5, 0, -4 },
  { 231, 4, 6, 5, 1, -6 },
  { 234, 3, 4, 5, 1, -4 },
  { 236, 3, 4, 5, 1, -4 },
  { 238, 4, 4, 5, 1, -4 },
  { 240, 5, 4, 5, 0, -4 },
  { 243, 4, 6, 5, 0, -4 },
  { 246, 4, 4, 5, 0, -4 },
  { 248, 4, 7, 5, 1, -6 },
  { 252, 1, 7, 5, 2, -6 },
  { 253, 4, 7, 5, 0, -6 },
  { 257, 5, 1, 5, 0, -3 },
};

const GFXfont IBMPlexMono_ThinItalic8pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic8pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _IBMPLEXMONO_THINITALIC8PT7B_H_
