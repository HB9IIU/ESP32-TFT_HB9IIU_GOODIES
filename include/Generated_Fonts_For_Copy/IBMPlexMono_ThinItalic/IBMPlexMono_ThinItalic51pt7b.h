#ifndef _IBMPLEXMONO_THINITALIC51PT7B_H_
#define _IBMPLEXMONO_THINITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0xE0, 0x30, 0x4C, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x36, 0x09, 0x02, 0x40,
  0x90, 0x24, 0x19, 0x04, 0xC1, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x02, 0x01, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x40, 0x60, 0x20, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x80,
  0x40, 0x00, 0x02, 0x01, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x04, 0x06, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x80, 0x40, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x02, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x23, 0x80, 0x0C, 0x04, 0x0C,
  0x03, 0x00, 0x80, 0xC0, 0x40, 0x10, 0x0C, 0x10, 0x06, 0x01, 0x02, 0x00,
  0x80, 0x00, 0xC0, 0x10, 0x00, 0x10, 0x02, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x40, 0x08, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x10, 0x08,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x04, 0x70, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x10, 0x06, 0x00, 0x02, 0x00, 0x40, 0x00, 0x40, 0x08, 0x00, 0x08, 0x01,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x40, 0x08, 0x00, 0x08, 0x01, 0x08, 0x01,
  0x00, 0x60, 0x80, 0x20, 0x08, 0x08, 0x04, 0x02, 0x00, 0xC0, 0x81, 0x80,
  0x0E, 0x30, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xC0, 0x18, 0x20, 0x00, 0x20, 0x08, 0x04, 0x00,
  0x10, 0x04, 0x00, 0x80, 0x08, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x80, 0x10, 0x00, 0x80, 0x40, 0x04, 0x00,
  0x20, 0x20, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x02, 0x04, 0x00, 0x10,
  0x01, 0x82, 0x00, 0x04, 0x00, 0x41, 0x00, 0x00, 0x80, 0x30, 0xC0, 0x00,
  0x20, 0x18, 0x20, 0x00, 0x06, 0x0C, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x06, 0x0E, 0x18, 0x00, 0x01, 0x06,
  0x01, 0x00, 0x00, 0x81, 0x00, 0x60, 0x00, 0x40, 0x80, 0x08, 0x00, 0x20,
  0x20, 0x02, 0x00, 0x18, 0x10, 0x00, 0x80, 0x04, 0x04, 0x00, 0x20, 0x02,
  0x01, 0x00, 0x08, 0x01, 0x00, 0x40, 0x02, 0x00, 0xC0, 0x10, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x40, 0x10, 0x01, 0x00, 0x10, 0x08, 0x00, 0x40, 0x08,
  0x06, 0x00, 0x08, 0x04, 0x01, 0x00, 0x01, 0x06, 0x00, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x06,
  0x00, 0x01, 0x00, 0x18, 0x00, 0x18, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x40, 0x04, 0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x02, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x0F, 0x86, 0x00, 0x03, 0x84, 0xC0, 0x00, 0x20,
  0x18, 0x00, 0x02, 0x00, 0x80, 0x00, 0x20, 0x02, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x20, 0x01, 0x00, 0x00, 0x80, 0x08, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x50, 0x06, 0x00, 0x02, 0xC0, 0x50, 0x00, 0x12, 0x04, 0xC0, 0x01,
  0x08, 0x22, 0x00, 0x18, 0x62, 0x08, 0x01, 0x81, 0x30, 0x30, 0x38, 0x05,
  0x00, 0x7E, 0x00, 0x30, 0x00, 0x25, 0xA4, 0x92, 0xD2, 0x48, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x30, 0x01, 0x00, 0x33, 0x80,
  0x40, 0x70, 0x1C, 0x20, 0xE0, 0x00, 0xEB, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x62, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x18, 0x30, 0x41, 0x82,
  0x0C, 0x18, 0x20, 0xC1, 0x02, 0x08, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x60, 0x30, 0x01, 0x80, 0x08, 0x03, 0x00, 0x04, 0x06,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x01, 0x10,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20,
  0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x18, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x20, 0x40,
  0x00, 0x40, 0x20, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x32, 0x00, 0x00,
  0xC4, 0x00, 0x03, 0x08, 0x00, 0x18, 0x10, 0x00, 0x60, 0x20, 0x01, 0x80,
  0xC0, 0x04, 0x01, 0x00, 0x30, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1C, 0x06, 0x00, 0x10, 0x00, 0x80, 0x10, 0x00, 0x20, 0x10,
  0x00, 0x10, 0x10, 0x00, 0x04, 0x08, 0x00, 0x02, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x20, 0x00, 0x60, 0x20, 0x00, 0x10, 0x30, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x10, 0x00,
  0x18, 0x04, 0x00, 0x18, 0x01, 0xC0, 0x30, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x20, 0x00, 0x01, 0x10, 0x00, 0x01, 0x08, 0x00, 0x01, 0x04,
  0x00, 0x01, 0x84, 0x00, 0x01, 0x82, 0x00, 0x00, 0x81, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x80, 0x40, 0x00, 0x80, 0x20, 0x00, 0x80, 0x20, 0x00, 0xC0,
  0x10, 0x00, 0x40, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x40,
  0x01, 0x00, 0x40, 0x01, 0x80, 0x60, 0x00, 0x80, 0x60, 0x00, 0x40, 0x20,
  0x00, 0x20, 0x20, 0x00, 0x10, 0x20, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0xFF, 0x00, 0x09, 0x80, 0xE0, 0x05, 0x00, 0x18,
  0x03, 0x00, 0x02, 0x03, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x30,
  0x00, 0x10, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x70, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x1F, 0xC0, 0x13, 0x80, 0xC0, 0x98,
  0x00, 0xC2, 0x80, 0x01, 0x14, 0x00, 0x02, 0x60, 0x00, 0x09, 0x80, 0x00,
  0x14, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00,
  0x01, 0x90, 0x00, 0x04, 0x40, 0x00, 0x20, 0x80, 0x01, 0x01, 0x00, 0x18,
  0x03, 0x01, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08,
  0x40, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x20, 0x00, 0x20, 0x20, 0x00, 0x18, 0x30, 0x00,
  0x04, 0x10, 0x00, 0x02, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x10, 0x20,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x00,
  0x3F, 0xE0, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0x20, 0x80, 0x00, 0x08, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02,
  0x60, 0x00, 0x01, 0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x12, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x10, 0x00, 0x08, 0x04, 0x00, 0x18, 0x01, 0xC0, 0x70, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x06, 0x03, 0x80, 0x60, 0x03, 0x03, 0x00,
  0x06, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x58, 0x00, 0x01,
  0x40, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00,
  0x19, 0x80, 0x00, 0xA2, 0x00, 0x06, 0x84, 0x00, 0x34, 0x0E, 0x07, 0x10,
  0x0F, 0xF0, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE1, 0xC3, 0x80, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x38, 0x18, 0x00, 0xC3, 0x00, 0x06,
  0x60, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x03,
  0xE0, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xE0, 0x70, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x20, 0x40,
  0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x04, 0x20, 0x00, 0x08, 0x80, 0x3F, 0x11, 0x00, 0xC1, 0x22, 0x02, 0x01,
  0x48, 0x08, 0x02, 0x90, 0x20, 0x02, 0x20, 0x40, 0x04, 0x40, 0x80, 0x08,
  0x82, 0x00, 0x12, 0x04, 0x00, 0x24, 0x08, 0x00, 0x48, 0x10, 0x01, 0x10,
  0x20, 0x02, 0x20, 0xC0, 0x04, 0x41, 0x80, 0x09, 0x03, 0x00, 0x32, 0x02,
  0x00, 0x64, 0x04, 0x01, 0x88, 0x08, 0x05, 0x10, 0x08, 0x1A, 0x20, 0x0E,
  0xE4, 0x40, 0x02, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x10, 0x00, 0x08, 0x04,
  0x00, 0x02, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00, 0x20,
  0x06, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x02, 0x00, 0x20, 0x00, 0x80, 0x10, 0x00, 0x30, 0x07, 0xFF, 0xFC,
  0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x40, 0x00, 0x10, 0x10, 0x00,
  0x04, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x01, 0x03, 0xFF, 0xF0, 0x02, 0x00, 0x1C, 0x06, 0x00, 0x06,
  0x04, 0x00, 0x02, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01,
  0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x08, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x04,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x30, 0x1F, 0xFF, 0xC0, 0x10, 0x00, 0x30,
  0x10, 0x00, 0x08, 0x10, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x02,
  0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02,
  0x60, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04,
  0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x30, 0x80, 0x00, 0xE0,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x60, 0x00, 0x40, 0x80, 0x00, 0x42, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x20, 0x00, 0x10, 0x40,
  0x00, 0x40, 0x40, 0x01, 0x00, 0x40, 0x04, 0x00, 0x60, 0x30, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x18, 0x00, 0x80, 0x03, 0x00,
  0x40, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04,
  0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x31, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40,
  0x00, 0x04, 0x60, 0x00, 0x02, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x60, 0x40, 0x00, 0x60, 0x20, 0x00, 0x60,
  0x10, 0x00, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xE0, 0x70, 0x01, 0x80, 0x18, 0x02, 0x00, 0x0C, 0x04,
  0x00, 0x04, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x10, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x1F, 0xFC, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80,
  0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x50, 0x40,
  0x00, 0x70, 0x60, 0x00, 0xA0, 0x30, 0x01, 0x20, 0x0C, 0x06, 0x20, 0x03,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x40, 0x00, 0x04,
  0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x08, 0x30, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x18, 0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00, 0x03, 0x07, 0xFF, 0xFF,
  0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x08,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x40, 0x00, 0x0C,
  0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00,
  0x40, 0x80, 0x01, 0x80, 0x80, 0x02, 0x01, 0x80, 0x18, 0x01, 0xC0, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18, 0x10, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x02, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x30, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x20, 0x03, 0x00, 0x03, 0x00, 0x20, 0x00, 0x10, 0x02, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x08, 0x28, 0x00, 0x00, 0x82, 0x60, 0x00, 0x04, 0x61, 0x00,
  0x00, 0x26, 0x08, 0x00, 0x01, 0x60, 0x20, 0x00, 0x0E, 0x01, 0x00, 0x00,
  0x60, 0x04, 0x00, 0x06, 0x00, 0x20, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x10, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x08, 0x02, 0x00, 0x00, 0x40, 0x10, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x68, 0x00, 0x0E, 0x04,
  0x80, 0x00, 0xA0, 0x48, 0x00, 0x12, 0x04, 0x80, 0x03, 0x20, 0x44, 0x00,
  0x22, 0x04, 0x40, 0x06, 0x60, 0xC4, 0x00, 0x44, 0x08, 0x20, 0x08, 0x40,
  0x82, 0x01, 0x84, 0x08, 0x20, 0x10, 0x40, 0x82, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x81, 0x04, 0x08, 0x10, 0x10, 0xC0, 0x81, 0x01, 0x08, 0x08,
  0x10, 0x09, 0x00, 0x81, 0x00, 0xB0, 0x08, 0x10, 0x0A, 0x00, 0x81, 0x00,
  0x40, 0x10, 0x20, 0x04, 0x01, 0x02, 0x00, 0x80, 0x10, 0x20, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x80, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x10, 0x50, 0x00,
  0x04, 0x16, 0x00, 0x01, 0x04, 0x80, 0x00, 0xC1, 0x20, 0x00, 0x20, 0x44,
  0x00, 0x08, 0x31, 0x00, 0x02, 0x08, 0x40, 0x00, 0x82, 0x08, 0x00, 0x20,
  0x82, 0x00, 0x08, 0x20, 0x80, 0x04, 0x08, 0x10, 0x01, 0x06, 0x04, 0x00,
  0x41, 0x01, 0x00, 0x10, 0x40, 0x20, 0x04, 0x10, 0x08, 0x01, 0x04, 0x02,
  0x00, 0x81, 0x00, 0x40, 0x20, 0x40, 0x10, 0x08, 0x20, 0x04, 0x02, 0x08,
  0x00, 0x80, 0x82, 0x00, 0x20, 0x20, 0x80, 0x0C, 0x10, 0x20, 0x01, 0x04,
  0x08, 0x00, 0x41, 0x04, 0x00, 0x18, 0x41, 0x00, 0x02, 0x10, 0x40, 0x00,
  0x84, 0x10, 0x00, 0x32, 0x04, 0x00, 0x04, 0x81, 0x00, 0x01, 0x20, 0x80,
  0x00, 0x28, 0x20, 0x00, 0x0A, 0x08, 0x00, 0x02, 0x82, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0xC0, 0x00, 0x60, 0x30, 0x01, 0x80, 0x08, 0x03, 0x00, 0x04,
  0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x01,
  0x10, 0x00, 0x01, 0x10, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01,
  0x20, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x08, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x20,
  0x40, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x10, 0x01, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00,
  0x10, 0x08, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x04, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x04, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x04, 0x00,
  0x07, 0x01, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x60, 0x30, 0x01, 0x80, 0x08, 0x03, 0x00, 0x04,
  0x06, 0x00, 0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x01,
  0x10, 0x00, 0x01, 0x10, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01,
  0x20, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x08, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x20,
  0x40, 0x00, 0x40, 0x20, 0x00, 0x80, 0x10, 0x01, 0x00, 0x0C, 0x06, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x04,
  0x00, 0x18, 0x18, 0x00, 0x08, 0x30, 0x00, 0x04, 0x60, 0x00, 0x06, 0x80,
  0x00, 0x03, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00,
  0x10, 0x08, 0x00, 0x02, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x04, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x04, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x04, 0x00,
  0x07, 0x01, 0xFF, 0xFE, 0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x00, 0x04,
  0x00, 0x80, 0x01, 0x00, 0x20, 0x00, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x60, 0x02, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x20, 0x00,
  0x40, 0x18, 0x00, 0x10, 0x04, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x10, 0x10, 0x00, 0x04, 0x04, 0x00, 0x00, 0x83, 0x00, 0x00, 0x20,
  0x00, 0x1F, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x60, 0x20, 0x00, 0x06, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x04, 0x04, 0x00, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x80,
  0x70, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x18, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04,
  0x30, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0xC0, 0x00,
  0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x03, 0x08, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00, 0x04, 0x10,
  0x00, 0x02, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x81,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x40, 0x40, 0x00, 0x60, 0x30, 0x00, 0x20,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x21, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40,
  0x00, 0x10, 0x20, 0x00, 0x08, 0x10, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x02,
  0x00, 0x04, 0x01, 0x00, 0x02, 0x00, 0x80, 0x02, 0x00, 0x40, 0x01, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x80, 0x02, 0x00, 0x40,
  0x01, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x40, 0x30, 0x00, 0x20, 0x10,
  0x00, 0x18, 0x18, 0x00, 0x04, 0x08, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x33, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x00, 0x90, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x02, 0x10, 0x06, 0x00, 0x82, 0x00, 0xC0, 0x10, 0x40,
  0x38, 0x02, 0x08, 0x05, 0x00, 0x41, 0x00, 0xA0, 0x10, 0x20, 0x22, 0x02,
  0x0C, 0x04, 0x40, 0x41, 0x01, 0x08, 0x18, 0x20, 0x21, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x40, 0x83, 0x02, 0x08, 0x10, 0x40,
  0x43, 0x01, 0x08, 0x08, 0x40, 0x21, 0x01, 0x18, 0x04, 0x40, 0x22, 0x00,
  0x88, 0x04, 0xC0, 0x11, 0x00, 0x90, 0x02, 0x20, 0x12, 0x00, 0x48, 0x02,
  0x80, 0x0D, 0x00, 0xD0, 0x00, 0xA0, 0x14, 0x00, 0x14, 0x02, 0x80, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x08, 0x02, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0x20, 0x18, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x10, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x10, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x01, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x80, 0x18, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x30, 0x10, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x40, 0x08, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x20, 0x06, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30,
  0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x01, 0xFF, 0xE0, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x04, 0x80, 0x00, 0x08, 0x80, 0x00, 0x10, 0xC0,
  0x00, 0x30, 0x40, 0x00, 0x60, 0x40, 0x00, 0x40, 0x20, 0x00, 0x80, 0x20,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x10, 0x02, 0x00, 0x08, 0x04, 0x00, 0x08,
  0x08, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x10, 0x00, 0x04, 0x20, 0x00, 0x02,
  0x40, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC1, 0x02, 0x08,
  0x10, 0x60, 0x81, 0x00, 0x7F, 0x00, 0x03, 0x03, 0x88, 0x18, 0x01, 0x90,
  0x60, 0x01, 0xA1, 0x80, 0x01, 0x42, 0x00, 0x01, 0x88, 0x00, 0x03, 0x10,
  0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x90, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00,
  0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x28, 0x20, 0x00, 0x50,
  0x60, 0x01, 0x60, 0x60, 0x0C, 0x80, 0x60, 0x31, 0xF8, 0x3F, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0xFC, 0x00, 0x86,
  0x06, 0x01, 0x10, 0x02, 0x02, 0x40, 0x02, 0x05, 0x00, 0x02, 0x0C, 0x00,
  0x04, 0x38, 0x00, 0x08, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x98, 0x00, 0x01, 0x20, 0x00, 0x02,
  0x40, 0x00, 0x0C, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x90, 0x00, 0x02, 0x20, 0x00, 0x04, 0x60, 0x00, 0x10, 0xC0,
  0x00, 0x21, 0x80, 0x00, 0x86, 0x80, 0x02, 0x08, 0x80, 0x08, 0x10, 0xC0,
  0x60, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x06, 0x00, 0x80,
  0x08, 0x08, 0x00, 0x20, 0x80, 0x00, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x01,
  0xA0, 0x00, 0x19, 0x00, 0x00, 0x84, 0x00, 0x08, 0x30, 0x00, 0x80, 0xC0,
  0x08, 0x03, 0x01, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x7F, 0x04, 0x01, 0x81, 0xC4, 0x06, 0x00,
  0x64, 0x0C, 0x00, 0x34, 0x18, 0x00, 0x14, 0x10, 0x00, 0x0C, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0x80, 0x00,
  0xA0, 0x40, 0x01, 0x20, 0x60, 0x01, 0x60, 0x30, 0x06, 0x40, 0x18, 0x0C,
  0x40, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x01, 0x80, 0x30, 0x01,
  0x01, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x60, 0x00, 0x11, 0x00, 0x00, 0x48,
  0x00, 0x03, 0x20, 0x00, 0x09, 0x00, 0x00, 0x64, 0x00, 0x03, 0x10, 0x00,
  0x18, 0x40, 0x03, 0x82, 0x01, 0xF0, 0x0F, 0xF8, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x04, 0x40,
  0x00, 0x19, 0x00, 0x00, 0x44, 0x00, 0x02, 0x08, 0x00, 0x18, 0x30, 0x00,
  0xC0, 0x60, 0x06, 0x00, 0xE0, 0x60, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x00, 0xA0, 0x04, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x71, 0x01, 0x80, 0x19, 0x03, 0x00,
  0x0D, 0x06, 0x00, 0x05, 0x04, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08, 0x00,
  0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x20, 0x00,
  0x02, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00,
  0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x18, 0x20, 0x00, 0x28, 0x10, 0x00,
  0x28, 0x18, 0x00, 0x58, 0x0C, 0x01, 0x90, 0x06, 0x03, 0x10, 0x01, 0xFC,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x40, 0x00, 0x80, 0xE0, 0x01,
  0x00, 0x18, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x3F, 0x00, 0x46, 0x06, 0x02, 0x40, 0x08, 0x34, 0x00, 0x61, 0x40,
  0x01, 0x0A, 0x00, 0x08, 0x60, 0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x11,
  0x80, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00,
  0x08, 0x80, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10,
  0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01,
  0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x06, 0x60, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x0C, 0x04, 0x00, 0x80, 0x20, 0x18, 0x03,
  0x01, 0x00, 0x10, 0x30, 0x00, 0x83, 0x00, 0x04, 0x60, 0x00, 0x26, 0x00,
  0x03, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x80, 0x40, 0x08,
  0x02, 0x00, 0x80, 0x10, 0x08, 0x00, 0xC0, 0x80, 0x06, 0x18, 0x00, 0x31,
  0x00, 0x01, 0x90, 0x00, 0x0D, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x83, 0xF8, 0x00, 0x86,
  0x03, 0x00, 0x44, 0x00, 0xC0, 0x24, 0x00, 0x20, 0x14, 0x00, 0x18, 0x0C,
  0x00, 0x04, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x01, 0x02, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x80, 0x40, 0x00, 0x80, 0x60, 0x01, 0x80,
  0x20, 0x03, 0x00, 0x10, 0x0E, 0x00, 0x08, 0x38, 0x00, 0x04, 0x18, 0x00,
  0x02, 0x04, 0x00, 0x03, 0x03, 0x00, 0x01, 0x00, 0x80, 0x02, 0x80, 0x20,
  0x02, 0x40, 0x10, 0x02, 0x20, 0x04, 0x06, 0x10, 0x02, 0x06, 0x18, 0x00,
  0x86, 0x08, 0x00, 0x66, 0x04, 0x00, 0x16, 0x00, 0x00, 0x06, 0x00, 0xFF,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x41, 0x00,
  0x30, 0x20, 0x08, 0x04, 0x06, 0x00, 0x81, 0x00, 0x10, 0xC0, 0x06, 0x30,
  0x00, 0x98, 0x00, 0x16, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x81,
  0x90, 0xC6, 0x18, 0x24, 0x09, 0x81, 0x05, 0x00, 0xA0, 0x10, 0xC0, 0x18,
  0x02, 0x10, 0x02, 0x00, 0x42, 0x00, 0x40, 0x08, 0xC0, 0x18, 0x01, 0x10,
  0x02, 0x00, 0x42, 0x00, 0x40, 0x08, 0x40, 0x08, 0x01, 0x08, 0x01, 0x00,
  0x21, 0x00, 0x20, 0x04, 0x40, 0x0C, 0x00, 0x88, 0x01, 0x00, 0x21, 0x00,
  0x20, 0x04, 0x20, 0x04, 0x00, 0x84, 0x00, 0x80, 0x10, 0x80, 0x10, 0x02,
  0x20, 0x06, 0x00, 0x44, 0x00, 0x80, 0x10, 0x80, 0x10, 0x02, 0x10, 0x02,
  0x00, 0x42, 0x00, 0x40, 0x08, 0x40, 0x08, 0x01, 0x10, 0x03, 0x00, 0x22,
  0x00, 0x40, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x23, 0x03, 0x01, 0x20, 0x04,
  0x1A, 0x00, 0x30, 0xA0, 0x00, 0x85, 0x00, 0x04, 0x30, 0x00, 0x21, 0x00,
  0x01, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11,
  0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00,
  0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x62, 0x00, 0x02, 0x20,
  0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x03,
  0x30, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x07, 0x03, 0x00, 0x20, 0x03, 0x01,
  0x00, 0x04, 0x08, 0x00, 0x08, 0x40, 0x00, 0x31, 0x00, 0x00, 0x48, 0x00,
  0x01, 0x20, 0x00, 0x05, 0x80, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01,
  0x40, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00,
  0x19, 0x00, 0x00, 0x44, 0x00, 0x02, 0x18, 0x00, 0x18, 0x20, 0x00, 0x40,
  0x40, 0x06, 0x00, 0xC0, 0x60, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x01,
  0x8C, 0x0C, 0x00, 0x88, 0x01, 0x00, 0x48, 0x00, 0x40, 0x28, 0x00, 0x10,
  0x18, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x06, 0x10, 0x00, 0x02, 0x08, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x86, 0x00, 0x00, 0x42, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x20, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x10, 0x30, 0x00, 0x10, 0x34,
  0x00, 0x10, 0x11, 0x00, 0x10, 0x08, 0x60, 0x30, 0x04, 0x0F, 0xE0, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x06, 0x07, 0x10, 0x60, 0x06,
  0x43, 0x00, 0x0D, 0x18, 0x00, 0x14, 0x40, 0x00, 0x32, 0x00, 0x00, 0xC8,
  0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0xA0, 0x00,
  0x02, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80,
  0x00, 0x22, 0x00, 0x01, 0x88, 0x00, 0x0A, 0x10, 0x00, 0x28, 0x60, 0x01,
  0x60, 0xC0, 0x19, 0x01, 0x80, 0xC4, 0x01, 0xFC, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0xFF, 0xC1,
  0xFF, 0x80, 0x23, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x04, 0x40, 0x00, 0x08, 0x20, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x0E, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x80,
  0x10, 0x01, 0x80, 0x08, 0x01, 0x00, 0x04, 0x03, 0x00, 0x02, 0x02, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x88, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02,
  0x20, 0x00, 0x31, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00, 0x44,
  0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x40, 0x00,
  0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x14, 0x40,
  0x00, 0xE1, 0x00, 0x0A, 0x08, 0x00, 0x90, 0x60, 0x08, 0x81, 0xC1, 0x84,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x05, 0xFE, 0x00, 0x0C, 0x04, 0x00, 0x08,
  0x08, 0x00, 0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81,
  0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00, 0x18, 0x20,
  0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x02, 0x02, 0x00,
  0x04, 0x04, 0x00, 0x18, 0x18, 0x00, 0x20, 0x20, 0x00, 0x80, 0x40, 0x03,
  0x00, 0x80, 0x04, 0x01, 0x00, 0x10, 0x02, 0x00, 0xC0, 0x04, 0x03, 0x00,
  0x10, 0x18, 0x00, 0x20, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x10, 0x02, 0x02,
  0x08, 0x01, 0x00, 0x84, 0x00, 0x80, 0x42, 0x00, 0x80, 0x23, 0x00, 0x40,
  0x11, 0x00, 0x20, 0x04, 0x80, 0x10, 0x02, 0x40, 0x08, 0x01, 0x20, 0x04,
  0x00, 0x90, 0x04, 0x00, 0x58, 0x02, 0x00, 0x28, 0x01, 0x00, 0x14, 0x00,
  0x80, 0x0A, 0x00, 0x40, 0x05, 0x00, 0x20, 0x06, 0x80, 0x20, 0x02, 0xC0,
  0x10, 0x01, 0x40, 0x08, 0x00, 0xA0, 0x04, 0x00, 0x50, 0x02, 0x00, 0x48,
  0x03, 0x00, 0x24, 0x01, 0x80, 0x32, 0x01, 0x40, 0x11, 0x00, 0xA0, 0x10,
  0x80, 0x90, 0x18, 0x21, 0x84, 0x18, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x40, 0x61, 0x01, 0xC3, 0x04, 0x04, 0x30, 0x08, 0x40,
  0x26, 0x00, 0x44, 0x00, 0x80, 0x01, 0x20, 0x04, 0x00, 0x0A, 0x00, 0x20,
  0x00, 0x50, 0x01, 0x00, 0x02, 0x80, 0x18, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x80, 0x01, 0x80, 0x14, 0x00, 0x08, 0x00,
  0xA0, 0x00, 0x40, 0x05, 0x00, 0x02, 0x00, 0x48, 0x00, 0x90, 0x06, 0x20,
  0x0C, 0xC0, 0x21, 0x01, 0x82, 0x02, 0x0C, 0x30, 0x08, 0x60, 0x26, 0x00,
  0x3C, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00,
  0x01, 0x02, 0x00, 0x03, 0x02, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00,
  0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x04, 0x00,
  0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08, 0x00,
  0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x10, 0x00, 0x18, 0x10, 0x00, 0x28, 0x10, 0x00, 0x38, 0x08, 0x00,
  0x50, 0x08, 0x00, 0x90, 0x0C, 0x01, 0x10, 0x07, 0x06, 0x10, 0x01, 0xF8,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x80, 0x01, 0x80, 0x60, 0x03,
  0x00, 0x38, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x03,
  0x00, 0xC2, 0x00, 0x70, 0x43, 0x00, 0x06, 0x21, 0x00, 0x00, 0xF0, 0x80,
  0x00, 0x30, 0x40, 0x00, 0x20, 0x20, 0x00, 0x20, 0x10, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x80, 0x01, 0x00, 0x80, 0x00,
  0x80, 0x80, 0x00, 0x41, 0x80, 0x00, 0x21, 0xC0, 0x00, 0x10, 0x9F, 0x00,
  0x08, 0x40, 0x7C, 0x02, 0x20, 0x01, 0xF1, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x60, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x06, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x42, 0x18, 0x00, 0x21,
  0x03, 0x00, 0x08, 0x80, 0x60, 0x04, 0x60, 0x08, 0x01, 0x10, 0x01, 0x00,
  0x84, 0x00, 0x20, 0x62, 0x00, 0x04, 0x30, 0x80, 0x00, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 36, 31, 12, -36 },
  { 37, 10, 13, 31, 13, -38 },
  { 54, 30, 36, 31, 1, -36 },
  { 189, 27, 47, 31, 2, -41 },
  { 348, 34, 37, 31, -1, -36 },
  { 506, 29, 37, 31, 1, -36 },
  { 641, 3, 13, 31, 17, -38 },
  { 646, 16, 46, 31, 12, -39 },
  { 738, 16, 46, 31, 4, -39 },
  { 830, 26, 25, 31, 3, -28 },
  { 912, 25, 25, 31, 3, -28 },
  { 991, 7, 13, 31, 8, -4 },
  { 1003, 13, 1, 31, 9, -16 },
  { 1005, 3, 3, 31, 12, -3 },
  { 1007, 27, 46, 31, 2, -39 },
  { 1163, 24, 37, 31, 4, -36 },
  { 1274, 23, 36, 31, 3, -36 },
  { 1378, 25, 36, 31, 2, -36 },
  { 1491, 25, 37, 31, 2, -36 },
  { 1607, 25, 36, 31, 2, -36 },
  { 1720, 25, 37, 31, 3, -36 },
  { 1836, 22, 37, 31, 4, -36 },
  { 1938, 24, 36, 31, 6, -36 },
  { 2046, 25, 37, 31, 3, -36 },
  { 2162, 22, 36, 31, 5, -36 },
  { 2261, 7, 27, 31, 12, -27 },
  { 2285, 11, 36, 31, 8, -27 },
  { 2335, 24, 27, 31, 5, -29 },
  { 2416, 26, 10, 31, 3, -21 },
  { 2449, 25, 27, 31, 2, -29 },
  { 2534, 20, 36, 31, 8, -36 },
  { 2624, 23, 41, 31, 4, -36 },
  { 2742, 26, 36, 31, 0, -36 },
  { 2859, 24, 36, 31, 3, -36 },
  { 2967, 23, 37, 31, 5, -36 },
  { 3074, 25, 36, 31, 3, -36 },
  { 3187, 27, 36, 31, 3, -36 },
  { 3309, 27, 36, 31, 3, -36 },
  { 3431, 24, 37, 31, 5, -36 },
  { 3542, 26, 36, 31, 3, -36 },
  { 3659, 28, 36, 31, 2, -36 },
  { 3785, 23, 37, 31, 4, -36 },
  { 3892, 29, 36, 31, 3, -36 },
  { 4023, 20, 36, 31, 5, -36 },
  { 4113, 28, 36, 31, 2, -36 },
  { 4239, 26, 36, 31, 3, -36 },
  { 4356, 24, 37, 31, 4, -36 },
  { 4467, 26, 36, 31, 3, -36 },
  { 4584, 24, 45, 31, 4, -36 },
  { 4719, 26, 36, 31, 3, -36 },
  { 4836, 27, 37, 31, 2, -36 },
  { 4961, 26, 36, 31, 6, -36 },
  { 5078, 25, 37, 31, 4, -36 },
  { 5194, 25, 36, 31, 7, -36 },
  { 5307, 27, 36, 31, 4, -36 },
  { 5429, 31, 36, 31, 0, -36 },
  { 5569, 28, 36, 31, 5, -36 },
  { 5695, 31, 36, 31, 0, -36 },
  { 5835, 20, 46, 31, 10, -39 },
  { 5950, 12, 46, 31, 10, -39 },
  { 6019, 19, 46, 31, 2, -39 },
  { 6129, 24, 19, 31, 4, -36 },
  { 6186, 24, 1, 31, 0, 6 },
  { 6189, 6, 8, 31, 12, -38 },
  { 6195, 23, 28, 31, 4, -27 },
  { 6276, 23, 39, 31, 4, -38 },
  { 6389, 21, 28, 31, 4, -27 },
  { 6463, 24, 39, 31, 4, -38 },
  { 6580, 22, 28, 31, 4, -27 },
  { 6657, 32, 49, 31, -1, -38 },
  { 6853, 24, 38, 31, 2, -27 },
  { 6967, 21, 38, 31, 4, -38 },
  { 7067, 21, 39, 31, 5, -38 },
  { 7170, 20, 49, 31, 6, -38 },
  { 7293, 25, 39, 31, 4, -38 },
  { 7415, 19, 39, 31, 6, -38 },
  { 7508, 27, 27, 31, 2, -27 },
  { 7600, 21, 27, 31, 4, -27 },
  { 7671, 22, 28, 31, 4, -27 },
  { 7748, 25, 37, 31, 2, -27 },
  { 7864, 22, 37, 31, 4, -27 },
  { 7966, 25, 26, 31, 6, -26 },
  { 8048, 24, 28, 31, 3, -27 },
  { 8132, 25, 37, 31, 4, -36 },
  { 8248, 21, 27, 31, 5, -26 },
  { 8319, 23, 27, 31, 4, -27 },
  { 8397, 25, 27, 31, 4, -26 },
  { 8482, 29, 28, 31, 1, -27 },
  { 8584, 24, 37, 31, 2, -26 },
  { 8695, 25, 28, 31, 3, -27 },
  { 8783, 23, 46, 31, 6, -39 },
  { 8916, 9, 46, 31, 11, -39 },
  { 8968, 23, 46, 31, 2, -39 },
  { 9101, 26, 9, 31, 3, -20 },
};

const GFXfont IBMPlexMono_ThinItalic51pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic51pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic51pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _IBMPLEXMONO_THINITALIC51PT7B_H_
