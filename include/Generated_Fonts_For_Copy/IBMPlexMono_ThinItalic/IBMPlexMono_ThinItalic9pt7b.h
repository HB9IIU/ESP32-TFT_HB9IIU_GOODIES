#ifndef _IBMPLEXMONO_THINITALIC9PT7B_H_
#define _IBMPLEXMONO_THINITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x39, 0xB5, 0x14, 0xDA, 0x80, 0x11, 0xBA, 0xC1, 0x55,
  0xC8, 0x6E, 0xA7, 0x16, 0xAA, 0x60, 0x32, 0x95, 0x49, 0xF4, 0xC0, 0x72,
  0x49, 0x26, 0x55, 0x5A, 0x44, 0xFE, 0x44, 0xF4, 0x40, 0xE8, 0xC0, 0x80,
  0x08, 0x84, 0x42, 0x22, 0x10, 0x79, 0x9D, 0xAE, 0x11, 0x18, 0x42, 0x7C,
  0x32, 0x42, 0x26, 0x78, 0x3A, 0x4C, 0x29, 0x38, 0x19, 0x95, 0x27, 0xC8,
  0x78, 0xEA, 0xAE, 0x68, 0xE9, 0xAE, 0xF9, 0x24, 0x88, 0x79, 0x69, 0x9E,
  0x69, 0x9E, 0x2C, 0x88, 0x40, 0xE8, 0x16, 0x88, 0x60, 0x78, 0x3E, 0x41,
  0x06, 0x6C, 0x00, 0x79, 0x24, 0x08, 0x79, 0xF9, 0xE8, 0xE0, 0x11, 0x94,
  0xA7, 0x4C, 0xF9, 0xE9, 0x9E, 0x69, 0x88, 0xAC, 0x69, 0x99, 0x9E, 0x78,
  0xF8, 0x8E, 0x78, 0xF8, 0x88, 0x69, 0x8B, 0xAE, 0x4C, 0x5F, 0x19, 0x48,
  0x79, 0x08, 0x42, 0x78, 0x71, 0x22, 0xAC, 0x9D, 0x31, 0x8A, 0x58, 0x92,
  0x49, 0xC0, 0x4E, 0xFB, 0x58, 0xC8, 0x4E, 0x6B, 0x5B, 0x48, 0x79, 0x99,
  0xAE, 0x79, 0x9F, 0x88, 0x79, 0x99, 0xAE, 0x52, 0x79, 0x9F, 0xCA, 0x36,
  0x58, 0x28, 0xB8, 0xFA, 0x10, 0x84, 0x20, 0x99, 0x99, 0xAE, 0x9C, 0xA9,
  0x4C, 0x20, 0x9C, 0xB5, 0xAA, 0x50, 0x4D, 0x42, 0x18, 0x52, 0x60, 0x9D,
  0x28, 0x84, 0x40, 0x78, 0x4C, 0x88, 0x7C, 0x72, 0x49, 0x26, 0xAA, 0xA9,
  0x31, 0x22, 0x22, 0x2E, 0x2E, 0x90, 0xF0, 0x80, 0x7A, 0xAA, 0xD0, 0x88,
  0xE9, 0x9A, 0xE0, 0x76, 0x5C, 0x11, 0x7A, 0xAA, 0xE0, 0x69, 0xEA, 0xE0,
  0x1C, 0x87, 0x88, 0x20, 0x8A, 0x30, 0x40, 0x3E, 0xA5, 0x27, 0x49, 0x80,
  0x91, 0xDB, 0x68, 0x40, 0xC4, 0x8B, 0x40, 0x10, 0xE2, 0x22, 0xAC, 0x40,
  0x88, 0xE9, 0xED, 0xA0, 0xC9, 0x49, 0x50, 0xBF, 0x6B, 0x5A, 0x80, 0xF6,
  0xDA, 0x69, 0x9A, 0xE0, 0x72, 0x63, 0x2F, 0x42, 0x00, 0x7A, 0xAA, 0xE2,
  0x20, 0xF4, 0x48, 0x80, 0x69, 0x62, 0xE0, 0x4F, 0x48, 0xB4, 0x9A, 0xAA,
  0xE0, 0x99, 0x9A, 0xC0, 0xDD, 0xDD, 0xA0, 0x3F, 0x49, 0x55, 0x00, 0x4C,
  0xA5, 0x27, 0x49, 0x80, 0x7C, 0x4D, 0xAF, 0x00, 0x34, 0x4A, 0x44, 0x86,
  0xEA, 0xAA, 0x32, 0x21, 0x64, 0x2C, 0x6C, 0x80,
};

const GFXglyph IBMPlexMono_ThinItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 2, -7 },
  { 3, 6, 6, 5, 0, -6 },
  { 8, 5, 8, 5, 0, -7 },
  { 13, 6, 6, 5, 0, -6 },
  { 18, 5, 6, 5, 0, -6 },
  { 22, 1, 2, 5, 3, -7 },
  { 23, 3, 8, 5, 2, -7 },
  { 26, 2, 8, 5, 1, -7 },
  { 28, 4, 4, 5, 1, -5 },
  { 30, 4, 5, 5, 1, -5 },
  { 33, 2, 3, 5, 1, -1 },
  { 34, 2, 1, 5, 2, -3 },
  { 35, 1, 1, 5, 2, -1 },
  { 36, 5, 8, 5, 0, -7 },
  { 41, 4, 6, 5, 1, -6 },
  { 44, 5, 6, 5, 0, -6 },
  { 48, 5, 6, 5, 0, -6 },
  { 52, 5, 6, 5, 0, -6 },
  { 56, 5, 6, 5, 0, -6 },
  { 60, 4, 6, 5, 1, -6 },
  { 63, 4, 6, 5, 1, -6 },
  { 66, 4, 6, 5, 1, -6 },
  { 69, 4, 6, 5, 1, -6 },
  { 72, 4, 6, 5, 1, -6 },
  { 75, 1, 5, 5, 2, -5 },
  { 76, 2, 7, 5, 1, -5 },
  { 78, 4, 5, 5, 1, -5 },
  { 81, 5, 3, 5, 0, -4 },
  { 83, 5, 5, 5, 0, -5 },
  { 87, 4, 6, 5, 1, -6 },
  { 90, 4, 7, 5, 1, -6 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 4, 6, 5, 1, -6 },
  { 101, 4, 6, 5, 1, -6 },
  { 104, 4, 6, 5, 1, -6 },
  { 107, 4, 6, 5, 1, -6 },
  { 110, 4, 6, 5, 1, -6 },
  { 113, 4, 6, 5, 1, -6 },
  { 116, 5, 6, 5, 0, -6 },
  { 120, 5, 6, 5, 0, -6 },
  { 124, 4, 6, 5, 1, -6 },
  { 127, 5, 6, 5, 1, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 4, 6, 5, 1, -6 },
  { 145, 4, 6, 5, 1, -6 },
  { 148, 4, 8, 5, 1, -6 },
  { 152, 4, 6, 5, 1, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 5, 6, 5, 1, -6 },
  { 163, 4, 6, 5, 1, -6 },
  { 166, 5, 6, 5, 1, -6 },
  { 170, 5, 6, 5, 1, -6 },
  { 174, 6, 6, 5, 0, -6 },
  { 179, 5, 6, 5, 1, -6 },
  { 183, 5, 6, 5, 0, -6 },
  { 187, 3, 8, 5, 2, -7 },
  { 190, 2, 8, 5, 2, -7 },
  { 192, 4, 8, 5, 0, -7 },
  { 196, 4, 3, 5, 1, -6 },
  { 198, 4, 1, 5, 0, 1 },
  { 199, 1, 1, 5, 2, -7 },
  { 200, 4, 5, 5, 1, -5 },
  { 203, 4, 7, 5, 1, -7 },
  { 207, 3, 5, 5, 1, -5 },
  { 209, 4, 7, 5, 1, -7 },
  { 213, 4, 5, 5, 1, -5 },
  { 216, 6, 9, 5, 0, -7 },
  { 223, 5, 7, 5, 0, -5 },
  { 228, 3, 7, 5, 1, -7 },
  { 231, 4, 7, 5, 1, -7 },
  { 235, 4, 9, 5, 1, -7 },
  { 240, 4, 7, 5, 1, -7 },
  { 244, 3, 7, 5, 1, -7 },
  { 247, 5, 5, 5, 0, -5 },
  { 251, 3, 5, 5, 1, -5 },
  { 253, 4, 5, 5, 1, -5 },
  { 256, 5, 7, 5, 0, -5 },
  { 261, 4, 7, 5, 1, -5 },
  { 265, 4, 5, 5, 1, -5 },
  { 268, 4, 5, 5, 1, -5 },
  { 271, 4, 6, 5, 1, -6 },
  { 274, 4, 5, 5, 1, -5 },
  { 277, 4, 5, 5, 1, -5 },
  { 280, 4, 5, 5, 1, -5 },
  { 283, 5, 5, 5, 0, -5 },
  { 287, 5, 7, 5, 0, -5 },
  { 292, 5, 5, 5, 0, -5 },
  { 296, 4, 8, 5, 1, -7 },
  { 300, 2, 8, 5, 2, -7 },
  { 302, 4, 8, 5, 0, -7 },
  { 306, 5, 2, 5, 0, -4 },
};

const GFXfont IBMPlexMono_ThinItalic9pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic9pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _IBMPLEXMONO_THINITALIC9PT7B_H_
