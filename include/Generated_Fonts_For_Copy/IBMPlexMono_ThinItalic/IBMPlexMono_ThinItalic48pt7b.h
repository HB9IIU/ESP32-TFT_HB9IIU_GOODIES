#ifndef _IBMPLEXMONO_THINITALIC48PT7B_H_
#define _IBMPLEXMONO_THINITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x60,
  0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0xE1, 0xC0, 0x60, 0xB0, 0x50, 0x68, 0x24,
  0x12, 0x0B, 0x05, 0x02, 0x83, 0x41, 0x20, 0x90, 0x40, 0x00, 0x01, 0x01,
  0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x08, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x08, 0x08, 0x00,
  0x01, 0x00, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0x01, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x80, 0x40, 0x0F, 0xF8,
  0x0F, 0xF8, 0x01, 0x80, 0x80, 0x00, 0x10, 0x08, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x04, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0x84, 0x70, 0x02, 0x02, 0x04, 0x02, 0x01, 0x01,
  0x02, 0x00, 0x80, 0x41, 0x00, 0x80, 0x01, 0x00, 0x40, 0x00, 0x80, 0x20,
  0x00, 0x40, 0x10, 0x00, 0x20, 0x08, 0x00, 0x10, 0x04, 0x00, 0x08, 0x04,
  0x00, 0x06, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x80, 0x00, 0x18,
  0x40, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x11, 0xC0, 0x00,
  0x08, 0x30, 0x00, 0x04, 0x04, 0x00, 0x02, 0x03, 0x00, 0x01, 0x00, 0x80,
  0x01, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x40, 0x10, 0x00, 0x20, 0x08,
  0x00, 0x10, 0x04, 0x00, 0x08, 0x02, 0x20, 0x08, 0x02, 0x18, 0x04, 0x01,
  0x06, 0x02, 0x01, 0x01, 0x81, 0x03, 0x00, 0x38, 0x87, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0x00, 0xC1, 0x80,
  0x02, 0x01, 0x00, 0x80, 0x04, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x40, 0x20, 0x04, 0x00, 0x40,
  0x40, 0x04, 0x00, 0x40, 0x80, 0x04, 0x00, 0x40, 0x80, 0x04, 0x00, 0x41,
  0x00, 0x04, 0x00, 0x82, 0x00, 0x04, 0x00, 0x84, 0x00, 0x02, 0x01, 0x04,
  0x00, 0x03, 0x06, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x10, 0x60, 0xC0, 0x00, 0x20, 0xC0, 0x60, 0x00, 0x40, 0x80,
  0x20, 0x00, 0x81, 0x00, 0x20, 0x00, 0x81, 0x00, 0x20, 0x01, 0x02, 0x00,
  0x20, 0x02, 0x02, 0x00, 0x20, 0x04, 0x02, 0x00, 0x20, 0x0C, 0x02, 0x00,
  0x20, 0x08, 0x02, 0x00, 0x20, 0x10, 0x02, 0x00, 0x40, 0x20, 0x02, 0x00,
  0x40, 0x60, 0x01, 0x00, 0x80, 0x40, 0x00, 0x83, 0x00, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x80, 0x08, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x18, 0x01, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x30, 0x08, 0x00, 0x02, 0x02, 0x00, 0x03, 0xE1, 0x80, 0x01, 0x84,
  0xC0, 0x00, 0x40, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x04, 0x00, 0x80, 0x01,
  0x80, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x01,
  0x00, 0x10, 0x00, 0x20, 0x02, 0x00, 0x02, 0x00, 0x40, 0x00, 0x60, 0x18,
  0x00, 0x14, 0x07, 0x00, 0x02, 0x40, 0xA0, 0x00, 0x8C, 0x22, 0x00, 0x10,
  0x84, 0x60, 0x04, 0x09, 0x03, 0x03, 0x01, 0x40, 0x1F, 0x80, 0x18, 0x00,
  0x2D, 0x24, 0x96, 0x92, 0x40, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x03, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x01, 0xE0, 0x08, 0x07, 0x1C, 0x18, 0x78, 0x03, 0x93, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x68, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x84, 0x00, 0x01, 0x02, 0x00, 0x02, 0x03, 0x00, 0x04, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x10, 0x00, 0x80, 0x20, 0x00, 0x40, 0x60, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x21, 0x86, 0x30, 0xC2, 0x18,
  0x41, 0x08, 0x20, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0x01, 0x80, 0x10, 0x01, 0x00, 0x80, 0x06, 0x04, 0x00, 0x08,
  0x20, 0x00, 0x11, 0x80, 0x00, 0x44, 0x00, 0x01, 0x30, 0x00, 0x04, 0x80,
  0x00, 0x12, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00,
  0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x03,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x04, 0x00, 0x08, 0x18,
  0x00, 0x40, 0x20, 0x02, 0x00, 0x60, 0x30, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x20, 0x00, 0x30,
  0x80, 0x03, 0x02, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x40, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x04, 0x02, 0x00, 0x02,
  0x02, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x20,
  0x18, 0x00, 0x20, 0x20, 0x00, 0x20, 0x80, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x90, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x80, 0x00, 0x02, 0x40, 0x00, 0x02, 0x20,
  0x00, 0x02, 0x20, 0x00, 0x03, 0x10, 0x00, 0x01, 0x08, 0x00, 0x01, 0x04,
  0x00, 0x01, 0x02, 0x00, 0x01, 0x01, 0x00, 0x01, 0x01, 0x00, 0x01, 0x00,
  0x80, 0x01, 0x80, 0x40, 0x00, 0x80, 0x20, 0x00, 0x80, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x80, 0x02, 0x00, 0xC0,
  0x01, 0x00, 0x40, 0x00, 0x80, 0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0x40,
  0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x7F, 0x00, 0x0B, 0x81, 0xC0, 0x14, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x20, 0x80, 0x00, 0x20, 0x40, 0x00, 0x40, 0x20, 0x01, 0x80, 0x1C, 0x07,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x43, 0xF8, 0x04, 0x60, 0x30, 0x2C, 0x00,
  0x42, 0xC0, 0x01, 0x1C, 0x00, 0x0C, 0xC0, 0x00, 0x2C, 0x00, 0x01, 0x60,
  0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x14, 0x00, 0x00,
  0xA0, 0x00, 0x05, 0x00, 0x00, 0x28, 0x00, 0x02, 0x40, 0x00, 0x11, 0x00,
  0x01, 0x0C, 0x00, 0x10, 0x30, 0x03, 0x00, 0xC0, 0x70, 0x01, 0xFC, 0x00,
  0x7F, 0xFF, 0xFD, 0x00, 0x00, 0x34, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80,
  0x00, 0x12, 0x00, 0x00, 0x88, 0x00, 0x06, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x06, 0x04, 0x00,
  0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08, 0x00,
  0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x06, 0x08, 0x00,
  0x04, 0x04, 0x00, 0x08, 0x02, 0x00, 0x10, 0x01, 0x80, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0x80, 0xC0, 0x0C, 0x00, 0x20, 0x10, 0x00, 0x10, 0x20, 0x00,
  0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x18, 0x40, 0x00, 0x10, 0x60, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x1C, 0x07, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x18, 0x0C,
  0x03, 0x00, 0x18, 0x30, 0x00, 0x41, 0x00, 0x01, 0x10, 0x00, 0x09, 0x00,
  0x00, 0x68, 0x00, 0x01, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0xC8, 0x00,
  0x06, 0x40, 0x00, 0x63, 0x00, 0x05, 0x0C, 0x00, 0x48, 0x38, 0x1C, 0x80,
  0x7F, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x70, 0xE0, 0x01,
  0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0x60, 0x20, 0x02, 0x08, 0x00, 0x22,
  0x00, 0x06, 0x80, 0x00, 0x50, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x38, 0x00, 0x70, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0x81, 0x80, 0x18, 0x01, 0x00, 0xC0, 0x02, 0x02, 0x00,
  0x08, 0x10, 0x00, 0x20, 0x40, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x40, 0x00, 0x11, 0x00, 0xF8, 0x44, 0x04, 0x1A, 0x20, 0x20, 0x18, 0x81,
  0x00, 0x62, 0x0C, 0x00, 0x88, 0x20, 0x02, 0x40, 0x80, 0x09, 0x06, 0x00,
  0x44, 0x10, 0x01, 0x10, 0x40, 0x04, 0x41, 0x00, 0x11, 0x04, 0x00, 0x48,
  0x10, 0x01, 0x20, 0x40, 0x08, 0x81, 0x00, 0x22, 0x04, 0x01, 0x88, 0x10,
  0x0A, 0x20, 0x20, 0x28, 0x80, 0xC3, 0x22, 0x00, 0xF1, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xA0, 0x00,
  0x01, 0x20, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10, 0x00, 0x06, 0x10, 0x00,
  0x04, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00,
  0x10, 0x08, 0x00, 0x10, 0x08, 0x00, 0x20, 0x08, 0x00, 0x20, 0x08, 0x00,
  0x40, 0x08, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x04, 0x00, 0x80, 0x04, 0x01,
  0x00, 0x04, 0x01, 0x00, 0x04, 0x03, 0xFF, 0xFC, 0x02, 0x00, 0x04, 0x04,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x10, 0x00, 0x02, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01, 0x40,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x07, 0xFF, 0xC0, 0x08, 0x00, 0x60, 0x10,
  0x00, 0x20, 0x20, 0x00, 0x20, 0x40, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x08, 0x20, 0x00,
  0x10, 0x40, 0x00, 0x21, 0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x0C,
  0x08, 0x00, 0x30, 0x1F, 0xFF, 0x80, 0x20, 0x00, 0xC0, 0x80, 0x00, 0x41,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10,
  0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x44, 0x00, 0x01, 0x88, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x40, 0x00,
  0x30, 0x80, 0x01, 0x81, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0,
  0xC0, 0x02, 0x00, 0x60, 0x18, 0x00, 0x40, 0x20, 0x00, 0x40, 0x80, 0x00,
  0x82, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x84, 0x00, 0x02, 0x08, 0x00, 0x04, 0x08, 0x00, 0x10,
  0x10, 0x00, 0x40, 0x18, 0x01, 0x00, 0x18, 0x0C, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x06, 0x00, 0x60, 0x04, 0x00, 0x10, 0x04, 0x00, 0x08,
  0x04, 0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00, 0x02, 0x0C, 0x00, 0x02,
  0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x03,
  0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02,
  0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x02,
  0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10,
  0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80,
  0x80, 0x06, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0xC0, 0x06, 0x00,
  0x60, 0x18, 0x00, 0x40, 0x60, 0x00, 0x40, 0x80, 0x00, 0x82, 0x00, 0x00,
  0x8C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0xFF, 0xC8, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x06, 0x40, 0x00,
  0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x42, 0x00, 0x01,
  0x84, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x10, 0x00, 0x50,
  0x10, 0x01, 0x20, 0x18, 0x0C, 0x40, 0x0F, 0xE1, 0x00, 0x04, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x81, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0xC0, 0x00,
  0x10, 0x40, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x08, 0x00,
  0x02, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x20, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x3F,
  0xFF, 0xFC, 0x10, 0x00, 0x02, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0x80, 0x00, 0x10,
  0x40, 0x00, 0x18, 0x20, 0x00, 0x08, 0x10, 0x00, 0x04, 0x08, 0x00, 0x02,
  0x04, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x20, 0x40, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x04, 0x00, 0x04, 0x18, 0x00,
  0x10, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0x20, 0x06, 0x00, 0x30, 0x38,
  0x00, 0x1F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x10,
  0x00, 0x04, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40, 0x08, 0x00, 0x30,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x01, 0x00,
  0x30, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x30, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x82, 0x80, 0x00, 0x10, 0x98,
  0x00, 0x02, 0x21, 0x00, 0x00, 0x48, 0x30, 0x00, 0x1A, 0x02, 0x00, 0x02,
  0x80, 0x60, 0x00, 0x60, 0x04, 0x00, 0x08, 0x00, 0x80, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x10, 0x01, 0x00, 0x02, 0x00, 0x20,
  0x00, 0x20, 0x04, 0x00, 0x04, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x08,
  0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x10, 0x00, 0x01, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x50,
  0x00, 0x1C, 0x14, 0x00, 0x05, 0x05, 0x00, 0x02, 0xC1, 0x20, 0x01, 0xA0,
  0xC8, 0x00, 0x48, 0x22, 0x00, 0x22, 0x08, 0x80, 0x08, 0x82, 0x10, 0x04,
  0x20, 0x84, 0x03, 0x18, 0x21, 0x00, 0x84, 0x08, 0x20, 0x41, 0x04, 0x08,
  0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x84, 0x04, 0x10, 0x11, 0x03, 0x04,
  0x04, 0x80, 0x81, 0x01, 0x60, 0x20, 0x80, 0x50, 0x08, 0x20, 0x08, 0x02,
  0x08, 0x02, 0x00, 0x82, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x20, 0x00,
  0x04, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x04, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x81, 0x40, 0x00, 0x40, 0xA0, 0x00, 0x20, 0xD0, 0x00, 0x10, 0x44,
  0x00, 0x08, 0x22, 0x00, 0x04, 0x11, 0x00, 0x04, 0x08, 0x40, 0x02, 0x04,
  0x20, 0x01, 0x06, 0x10, 0x00, 0x82, 0x04, 0x00, 0x41, 0x02, 0x00, 0x20,
  0x81, 0x00, 0x20, 0x40, 0x40, 0x10, 0x20, 0x20, 0x08, 0x30, 0x10, 0x04,
  0x10, 0x04, 0x02, 0x08, 0x02, 0x01, 0x04, 0x01, 0x81, 0x02, 0x00, 0x40,
  0x81, 0x00, 0x20, 0x40, 0x80, 0x18, 0x20, 0x80, 0x04, 0x10, 0x40, 0x02,
  0x08, 0x20, 0x00, 0x88, 0x10, 0x00, 0x44, 0x08, 0x00, 0x22, 0x04, 0x00,
  0x09, 0x04, 0x00, 0x04, 0x82, 0x00, 0x02, 0x41, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x60, 0x40, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x80, 0x06, 0x04, 0x00, 0x08, 0x20, 0x00, 0x11, 0x80,
  0x00, 0x44, 0x00, 0x01, 0x30, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02,
  0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80,
  0x00, 0x62, 0x00, 0x01, 0x04, 0x00, 0x08, 0x18, 0x00, 0x40, 0x20, 0x02,
  0x00, 0x60, 0x30, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x06, 0x00,
  0x0C, 0x04, 0x00, 0x06, 0x04, 0x00, 0x02, 0x04, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00,
  0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x03, 0x18, 0x00,
  0x02, 0x10, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x1F, 0xFF,
  0xC0, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0x01, 0x80, 0x10, 0x01, 0x00, 0x80, 0x06,
  0x04, 0x00, 0x08, 0x20, 0x00, 0x11, 0x80, 0x00, 0x44, 0x00, 0x01, 0x30,
  0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00,
  0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0A, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x48, 0x00, 0x03, 0x20, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x04,
  0x00, 0x08, 0x18, 0x00, 0x40, 0x20, 0x02, 0x00, 0x60, 0x30, 0x00, 0x7F,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x10, 0x00, 0x80, 0xE0, 0x01, 0x06,
  0x00, 0x02, 0x20, 0x00, 0x0D, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xF0,
  0x06, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x04, 0x00, 0x02, 0x04, 0x00, 0x01,
  0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x03,
  0x18, 0x00, 0x02, 0x10, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x30,
  0x1F, 0xFF, 0xC0, 0x10, 0x08, 0x00, 0x30, 0x08, 0x00, 0x20, 0x04, 0x00,
  0x20, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x60, 0x01, 0x00, 0x40, 0x01, 0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0x80,
  0x40, 0x00, 0x40, 0x40, 0x00, 0x40, 0x40, 0x00, 0x20, 0x80, 0x00, 0x20,
  0x80, 0x00, 0x10, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x40, 0x00,
  0x80, 0x40, 0x00, 0x20, 0x40, 0x00, 0x08, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x60, 0x07, 0x00,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00,
  0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00,
  0x06, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x30, 0x00,
  0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x08, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00,
  0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x40, 0x80, 0x00, 0x40, 0x40, 0x00,
  0x80, 0x40, 0x01, 0x80, 0x20, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x0F, 0xF0,
  0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x40, 0x00, 0x04, 0x40, 0x00,
  0x04, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x10, 0x20, 0x00, 0x30, 0x20, 0x00, 0x20, 0x20, 0x00, 0x60, 0x20, 0x00,
  0x40, 0x20, 0x00, 0xC0, 0x20, 0x00, 0x80, 0x30, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x10, 0x02, 0x00, 0x10, 0x02, 0x00, 0x10, 0x04,
  0x00, 0x10, 0x04, 0x00, 0x08, 0x08, 0x00, 0x08, 0x08, 0x00, 0x08, 0x10,
  0x00, 0x08, 0x10, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x04, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x05, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x21, 0x00, 0x60, 0x08, 0x40, 0x18,
  0x04, 0x10, 0x0A, 0x01, 0x04, 0x02, 0x80, 0x41, 0x01, 0x20, 0x30, 0x40,
  0x44, 0x08, 0x10, 0x21, 0x02, 0x04, 0x08, 0x40, 0x81, 0x06, 0x10, 0x40,
  0x41, 0x04, 0x10, 0x10, 0x41, 0x04, 0x04, 0x20, 0x41, 0x01, 0x08, 0x18,
  0x80, 0x44, 0x02, 0x20, 0x11, 0x00, 0x88, 0x08, 0x80, 0x22, 0x02, 0x20,
  0x09, 0x00, 0x90, 0x02, 0x40, 0x24, 0x00, 0x90, 0x0A, 0x00, 0x24, 0x02,
  0x80, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x40, 0x08, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x10, 0x06, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x02, 0x04, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0x20, 0x00, 0x04, 0x0C, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x40, 0x08, 0x00, 0x20, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x04, 0x00, 0x10, 0x02, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04, 0x10, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x28, 0x00, 0x01, 0xB0, 0x00,
  0x04, 0x40, 0x00, 0x21, 0x00, 0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x20,
  0x10, 0x01, 0x00, 0x40, 0x08, 0x00, 0x80, 0x60, 0x02, 0x01, 0x00, 0x08,
  0x08, 0x00, 0x10, 0x40, 0x00, 0x42, 0x00, 0x00, 0x98, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFE, 0x84, 0x10, 0x82, 0x18,
  0x41, 0x00, 0x7E, 0x04, 0x06, 0x06, 0x10, 0x60, 0x06, 0x43, 0x00, 0x0A,
  0x08, 0x00, 0x18, 0x40, 0x00, 0x63, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20,
  0x00, 0x09, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00,
  0x11, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22,
  0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0xA1, 0x00,
  0x03, 0x02, 0x00, 0x14, 0x04, 0x00, 0x90, 0x0C, 0x0C, 0x7C, 0x0F, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x7E, 0x00, 0x8C, 0x0C, 0x04,
  0x80, 0x10, 0x48, 0x00, 0x42, 0x80, 0x02, 0x18, 0x00, 0x08, 0xC0, 0x00,
  0x44, 0x00, 0x02, 0x20, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80,
  0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x58, 0x00, 0x02,
  0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x88, 0x00,
  0x04, 0xA0, 0x00, 0x45, 0x00, 0x04, 0x24, 0x00, 0x41, 0x18, 0x0C, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x18, 0x06, 0x00, 0x40, 0x80,
  0x02, 0x10, 0x00, 0x23, 0x00, 0x01, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x28, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x08, 0x20, 0x01,
  0x03, 0x00, 0x20, 0x0C, 0x0C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x7E, 0x04, 0x01, 0x81, 0x84, 0x06,
  0x00, 0x68, 0x0C, 0x00, 0x28, 0x08, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x40,
  0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x80,
  0x00, 0x10, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x40,
  0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0xA0, 0x40, 0x00, 0xC0, 0x20,
  0x01, 0x40, 0x10, 0x02, 0x40, 0x0C, 0x0C, 0x40, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x18, 0x0C, 0x06, 0x00, 0x20, 0xC0, 0x01, 0x18, 0x00, 0x11,
  0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x06,
  0x40, 0x00, 0xC8, 0x00, 0x30, 0x80, 0x7C, 0x0F, 0xF8, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x28, 0x00,
  0x02, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x20, 0x01, 0x83, 0x00, 0x30, 0x0C,
  0x0C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x20, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3F, 0x02, 0x01, 0x81, 0x84, 0x0C, 0x00, 0xC8,
  0x30, 0x00, 0xA0, 0x40, 0x00, 0xC1, 0x00, 0x01, 0x86, 0x00, 0x01, 0x08,
  0x00, 0x02, 0x10, 0x00, 0x04, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00,
  0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x20, 0x80, 0x00, 0x41, 0x00, 0x01,
  0x82, 0x00, 0x05, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x28, 0x04, 0x00, 0x90,
  0x06, 0x06, 0x20, 0x03, 0xF0, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x20, 0x00, 0x80, 0xE0,
  0x02, 0x00, 0x70, 0x18, 0x00, 0x3F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x83, 0xF0, 0x08, 0xC0, 0xC0, 0x90, 0x06, 0x0A, 0x00, 0x20, 0xC0, 0x01,
  0x1C, 0x00, 0x11, 0x80, 0x01, 0x18, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00,
  0x11, 0x00, 0x02, 0x30, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x20, 0x00, 0x22, 0x00, 0x04, 0x60, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x08, 0xC0, 0x00, 0x88,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x01,
  0x01, 0x00, 0x20, 0x10, 0x0C, 0x01, 0x01, 0x80, 0x10, 0x20, 0x02, 0x0C,
  0x00, 0x21, 0x00, 0x02, 0x60, 0x00, 0x28, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x80, 0x08, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x80, 0x0C, 0x08, 0x00, 0x61, 0x80, 0x03, 0x10, 0x00, 0x19,
  0x00, 0x00, 0x50, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x3F, 0x80, 0x08, 0xC0, 0x60, 0x19, 0x00, 0x20,
  0x12, 0x00, 0x10, 0x14, 0x00, 0x10, 0x18, 0x00, 0x10, 0x18, 0x00, 0x10,
  0x10, 0x00, 0x10, 0x30, 0x00, 0x30, 0x20, 0x00, 0x20, 0x20, 0x00, 0x40,
  0x20, 0x01, 0x80, 0x20, 0x06, 0x00, 0x20, 0x38, 0x00, 0x21, 0x80, 0x00,
  0x40, 0x80, 0x00, 0x40, 0x80, 0x00, 0x40, 0x40, 0x02, 0x40, 0x60, 0x03,
  0x40, 0x20, 0x0C, 0x40, 0x10, 0x18, 0x80, 0x10, 0x30, 0x80, 0x08, 0x60,
  0x80, 0x08, 0xC0, 0x80, 0x05, 0x80, 0x00, 0x06, 0x00, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x01,
  0x04, 0x01, 0x81, 0x00, 0xC0, 0x80, 0x40, 0x20, 0x60, 0x08, 0x20, 0x02,
  0x30, 0x00, 0x90, 0x00, 0x78, 0x00, 0x18, 0x00, 0x00, 0x08, 0xF8, 0x1E,
  0x04, 0x86, 0x30, 0x82, 0x81, 0x20, 0x21, 0x80, 0x60, 0x11, 0x80, 0x30,
  0x08, 0xC0, 0x10, 0x04, 0x40, 0x08, 0x02, 0x20, 0x08, 0x01, 0x10, 0x04,
  0x00, 0x88, 0x02, 0x00, 0x8C, 0x01, 0x00, 0x44, 0x00, 0x80, 0x22, 0x00,
  0x40, 0x11, 0x00, 0x40, 0x08, 0x80, 0x20, 0x04, 0x40, 0x10, 0x04, 0x40,
  0x08, 0x02, 0x20, 0x04, 0x01, 0x10, 0x02, 0x00, 0x88, 0x02, 0x00, 0x44,
  0x01, 0x00, 0x22, 0x00, 0x80, 0x22, 0x00, 0x40, 0x11, 0x00, 0x20, 0x08,
  0x80, 0x30, 0x04, 0x00, 0x08, 0x3F, 0x00, 0x8C, 0x0C, 0x09, 0x00, 0x60,
  0xA0, 0x02, 0x0C, 0x00, 0x11, 0xC0, 0x01, 0x18, 0x00, 0x11, 0x80, 0x01,
  0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x23, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x46, 0x00,
  0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x8C, 0x00, 0x08, 0x80, 0x00, 0x80, 0x00, 0x7E, 0x00, 0x1C, 0x0C,
  0x01, 0x80, 0x10, 0x10, 0x00, 0x41, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x50, 0x00,
  0x02, 0x80, 0x00, 0x14, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x00, 0x00, 0x44,
  0x00, 0x04, 0x20, 0x00, 0x60, 0x80, 0x02, 0x06, 0x00, 0x60, 0x1C, 0x0C,
  0x00, 0x3F, 0x80, 0x00, 0x02, 0x0F, 0xC0, 0x04, 0x60, 0x60, 0x09, 0x00,
  0x20, 0x24, 0x00, 0x20, 0x50, 0x00, 0x40, 0xC0, 0x00, 0x41, 0x80, 0x00,
  0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x18, 0x00, 0x04, 0x20, 0x00, 0x08,
  0x40, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0x8C,
  0x00, 0x01, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80,
  0x00, 0x41, 0x00, 0x00, 0x85, 0x00, 0x02, 0x0A, 0x00, 0x08, 0x12, 0x00,
  0x20, 0x23, 0x01, 0x80, 0x41, 0xFC, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x04,
  0x06, 0x06, 0x10, 0x60, 0x06, 0x43, 0x00, 0x0A, 0x08, 0x00, 0x18, 0x40,
  0x00, 0x63, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x09, 0x00, 0x00,
  0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x48,
  0x00, 0x01, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x84, 0x00,
  0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0xA1, 0x00, 0x03, 0x02, 0x00, 0x14,
  0x04, 0x00, 0x90, 0x0C, 0x0C, 0x40, 0x0F, 0xC1, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x83,
  0xFE, 0x01, 0x18, 0x00, 0x02, 0x40, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x0E, 0x01, 0x80, 0x60, 0x01, 0x83, 0x00, 0x03, 0x08, 0x00, 0x04,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x46, 0x00,
  0x03, 0x0C, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x20, 0x04, 0x00, 0xE0, 0x10, 0x03, 0x00, 0x20, 0x18, 0x00, 0x40, 0x40,
  0x00, 0x83, 0x00, 0x01, 0x08, 0x00, 0x02, 0x60, 0x00, 0x0B, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x31, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x62, 0x00, 0x04, 0x40,
  0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x18,
  0x80, 0x01, 0x88, 0x00, 0x10, 0x80, 0x05, 0x08, 0x00, 0x50, 0xC0, 0x09,
  0x04, 0x01, 0x10, 0x30, 0x61, 0x00, 0xF8, 0x20, 0xFE, 0x00, 0x08, 0x10,
  0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x10, 0x20, 0x00, 0x82, 0x00, 0x04,
  0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x41, 0x00,
  0x02, 0x08, 0x00, 0x10, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00, 0x81,
  0x00, 0x04, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02,
  0x01, 0x00, 0x20, 0x08, 0x06, 0x00, 0x40, 0x60, 0x02, 0x1C, 0x00, 0x1F,
  0x00, 0x00, 0x08, 0x02, 0x02, 0x08, 0x02, 0x02, 0x10, 0x06, 0x02, 0x10,
  0x04, 0x01, 0x10, 0x04, 0x01, 0x10, 0x04, 0x01, 0x10, 0x04, 0x01, 0x10,
  0x04, 0x01, 0x20, 0x0C, 0x01, 0x20, 0x08, 0x01, 0x20, 0x08, 0x01, 0x20,
  0x08, 0x01, 0x20, 0x08, 0x01, 0x20, 0x08, 0x01, 0x40, 0x08, 0x01, 0x40,
  0x10, 0x01, 0x40, 0x10, 0x02, 0x40, 0x10, 0x02, 0x40, 0x10, 0x02, 0x40,
  0x30, 0x06, 0x40, 0x30, 0x04, 0xC0, 0x50, 0x0C, 0x40, 0x50, 0x08, 0x40,
  0x90, 0x10, 0x61, 0x08, 0x60, 0x1E, 0x07, 0xC0, 0x00, 0x60, 0x0F, 0x00,
  0x32, 0x02, 0x18, 0x18, 0x20, 0x81, 0x0C, 0x04, 0x20, 0x16, 0x00, 0xC8,
  0x02, 0x00, 0x09, 0x00, 0x40, 0x01, 0x40, 0x08, 0x00, 0x28, 0x01, 0x00,
  0x06, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x02, 0x00, 0x50, 0x00,
  0x40, 0x0A, 0x00, 0x08, 0x02, 0x40, 0x01, 0x00, 0x44, 0x01, 0xA0, 0x10,
  0x80, 0xC2, 0x06, 0x18, 0x60, 0x61, 0x81, 0x30, 0x03, 0xC0, 0x18, 0x00,
  0x02, 0x00, 0x06, 0x04, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20,
  0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x03, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80,
  0x01, 0x81, 0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00,
  0x10, 0x20, 0x00, 0x20, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x01, 0x00, 0x0A,
  0x02, 0x00, 0x14, 0x06, 0x00, 0x48, 0x04, 0x01, 0x10, 0x06, 0x0C, 0x60,
  0x03, 0xE0, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x40, 0x00, 0x80, 0x40, 0x06, 0x00, 0x60,
  0x38, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x01, 0x06, 0x07, 0xC1, 0x04,
  0x00, 0xF3, 0x08, 0x00, 0x1E, 0x08, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x10,
  0x00, 0x18, 0x10, 0x00, 0x20, 0x10, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x10, 0x03, 0x00, 0x10, 0x04,
  0x00, 0x10, 0x08, 0x00, 0x10, 0x10, 0x00, 0x08, 0x60, 0x00, 0x08, 0x5F,
  0x00, 0x08, 0x40, 0xF8, 0x08, 0x40, 0x07, 0xC8, 0x80, 0x00, 0x38, 0x00,
  0x1F, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x01, 0x18, 0x40, 0x01, 0x30, 0x20, 0x02, 0x20, 0x10, 0x02, 0x40, 0x08,
  0x04, 0x80, 0x0C, 0x08, 0x80, 0x06, 0x10, 0x80, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_ThinItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 34, 29, 11, -34 },
  { 31, 9, 12, 29, 13, -36 },
  { 45, 28, 34, 29, 1, -34 },
  { 164, 25, 45, 29, 2, -39 },
  { 305, 32, 35, 29, -1, -34 },
  { 445, 27, 35, 29, 1, -34 },
  { 564, 3, 12, 29, 16, -36 },
  { 569, 15, 43, 29, 11, -36 },
  { 650, 15, 43, 29, 3, -36 },
  { 731, 24, 24, 29, 3, -26 },
  { 803, 23, 23, 29, 3, -26 },
  { 870, 6, 12, 29, 8, -4 },
  { 879, 13, 1, 29, 8, -15 },
  { 881, 3, 3, 29, 11, -3 },
  { 883, 25, 43, 29, 2, -36 },
  { 1018, 22, 35, 29, 4, -34 },
  { 1115, 22, 34, 29, 2, -34 },
  { 1209, 24, 34, 29, 2, -34 },
  { 1311, 23, 35, 29, 2, -34 },
  { 1412, 25, 34, 29, 1, -34 },
  { 1519, 24, 35, 29, 3, -34 },
  { 1624, 21, 35, 29, 4, -34 },
  { 1716, 22, 34, 29, 6, -34 },
  { 1810, 24, 35, 29, 3, -34 },
  { 1915, 21, 34, 29, 5, -34 },
  { 2005, 7, 25, 29, 11, -25 },
  { 2027, 10, 33, 29, 8, -25 },
  { 2069, 23, 26, 29, 4, -28 },
  { 2144, 24, 9, 29, 3, -19 },
  { 2171, 23, 26, 29, 2, -28 },
  { 2246, 19, 34, 29, 7, -34 },
  { 2327, 22, 39, 29, 4, -34 },
  { 2435, 24, 34, 29, 0, -34 },
  { 2537, 23, 34, 29, 3, -34 },
  { 2635, 23, 35, 29, 4, -34 },
  { 2736, 24, 34, 29, 3, -34 },
  { 2838, 25, 34, 29, 3, -34 },
  { 2945, 25, 34, 29, 3, -34 },
  { 3052, 23, 35, 29, 4, -34 },
  { 3153, 25, 34, 29, 3, -34 },
  { 3260, 26, 34, 29, 2, -34 },
  { 3371, 23, 35, 29, 3, -34 },
  { 3472, 27, 34, 29, 3, -34 },
  { 3587, 18, 34, 29, 5, -34 },
  { 3664, 26, 34, 29, 2, -34 },
  { 3775, 25, 34, 29, 3, -34 },
  { 3882, 22, 35, 29, 4, -34 },
  { 3979, 24, 34, 29, 3, -34 },
  { 4081, 22, 42, 29, 4, -34 },
  { 4197, 24, 34, 29, 3, -34 },
  { 4299, 25, 35, 29, 2, -34 },
  { 4409, 25, 34, 29, 5, -34 },
  { 4516, 24, 35, 29, 4, -34 },
  { 4621, 24, 34, 29, 6, -34 },
  { 4723, 26, 34, 29, 4, -34 },
  { 4834, 30, 34, 29, 0, -34 },
  { 4962, 26, 34, 29, 5, -34 },
  { 5073, 29, 34, 29, 0, -34 },
  { 5197, 19, 43, 29, 9, -36 },
  { 5300, 11, 43, 29, 10, -36 },
  { 5360, 19, 43, 29, 1, -36 },
  { 5463, 22, 18, 29, 4, -34 },
  { 5513, 23, 1, 29, 0, 6 },
  { 5516, 5, 8, 29, 12, -37 },
  { 5521, 22, 26, 29, 3, -25 },
  { 5593, 21, 37, 29, 4, -36 },
  { 5691, 20, 26, 29, 4, -25 },
  { 5756, 24, 37, 29, 3, -36 },
  { 5867, 20, 26, 29, 4, -25 },
  { 5932, 29, 46, 29, 0, -36 },
  { 6099, 23, 35, 29, 2, -25 },
  { 6200, 20, 36, 29, 4, -36 },
  { 6290, 20, 37, 29, 4, -36 },
  { 6383, 20, 46, 29, 5, -36 },
  { 6498, 24, 37, 29, 4, -36 },
  { 6609, 18, 37, 29, 6, -36 },
  { 6693, 25, 25, 29, 2, -25 },
  { 6772, 20, 25, 29, 4, -25 },
  { 6835, 21, 26, 29, 4, -25 },
  { 6904, 23, 35, 29, 2, -25 },
  { 7005, 22, 35, 29, 3, -25 },
  { 7102, 23, 25, 29, 6, -25 },
  { 7174, 22, 26, 29, 3, -25 },
  { 7246, 23, 35, 29, 4, -34 },
  { 7347, 20, 26, 29, 5, -25 },
  { 7412, 21, 25, 29, 4, -25 },
  { 7478, 24, 26, 29, 3, -25 },
  { 7556, 27, 26, 29, 1, -25 },
  { 7644, 23, 35, 29, 2, -25 },
  { 7745, 24, 26, 29, 2, -25 },
  { 7823, 21, 43, 29, 6, -36 },
  { 7936, 8, 43, 29, 11, -36 },
  { 7979, 22, 43, 29, 2, -36 },
  { 8098, 24, 8, 29, 3, -19 },
};

const GFXfont IBMPlexMono_ThinItalic48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_THINITALIC48PT7B_H_
