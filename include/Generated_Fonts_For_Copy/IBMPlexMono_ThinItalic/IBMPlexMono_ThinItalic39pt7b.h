#ifndef _IBMPLEXMONO_THINITALIC39PT7B_H_
#define _IBMPLEXMONO_THINITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x08, 0x00, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x21, 0x21,
  0x41, 0x42, 0x42, 0x42, 0x42, 0x42, 0x84, 0x84, 0x00, 0x08, 0x10, 0x00,
  0x20, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00, 0x02, 0x04, 0x00, 0x04,
  0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x7F, 0x81,
  0xFC, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x40,
  0x00, 0x40, 0x80, 0x00, 0x82, 0x00, 0x02, 0x04, 0x01, 0xFC, 0x0F, 0xE0,
  0x08, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x00, 0x82, 0x00, 0x02,
  0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x07, 0xF8, 0x00, 0xC2, 0x30, 0x18, 0x20, 0x40, 0x81, 0x01, 0x08,
  0x08, 0x00, 0x40, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00, 0x81, 0x00,
  0x04, 0x08, 0x00, 0x10, 0x40, 0x00, 0xC2, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x08, 0xC0, 0x00, 0x41, 0x80, 0x02, 0x04, 0x00, 0x10, 0x10,
  0x00, 0x80, 0x80, 0x08, 0x04, 0x00, 0x40, 0x20, 0x02, 0x02, 0x30, 0x10,
  0x10, 0x80, 0x81, 0x83, 0x04, 0x18, 0x0E, 0x43, 0x80, 0x0F, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF8,
  0x00, 0x40, 0x43, 0x00, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x00, 0x81, 0x00, 0x80, 0x20, 0x80, 0x20, 0x08, 0x40,
  0x08, 0x02, 0x10, 0x02, 0x01, 0x08, 0x00, 0x40, 0xC4, 0x00, 0x18, 0x62,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0x0C, 0x20, 0x00, 0x84, 0x04, 0x00, 0x22, 0x01, 0x00, 0x10, 0x80, 0x40,
  0x08, 0x20, 0x10, 0x04, 0x10, 0x04, 0x02, 0x04, 0x01, 0x00, 0x81, 0x00,
  0x40, 0x40, 0x40, 0x20, 0x20, 0x08, 0x08, 0x10, 0x01, 0x0C, 0x0C, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x02, 0x00, 0x04, 0x02, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x02, 0x01, 0x00, 0x04, 0x02, 0x00, 0x04, 0x08,
  0x00, 0x38, 0x20, 0x01, 0x8B, 0x80, 0x04, 0x08, 0x00, 0x10, 0x10, 0x00,
  0x40, 0x10, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x20, 0x08,
  0x00, 0x20, 0x10, 0x00, 0xC0, 0x50, 0x01, 0x41, 0x20, 0x04, 0x44, 0x20,
  0x18, 0x88, 0x60, 0x60, 0xA0, 0x3F, 0x00, 0x80, 0x55, 0x6A, 0xA0, 0x00,
  0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x06, 0x02, 0x03, 0x9C, 0x21, 0xC0, 0x3D, 0xE0, 0x00, 0x60,
  0x00, 0x0A, 0x00, 0x01, 0x10, 0x00, 0x31, 0x00, 0x02, 0x08, 0x00, 0x40,
  0x80, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x61, 0x04, 0x20, 0x84, 0x10, 0x42, 0x00,
  0xFF, 0xC0, 0xDC, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0,
  0x40, 0x08, 0x20, 0x01, 0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80,
  0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28,
  0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x21, 0x00,
  0x10, 0x60, 0x08, 0x0C, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x0D,
  0x00, 0x06, 0x80, 0x02, 0x20, 0x03, 0x08, 0x01, 0x82, 0x00, 0xC0, 0x80,
  0x40, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x0F, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x30, 0x30, 0x08, 0x03, 0x02, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x44,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x60, 0x30, 0x10, 0x03, 0x04, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x18, 0x40,
  0x06, 0x06, 0x03, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0A,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x44, 0x00, 0x08,
  0x40, 0x01, 0x04, 0x00, 0x20, 0x80, 0x04, 0x08, 0x00, 0x40, 0x80, 0x08,
  0x08, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x10, 0x10,
  0x01, 0x02, 0x00, 0x10, 0x20, 0x01, 0x04, 0x00, 0x20, 0xFF, 0xFF, 0xF0,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0xF0, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x1F, 0xC0, 0x16, 0x06, 0x01,
  0x80, 0x10, 0x10, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x80, 0x01,
  0x04, 0x00, 0x10, 0x20, 0x02, 0x01, 0x80, 0xC0, 0x07, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x7F,
  0x02, 0xC0, 0x62, 0x80, 0x19, 0x80, 0x04, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x04,
  0x80, 0x04, 0x60, 0x04, 0x18, 0x0C, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x18, 0x0C, 0x06, 0x00, 0x60, 0x40, 0x02, 0x08, 0x00, 0x20, 0x80,
  0x01, 0x10, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x04, 0x04,
  0x00, 0xC0, 0x20, 0x30, 0x01, 0xFC, 0x00, 0xE0, 0x20, 0x18, 0x01, 0x82,
  0x00, 0x08, 0x40, 0x00, 0x44, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x48, 0x00, 0x04, 0x40, 0x00, 0x84, 0x00, 0x18, 0x20, 0x03,
  0x01, 0x80, 0xC0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0x03, 0x06, 0x00,
  0xC4, 0x00, 0x22, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x28, 0x00, 0x12, 0x00, 0x18,
  0x80, 0x18, 0x60, 0x34, 0x0F, 0xE4, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x38, 0x03, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x06, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x30, 0x30, 0x80, 0x12, 0x00, 0x14, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x70,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x60, 0xC0, 0x20, 0x08, 0x10, 0x02, 0x08, 0x00,
  0x42, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x20, 0x3E, 0x48, 0x30, 0x52,
  0x08, 0x18, 0x84, 0x02, 0x41, 0x00, 0x90, 0x80, 0x24, 0x20, 0x09, 0x08,
  0x02, 0x42, 0x01, 0x20, 0x80, 0x48, 0x20, 0x12, 0x08, 0x04, 0x82, 0x03,
  0x20, 0x81, 0x48, 0x19, 0xA2, 0x01, 0x80, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x05, 0x00, 0x00, 0x90, 0x00, 0x09, 0x00,
  0x01, 0x10, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x04, 0x08,
  0x00, 0x40, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x10, 0x08, 0x02, 0x00,
  0x40, 0x20, 0x04, 0x04, 0x00, 0x40, 0x7F, 0xFC, 0x04, 0x00, 0x40, 0x80,
  0x04, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x22, 0x00, 0x02, 0x20,
  0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x10, 0x07, 0xFF, 0x01, 0x00, 0x30,
  0x20, 0x01, 0x04, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x08,
  0x80, 0x01, 0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x41,
  0x00, 0x30, 0x3F, 0xF8, 0x08, 0x00, 0xC1, 0x00, 0x04, 0x20, 0x00, 0x84,
  0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90,
  0x00, 0x22, 0x00, 0x04, 0x40, 0x01, 0x10, 0x00, 0xC3, 0xFF, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0xC0, 0x80, 0x40, 0x10, 0x20, 0x02, 0x10, 0x00, 0x88,
  0x00, 0x12, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x02, 0x20,
  0x00, 0x88, 0x00, 0x41, 0x00, 0x10, 0x40, 0x18, 0x0C, 0x0C, 0x00, 0xFC,
  0x00, 0x0F, 0xFC, 0x01, 0x00, 0xC0, 0x20, 0x04, 0x08, 0x00, 0x41, 0x00,
  0x04, 0x20, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x24, 0x00,
  0x04, 0x80, 0x00, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00,
  0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x48, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x84, 0x00, 0x30, 0x80, 0x0C,
  0x10, 0x06, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x03, 0xFF, 0xF8, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x80, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF,
  0xF8, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x30, 0x60, 0x18, 0x02, 0x02, 0x00, 0x20, 0x80, 0x04, 0x20, 0x00,
  0x44, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x01, 0xFC,
  0x80, 0x40, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x10,
  0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x18, 0x20, 0x05, 0x03, 0x03, 0x20,
  0x1F, 0x88, 0x00, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10,
  0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x20, 0x00, 0x43,
  0xFF, 0xFC, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x42, 0x00, 0x04,
  0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00,
  0x84, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x08,
  0x00, 0x42, 0x00, 0x20, 0x40, 0x10, 0x08, 0x18, 0x01, 0xF8, 0x00, 0x08,
  0x00, 0x18, 0x40, 0x01, 0x82, 0x00, 0x10, 0x20, 0x01, 0x01, 0x00, 0x10,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x01, 0x00, 0x10, 0x10, 0x01, 0x01,
  0x00, 0x08, 0x10, 0x00, 0x41, 0x00, 0x02, 0x38, 0x00, 0x13, 0x20, 0x01,
  0x21, 0x00, 0x0A, 0x04, 0x00, 0x60, 0x20, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x40, 0x02, 0x02, 0x00, 0x10, 0x10,
  0x00, 0x40, 0x80, 0x02, 0x04, 0x00, 0x08, 0x20, 0x00, 0x60, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0xFF,
  0xF8, 0x0C, 0x00, 0x18, 0x60, 0x01, 0x43, 0x00, 0x0A, 0x28, 0x00, 0xA1,
  0x20, 0x05, 0x09, 0x00, 0x48, 0x48, 0x04, 0x42, 0x20, 0x22, 0x11, 0x02,
  0x11, 0x08, 0x11, 0x08, 0x41, 0x08, 0x41, 0x10, 0x42, 0x08, 0x82, 0x10,
  0x48, 0x10, 0x81, 0x80, 0x88, 0x0C, 0x08, 0x40, 0x40, 0x42, 0x00, 0x02,
  0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x04, 0x40, 0x00, 0x42, 0x00,
  0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x04, 0x20, 0x00, 0x20,
  0x04, 0x00, 0x10, 0xC0, 0x01, 0x0A, 0x00, 0x10, 0xA0, 0x01, 0x09, 0x00,
  0x10, 0x90, 0x01, 0x11, 0x00, 0x21, 0x08, 0x02, 0x10, 0x80, 0x21, 0x08,
  0x02, 0x10, 0x40, 0x21, 0x04, 0x02, 0x20, 0x40, 0x42, 0x02, 0x04, 0x20,
  0x20, 0x42, 0x02, 0x04, 0x20, 0x10, 0x42, 0x01, 0x04, 0x40, 0x10, 0x84,
  0x00, 0x88, 0x40, 0x08, 0x84, 0x00, 0x48, 0x40, 0x04, 0x84, 0x00, 0x48,
  0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x03, 0x00, 0x00, 0xFC, 0x00, 0xC0,
  0xC0, 0x40, 0x08, 0x20, 0x01, 0x10, 0x00, 0x44, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x21,
  0x00, 0x10, 0x60, 0x08, 0x0C, 0x0C, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x01,
  0x00, 0x10, 0x20, 0x01, 0x08, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90,
  0x00, 0x22, 0x00, 0x08, 0x40, 0x06, 0x0F, 0xFF, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xC0, 0xC0, 0x40, 0x08, 0x20, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x12, 0x00, 0x04, 0x80, 0x01, 0x40, 0x00, 0x50, 0x00,
  0x14, 0x00, 0x05, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80,
  0x01, 0x20, 0x00, 0x48, 0x00, 0x21, 0x00, 0x10, 0x60, 0x08, 0x0C, 0x0C,
  0x00, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x20, 0x04, 0x10,
  0x00, 0x88, 0x00, 0x2C, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x01, 0x00, 0x10,
  0x20, 0x01, 0x08, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08,
  0x80, 0x01, 0x10, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x22,
  0x00, 0x08, 0x40, 0x06, 0x0F, 0xFF, 0x02, 0x02, 0x00, 0x40, 0x40, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x01, 0x00, 0x10, 0x20,
  0x02, 0x04, 0x00, 0x20, 0x80, 0x04, 0x10, 0x00, 0x42, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0x00, 0x0C, 0x07, 0x01, 0x80, 0x04, 0x08, 0x00, 0x10, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x23, 0x00, 0x01,
  0x08, 0x00, 0x18, 0x30, 0x01, 0x80, 0x60, 0x38, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x48, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01,
  0x10, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04,
  0x40, 0x00, 0x88, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11,
  0x00, 0x04, 0x20, 0x00, 0x82, 0x00, 0x20, 0x40, 0x0C, 0x06, 0x03, 0x00,
  0x3F, 0x80, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00,
  0x44, 0x00, 0x08, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00, 0x10, 0x40, 0x02,
  0x08, 0x00, 0x80, 0x80, 0x10, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x08, 0x04, 0x01, 0x01, 0x00, 0x10, 0x20, 0x02, 0x08, 0x00, 0x41, 0x00,
  0x08, 0x40, 0x01, 0x08, 0x00, 0x22, 0x00, 0x02, 0x40, 0x00, 0x50, 0x00,
  0x0A, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x09, 0x00,
  0x00, 0x48, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x09,
  0x00, 0x00, 0x88, 0x00, 0x04, 0x40, 0x60, 0x22, 0x03, 0x02, 0x10, 0x28,
  0x10, 0x81, 0x40, 0x84, 0x12, 0x04, 0x20, 0x90, 0x41, 0x04, 0x42, 0x08,
  0x42, 0x10, 0x42, 0x10, 0x82, 0x20, 0x88, 0x11, 0x04, 0x40, 0x90, 0x22,
  0x04, 0x81, 0x10, 0x48, 0x09, 0x02, 0x40, 0x28, 0x14, 0x01, 0x40, 0xA0,
  0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0x04, 0x00, 0x01, 0x02, 0x00,
  0x02, 0x02, 0x00, 0x04, 0x01, 0x00, 0x08, 0x01, 0x00, 0x10, 0x00, 0x80,
  0x20, 0x00, 0x80, 0x20, 0x00, 0x40, 0x40, 0x00, 0x40, 0x80, 0x00, 0x21,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x14, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x24, 0x00, 0x00, 0x42, 0x00, 0x00, 0x82,
  0x00, 0x01, 0x81, 0x00, 0x01, 0x01, 0x00, 0x02, 0x00, 0x80, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x10, 0x00, 0x40, 0x30, 0x00, 0x20, 0x20, 0x00,
  0x20, 0xC0, 0x00, 0x10, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x08,
  0x40, 0x00, 0x82, 0x00, 0x04, 0x10, 0x00, 0x40, 0x40, 0x04, 0x02, 0x00,
  0x40, 0x08, 0x04, 0x00, 0x40, 0x20, 0x01, 0x02, 0x00, 0x08, 0x20, 0x00,
  0x22, 0x00, 0x01, 0x20, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x04, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x03, 0xFE, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x03, 0xFE,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x83, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x02,
  0x10, 0x00, 0x84, 0x00, 0x41, 0x00, 0x20, 0x20, 0x10, 0x08, 0x04, 0x01,
  0x02, 0x00, 0x41, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x90, 0x00, 0x18,
  0x00, 0x04, 0xFF, 0xFF, 0xE0, 0xC2, 0x08, 0x41, 0x0C, 0x03, 0xF0, 0x87,
  0x06, 0x46, 0x00, 0xA6, 0x00, 0x52, 0x00, 0x12, 0x00, 0x09, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x48, 0x00,
  0x24, 0x00, 0x12, 0x00, 0x19, 0x00, 0x14, 0x40, 0x0C, 0x20, 0x0A, 0x0C,
  0x19, 0x01, 0xF0, 0xF0, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x3F, 0x01, 0x30, 0x60, 0x50, 0x04, 0x18, 0x00, 0x86, 0x00, 0x21,
  0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80,
  0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x40, 0x01,
  0x28, 0x00, 0x8A, 0x00, 0x42, 0x60, 0x60, 0x87, 0xE0, 0x00, 0x01, 0xF8,
  0x06, 0x04, 0x08, 0x02, 0x10, 0x01, 0x20, 0x01, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x03, 0x40, 0x02, 0x40, 0x04, 0x20, 0x08, 0x18, 0x30,
  0x07, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x7E, 0x10, 0x38, 0x32, 0x0C, 0x01, 0x43, 0x00, 0x28, 0x40, 0x02, 0x10,
  0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40,
  0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x30, 0x80,
  0x0A, 0x08, 0x01, 0x81, 0x00, 0x50, 0x18, 0x32, 0x00, 0xF8, 0x40, 0x01,
  0xFC, 0x03, 0x01, 0x02, 0x00, 0x42, 0x00, 0x12, 0x00, 0x09, 0x00, 0x05,
  0x00, 0x04, 0x80, 0x06, 0x80, 0x0C, 0x40, 0x78, 0x3F, 0xC0, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x04, 0x80, 0x04, 0x40, 0x06, 0x10,
  0x06, 0x06, 0x06, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x80, 0x40, 0x00,
  0xC0, 0x40, 0x00, 0x60, 0x40, 0x00, 0x10, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x04, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xF8, 0x41,
  0xC1, 0x90, 0xC0, 0x14, 0x60, 0x05, 0x10, 0x00, 0x88, 0x00, 0x22, 0x00,
  0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x11, 0x00, 0x04,
  0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x31, 0x00, 0x14, 0x20, 0x06, 0x08,
  0x02, 0x81, 0x83, 0x20, 0x1F, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x08, 0x20, 0x06, 0x06, 0x06, 0x00, 0x7E, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0xFC, 0x11, 0x06, 0x12, 0x01,
  0x14, 0x01, 0x18, 0x01, 0x10, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x80, 0x04, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x02, 0x04, 0x07, 0x04, 0x0C, 0x04, 0x30,
  0x08, 0x40, 0x09, 0x80, 0x0A, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x80, 0x20, 0x40, 0x20, 0x30, 0x20,
  0x18, 0x40, 0x0C, 0x40, 0x06, 0x40, 0x01, 0x40, 0x00, 0xC0, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x0F, 0x80, 0x4E, 0x0C,
  0x0B, 0x00, 0x81, 0x80, 0x08, 0x30, 0x01, 0x0C, 0x00, 0x21, 0x00, 0x08,
  0x20, 0x03, 0x04, 0x00, 0x80, 0x80, 0x60, 0x10, 0x70, 0x04, 0x30, 0x00,
  0x82, 0x00, 0x10, 0x40, 0x0A, 0x04, 0x03, 0x40, 0x40, 0x88, 0x08, 0x22,
  0x00, 0x88, 0x40, 0x0A, 0x08, 0x01, 0x80, 0xFF, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x10, 0x80, 0xC4,
  0x0C, 0x10, 0x60, 0x46, 0x01, 0x30, 0x07, 0x00, 0x18, 0x00, 0x13, 0xC1,
  0xE1, 0x42, 0x62, 0x18, 0x28, 0x13, 0x01, 0x01, 0x20, 0x10, 0x12, 0x02,
  0x01, 0x20, 0x20, 0x12, 0x02, 0x01, 0x40, 0x20, 0x24, 0x02, 0x02, 0x40,
  0x20, 0x24, 0x04, 0x02, 0x40, 0x40, 0x24, 0x04, 0x02, 0x80, 0x40, 0x48,
  0x04, 0x04, 0x80, 0x40, 0x48, 0x08, 0x04, 0x80, 0x80, 0x48, 0x08, 0x08,
  0x08, 0xFC, 0x11, 0x06, 0x12, 0x01, 0x14, 0x01, 0x18, 0x01, 0x10, 0x01,
  0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01, 0x20, 0x01,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x04, 0x80, 0x04, 0x01, 0xF8, 0x03, 0x03, 0x02, 0x00, 0x42, 0x00,
  0x22, 0x00, 0x09, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x05,
  0x80, 0x04, 0x40, 0x06, 0x10, 0x06, 0x06, 0x06, 0x01, 0xFC, 0x00, 0x08,
  0x7E, 0x01, 0x30, 0x60, 0x28, 0x02, 0x06, 0x00, 0x20, 0xC0, 0x04, 0x10,
  0x00, 0x84, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x08, 0x40,
  0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x21, 0x00,
  0x04, 0x50, 0x01, 0x0A, 0x00, 0x41, 0x30, 0x30, 0x21, 0xF8, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF0, 0x87, 0x06, 0x46, 0x00,
  0xA6, 0x00, 0x52, 0x00, 0x1A, 0x00, 0x09, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x19, 0x00, 0x14, 0x40, 0x0A, 0x20, 0x0A, 0x0C, 0x19, 0x01, 0xF0,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0xFF, 0x1F, 0xC0, 0x98, 0x00, 0x28,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0x30, 0x20, 0x01, 0x04, 0x00,
  0x31, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0xC0, 0x00, 0x84, 0x00, 0x20, 0x60, 0x18,
  0x03, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x07, 0xFF, 0xFF, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x40, 0x40, 0x18, 0x08, 0x0C, 0x01, 0x02, 0x00, 0x21, 0x80,
  0x04, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x20, 0x01, 0x20, 0x01,
  0x20, 0x01, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x0C, 0x80, 0x18, 0x80, 0x18, 0x40, 0x28, 0x60, 0xC8, 0x1F, 0x08,
  0xFC, 0x00, 0x81, 0x00, 0x20, 0x40, 0x04, 0x10, 0x01, 0x08, 0x00, 0x42,
  0x00, 0x10, 0x80, 0x04, 0x20, 0x02, 0x08, 0x00, 0x82, 0x00, 0x20, 0x80,
  0x08, 0x40, 0x04, 0x10, 0x01, 0x04, 0x00, 0x81, 0x00, 0x40, 0x40, 0x20,
  0x10, 0x18, 0x04, 0x18, 0x02, 0x1C, 0x00, 0x78, 0x00, 0x20, 0x30, 0x44,
  0x04, 0x08, 0x80, 0x80, 0x90, 0x10, 0x12, 0x02, 0x02, 0x80, 0x40, 0x50,
  0x10, 0x0A, 0x02, 0x01, 0x40, 0x40, 0x28, 0x08, 0x06, 0x01, 0x00, 0xC0,
  0x20, 0x18, 0x08, 0x03, 0x01, 0x00, 0xA0, 0x20, 0x14, 0x04, 0x02, 0x81,
  0x80, 0x90, 0x50, 0x23, 0x11, 0x08, 0x3C, 0x1E, 0x00, 0x01, 0x80, 0xF0,
  0x19, 0x0C, 0x21, 0x84, 0x20, 0x98, 0x09, 0x01, 0x00, 0x28, 0x04, 0x00,
  0xA0, 0x10, 0x03, 0x00, 0x40, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x02, 0x01, 0x80, 0x08,
  0x06, 0x00, 0x20, 0x28, 0x00, 0x80, 0x90, 0x3A, 0x04, 0x43, 0x04, 0x20,
  0x90, 0x0F, 0x03, 0x80, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00,
  0x88, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0x42,
  0x00, 0x30, 0x80, 0x18, 0x20, 0x06, 0x04, 0x02, 0x81, 0x83, 0x20, 0x1F,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08,
  0x20, 0x04, 0x06, 0x06, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x21, 0x03, 0xC4,
  0x40, 0x0E, 0x88, 0x00, 0x22, 0x00, 0x08, 0x40, 0x02, 0x08, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x10, 0x18, 0x02, 0x04, 0x00, 0x41, 0x00, 0x08, 0x40, 0x00, 0x9F,
  0xE0, 0x12, 0x0F, 0xE2, 0x40, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x01, 0x80, 0x7F, 0x00, 0x01, 0xC0, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0xF8, 0x00, 0x04, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x10, 0x82,
  0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08,
  0x00, 0x03, 0xFC, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x11, 0x08, 0x02, 0x20, 0x40, 0x24,
  0x06, 0x02, 0x40, 0x20, 0x48, 0x01, 0x88, 0x80, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 27, 23, 9, -27 },
  { 22, 8, 10, 23, 10, -29 },
  { 32, 23, 27, 23, 1, -27 },
  { 110, 21, 35, 23, 1, -31 },
  { 202, 26, 27, 23, -1, -27 },
  { 290, 23, 27, 23, 0, -27 },
  { 368, 2, 10, 23, 13, -29 },
  { 371, 12, 35, 23, 9, -30 },
  { 424, 12, 35, 23, 3, -30 },
  { 477, 20, 19, 23, 2, -21 },
  { 525, 18, 19, 23, 3, -21 },
  { 568, 6, 10, 23, 6, -3 },
  { 576, 10, 1, 23, 7, -12 },
  { 578, 3, 2, 23, 9, -2 },
  { 579, 20, 35, 23, 2, -30 },
  { 667, 18, 27, 23, 3, -27 },
  { 728, 18, 27, 23, 2, -27 },
  { 789, 19, 27, 23, 2, -27 },
  { 854, 19, 27, 23, 2, -27 },
  { 919, 20, 27, 23, 1, -27 },
  { 987, 20, 27, 23, 2, -27 },
  { 1055, 17, 27, 23, 3, -27 },
  { 1113, 18, 27, 23, 5, -27 },
  { 1174, 20, 27, 23, 2, -27 },
  { 1242, 17, 27, 23, 4, -27 },
  { 1300, 6, 20, 23, 9, -20 },
  { 1315, 9, 27, 23, 6, -20 },
  { 1346, 18, 21, 23, 4, -22 },
  { 1394, 20, 8, 23, 2, -16 },
  { 1414, 18, 21, 23, 2, -22 },
  { 1462, 15, 27, 23, 6, -27 },
  { 1513, 18, 31, 23, 3, -27 },
  { 1583, 20, 27, 23, 0, -27 },
  { 1651, 19, 27, 23, 2, -27 },
  { 1716, 18, 27, 23, 4, -27 },
  { 1777, 19, 27, 23, 3, -27 },
  { 1842, 20, 27, 23, 3, -27 },
  { 1910, 20, 27, 23, 3, -27 },
  { 1978, 19, 27, 23, 3, -27 },
  { 2043, 20, 27, 23, 2, -27 },
  { 2111, 21, 27, 23, 2, -27 },
  { 2182, 18, 27, 23, 3, -27 },
  { 2243, 21, 27, 23, 3, -27 },
  { 2314, 15, 27, 23, 4, -27 },
  { 2365, 21, 27, 23, 2, -27 },
  { 2436, 20, 27, 23, 2, -27 },
  { 2504, 18, 27, 23, 3, -27 },
  { 2565, 19, 27, 23, 3, -27 },
  { 2630, 18, 34, 23, 3, -27 },
  { 2707, 19, 27, 23, 3, -27 },
  { 2772, 21, 27, 23, 1, -27 },
  { 2843, 21, 27, 23, 4, -27 },
  { 2914, 19, 27, 23, 3, -27 },
  { 2979, 19, 27, 23, 5, -27 },
  { 3044, 21, 27, 23, 3, -27 },
  { 3115, 24, 27, 23, 0, -27 },
  { 3196, 21, 27, 23, 4, -27 },
  { 3267, 24, 27, 23, 0, -27 },
  { 3348, 15, 35, 23, 8, -30 },
  { 3414, 9, 35, 23, 8, -30 },
  { 3454, 15, 35, 23, 1, -30 },
  { 3520, 18, 15, 23, 3, -27 },
  { 3554, 19, 1, 23, 0, 5 },
  { 3557, 5, 6, 23, 9, -29 },
  { 3561, 17, 20, 23, 3, -20 },
  { 3604, 18, 29, 23, 3, -29 },
  { 3670, 16, 20, 23, 3, -20 },
  { 3710, 19, 29, 23, 3, -29 },
  { 3779, 17, 20, 23, 3, -20 },
  { 3822, 24, 37, 23, 0, -29 },
  { 3933, 18, 28, 23, 2, -20 },
  { 3996, 16, 29, 23, 3, -29 },
  { 4054, 16, 29, 23, 4, -29 },
  { 4112, 16, 37, 23, 4, -29 },
  { 4186, 19, 29, 23, 3, -29 },
  { 4255, 14, 29, 23, 5, -29 },
  { 4306, 20, 20, 23, 2, -20 },
  { 4356, 16, 20, 23, 3, -20 },
  { 4396, 17, 20, 23, 3, -20 },
  { 4439, 19, 28, 23, 2, -20 },
  { 4506, 17, 28, 23, 3, -20 },
  { 4566, 18, 20, 23, 5, -20 },
  { 4611, 19, 20, 23, 2, -20 },
  { 4659, 19, 27, 23, 3, -27 },
  { 4724, 16, 20, 23, 4, -20 },
  { 4764, 18, 20, 23, 3, -20 },
  { 4809, 19, 20, 23, 3, -20 },
  { 4857, 22, 20, 23, 1, -20 },
  { 4912, 18, 28, 23, 2, -20 },
  { 4975, 19, 20, 23, 2, -20 },
  { 5023, 17, 35, 23, 5, -30 },
  { 5098, 6, 35, 23, 9, -30 },
  { 5125, 17, 35, 23, 2, -30 },
  { 5200, 20, 7, 23, 2, -15 },
};

const GFXfont IBMPlexMono_ThinItalic39pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic39pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _IBMPLEXMONO_THINITALIC39PT7B_H_
