#ifndef _IBMPLEXMONO_THINITALIC68PT7B_H_
#define _IBMPLEXMONO_THINITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x07, 0x81, 0xF0, 0x1C, 0x00, 0x10, 0x19, 0x80, 0xCC, 0x06, 0x60,
  0x33, 0x01, 0x10, 0x08, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x98, 0x08,
  0x80, 0x44, 0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0x40, 0x04, 0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0x06, 0x3C, 0x00, 0x03, 0x00, 0x80, 0xE0, 0x01, 0x80, 0x10, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x60, 0x18, 0x00, 0x40, 0x06, 0x02, 0x00, 0x18, 0x00,
  0x40, 0xC0, 0x03, 0x00, 0x00, 0x10, 0x00, 0x40, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x18, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x10,
  0x00, 0x00, 0x07, 0x02, 0x00, 0x00, 0x00, 0x3C, 0x40, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x63, 0xC0, 0x00,
  0x00, 0x08, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x20, 0x04,
  0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x20, 0x80, 0x01, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x01, 0x81, 0x80, 0x0C, 0x00, 0x60, 0x18, 0x01, 0x00, 0x18, 0x01, 0x80,
  0x20, 0x06, 0x00, 0x1C, 0x04, 0x03, 0x80, 0x00, 0xF0, 0x83, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x04, 0x00, 0x20, 0x00, 0x40, 0x00, 0x20, 0x03,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x30, 0x00, 0x30, 0x00, 0x08, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x20, 0x18, 0x00, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x10, 0x08, 0x00, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x00,
  0x08, 0x0C, 0x00, 0x00, 0x0C, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x18, 0x0C, 0x01, 0x00, 0x00, 0x01, 0x80, 0x80, 0x04, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x80, 0x00,
  0x08, 0x04, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x20, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x04, 0x00, 0x02, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x20, 0x01, 0x00, 0x00, 0x80, 0x03, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x10, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x00, 0x7D, 0x81, 0x80, 0x00, 0x03, 0x01, 0x1C, 0x00,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0xA0, 0x00, 0xC0, 0x00, 0x01,
  0x60, 0x02, 0xC0, 0x00, 0x02, 0x60, 0x0D, 0x80, 0x00, 0x04, 0x40, 0x11,
  0x00, 0x00, 0x10, 0xC0, 0x43, 0x00, 0x00, 0x60, 0x81, 0x82, 0x00, 0x00,
  0x80, 0x82, 0x02, 0x00, 0x02, 0x01, 0x8C, 0x03, 0x00, 0x18, 0x01, 0x30,
  0x03, 0x80, 0xE0, 0x03, 0x40, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x18, 0x84,
  0x63, 0x18, 0xC4, 0x23, 0x18, 0xC6, 0x21, 0x18, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x07, 0xF0, 0x00, 0x80, 0x07, 0x83, 0xC0, 0x10, 0x0F,
  0x80, 0x0F, 0x06, 0x0F, 0x80, 0x00, 0x3C, 0xDF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0C,
  0x06, 0x06, 0x03, 0x01, 0x01, 0x80, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x7B,
  0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x04, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x01, 0x60, 0x01, 0xC0, 0x01, 0x60, 0x01, 0xC0,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0x40, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x08, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x38, 0x02, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x02, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00,
  0x30, 0x08, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x02, 0x07, 0xFC, 0x00, 0x01, 0x8E, 0x01, 0xE0,
  0x00, 0x64, 0x00, 0x0C, 0x00, 0x16, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x01, 0xFE, 0x00, 0x0C, 0x38, 0x07, 0x00, 0x23, 0x00,
  0x03, 0x01, 0xB0, 0x00, 0x06, 0x05, 0x80, 0x00, 0x08, 0x34, 0x00, 0x00,
  0x10, 0xA0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x9C, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60,
  0x08, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x02, 0x40, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x05, 0x08, 0x00, 0x00, 0x2C, 0x30, 0x00,
  0x01, 0xA0, 0x60, 0x00, 0x1D, 0x80, 0xC0, 0x00, 0xC4, 0x00, 0xE0, 0x1C,
  0x30, 0x00, 0x7F, 0x80, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x0F, 0x81,
  0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x08,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x13, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x60, 0x00, 0x08, 0x03, 0x00, 0x00, 0x20,
  0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x41, 0x00, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x10, 0x80, 0x03, 0xF0, 0x42, 0x00, 0x70,
  0x31, 0x18, 0x03, 0x00, 0x2C, 0x40, 0x18, 0x00, 0xB1, 0x00, 0x40, 0x01,
  0xCC, 0x03, 0x00, 0x06, 0x30, 0x08, 0x00, 0x18, 0x80, 0x60, 0x00, 0x62,
  0x01, 0x00, 0x01, 0x88, 0x04, 0x00, 0x06, 0x60, 0x30, 0x00, 0x19, 0x80,
  0xC0, 0x00, 0x46, 0x02, 0x00, 0x01, 0x10, 0x08, 0x00, 0x04, 0x40, 0x20,
  0x00, 0x11, 0x01, 0x80, 0x00, 0xCC, 0x06, 0x00, 0x03, 0x30, 0x18, 0x00,
  0x08, 0xC0, 0x60, 0x00, 0x22, 0x01, 0x80, 0x01, 0x88, 0x06, 0x00, 0x06,
  0x20, 0x18, 0x00, 0x18, 0x80, 0x20, 0x00, 0xE2, 0x00, 0x80, 0x05, 0x08,
  0x03, 0x00, 0x34, 0x20, 0x06, 0x01, 0x90, 0x80, 0x0C, 0x0C, 0x42, 0x00,
  0x1F, 0xC3, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x06, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x80,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x08, 0x18, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x08, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x60, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x00, 0x80, 0xC0, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x04, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0xC0, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0xA0, 0x20, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x01, 0x60, 0x10, 0x00, 0x02, 0x60, 0x08, 0x00, 0x04, 0x40, 0x06, 0x00,
  0x18, 0x40, 0x03, 0x80, 0x70, 0x40, 0x00, 0x7F, 0x80, 0x80, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x04, 0x01, 0x00, 0x00, 0x10,
  0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x04, 0x03, 0x80, 0x00, 0x00,
  0x10, 0x1A, 0x00, 0x00, 0x00, 0x40, 0xCC, 0x00, 0x00, 0x03, 0x06, 0x10,
  0x00, 0x00, 0x0C, 0x20, 0x60, 0x00, 0x00, 0x31, 0x00, 0x80, 0x00, 0x00,
  0x98, 0x03, 0x00, 0x00, 0x02, 0xC0, 0x04, 0x00, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0xA0, 0x12, 0x00, 0x00, 0x09,
  0x00, 0x90, 0x00, 0x00, 0xC8, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x62, 0x00,
  0x00, 0x66, 0x03, 0x10, 0x00, 0x06, 0x30, 0x18, 0xC0, 0x00, 0x21, 0x00,
  0x86, 0x00, 0x03, 0x08, 0x04, 0x10, 0x00, 0x10, 0x40, 0x20, 0x80, 0x01,
  0x86, 0x03, 0x06, 0x00, 0x18, 0x30, 0x18, 0x10, 0x00, 0x81, 0x80, 0xC0,
  0x80, 0x0C, 0x08, 0x04, 0x06, 0x00, 0xC0, 0x40, 0x20, 0x30, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x30,
  0x30, 0x0C, 0x06, 0x00, 0x83, 0x00, 0x40, 0x20, 0x04, 0x10, 0x02, 0x01,
  0x00, 0x31, 0x80, 0x10, 0x08, 0x01, 0x88, 0x01, 0x80, 0xC0, 0x04, 0x80,
  0x0C, 0x06, 0x00, 0x2C, 0x00, 0x60, 0x30, 0x01, 0xC0, 0x02, 0x01, 0x00,
  0x06, 0x00, 0x10, 0x08, 0x00, 0x20, 0x00, 0x80, 0x40, 0x02, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x38, 0x00, 0x00, 0x0C,
  0x07, 0x80, 0x00, 0x01, 0x80, 0xD0, 0x00, 0x00, 0x30, 0x12, 0x00, 0x00,
  0x04, 0x02, 0x60, 0x00, 0x00, 0x80, 0x44, 0x00, 0x00, 0x10, 0x18, 0xC0,
  0x00, 0x06, 0x03, 0x18, 0x00, 0x00, 0xC0, 0x41, 0x00, 0x00, 0x18, 0x08,
  0x30, 0x00, 0x02, 0x01, 0x06, 0x00, 0x00, 0x40, 0x20, 0x40, 0x00, 0x08,
  0x0C, 0x0C, 0x00, 0x03, 0x01, 0x81, 0x80, 0x00, 0x60, 0x20, 0x10, 0x00,
  0x0C, 0x04, 0x03, 0x00, 0x01, 0x00, 0x80, 0x20, 0x00, 0x20, 0x30, 0x04,
  0x00, 0x04, 0x06, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x08, 0x00, 0x30, 0x10,
  0x01, 0x00, 0x06, 0x02, 0x00, 0x30, 0x00, 0x80, 0x40, 0x02, 0x00, 0x10,
  0x18, 0x00, 0x60, 0x02, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x60, 0x00, 0x80,
  0x18, 0x08, 0x00, 0x18, 0x03, 0x01, 0x00, 0x03, 0x00, 0x40, 0x20, 0x00,
  0x20, 0x08, 0x0C, 0x00, 0x06, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x30,
  0x00, 0x08, 0x0C, 0x04, 0x00, 0x01, 0x81, 0x80, 0x80, 0x00, 0x10, 0x20,
  0x10, 0x00, 0x02, 0x04, 0x06, 0x00, 0x00, 0x60, 0x80, 0xC0, 0x00, 0x04,
  0x30, 0x18, 0x00, 0x00, 0x86, 0x02, 0x00, 0x00, 0x18, 0x80, 0x40, 0x00,
  0x01, 0x10, 0x08, 0x00, 0x00, 0x32, 0x03, 0x00, 0x00, 0x06, 0x40, 0x60,
  0x00, 0x00, 0x58, 0x0C, 0x00, 0x00, 0x0F, 0x01, 0x00, 0x00, 0x01, 0xC0,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x04, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00,
  0x01, 0x18, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x04, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x80, 0x30, 0x00, 0x01,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x08, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x00, 0x10, 0x00, 0x03, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x80, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00,
  0x10, 0x10, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x08, 0x00,
  0x00, 0x20, 0x01, 0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x80, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x40, 0x02,
  0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x20, 0x02, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x08, 0x01, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00, 0x10, 0x20, 0x00, 0xC0,
  0x01, 0x02, 0x00, 0x1C, 0x00, 0x30, 0x20, 0x01, 0x40, 0x02, 0x02, 0x00,
  0x34, 0x00, 0x20, 0x20, 0x02, 0x40, 0x06, 0x02, 0x00, 0x66, 0x00, 0x60,
  0x60, 0x06, 0x60, 0x04, 0x06, 0x00, 0x46, 0x00, 0x40, 0x60, 0x0C, 0x20,
  0x0C, 0x06, 0x00, 0x82, 0x00, 0xC0, 0x60, 0x18, 0x20, 0x08, 0x06, 0x01,
  0x02, 0x00, 0x80, 0x40, 0x30, 0x20, 0x18, 0x04, 0x02, 0x03, 0x01, 0x80,
  0x40, 0x60, 0x30, 0x10, 0x04, 0x04, 0x03, 0x01, 0x00, 0x40, 0xC0, 0x10,
  0x30, 0x04, 0x08, 0x01, 0x02, 0x00, 0x41, 0x80, 0x10, 0x20, 0x04, 0x10,
  0x01, 0x06, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x0C, 0x30, 0x01, 0x84, 0x00,
  0xC2, 0x00, 0x18, 0x40, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x08,
  0xC0, 0x0C, 0xC0, 0x00, 0x88, 0x00, 0xC8, 0x00, 0x08, 0x80, 0x09, 0x80,
  0x00, 0x98, 0x00, 0x90, 0x00, 0x0D, 0x80, 0x0B, 0x00, 0x00, 0xD0, 0x00,
  0xA0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x01, 0x00, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x40, 0x06, 0x00, 0x01, 0x80, 0x04, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x20, 0x00, 0x10, 0x00, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0xE0, 0x20, 0x30, 0x10,
  0x18, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0,
  0x38, 0x10, 0x0C, 0x00, 0x18, 0x40, 0x60, 0x00, 0x33, 0x03, 0x00, 0x00,
  0x4C, 0x18, 0x00, 0x00, 0xB0, 0xC0, 0x00, 0x02, 0x82, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x42, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x0F, 0x06, 0x00,
  0x00, 0x28, 0x08, 0x00, 0x01, 0x20, 0x30, 0x00, 0x08, 0x80, 0x60, 0x00,
  0x46, 0x00, 0xC0, 0x02, 0x18, 0x00, 0xC0, 0x70, 0x3F, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x7F, 0x80, 0x01,
  0x83, 0x80, 0xC0, 0x02, 0x18, 0x00, 0x60, 0x04, 0x60, 0x00, 0x60, 0x09,
  0x80, 0x00, 0x40, 0x12, 0x00, 0x00, 0x40, 0x68, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x00, 0x81, 0x40, 0x00, 0x01, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x03, 0x07, 0x00, 0x00, 0x04, 0x0D, 0x00, 0x00, 0x18, 0x13,
  0x00, 0x00, 0x60, 0x23, 0x00, 0x01, 0x80, 0x43, 0x00, 0x0C, 0x00, 0x81,
  0x80, 0x70, 0x02, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x03, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x3F, 0xE0, 0x10, 0x00, 0x70, 0x1C, 0x08, 0x00,
  0xC0, 0x01, 0x84, 0x00, 0xC0, 0x00, 0x66, 0x00, 0xC0, 0x00, 0x13, 0x00,
  0xC0, 0x00, 0x05, 0x80, 0xC0, 0x00, 0x02, 0x80, 0x40, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x70, 0x08, 0x00, 0x00, 0x58, 0x06, 0x00, 0x00, 0x28, 0x01, 0x00,
  0x00, 0x24, 0x00, 0xC0, 0x00, 0x22, 0x00, 0x30, 0x00, 0x23, 0x00, 0x0C,
  0x00, 0x21, 0x80, 0x01, 0x80, 0xE0, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x08,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x01, 0x18, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x04, 0x40, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x08,
  0x00, 0x0F, 0x00, 0x80, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0E,
  0x03, 0x81, 0x00, 0x30, 0x00, 0x61, 0x00, 0x60, 0x00, 0x33, 0x00, 0xC0,
  0x00, 0x13, 0x01, 0x80, 0x00, 0x0B, 0x03, 0x00, 0x00, 0x0A, 0x02, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x30, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x70, 0x10, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x00, 0xA0, 0x08, 0x00,
  0x01, 0x20, 0x0C, 0x00, 0x02, 0x20, 0x06, 0x00, 0x04, 0x60, 0x03, 0x00,
  0x08, 0x60, 0x00, 0xC0, 0x70, 0x40, 0x00, 0x3F, 0xC0, 0x40, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x40, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x01, 0xFC, 0x00, 0x20, 0xE0, 0x30, 0x02, 0x18,
  0x00, 0x80, 0x62, 0x00, 0x04, 0x06, 0x40, 0x00, 0x60, 0x68, 0x00, 0x02,
  0x05, 0x00, 0x00, 0x30, 0x50, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x43, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x20, 0x00, 0x60, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x40, 0x00, 0x60, 0x18, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x10, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x04, 0x00, 0x06, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x0F, 0xF0, 0x00, 0x0C, 0x1C, 0x03, 0x00, 0x02, 0x0C, 0x00, 0x20, 0x00,
  0x8C, 0x00, 0x04, 0x00, 0x26, 0x00, 0x01, 0x80, 0x1B, 0x00, 0x00, 0x20,
  0x06, 0x80, 0x00, 0x08, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x18, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x80, 0x08, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00, 0x01,
  0x01, 0xE0, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x03, 0x20, 0x03, 0x00, 0x01, 0x88, 0x00, 0x40, 0x00, 0xC2, 0x00, 0x18,
  0x00, 0x61, 0x80, 0x02, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x18, 0x18, 0x00,
  0x10, 0x0C, 0x04, 0x00, 0x02, 0x04, 0x01, 0x00, 0x00, 0xC2, 0x00, 0x40,
  0x00, 0x11, 0x00, 0x30, 0x00, 0x06, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x01, 0x80,
  0x06, 0x00, 0x40, 0x02, 0x00, 0x10, 0x03, 0x00, 0x0C, 0x01, 0x00, 0x03,
  0x01, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x08, 0x40, 0x00,
  0x06, 0x60, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x42, 0x0C, 0x0C, 0x18, 0x19, 0x80, 0xC2, 0x01, 0x03,
  0x40, 0x08, 0x80, 0x30, 0x70, 0x01, 0x20, 0x02, 0x0A, 0x00, 0x38, 0x00,
  0x41, 0x80, 0x07, 0x00, 0x08, 0x30, 0x00, 0xC0, 0x01, 0x0C, 0x00, 0x18,
  0x00, 0x21, 0x80, 0x02, 0x00, 0x04, 0x20, 0x00, 0x40, 0x00, 0x84, 0x00,
  0x08, 0x00, 0x30, 0x80, 0x03, 0x00, 0x06, 0x10, 0x00, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x00, 0x10, 0xC0, 0x01, 0x00, 0x02, 0x18, 0x00, 0x20, 0x00,
  0x42, 0x00, 0x04, 0x00, 0x18, 0x40, 0x01, 0x80, 0x03, 0x08, 0x00, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x00, 0x08, 0x60, 0x00, 0x80, 0x01, 0x0C, 0x00,
  0x10, 0x00, 0x21, 0x00, 0x02, 0x00, 0x0C, 0x20, 0x00, 0xC0, 0x01, 0x84,
  0x00, 0x18, 0x00, 0x31, 0x80, 0x03, 0x00, 0x04, 0x30, 0x00, 0x40, 0x00,
  0x86, 0x00, 0x08, 0x00, 0x10, 0x80, 0x01, 0x00, 0x06, 0x10, 0x00, 0x60,
  0x00, 0xC2, 0x00, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x02, 0x18, 0x00,
  0x20, 0x00, 0x43, 0x00, 0x04, 0x00, 0x08, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x20, 0xE0, 0x30, 0x02, 0x18, 0x00, 0x80, 0x62,
  0x00, 0x04, 0x06, 0x40, 0x00, 0x60, 0x68, 0x00, 0x02, 0x05, 0x00, 0x00,
  0x30, 0x50, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x61, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x30, 0x00, 0x60, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x60, 0xE0, 0x30, 0x00, 0x21, 0x80, 0x06, 0x00, 0x11, 0x80,
  0x01, 0x80, 0x09, 0x80, 0x00, 0x40, 0x04, 0x80, 0x00, 0x10, 0x06, 0x80,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x02, 0x01, 0x40, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x06, 0x04,
  0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x00, 0x40, 0x34, 0x00, 0x00, 0x60, 0x1B, 0x00, 0x00,
  0x60, 0x08, 0xC0, 0x00, 0x60, 0x04, 0x30, 0x00, 0xC0, 0x02, 0x06, 0x01,
  0xC0, 0x03, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x38, 0x10, 0x0C, 0x00, 0x18, 0x40,
  0x60, 0x00, 0x33, 0x03, 0x00, 0x00, 0x4C, 0x18, 0x00, 0x00, 0xB0, 0xC0,
  0x00, 0x02, 0x82, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x88, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0xC1, 0x00, 0x00, 0x0F, 0x06, 0x00, 0x00, 0x28, 0x08, 0x00, 0x01, 0x20,
  0x30, 0x00, 0x08, 0x80, 0x60, 0x00, 0x46, 0x00, 0xC0, 0x02, 0x18, 0x00,
  0xC0, 0x70, 0x60, 0x00, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x06, 0x1C, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x80, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x01, 0x80, 0x02, 0x00, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x08,
  0x10, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x21, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x61, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x43, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0xA0, 0x80, 0x00, 0x0A,
  0x0C, 0x00, 0x01, 0x60, 0x40, 0x00, 0x16, 0x04, 0x00, 0x02, 0x60, 0x20,
  0x00, 0x44, 0x03, 0x00, 0x18, 0x40, 0x0C, 0x07, 0x04, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x08, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0x40, 0x60, 0x00, 0x01, 0x01, 0x80, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x40, 0x40, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x20, 0x18, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x04, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x20, 0x01, 0x00, 0x01, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x70,
  0x00, 0x08, 0x07, 0x00, 0x00, 0x20, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x10, 0x03, 0x06, 0x00, 0x08, 0x01, 0x83, 0x00, 0x04,
  0x00, 0x41, 0x00, 0x06, 0x00, 0x20, 0x80, 0x03, 0x00, 0x18, 0x40, 0x01,
  0x00, 0x0C, 0x60, 0x00, 0x80, 0x02, 0x30, 0x00, 0x40, 0x01, 0x18, 0x00,
  0x20, 0x00, 0x88, 0x00, 0x30, 0x00, 0x44, 0x00, 0x18, 0x00, 0x22, 0x00,
  0x08, 0x00, 0x11, 0x00, 0x04, 0x00, 0x09, 0x80, 0x02, 0x00, 0x04, 0xC0,
  0x01, 0x00, 0x02, 0x40, 0x01, 0x80, 0x01, 0x20, 0x00, 0xC0, 0x00, 0x90,
  0x00, 0x40, 0x00, 0x48, 0x00, 0x20, 0x00, 0x2C, 0x00, 0x10, 0x00, 0x16,
  0x00, 0x08, 0x00, 0x1A, 0x00, 0x0C, 0x00, 0x0D, 0x00, 0x06, 0x00, 0x06,
  0x80, 0x03, 0x00, 0x02, 0x40, 0x01, 0x00, 0x01, 0x60, 0x00, 0x80, 0x01,
  0xB0, 0x00, 0xC0, 0x00, 0x98, 0x00, 0x60, 0x00, 0xC8, 0x00, 0x50, 0x00,
  0x64, 0x00, 0x28, 0x00, 0x22, 0x00, 0x14, 0x00, 0x31, 0x80, 0x12, 0x00,
  0x30, 0xC0, 0x11, 0x80, 0x30, 0x20, 0x18, 0x40, 0x30, 0x0C, 0x18, 0x18,
  0x30, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x00,
  0xE4, 0x00, 0x41, 0x80, 0x0E, 0x18, 0x06, 0x01, 0x01, 0xC0, 0x30, 0x30,
  0x06, 0x1C, 0x00, 0xC1, 0x80, 0x09, 0xC0, 0x01, 0x04, 0x00, 0x20, 0x00,
  0x06, 0x20, 0x00, 0xC0, 0x00, 0x08, 0x80, 0x03, 0x00, 0x00, 0x24, 0x00,
  0x0C, 0x00, 0x00, 0x90, 0x00, 0x30, 0x00, 0x02, 0x40, 0x00, 0x80, 0x00,
  0x0E, 0x00, 0x02, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x03, 0x00, 0x02, 0x80, 0x00, 0x08, 0x00, 0x0A,
  0x00, 0x00, 0x20, 0x00, 0x48, 0x00, 0x00, 0x80, 0x01, 0x20, 0x00, 0x02,
  0x00, 0x0C, 0xC0, 0x00, 0x08, 0x00, 0x21, 0x00, 0x02, 0x20, 0x01, 0x04,
  0x00, 0x3C, 0x80, 0x0C, 0x18, 0x03, 0x83, 0x00, 0x60, 0x20, 0x38, 0x06,
  0x03, 0x00, 0xC3, 0x80, 0x0C, 0x18, 0x01, 0xB8, 0x00, 0x1F, 0x80, 0x03,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x02, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x04, 0x03, 0x00,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x08, 0x06, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x10, 0x0C, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x30, 0x08, 0x00,
  0x00, 0x60, 0x08, 0x00, 0x00, 0xA0, 0x08, 0x00, 0x00, 0xA0, 0x0C, 0x00,
  0x01, 0x60, 0x04, 0x00, 0x01, 0x60, 0x04, 0x00, 0x02, 0x60, 0x02, 0x00,
  0x04, 0x40, 0x03, 0x00, 0x18, 0x40, 0x00, 0xC0, 0x70, 0x40, 0x00, 0x3F,
  0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xC0,
  0x38, 0x00, 0xC0, 0xC0, 0x03, 0x80, 0x40, 0xC0, 0x00, 0x30, 0x20, 0x40,
  0x00, 0x07, 0x10, 0x60, 0x00, 0x00, 0x78, 0x20, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0xC0, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x00, 0x41, 0xF0, 0x00, 0x00, 0x20, 0xC7, 0xC0, 0x00, 0x18, 0x40, 0x1F,
  0x00, 0x0C, 0x20, 0x00, 0x7C, 0x06, 0x10, 0x00, 0x03, 0xF1, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x41, 0xC3, 0x00,
  0x00, 0x30, 0xC0, 0x60, 0x00, 0x08, 0x60, 0x0C, 0x00, 0x02, 0x10, 0x01,
  0x80, 0x01, 0x08, 0x00, 0x30, 0x00, 0x46, 0x00, 0x06, 0x00, 0x21, 0x00,
  0x00, 0x80, 0x18, 0xC0, 0x00, 0x10, 0x0C, 0x20, 0x00, 0x03, 0x0C, 0x08,
  0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 11, 47, 41, 15, -47 },
  { 66, 13, 17, 41, 18, -50 },
  { 94, 41, 47, 41, 1, -47 },
  { 335, 35, 63, 41, 3, -55 },
  { 611, 45, 49, 41, -1, -48 },
  { 887, 39, 49, 41, 1, -48 },
  { 1126, 5, 17, 41, 22, -50 },
  { 1137, 21, 61, 41, 16, -52 },
  { 1298, 21, 61, 41, 5, -52 },
  { 1459, 35, 34, 41, 4, -37 },
  { 1608, 32, 33, 41, 5, -37 },
  { 1740, 9, 17, 41, 11, -5 },
  { 1760, 18, 1, 41, 12, -21 },
  { 1763, 5, 4, 41, 15, -4 },
  { 1766, 36, 61, 41, 3, -52 },
  { 2041, 32, 49, 41, 5, -48 },
  { 2237, 31, 47, 41, 3, -47 },
  { 2420, 33, 48, 41, 3, -48 },
  { 2618, 33, 49, 41, 3, -48 },
  { 2821, 35, 47, 41, 2, -47 },
  { 3027, 34, 48, 41, 4, -47 },
  { 3231, 30, 48, 41, 5, -47 },
  { 3411, 32, 47, 41, 8, -47 },
  { 3599, 34, 49, 41, 4, -48 },
  { 3808, 30, 48, 41, 7, -48 },
  { 3988, 10, 36, 41, 15, -36 },
  { 4033, 14, 48, 41, 11, -36 },
  { 4117, 33, 36, 41, 6, -39 },
  { 4266, 34, 13, 41, 4, -27 },
  { 4322, 33, 36, 41, 3, -39 },
  { 4471, 27, 48, 41, 10, -48 },
  { 4633, 30, 55, 41, 6, -48 },
  { 4840, 33, 47, 41, 1, -47 },
  { 5034, 32, 47, 41, 4, -47 },
  { 5222, 32, 49, 41, 6, -48 },
  { 5418, 34, 47, 41, 4, -47 },
  { 5618, 36, 47, 41, 4, -47 },
  { 5830, 36, 47, 41, 4, -47 },
  { 6042, 32, 49, 41, 6, -48 },
  { 6238, 35, 47, 41, 4, -47 },
  { 6444, 37, 47, 41, 3, -47 },
  { 6662, 31, 48, 41, 5, -47 },
  { 6848, 38, 47, 41, 4, -47 },
  { 7072, 26, 47, 41, 7, -47 },
  { 7225, 37, 47, 41, 3, -47 },
  { 7443, 35, 47, 41, 4, -47 },
  { 7649, 32, 49, 41, 5, -48 },
  { 7845, 35, 47, 41, 4, -47 },
  { 8051, 32, 59, 41, 5, -48 },
  { 8287, 35, 47, 41, 4, -47 },
  { 8493, 35, 49, 41, 3, -48 },
  { 8708, 35, 47, 41, 8, -47 },
  { 8914, 33, 48, 41, 6, -47 },
  { 9112, 33, 47, 41, 9, -47 },
  { 9306, 36, 47, 41, 6, -47 },
  { 9518, 41, 47, 41, 1, -47 },
  { 9759, 37, 47, 41, 7, -47 },
  { 9977, 41, 47, 41, 0, -47 },
  { 10218, 27, 61, 41, 13, -52 },
  { 10424, 15, 61, 41, 14, -52 },
  { 10539, 26, 61, 41, 2, -52 },
  { 10738, 31, 26, 41, 6, -47 },
  { 10839, 32, 1, 41, 0, 8 },
  { 10843, 8, 11, 41, 16, -52 },
  { 10854, 30, 37, 41, 5, -36 },
  { 10993, 31, 51, 41, 5, -50 },
  { 11191, 28, 37, 41, 6, -36 },
  { 11321, 33, 51, 41, 5, -50 },
  { 11532, 28, 37, 41, 6, -36 },
  { 11662, 43, 64, 41, -1, -50 },
  { 12006, 32, 50, 41, 3, -36 },
  { 12206, 28, 50, 41, 6, -50 },
  { 12381, 28, 52, 41, 6, -51 },
  { 12563, 28, 65, 41, 7, -51 },
  { 12791, 34, 51, 41, 5, -50 },
  { 13008, 26, 51, 41, 8, -50 },
  { 13174, 35, 36, 41, 3, -36 },
  { 13332, 28, 36, 41, 6, -36 },
  { 13458, 29, 37, 41, 6, -36 },
  { 13593, 33, 50, 41, 3, -36 },
  { 13800, 30, 50, 41, 5, -36 },
  { 13988, 33, 35, 41, 8, -35 },
  { 14133, 32, 37, 41, 4, -36 },
  { 14281, 33, 48, 41, 5, -47 },
  { 14479, 28, 36, 41, 7, -35 },
  { 14605, 30, 35, 41, 6, -35 },
  { 14737, 33, 36, 41, 5, -35 },
  { 14886, 38, 37, 41, 2, -36 },
  { 15062, 32, 49, 41, 3, -35 },
  { 15258, 33, 37, 41, 4, -36 },
  { 15411, 31, 61, 41, 8, -52 },
  { 15648, 12, 61, 41, 15, -52 },
  { 15740, 31, 61, 41, 3, -52 },
  { 15977, 34, 11, 41, 4, -26 },
};

const GFXfont IBMPlexMono_ThinItalic68pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic68pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic68pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _IBMPLEXMONO_THINITALIC68PT7B_H_
