#ifndef _IBMPLEXMONO_THINITALIC62PT7B_H_
#define _IBMPLEXMONO_THINITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x10, 0x11, 0x01, 0x30, 0x13,
  0x03, 0x30, 0x32, 0x03, 0x20, 0x22, 0x02, 0x60, 0x26, 0x06, 0x60, 0x64,
  0x06, 0x40, 0x44, 0x04, 0xC0, 0x4C, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x40, 0x08,
  0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x08, 0x03, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x08, 0x01, 0x00, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x04, 0x00, 0x80, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x10, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x20, 0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x10, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1C, 0x10, 0xE0, 0x00,
  0x30, 0x08, 0x0C, 0x00, 0x30, 0x04, 0x03, 0x00, 0x20, 0x02, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x30, 0x10, 0x01, 0x00, 0x10, 0x18, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x04, 0x00, 0x20, 0x00, 0x02, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x04, 0x00,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x10, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x07, 0x10, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00,
  0x20, 0x06, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x40, 0x00, 0x04, 0x00, 0x20, 0x00, 0x02, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x08, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0xC0, 0x06, 0x10,
  0x00, 0x40, 0x02, 0x0C, 0x00, 0x20, 0x03, 0x03, 0x00, 0x10, 0x01, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x0E, 0x06, 0x03, 0x00,
  0x01, 0xE2, 0x0F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x08, 0x03, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x00, 0x40, 0x08, 0x00, 0x20, 0x00, 0x40,
  0x04, 0x00, 0x10, 0x00, 0x60, 0x04, 0x00, 0x08, 0x00, 0x60, 0x02, 0x00,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x02, 0x00, 0x20, 0x01, 0x80, 0x01, 0x00,
  0x30, 0x00, 0x80, 0x00, 0x80, 0x30, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x10, 0x00, 0x10, 0x00, 0x30, 0x10, 0x00, 0x08, 0x00,
  0x10, 0x18, 0x00, 0x04, 0x00, 0x18, 0x08, 0x00, 0x03, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x80, 0x08, 0x08, 0x00, 0x00, 0x20, 0x0C, 0x0C, 0x00, 0x00,
  0x0C, 0x18, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x80, 0xC1, 0x80, 0x00,
  0x01, 0x81, 0x80, 0x20, 0x00, 0x00, 0x80, 0x80, 0x08, 0x00, 0x00, 0x80,
  0x80, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x01, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x80, 0x00, 0x40, 0x60, 0x00, 0x40, 0x00, 0x40, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x10, 0x00, 0x10, 0x00, 0x60, 0x08, 0x00, 0x08, 0x00, 0x20, 0x04,
  0x00, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x06, 0x00, 0x20, 0x01, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x80, 0x01, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x10, 0x00, 0x08, 0x00, 0x80, 0x18, 0x00, 0x06,
  0x00, 0x80, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x0F, 0x40, 0xC0, 0x00, 0x03, 0x02, 0x70, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x10, 0x01, 0x00, 0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x00, 0xA0, 0x03, 0x80, 0x00, 0x0B, 0x00, 0x68,
  0x00, 0x00, 0x90, 0x04, 0xC0, 0x00, 0x11, 0x80, 0x84, 0x00, 0x01, 0x0C,
  0x18, 0x60, 0x00, 0x20, 0x41, 0x03, 0x00, 0x06, 0x06, 0x30, 0x18, 0x00,
  0xC0, 0x22, 0x00, 0xE0, 0x30, 0x01, 0x40, 0x03, 0xFC, 0x00, 0x1C, 0x00,
  0x11, 0x33, 0x32, 0x22, 0x66, 0x64, 0x44, 0xCC, 0x00, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x08, 0x00, 0x37, 0x80, 0x10, 0x03,
  0xC1, 0xE0, 0x20, 0x3C, 0x00, 0x78, 0x47, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x10, 0x08, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0x07, 0x06, 0x0E,
  0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x20, 0x60, 0x60, 0x40, 0xC0, 0x80,
  0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x00, 0x80, 0x18, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x02, 0x80, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x80, 0x20, 0x00, 0x08, 0x00,
  0x80, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x18, 0x08, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x02, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x01, 0x01, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x20, 0x01, 0x00, 0x00, 0x80,
  0x02, 0x00, 0x03, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0x80, 0x04, 0x00, 0x01,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x41, 0xFF, 0x00, 0x01, 0x18, 0x07, 0x00, 0x0D, 0x80,
  0x03, 0x00, 0x28, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00,
  0x80, 0x30, 0x00, 0x04, 0x00, 0x60, 0x00, 0x60, 0x00, 0xF0, 0x06, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x03, 0xFC, 0x00, 0x63, 0x80, 0x70, 0x09, 0xC0, 0x03, 0x01,
  0x60, 0x00, 0x30, 0x58, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x22, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x10, 0x00, 0x08, 0x01, 0x00,
  0x06, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xF9, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x21, 0x00, 0x00, 0x03, 0x08, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x18, 0x04, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0x10,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x38, 0x06, 0x00, 0x30, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x08,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x22, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x50, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0E, 0x40, 0x00, 0x02, 0x98, 0x00, 0x01, 0x63, 0x00, 0x01,
  0x90, 0x60, 0x00, 0xCC, 0x06, 0x01, 0xC2, 0x00, 0x7F, 0x81, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x83, 0xC1,
  0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x04,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00, 0xC1,
  0x80, 0x00, 0x21, 0x80, 0x00, 0x08, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x03,
  0x40, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x40, 0x00, 0x20, 0x08,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x10, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00,
  0x10, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x10, 0x80, 0x0F, 0xC1, 0x08, 0x03, 0x83, 0x11, 0x80, 0x60,
  0x0B, 0x10, 0x0C, 0x00, 0x71, 0x00, 0x80, 0x06, 0x10, 0x18, 0x00, 0x63,
  0x01, 0x00, 0x02, 0x30, 0x30, 0x00, 0x22, 0x02, 0x00, 0x06, 0x20, 0x20,
  0x00, 0x62, 0x02, 0x00, 0x04, 0x60, 0x60, 0x00, 0x46, 0x06, 0x00, 0x04,
  0x60, 0x60, 0x00, 0x44, 0x04, 0x00, 0x0C, 0x40, 0x40, 0x00, 0xC4, 0x04,
  0x00, 0x08, 0x40, 0x40, 0x00, 0x8C, 0x04, 0x00, 0x18, 0xC0, 0x40, 0x01,
  0x8C, 0x06, 0x00, 0x38, 0x80, 0x20, 0x03, 0x88, 0x02, 0x00, 0x50, 0x80,
  0x10, 0x19, 0x08, 0x00, 0xE7, 0x10, 0x80, 0x03, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60,
  0x20, 0x00, 0x01, 0x00, 0x80, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x04, 0x00, 0x40, 0x00, 0x30, 0x01, 0x00,
  0x00, 0x80, 0x04, 0x00, 0x06, 0x00, 0x10, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x02, 0x00, 0x18, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x80, 0x08, 0x00, 0x03, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x00, 0x86, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x0F, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x1C, 0x02, 0x00, 0x00,
  0x30, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08,
  0x60, 0x00, 0x00, 0x42, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x63, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x06, 0x04, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x80, 0x08, 0x00, 0x06, 0x00, 0x80, 0x00, 0x10, 0x08, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x04, 0x00,
  0x1C, 0x00, 0x10, 0x00, 0x18, 0x00, 0x40, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x20, 0x0C, 0x00, 0x00, 0x40, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x21, 0x00, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x60, 0x10, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18,
  0x08, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x1F, 0xFE,
  0x20, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x14, 0x0C,
  0x00, 0x00, 0xA0, 0x20, 0x00, 0x0B, 0x01, 0x80, 0x00, 0x98, 0x06, 0x00,
  0x18, 0x80, 0x0E, 0x03, 0x84, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x0C, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x0C, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x20, 0x28, 0x00, 0x00, 0x08, 0x33, 0x00, 0x00, 0x02, 0x18, 0x40,
  0x00, 0x01, 0x8C, 0x18, 0x00, 0x00, 0x66, 0x02, 0x00, 0x00, 0x13, 0x00,
  0xC0, 0x00, 0x05, 0x80, 0x10, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x20, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00,
  0x18, 0x01, 0x00, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0xA0, 0x78, 0x00, 0x00, 0xD0, 0x24, 0x00, 0x00,
  0x58, 0x12, 0x00, 0x00, 0x6C, 0x09, 0x80, 0x00, 0x64, 0x04, 0x40, 0x00,
  0x22, 0x06, 0x20, 0x00, 0x31, 0x03, 0x10, 0x00, 0x10, 0x81, 0x0C, 0x00,
  0x10, 0xC0, 0x82, 0x00, 0x18, 0x60, 0x41, 0x00, 0x08, 0x20, 0x20, 0xC0,
  0x0C, 0x10, 0x30, 0x20, 0x0C, 0x08, 0x18, 0x10, 0x04, 0x04, 0x08, 0x08,
  0x06, 0x06, 0x04, 0x06, 0x02, 0x03, 0x02, 0x01, 0x02, 0x01, 0x01, 0x00,
  0x83, 0x00, 0x81, 0x80, 0x61, 0x00, 0x40, 0xC0, 0x11, 0x80, 0x20, 0x40,
  0x08, 0x80, 0x30, 0x20, 0x04, 0x80, 0x18, 0x10, 0x03, 0xC0, 0x08, 0x08,
  0x00, 0xC0, 0x04, 0x0C, 0x00, 0x60, 0x02, 0x06, 0x00, 0x20, 0x01, 0x02,
  0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x08,
  0x10, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x00, 0x81, 0x80, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x80, 0x78,
  0x00, 0x00, 0x40, 0x24, 0x00, 0x00, 0x20, 0x12, 0x00, 0x00, 0x10, 0x09,
  0x80, 0x00, 0x18, 0x0C, 0x40, 0x00, 0x0C, 0x06, 0x20, 0x00, 0x04, 0x03,
  0x18, 0x00, 0x02, 0x01, 0x04, 0x00, 0x01, 0x00, 0x82, 0x00, 0x00, 0x80,
  0x41, 0x80, 0x00, 0xC0, 0x60, 0x40, 0x00, 0x60, 0x30, 0x20, 0x00, 0x20,
  0x18, 0x18, 0x00, 0x10, 0x08, 0x04, 0x00, 0x08, 0x04, 0x02, 0x00, 0x04,
  0x02, 0x01, 0x80, 0x06, 0x03, 0x00, 0x40, 0x03, 0x01, 0x80, 0x30, 0x01,
  0x00, 0x80, 0x18, 0x00, 0x80, 0x40, 0x04, 0x00, 0x40, 0x20, 0x03, 0x00,
  0x20, 0x10, 0x00, 0x80, 0x30, 0x18, 0x00, 0x40, 0x18, 0x0C, 0x00, 0x30,
  0x08, 0x04, 0x00, 0x08, 0x04, 0x02, 0x00, 0x04, 0x02, 0x01, 0x00, 0x03,
  0x01, 0x00, 0x80, 0x00, 0x81, 0x80, 0xC0, 0x00, 0x40, 0xC0, 0x60, 0x00,
  0x30, 0x40, 0x20, 0x00, 0x08, 0x20, 0x10, 0x00, 0x04, 0x10, 0x08, 0x00,
  0x03, 0x08, 0x04, 0x00, 0x00, 0x8C, 0x06, 0x00, 0x00, 0x66, 0x03, 0x00,
  0x00, 0x32, 0x01, 0x00, 0x00, 0x09, 0x00, 0x80, 0x00, 0x06, 0x80, 0x40,
  0x00, 0x01, 0x40, 0x20, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x80, 0x18, 0x00, 0x02, 0x00, 0x80, 0x00, 0x10, 0x08, 0x00,
  0x00, 0x40, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x21, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x08, 0x00, 0x80, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x02, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x04, 0x18,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x00, 0x80, 0x18, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02,
  0x0C, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x80, 0x20, 0x00, 0x08, 0x00,
  0x80, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x08, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x04, 0x18, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x10, 0x60, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x00, 0x41, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x01, 0x80, 0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x30,
  0x07, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x20, 0x01, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0x80, 0x02, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x18, 0x00, 0x40, 0x00, 0x10, 0x01, 0x80,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x60, 0x08, 0x00,
  0x00, 0x40, 0x10, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x01, 0x01, 0x80, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x04,
  0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x00, 0x83, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x81, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x01, 0x02, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x00, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x20, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x40, 0x80, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x04, 0x00, 0x40, 0x00, 0x30, 0x01, 0x00, 0x00, 0x80, 0x06, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x02,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x08, 0x00, 0x40, 0x00, 0x20, 0x03, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0x60, 0x00, 0x04, 0x01, 0x00, 0x00,
  0x10, 0x0C, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01, 0x01, 0x80, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x20, 0x80, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00, 0x08, 0x20, 0x00,
  0x00, 0x04, 0x10, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x41, 0x00,
  0x0C, 0x00, 0x60, 0x80, 0x0E, 0x00, 0x20, 0x40, 0x05, 0x00, 0x10, 0x20,
  0x06, 0x80, 0x18, 0x10, 0x02, 0x40, 0x0C, 0x08, 0x03, 0x20, 0x04, 0x04,
  0x01, 0x18, 0x02, 0x02, 0x00, 0x8C, 0x03, 0x01, 0x00, 0x82, 0x01, 0x00,
  0x80, 0x41, 0x00, 0x80, 0xC0, 0x60, 0x80, 0x40, 0x60, 0x20, 0x40, 0x60,
  0x30, 0x30, 0x20, 0x20, 0x18, 0x10, 0x18, 0x10, 0x08, 0x18, 0x0C, 0x08,
  0x04, 0x08, 0x06, 0x0C, 0x02, 0x0C, 0x01, 0x04, 0x01, 0x04, 0x00, 0x82,
  0x00, 0x86, 0x00, 0x43, 0x00, 0x42, 0x00, 0x21, 0x80, 0x21, 0x00, 0x10,
  0x80, 0x11, 0x00, 0x0C, 0x40, 0x08, 0x80, 0x06, 0x60, 0x04, 0xC0, 0x01,
  0x20, 0x02, 0x40, 0x00, 0x90, 0x03, 0x60, 0x00, 0x48, 0x01, 0xA0, 0x00,
  0x2C, 0x00, 0xF0, 0x00, 0x14, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x04, 0xC0,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x00, 0x80, 0x00, 0x10, 0x06,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x18, 0x00, 0x80, 0x00, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x18, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x81, 0x81, 0x03,
  0x02, 0x06, 0x04, 0x04, 0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x01, 0xC1,
  0x00, 0xC0, 0x06, 0x10, 0x10, 0x00, 0x13, 0x02, 0x00, 0x00, 0xB0, 0x40,
  0x00, 0x0A, 0x0C, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x05, 0x06, 0x00, 0x00, 0x70, 0x20, 0x00, 0x0B, 0x03, 0x00,
  0x01, 0x20, 0x18, 0x00, 0x22, 0x00, 0xC0, 0x04, 0x20, 0x07, 0x03, 0x83,
  0xF0, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x7F, 0x00, 0x06, 0x1C, 0x0E, 0x00, 0x42, 0x00, 0x30,
  0x04, 0x40, 0x01, 0x80, 0x48, 0x00, 0x0C, 0x05, 0x00, 0x00, 0x40, 0xE0,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x31, 0x00, 0x00,
  0x03, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x86, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x03, 0x05, 0x00, 0x00, 0x20, 0x50, 0x00, 0x04, 0x0C, 0x80,
  0x00, 0x80, 0xC6, 0x00, 0x30, 0x08, 0x38, 0x0E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x20, 0x00, 0x04, 0x0C,
  0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0x30, 0x01, 0x80, 0x03, 0x01, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x40, 0x07, 0x01, 0xC1,
  0x00, 0x30, 0x01, 0x84, 0x01, 0x00, 0x01, 0x30, 0x08, 0x00, 0x02, 0xC0,
  0x40, 0x00, 0x0A, 0x03, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x40, 0x60, 0x00,
  0x07, 0x00, 0x80, 0x00, 0x2C, 0x03, 0x00, 0x01, 0x20, 0x06, 0x00, 0x08,
  0x80, 0x0C, 0x00, 0x42, 0x00, 0x1C, 0x0E, 0x08, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04,
  0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x02, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x60, 0xC0, 0x01, 0xE0, 0x30, 0x0F, 0x80, 0x0F,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x11, 0x80, 0x00, 0x08, 0x20, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x01, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x70, 0x40,
  0x18, 0x00, 0xC2, 0x01, 0x00, 0x01, 0x30, 0x10, 0x00, 0x05, 0x81, 0x00,
  0x00, 0x28, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x61, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x00, 0x86, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0xA0, 0x60, 0x00, 0x07, 0x01, 0x00, 0x00,
  0x58, 0x0C, 0x00, 0x04, 0x80, 0x30, 0x00, 0x44, 0x00, 0xC0, 0x04, 0x20,
  0x03, 0x81, 0xC1, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0xFE,
  0x00, 0x21, 0xC0, 0xE0, 0x18, 0xC0, 0x0C, 0x06, 0x40, 0x01, 0x81, 0xA0,
  0x00, 0x20, 0x58, 0x00, 0x08, 0x14, 0x00, 0x03, 0x06, 0x00, 0x00, 0x43,
  0x80, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x08, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x60, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x21, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x10,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04,
  0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x08, 0x60, 0x00, 0x02, 0x18, 0x00, 0x00, 0x84, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x04, 0x30, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x10, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x20, 0x02, 0x00, 0x60, 0x01,
  0x00, 0x40, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x80, 0x00, 0x61, 0x80, 0x00,
  0x21, 0x80, 0x00, 0x13, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x06, 0x01, 0x00, 0x03, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x06, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00, 0x60, 0x30, 0x00, 0x08, 0x18,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x7F, 0x80, 0x01,
  0x07, 0x01, 0xC0, 0x02, 0x18, 0x00, 0xC0, 0x04, 0x40, 0x00, 0x80, 0x09,
  0x00, 0x01, 0x80, 0x34, 0x00, 0x01, 0x00, 0x70, 0x00, 0x02, 0x00, 0xA0,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x10, 0x04, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x20, 0x01, 0x00, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x6C, 0x01, 0x80, 0x01, 0x10, 0x01, 0x80, 0x04,
  0x20, 0x01, 0x00, 0x10, 0x40, 0x03, 0x00, 0x40, 0x80, 0x02, 0x01, 0x03,
  0x00, 0x06, 0x04, 0x06, 0x00, 0x04, 0x10, 0x08, 0x00, 0x0C, 0x40, 0x10,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x30, 0x20, 0x00, 0x80, 0x40, 0x06, 0x01, 0x80, 0x10,
  0x03, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x08, 0x18, 0x00, 0x10, 0x40, 0x00,
  0x63, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x04, 0x61, 0x83, 0x04, 0x04, 0x80, 0x44, 0x02,
  0x05, 0x00, 0x48, 0x03, 0x0E, 0x00, 0x50, 0x01, 0x0E, 0x00, 0x70, 0x01,
  0x0C, 0x00, 0x60, 0x01, 0x08, 0x00, 0x60, 0x01, 0x08, 0x00, 0x60, 0x01,
  0x08, 0x00, 0x40, 0x03, 0x18, 0x00, 0x40, 0x03, 0x10, 0x00, 0x40, 0x02,
  0x10, 0x00, 0xC0, 0x02, 0x10, 0x00, 0xC0, 0x02, 0x10, 0x00, 0x80, 0x02,
  0x10, 0x00, 0x80, 0x06, 0x30, 0x00, 0x80, 0x06, 0x20, 0x00, 0x80, 0x04,
  0x20, 0x01, 0x80, 0x04, 0x20, 0x01, 0x80, 0x04, 0x20, 0x01, 0x00, 0x04,
  0x20, 0x01, 0x00, 0x0C, 0x60, 0x01, 0x00, 0x0C, 0x40, 0x01, 0x00, 0x08,
  0x40, 0x03, 0x00, 0x08, 0x40, 0x03, 0x00, 0x08, 0x40, 0x02, 0x00, 0x08,
  0x40, 0x02, 0x00, 0x18, 0xC0, 0x02, 0x00, 0x18, 0xC0, 0x02, 0x00, 0x10,
  0x80, 0x06, 0x00, 0x10, 0x80, 0x06, 0x00, 0x10, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x03, 0xF8, 0x00, 0x87, 0x03, 0x80, 0x23, 0x00, 0x30, 0x19, 0x00,
  0x06, 0x06, 0x80, 0x00, 0x81, 0x60, 0x00, 0x20, 0x50, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C,
  0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x08, 0x60, 0x00, 0x02, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x04, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0x60, 0x00, 0x02, 0x10, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x02, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x08, 0x08, 0x00, 0x01, 0x82, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x02, 0x10, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x31, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x04, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x06,
  0x1C, 0x0E, 0x00, 0x10, 0x80, 0x0C, 0x00, 0x44, 0x00, 0x18, 0x01, 0x20,
  0x00, 0x30, 0x05, 0x00, 0x00, 0x40, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x18, 0x20, 0x00, 0x00, 0x60, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x30, 0x14, 0x00, 0x00, 0x80, 0xD0, 0x00, 0x04, 0x03,
  0x20, 0x00, 0x20, 0x0C, 0x60, 0x03, 0x00, 0x20, 0xE0, 0x38, 0x00, 0x80,
  0x7F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0x01, 0xC1, 0x00, 0xC0, 0x06, 0x10, 0x10, 0x00, 0x13, 0x02, 0x00,
  0x00, 0xB0, 0x40, 0x00, 0x0A, 0x0C, 0x00, 0x00, 0x60, 0x80, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x61, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x05, 0x06, 0x00, 0x00, 0x70, 0x20, 0x00,
  0x0B, 0x03, 0x00, 0x01, 0x20, 0x18, 0x00, 0x22, 0x00, 0xC0, 0x04, 0x20,
  0x07, 0x03, 0x82, 0x00, 0x0F, 0xE0, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xF8,
  0x1F, 0xFE, 0x00, 0x63, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0x80, 0x38, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x03, 0x02, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x04, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x60, 0x01, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x30, 0x01, 0x00, 0x00, 0x80, 0x18, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x60, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x84, 0x00, 0x00, 0x21, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x06, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x04, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x08, 0x60, 0x00, 0x02, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x18, 0x40, 0x00, 0x04, 0x10, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0C,
  0x00, 0x02, 0x81, 0x00, 0x00, 0xA0, 0x40, 0x00, 0x48, 0x08, 0x00, 0x22,
  0x03, 0x00, 0x11, 0x80, 0x70, 0x38, 0x60, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x60, 0x08, 0x00, 0x02, 0x00, 0x80, 0x00, 0x20, 0x08, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00, 0x10,
  0x10, 0x00, 0x01, 0x01, 0x00, 0x00, 0x10, 0x10, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x02, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x02,
  0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x40, 0x04,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x00, 0xC0, 0x0C,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x08, 0x38, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x08, 0x00, 0x40, 0x10, 0x60, 0x01, 0x00, 0x61, 0x80,
  0x0C, 0x00, 0x84, 0x00, 0x30, 0x02, 0x10, 0x00, 0x80, 0x08, 0x40, 0x02,
  0x00, 0x31, 0x00, 0x08, 0x00, 0xCC, 0x00, 0x20, 0x01, 0x30, 0x01, 0x80,
  0x04, 0x80, 0x06, 0x00, 0x12, 0x00, 0x10, 0x00, 0x48, 0x00, 0x40, 0x01,
  0x20, 0x01, 0x00, 0x05, 0x80, 0x04, 0x00, 0x16, 0x00, 0x30, 0x00, 0x58,
  0x00, 0xC0, 0x01, 0x40, 0x02, 0x00, 0x05, 0x00, 0x08, 0x00, 0x34, 0x00,
  0x20, 0x00, 0xD0, 0x00, 0x80, 0x02, 0xC0, 0x06, 0x00, 0x0B, 0x00, 0x18,
  0x00, 0x28, 0x00, 0x40, 0x01, 0xA0, 0x01, 0x00, 0x04, 0x80, 0x04, 0x00,
  0x12, 0x00, 0x30, 0x00, 0xC8, 0x00, 0xC0, 0x02, 0x20, 0x05, 0x00, 0x18,
  0x80, 0x14, 0x00, 0x42, 0x00, 0x98, 0x02, 0x0C, 0x04, 0x20, 0x10, 0x18,
  0x60, 0x41, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x06, 0x60, 0x0C, 0x30, 0x07, 0x04, 0x02, 0x01, 0x03, 0x80, 0x40, 0x80,
  0x31, 0xC0, 0x08, 0x20, 0x02, 0x60, 0x01, 0x8C, 0x00, 0x40, 0x00, 0x11,
  0x00, 0x08, 0x00, 0x02, 0x40, 0x01, 0x00, 0x00, 0x48, 0x00, 0x20, 0x00,
  0x0D, 0x00, 0x04, 0x00, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x38, 0x00, 0x20,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x0A, 0x00, 0x00, 0x40, 0x01, 0x40, 0x00, 0x08, 0x00, 0x28, 0x00,
  0x03, 0x00, 0x09, 0x80, 0x00, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x42,
  0x00, 0x18, 0x80, 0x18, 0x60, 0x0C, 0x10, 0x02, 0x04, 0x06, 0x03, 0x01,
  0x80, 0xC3, 0x80, 0x30, 0x60, 0x09, 0xC0, 0x01, 0xF0, 0x00, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01,
  0x01, 0x80, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x08, 0x04, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x40, 0x10, 0x00, 0x0A, 0x00, 0x80, 0x00, 0x90, 0x02, 0x00, 0x08,
  0x80, 0x18, 0x00, 0x8C, 0x00, 0x70, 0x38, 0x40, 0x00, 0x7F, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x10, 0x06, 0x00, 0x01, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x06, 0x03, 0x80, 0x10, 0x20, 0x01, 0xC0, 0x41, 0x80, 0x00, 0xC1, 0x04,
  0x00, 0x00, 0xEC, 0x30, 0x00, 0x00, 0x60, 0x80, 0x00, 0x03, 0x02, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x40, 0x18, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0x10, 0x70, 0x00, 0x00, 0x61, 0x3E, 0x00, 0x01,
  0x84, 0x0F, 0x80, 0x02, 0x30, 0x01, 0xF0, 0x08, 0xC0, 0x00, 0x3E, 0x20,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x03, 0x0C, 0x00, 0x03, 0x04,
  0x06, 0x00, 0x02, 0x08, 0x02, 0x00, 0x06, 0x10, 0x01, 0x00, 0x04, 0x30,
  0x01, 0x80, 0x0C, 0x20, 0x00, 0xC0, 0x08, 0x60, 0x00, 0x40, 0x18, 0x40,
  0x00, 0x20, 0x30, 0x40, 0x00, 0x18, 0x60, 0xC0, 0x00, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_ThinItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 10, 43, 37, 14, -43 },
  { 55, 12, 16, 37, 16, -46 },
  { 79, 37, 43, 37, 1, -43 },
  { 278, 33, 57, 37, 2, -50 },
  { 514, 41, 45, 37, -1, -44 },
  { 745, 36, 45, 37, 1, -44 },
  { 948, 4, 16, 37, 20, -46 },
  { 956, 19, 56, 37, 15, -47 },
  { 1089, 19, 56, 37, 5, -47 },
  { 1222, 31, 31, 37, 4, -34 },
  { 1343, 30, 31, 37, 4, -34 },
  { 1460, 8, 16, 37, 10, -5 },
  { 1476, 16, 1, 37, 11, -19 },
  { 1478, 4, 4, 37, 14, -4 },
  { 1480, 33, 56, 37, 2, -47 },
  { 1711, 29, 45, 37, 5, -44 },
  { 1875, 28, 43, 37, 3, -43 },
  { 2026, 30, 44, 37, 3, -44 },
  { 2191, 30, 45, 37, 3, -44 },
  { 2360, 31, 43, 37, 2, -43 },
  { 2527, 30, 44, 37, 4, -43 },
  { 2692, 27, 44, 37, 5, -43 },
  { 2841, 29, 43, 37, 7, -43 },
  { 2997, 30, 45, 37, 4, -44 },
  { 3166, 26, 44, 37, 7, -44 },
  { 3309, 9, 33, 37, 14, -33 },
  { 3347, 13, 44, 37, 10, -33 },
  { 3419, 29, 33, 37, 6, -35 },
  { 3539, 32, 12, 37, 3, -25 },
  { 3587, 29, 33, 37, 3, -35 },
  { 3707, 25, 44, 37, 9, -44 },
  { 3845, 28, 51, 37, 5, -44 },
  { 4024, 30, 43, 37, 1, -43 },
  { 4186, 29, 43, 37, 4, -43 },
  { 4342, 29, 45, 37, 6, -44 },
  { 4506, 30, 43, 37, 4, -43 },
  { 4668, 32, 43, 37, 4, -43 },
  { 4840, 33, 43, 37, 4, -43 },
  { 5018, 29, 45, 37, 6, -44 },
  { 5182, 33, 43, 37, 3, -43 },
  { 5360, 33, 43, 37, 3, -43 },
  { 5538, 28, 44, 37, 5, -43 },
  { 5692, 34, 43, 37, 4, -43 },
  { 5875, 24, 43, 37, 6, -43 },
  { 6004, 33, 43, 37, 3, -43 },
  { 6182, 33, 43, 37, 3, -43 },
  { 6360, 29, 45, 37, 5, -44 },
  { 6524, 31, 43, 37, 4, -43 },
  { 6691, 29, 54, 37, 5, -44 },
  { 6887, 31, 43, 37, 4, -43 },
  { 7054, 33, 45, 37, 2, -44 },
  { 7240, 32, 43, 37, 7, -43 },
  { 7412, 31, 44, 37, 5, -43 },
  { 7583, 30, 43, 37, 8, -43 },
  { 7745, 33, 43, 37, 5, -43 },
  { 7923, 38, 43, 37, 0, -43 },
  { 8128, 34, 43, 37, 6, -43 },
  { 8311, 37, 43, 37, 0, -43 },
  { 8510, 24, 56, 37, 12, -47 },
  { 8678, 14, 56, 37, 12, -47 },
  { 8776, 24, 56, 37, 2, -47 },
  { 8944, 29, 23, 37, 5, -43 },
  { 9028, 30, 1, 37, 0, 8 },
  { 9032, 7, 10, 37, 15, -47 },
  { 9041, 28, 34, 37, 4, -33 },
  { 9160, 28, 47, 37, 5, -46 },
  { 9325, 26, 34, 37, 5, -33 },
  { 9436, 30, 47, 37, 4, -46 },
  { 9613, 26, 34, 37, 5, -33 },
  { 9724, 39, 59, 37, -1, -46 },
  { 10012, 29, 46, 37, 3, -33 },
  { 10179, 26, 46, 37, 5, -46 },
  { 10329, 25, 47, 37, 6, -46 },
  { 10476, 25, 59, 37, 7, -46 },
  { 10661, 31, 47, 37, 5, -46 },
  { 10844, 23, 47, 37, 8, -46 },
  { 10980, 32, 33, 37, 3, -33 },
  { 11112, 26, 33, 37, 5, -33 },
  { 11220, 27, 34, 37, 5, -33 },
  { 11335, 30, 45, 37, 3, -33 },
  { 11504, 28, 45, 37, 4, -33 },
  { 11662, 30, 32, 37, 7, -32 },
  { 11782, 29, 34, 37, 4, -33 },
  { 11906, 30, 44, 37, 5, -43 },
  { 12071, 26, 33, 37, 6, -32 },
  { 12179, 28, 32, 37, 5, -32 },
  { 12291, 30, 33, 37, 5, -32 },
  { 12415, 35, 34, 37, 1, -33 },
  { 12564, 29, 45, 37, 3, -32 },
  { 12728, 30, 34, 37, 3, -33 },
  { 12856, 27, 56, 37, 8, -47 },
  { 13045, 10, 56, 37, 14, -47 },
  { 13115, 28, 56, 37, 3, -47 },
  { 13311, 32, 11, 37, 3, -24 },
};

const GFXfont IBMPlexMono_ThinItalic62pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic62pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic62pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _IBMPLEXMONO_THINITALIC62PT7B_H_
