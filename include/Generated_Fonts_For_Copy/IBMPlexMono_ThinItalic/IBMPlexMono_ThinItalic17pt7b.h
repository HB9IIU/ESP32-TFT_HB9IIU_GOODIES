#ifndef _IBMPLEXMONO_THINITALIC17PT7B_H_
#define _IBMPLEXMONO_THINITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x25, 0x24, 0x00, 0x40, 0xD9, 0xAA, 0x04, 0x81, 0x40, 0x90,
  0xE3, 0x4B, 0x04, 0x81, 0x20, 0x48, 0xE3, 0x89, 0x02, 0x41, 0x20, 0x04,
  0x02, 0x07, 0x8D, 0x24, 0x9C, 0x41, 0x20, 0x70, 0x16, 0x09, 0x04, 0x52,
  0x49, 0x23, 0xE0, 0x80, 0x40, 0x18, 0x24, 0x89, 0x12, 0x22, 0x84, 0x50,
  0x70, 0x00, 0xE0, 0xA4, 0x28, 0x89, 0x12, 0x22, 0x43, 0x80, 0x0E, 0x04,
  0x42, 0x10, 0x84, 0x11, 0x0D, 0x84, 0x82, 0x20, 0x84, 0x20, 0x98, 0x59,
  0xE2, 0xF0, 0x09, 0x88, 0x88, 0x42, 0x10, 0x84, 0x21, 0x08, 0x21, 0x80,
  0x10, 0x40, 0x82, 0x08, 0x20, 0x42, 0x08, 0x20, 0x84, 0x21, 0x08, 0x00,
  0x08, 0x04, 0x02, 0x19, 0x33, 0xE1, 0xC0, 0x90, 0x8C, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x6A, 0xF8, 0x80, 0x01, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04,
  0x02, 0x00, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x89, 0x81, 0x81, 0x82,
  0x46, 0x38, 0x04, 0x1C, 0x38, 0x48, 0x88, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0xFF, 0x1E, 0x21, 0x41, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x60,
  0x80, 0xFE, 0x1E, 0x61, 0x01, 0x01, 0x02, 0x1C, 0x06, 0x02, 0x02, 0x82,
  0x82, 0x7C, 0x01, 0x06, 0x0A, 0x12, 0x22, 0x42, 0x84, 0x84, 0xFF, 0x04,
  0x04, 0x04, 0x3F, 0x20, 0x40, 0x40, 0x3C, 0x42, 0x02, 0x02, 0x02, 0x82,
  0x82, 0x7C, 0x06, 0x08, 0x10, 0x20, 0x40, 0x5C, 0x62, 0x81, 0x81, 0x82,
  0x42, 0x3C, 0xFF, 0x82, 0x82, 0x84, 0x08, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x40, 0x80, 0x1E, 0x21, 0x41, 0x41, 0x41, 0x3E, 0x62, 0x81, 0x81, 0x81,
  0x82, 0x7C, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x61, 0x3E, 0x08, 0x20, 0x86,
  0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x00, 0x52, 0x40, 0x03, 0x04, 0x18,
  0x60, 0x80, 0x80, 0x60, 0x10, 0x0C, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x06, 0x18, 0x20, 0xC0, 0x3B, 0x18, 0x41, 0x04,
  0x21, 0x18, 0x41, 0x00, 0x30, 0x0E, 0x11, 0x21, 0x41, 0x4F, 0x93, 0xA1,
  0xA2, 0xA2, 0x96, 0x88, 0x80, 0x40, 0x3C, 0x02, 0x03, 0x02, 0x81, 0x41,
  0x20, 0x88, 0x84, 0x42, 0x3F, 0x20, 0x90, 0x50, 0x30, 0x3E, 0x41, 0x41,
  0x41, 0x42, 0x7C, 0x82, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x1C, 0xC6, 0x0C,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x0A, 0x23, 0x80, 0x3E, 0x41, 0x41, 0x41,
  0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x86, 0xF8, 0x3F, 0xA0, 0x10, 0x08,
  0x04, 0x03, 0xFA, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xC0, 0x3F, 0xA0,
  0x10, 0x08, 0x04, 0x03, 0xFA, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00,
  0x3C, 0x42, 0x82, 0x81, 0x80, 0x80, 0x9E, 0x82, 0x82, 0x84, 0x8C, 0x74,
  0x40, 0xA0, 0x50, 0x48, 0x28, 0x13, 0xFA, 0x05, 0x02, 0x82, 0x41, 0x20,
  0x90, 0x40, 0x3F, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x1F, 0xC0, 0x1F, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x84, 0x84, 0x78, 0x40, 0xD0, 0x44, 0x21, 0x10, 0x48, 0x14, 0x0A,
  0x81, 0x20, 0x84, 0x21, 0x08, 0x22, 0x0C, 0x41, 0x04, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x3F, 0x40, 0xB0, 0x58, 0x74, 0x6A, 0x54, 0xAA, 0x65,
  0x22, 0x81, 0x41, 0x20, 0x90, 0x40, 0x20, 0xB0, 0x58, 0x4A, 0x25, 0x14,
  0x8A, 0x25, 0x12, 0x8A, 0x43, 0x21, 0x90, 0xC0, 0x1E, 0x21, 0x41, 0x41,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x46, 0x38, 0x3F, 0x20, 0x90, 0x28,
  0x14, 0x0A, 0x09, 0xF9, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x21,
  0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x46, 0x38, 0x11, 0x0A,
  0x04, 0x3F, 0x20, 0x90, 0x28, 0x14, 0x0A, 0x09, 0xF9, 0x10, 0x88, 0x42,
  0x21, 0x10, 0x40, 0x1E, 0x30, 0x90, 0x70, 0x04, 0x01, 0xC0, 0x18, 0x04,
  0x01, 0x41, 0x20, 0x8F, 0x80, 0xFF, 0x88, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x40, 0xA0, 0x50, 0x48, 0x28,
  0x14, 0x0A, 0x05, 0x02, 0x82, 0x41, 0x20, 0x8F, 0x80, 0x81, 0xC0, 0xA0,
  0x90, 0x48, 0x44, 0x21, 0x20, 0x90, 0x50, 0x28, 0x18, 0x04, 0x00, 0x40,
  0xC0, 0x60, 0x30, 0x18, 0x94, 0xCA, 0x65, 0x52, 0xA6, 0x63, 0x11, 0x90,
  0x80, 0x20, 0x48, 0x21, 0x10, 0x44, 0x0A, 0x03, 0x00, 0xC0, 0x50, 0x22,
  0x08, 0x84, 0x12, 0x06, 0x80, 0xC0, 0xA0, 0x88, 0x84, 0x41, 0x40, 0xC0,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x3F, 0xC0, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x03, 0xFE, 0x1E, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x3C, 0x00, 0x88,
  0x84, 0x44, 0x44, 0x22, 0x22, 0x11, 0x10, 0x3C, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x21, 0x04, 0x10, 0x4F, 0x00, 0x04, 0x1C, 0x12, 0x22, 0x41,
  0x81, 0xFF, 0xA4, 0x3D, 0x43, 0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0x7B,
  0x20, 0x20, 0x40, 0x40, 0x5E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x82, 0x42,
  0xBC, 0x1C, 0x45, 0x0C, 0x08, 0x10, 0x20, 0xA2, 0x38, 0x01, 0x01, 0x01,
  0x01, 0x3D, 0x43, 0x82, 0x82, 0x82, 0x82, 0x82, 0x86, 0x7C, 0x1E, 0x21,
  0xC1, 0x82, 0xFC, 0x80, 0x82, 0x42, 0x3C, 0x03, 0xC1, 0x00, 0x40, 0x10,
  0x3F, 0xC1, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x88, 0x34,
  0x03, 0x00, 0x40, 0x3D, 0x43, 0x82, 0x82, 0x82, 0x82, 0x82, 0x86, 0x7C,
  0x04, 0x84, 0x78, 0x20, 0x40, 0x82, 0x04, 0xEE, 0x50, 0xA1, 0x43, 0x06,
  0x0C, 0x18, 0x20, 0x18, 0x00, 0x00, 0x0F, 0x04, 0x08, 0x10, 0x20, 0x85,
  0x32, 0x86, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0x81, 0x04, 0x08, 0x10,
  0x20, 0x48, 0x9A, 0x0C, 0x08, 0x20, 0x10, 0x10, 0x08, 0x04, 0xE3, 0x89,
  0x04, 0x84, 0x5C, 0x50, 0x64, 0x71, 0x48, 0x40, 0xF0, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x41, 0x14, 0xD4, 0x60, 0xFB, 0x66, 0x62, 0x31, 0x28, 0x94,
  0x8A, 0x45, 0x22, 0x91, 0x00, 0x4E, 0xE5, 0x0A, 0x14, 0x30, 0x60, 0xC1,
  0x82, 0x1E, 0x22, 0x41, 0x81, 0x81, 0x81, 0x82, 0x42, 0x3C, 0x5E, 0x21,
  0x41, 0x41, 0x81, 0x81, 0x82, 0x42, 0xBC, 0x80, 0x80, 0x80, 0x3D, 0x43,
  0x82, 0x82, 0x82, 0x82, 0x82, 0x86, 0x7C, 0x04, 0x04, 0x04, 0xE7, 0x38,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x3E, 0x41, 0x40, 0x40, 0x3E,
  0x02, 0x02, 0x82, 0x7C, 0x08, 0x08, 0x04, 0x1F, 0xF1, 0x00, 0x80, 0x40,
  0x40, 0x21, 0x13, 0x0A, 0x06, 0x00, 0x83, 0x0A, 0x14, 0x28, 0x50, 0xA1,
  0x4C, 0xF8, 0xE1, 0x21, 0x21, 0x41, 0x41, 0x42, 0x42, 0x4C, 0x70, 0x49,
  0x44, 0xA2, 0x31, 0x18, 0x8C, 0x8A, 0x45, 0x22, 0x6E, 0x00, 0x19, 0x8A,
  0x94, 0xC4, 0x11, 0x08, 0x22, 0x08, 0x8A, 0x54, 0x62, 0x00, 0x41, 0x42,
  0x42, 0x82, 0x82, 0x82, 0x82, 0x4C, 0x7C, 0x04, 0x8C, 0x78, 0x3D, 0x43,
  0x82, 0x04, 0x18, 0x20, 0xC2, 0xF2, 0x9E, 0x0F, 0x10, 0x10, 0x10, 0x10,
  0x08, 0x08, 0xF0, 0x30, 0x10, 0x20, 0x40, 0x40, 0x40, 0x78, 0x29, 0x24,
  0x94, 0x92, 0x49, 0x20, 0x3C, 0x08, 0x10, 0x41, 0x02, 0x04, 0x07, 0x10,
  0x40, 0x80, 0x81, 0x02, 0x3C, 0x00, 0x71, 0xC8, 0xA2, 0x50, 0xC0,
};

const GFXglyph IBMPlexMono_ThinItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 4, -12 },
  { 6, 4, 4, 10, 4, -13 },
  { 8, 10, 12, 10, 0, -12 },
  { 23, 9, 16, 10, 1, -14 },
  { 41, 11, 12, 10, 0, -12 },
  { 58, 10, 12, 10, 0, -12 },
  { 73, 1, 4, 10, 6, -13 },
  { 74, 5, 15, 10, 4, -13 },
  { 84, 6, 15, 10, 1, -13 },
  { 96, 9, 8, 10, 1, -9 },
  { 105, 8, 9, 10, 1, -10 },
  { 114, 2, 4, 10, 3, -1 },
  { 115, 5, 1, 10, 3, -6 },
  { 116, 1, 1, 10, 4, -1 },
  { 117, 9, 15, 10, 1, -13 },
  { 134, 8, 12, 10, 1, -12 },
  { 146, 8, 12, 10, 1, -12 },
  { 158, 8, 12, 10, 1, -12 },
  { 170, 8, 12, 10, 1, -12 },
  { 182, 8, 12, 10, 1, -12 },
  { 194, 8, 12, 10, 1, -12 },
  { 206, 8, 12, 10, 1, -12 },
  { 218, 8, 12, 10, 2, -12 },
  { 230, 8, 12, 10, 1, -12 },
  { 242, 7, 12, 10, 2, -12 },
  { 253, 2, 9, 10, 4, -9 },
  { 256, 3, 12, 10, 3, -9 },
  { 261, 8, 9, 10, 2, -10 },
  { 270, 9, 4, 10, 1, -7 },
  { 275, 8, 9, 10, 1, -10 },
  { 284, 6, 12, 10, 3, -12 },
  { 293, 8, 14, 10, 1, -12 },
  { 307, 9, 12, 10, 0, -12 },
  { 321, 8, 12, 10, 1, -12 },
  { 333, 7, 12, 10, 2, -12 },
  { 344, 8, 12, 10, 1, -12 },
  { 356, 9, 12, 10, 1, -12 },
  { 370, 9, 12, 10, 1, -12 },
  { 384, 8, 12, 10, 2, -12 },
  { 396, 9, 12, 10, 1, -12 },
  { 410, 9, 12, 10, 1, -12 },
  { 424, 8, 12, 10, 1, -12 },
  { 436, 10, 12, 10, 1, -12 },
  { 451, 6, 12, 10, 2, -12 },
  { 460, 9, 12, 10, 1, -12 },
  { 474, 9, 12, 10, 1, -12 },
  { 488, 8, 12, 10, 1, -12 },
  { 500, 9, 12, 10, 1, -12 },
  { 514, 8, 15, 10, 1, -12 },
  { 529, 9, 12, 10, 1, -12 },
  { 543, 9, 12, 10, 1, -12 },
  { 557, 9, 12, 10, 2, -12 },
  { 571, 9, 12, 10, 1, -12 },
  { 585, 9, 12, 10, 2, -12 },
  { 599, 9, 12, 10, 1, -12 },
  { 613, 10, 12, 10, 0, -12 },
  { 628, 9, 12, 10, 2, -12 },
  { 642, 10, 12, 10, 0, -12 },
  { 657, 7, 15, 10, 3, -13 },
  { 671, 4, 15, 10, 3, -13 },
  { 679, 6, 15, 10, 1, -13 },
  { 691, 8, 6, 10, 1, -12 },
  { 697, 8, 1, 10, 0, 2 },
  { 698, 2, 3, 10, 4, -14 },
  { 699, 8, 9, 10, 1, -9 },
  { 708, 8, 13, 10, 1, -13 },
  { 721, 7, 9, 10, 1, -9 },
  { 729, 8, 13, 10, 1, -13 },
  { 742, 8, 9, 10, 1, -9 },
  { 751, 10, 16, 10, 0, -13 },
  { 771, 8, 12, 10, 1, -9 },
  { 783, 7, 13, 10, 1, -13 },
  { 795, 7, 13, 10, 2, -13 },
  { 807, 7, 16, 10, 2, -13 },
  { 821, 9, 13, 10, 1, -13 },
  { 836, 6, 13, 10, 2, -13 },
  { 846, 9, 9, 10, 1, -9 },
  { 857, 7, 9, 10, 1, -9 },
  { 865, 8, 9, 10, 1, -9 },
  { 874, 8, 12, 10, 1, -9 },
  { 886, 8, 12, 10, 1, -9 },
  { 898, 8, 9, 10, 2, -9 },
  { 907, 8, 9, 10, 1, -9 },
  { 916, 9, 12, 10, 1, -12 },
  { 930, 7, 9, 10, 2, -9 },
  { 938, 8, 9, 10, 1, -9 },
  { 947, 9, 9, 10, 1, -9 },
  { 958, 10, 9, 10, 0, -9 },
  { 970, 8, 12, 10, 1, -9 },
  { 982, 8, 9, 10, 1, -9 },
  { 991, 8, 15, 10, 2, -13 },
  { 1006, 3, 15, 10, 4, -13 },
  { 1012, 7, 15, 10, 1, -13 },
  { 1026, 9, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_ThinItalic17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_THINITALIC17PT7B_H_
