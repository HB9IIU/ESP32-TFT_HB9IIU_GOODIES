#ifndef _IBMPLEXMONO_THINITALIC49PT7B_H_
#define _IBMPLEXMONO_THINITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x20,
  0x90, 0x58, 0x28, 0x14, 0x0A, 0x0D, 0x04, 0x82, 0xC1, 0x40, 0xA0, 0x50,
  0x60, 0x00, 0x01, 0x80, 0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x10, 0x08, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40,
  0x20, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x10, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x08, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x03, 0x01, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x08, 0x04, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x02, 0x02, 0x00,
  0x00, 0x20, 0x10, 0x00, 0x01, 0x00, 0x80, 0x00, 0x08, 0x08, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x04, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x80, 0x80, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x40, 0x60, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x0E, 0x10, 0xC0, 0x06, 0x04, 0x0C, 0x02, 0x01, 0x01, 0x81, 0x00,
  0x40, 0x20, 0x40, 0x10, 0x04, 0x20, 0x04, 0x00, 0x08, 0x02, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x20, 0x08, 0x00, 0x08, 0x02, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x40, 0x40, 0x00, 0x18, 0x10, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x39, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x17, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x10,
  0x00, 0x08, 0x06, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00, 0x20, 0x00, 0x40,
  0x08, 0x00, 0x10, 0x02, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0x42, 0x00,
  0x40, 0x10, 0x40, 0x20, 0x08, 0x18, 0x08, 0x04, 0x03, 0x02, 0x03, 0x00,
  0x38, 0x87, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x60, 0x10, 0x00, 0x80,
  0x20, 0x08, 0x00, 0x40, 0x20, 0x02, 0x00, 0x40, 0x10, 0x01, 0x00, 0x40,
  0x10, 0x00, 0x80, 0x40, 0x08, 0x00, 0x40, 0x20, 0x04, 0x00, 0x40, 0x20,
  0x02, 0x00, 0x20, 0x20, 0x01, 0x00, 0x10, 0x20, 0x00, 0x80, 0x18, 0x10,
  0x00, 0x40, 0x08, 0x10, 0x00, 0x10, 0x08, 0x10, 0x00, 0x04, 0x18, 0x10,
  0x00, 0x01, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81,
  0xF8, 0x00, 0x00, 0x81, 0x86, 0x00, 0x00, 0x81, 0x00, 0x80, 0x00, 0x81,
  0x00, 0x20, 0x00, 0x81, 0x00, 0x10, 0x00, 0xC0, 0x80, 0x08, 0x00, 0x40,
  0x40, 0x04, 0x00, 0x40, 0x40, 0x02, 0x00, 0x40, 0x20, 0x01, 0x00, 0x60,
  0x10, 0x01, 0x80, 0x20, 0x08, 0x00, 0x80, 0x20, 0x04, 0x00, 0x40, 0x20,
  0x01, 0x00, 0x40, 0x30, 0x00, 0x80, 0x60, 0x10, 0x00, 0x30, 0x60, 0x10,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x08, 0x00, 0x80, 0x01, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x01, 0x00, 0x08, 0x00, 0x10, 0x00, 0x80, 0x01, 0x80,
  0x08, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x7A, 0x18, 0x00, 0x18, 0x1E, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x40, 0x08, 0x00, 0x04, 0x00, 0x40, 0x00, 0x80, 0x04, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x08, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x80, 0x08, 0x00, 0x0C, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x12,
  0x02, 0x80, 0x01, 0x20, 0x48, 0x00, 0x11, 0x04, 0x40, 0x02, 0x18, 0x82,
  0x00, 0x40, 0x98, 0x18, 0x18, 0x05, 0x00, 0x7E, 0x00, 0x60, 0x24, 0xB6,
  0x92, 0x5B, 0x40, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x70, 0x04, 0x01, 0xC7, 0x02, 0x07, 0x00,
  0x71, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x86, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0xC0, 0x20, 0x00, 0x40, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x01,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x31, 0x86, 0x10, 0xC2, 0x18, 0x41, 0x08, 0x20, 0xFF, 0xF8,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0xC0, 0x06, 0x00, 0x40, 0x10, 0x00,
  0x40, 0x40, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x10, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x14, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x04, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x03,
  0x10, 0x00, 0x04, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60, 0x60, 0x01, 0x80,
  0x60, 0x06, 0x00, 0x70, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x80, 0x00, 0x1B, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x08, 0x00,
  0x0C, 0x10, 0x00, 0x60, 0x20, 0x01, 0x80, 0x40, 0x06, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x70, 0x18, 0x00, 0xC0, 0x04, 0x01, 0x00, 0x02, 0x03,
  0x00, 0x02, 0x02, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x60, 0x38, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x06, 0x02, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x80, 0x00, 0x18, 0x40, 0x00, 0x10, 0x60, 0x00, 0x20, 0x30,
  0x00, 0x40, 0x0C, 0x03, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x84, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x18, 0x08, 0x00, 0x10, 0x08, 0x00,
  0x20, 0x18, 0x00, 0x40, 0x10, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x10, 0x06, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x20, 0x10,
  0x00, 0x20, 0x20, 0x00, 0x20, 0x40, 0x00, 0x20, 0x80, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x7F, 0x00, 0x09,
  0x80, 0xC0, 0x16, 0x00, 0x20, 0x18, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x20, 0x40,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x43, 0xF8, 0x04, 0x60, 0x38, 0x2C, 0x00, 0x63, 0xC0, 0x01, 0x94, 0x00,
  0x04, 0xC0, 0x00, 0x34, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x05, 0x00, 0x00,
  0x28, 0x00, 0x01, 0x60, 0x00, 0x11, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x30,
  0x01, 0x80, 0xE0, 0x30, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x80, 0x00,
  0x09, 0x00, 0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x02,
  0x20, 0x00, 0x08, 0x40, 0x00, 0x30, 0x80, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x60, 0x38, 0x01, 0x80, 0x04, 0x03, 0x00, 0x02, 0x02, 0x00, 0x02,
  0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00, 0x02,
  0x04, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x18, 0x01, 0x80, 0x60,
  0x00, 0x7F, 0x80, 0x03, 0x80, 0xC0, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x18,
  0x20, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x04,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x40, 0x00, 0x10, 0x60, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x1C, 0x06, 0x01, 0x00, 0x18, 0x10, 0x00, 0x21, 0x00, 0x01, 0x10, 0x00,
  0x05, 0x80, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x68, 0x00, 0x06, 0x40, 0x00, 0x31, 0x00, 0x02, 0x8C, 0x00, 0x68, 0x18,
  0x0C, 0x40, 0x3F, 0x84, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0xE1, 0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x70, 0x38,
  0x08, 0x00, 0xC1, 0x00, 0x06, 0x20, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00,
  0x38, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x0F, 0x80, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0x80, 0xC0, 0x08, 0x01, 0x80, 0x40, 0x02, 0x02, 0x00,
  0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x60, 0x00, 0x11, 0x00, 0x7C, 0x44, 0x06, 0x09, 0x10, 0x20, 0x14, 0x81,
  0x80, 0x52, 0x04, 0x00, 0xC8, 0x20, 0x02, 0x20, 0x80, 0x09, 0x02, 0x00,
  0x24, 0x08, 0x00, 0x90, 0x40, 0x02, 0x41, 0x00, 0x19, 0x04, 0x00, 0x44,
  0x10, 0x01, 0x30, 0x40, 0x04, 0x81, 0x00, 0x12, 0x04, 0x00, 0xC8, 0x10,
  0x07, 0x20, 0x20, 0x18, 0x80, 0x80, 0xA2, 0x01, 0xCC, 0x88, 0x01, 0xC0,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x11, 0x00, 0x00, 0x08, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x04, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x04, 0x00, 0x02, 0x02, 0x00,
  0x01, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x20,
  0x00, 0x40, 0x08, 0x00, 0x60, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x18, 0x00, 0x40, 0x08, 0x00, 0x10, 0x0F, 0xFF,
  0xF8, 0x04, 0x00, 0x04, 0x06, 0x00, 0x02, 0x02, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x04, 0x40, 0x00, 0x02, 0x40, 0x00, 0x01, 0x60, 0x00, 0x00, 0x40,
  0x07, 0xFF, 0xE0, 0x08, 0x00, 0x30, 0x10, 0x00, 0x30, 0x20, 0x00, 0x20,
  0x40, 0x00, 0x20, 0x80, 0x00, 0x43, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08,
  0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x21, 0x80,
  0x00, 0x42, 0x00, 0x01, 0x04, 0x00, 0x04, 0x08, 0x00, 0x30, 0x1F, 0xFF,
  0x80, 0x20, 0x00, 0xC0, 0xC0, 0x00, 0x41, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x02, 0x60, 0x00, 0x04,
  0x80, 0x00, 0x09, 0x00, 0x00, 0x32, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88,
  0x00, 0x03, 0x30, 0x00, 0x04, 0x40, 0x00, 0x30, 0x80, 0x00, 0xC1, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x60, 0x02, 0x00, 0x20, 0x08,
  0x00, 0x20, 0x20, 0x00, 0x40, 0x80, 0x00, 0x41, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x08, 0x10, 0x00, 0x20, 0x30, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0x38, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x02, 0x00, 0x70, 0x06, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x04, 0x00,
  0x04, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x01, 0x0C, 0x00,
  0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00,
  0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00,
  0x01, 0x10, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00,
  0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00,
  0x04, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x20, 0x40, 0x00, 0x40, 0x40, 0x01, 0x80, 0xC0, 0x07,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xC0, 0x60, 0x02, 0x00, 0x20, 0x08, 0x00, 0x20, 0x20, 0x00,
  0x40, 0x80, 0x00, 0x43, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xD0, 0x00,
  0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x62, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x06,
  0x10, 0x00, 0x0C, 0x10, 0x00, 0x28, 0x20, 0x00, 0xA0, 0x20, 0x02, 0x40,
  0x38, 0x18, 0x80, 0x1F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x30, 0x40, 0x00, 0x10, 0x60, 0x00,
  0x08, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00, 0x0C, 0x1F, 0xFF, 0xFC, 0x10,
  0x00, 0x02, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x08,
  0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x10, 0x40, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x10, 0x30, 0x00, 0x80,
  0x60, 0x04, 0x00, 0xC0, 0x60, 0x00, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x18, 0x18, 0x00, 0x06, 0x02, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x40, 0x08, 0x00, 0x10, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x20, 0x04, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x83, 0x80, 0x00, 0x10, 0x88, 0x00, 0x02, 0x21, 0x00, 0x00, 0x48, 0x10,
  0x00, 0x0A, 0x02, 0x00, 0x03, 0x80, 0x20, 0x00, 0x60, 0x04, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x01, 0x80, 0x01, 0x00, 0x20, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0x80,
  0x00, 0x40, 0x10, 0x00, 0x04, 0x02, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x08,
  0x10, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFF,
  0xFC, 0x02, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x14, 0x14, 0x00, 0x05, 0x02,
  0x80, 0x00, 0xA0, 0x48, 0x00, 0x24, 0x09, 0x00, 0x04, 0x81, 0x20, 0x01,
  0x10, 0x64, 0x00, 0x42, 0x08, 0x40, 0x08, 0x81, 0x08, 0x02, 0x10, 0x21,
  0x00, 0x42, 0x04, 0x10, 0x10, 0x40, 0x82, 0x04, 0x08, 0x30, 0x40, 0x81,
  0x04, 0x08, 0x20, 0x40, 0x80, 0x88, 0x08, 0x10, 0x11, 0x01, 0x02, 0x02,
  0x40, 0x20, 0x40, 0x38, 0x04, 0x18, 0x06, 0x01, 0x82, 0x00, 0x80, 0x20,
  0x40, 0x10, 0x04, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x20, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x08, 0x10, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x83,
  0x80, 0x00, 0x41, 0x40, 0x00, 0x20, 0xA0, 0x00, 0x10, 0x58, 0x00, 0x10,
  0x64, 0x00, 0x08, 0x22, 0x00, 0x04, 0x10, 0x80, 0x02, 0x08, 0x40, 0x01,
  0x04, 0x20, 0x00, 0x82, 0x08, 0x00, 0x83, 0x04, 0x00, 0x41, 0x02, 0x00,
  0x20, 0x80, 0x80, 0x10, 0x40, 0x40, 0x08, 0x20, 0x20, 0x04, 0x10, 0x08,
  0x04, 0x18, 0x04, 0x02, 0x08, 0x03, 0x01, 0x04, 0x00, 0x80, 0x82, 0x00,
  0x40, 0x41, 0x00, 0x30, 0x20, 0x80, 0x08, 0x20, 0xC0, 0x04, 0x10, 0x40,
  0x01, 0x08, 0x20, 0x00, 0x84, 0x10, 0x00, 0x42, 0x08, 0x00, 0x11, 0x04,
  0x00, 0x09, 0x04, 0x00, 0x04, 0x82, 0x00, 0x01, 0x41, 0x00, 0x00, 0xA0,
  0x80, 0x00, 0x50, 0x40, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xC0,
  0xC0, 0x06, 0x00, 0x40, 0x10, 0x00, 0x40, 0x40, 0x00, 0x41, 0x80, 0x00,
  0x82, 0x00, 0x01, 0x08, 0x00, 0x01, 0x10, 0x00, 0x02, 0x40, 0x00, 0x04,
  0x80, 0x00, 0x09, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50,
  0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00,
  0x01, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x88, 0x00, 0x03, 0x10, 0x00, 0x04, 0x10, 0x00, 0x10,
  0x20, 0x00, 0x60, 0x60, 0x01, 0x80, 0x60, 0x06, 0x00, 0x70, 0x30, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x80, 0x80, 0x00, 0x20, 0x40, 0x00, 0x18, 0x20, 0x00, 0x04, 0x10, 0x00,
  0x02, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18, 0x60,
  0x00, 0x08, 0x20, 0x00, 0x18, 0x10, 0x00, 0x18, 0x0F, 0xFF, 0xF0, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0xC0, 0x06, 0x00, 0x40, 0x10,
  0x00, 0x40, 0x40, 0x00, 0x41, 0x80, 0x00, 0x82, 0x00, 0x01, 0x08, 0x00,
  0x01, 0x10, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x04, 0x80,
  0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00,
  0x03, 0x10, 0x00, 0x04, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60, 0x60, 0x01,
  0x80, 0x60, 0x06, 0x00, 0x70, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x08, 0x30, 0x00, 0x08, 0xC0,
  0x00, 0x0B, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x80, 0x80, 0x00, 0x20, 0x40, 0x00, 0x18, 0x20, 0x00,
  0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x61, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40,
  0x00, 0x18, 0x60, 0x00, 0x08, 0x20, 0x00, 0x18, 0x10, 0x00, 0x18, 0x0F,
  0xFF, 0xF0, 0x04, 0x02, 0x00, 0x02, 0x00, 0x80, 0x03, 0x00, 0x40, 0x01,
  0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x18, 0x00, 0x20, 0x08, 0x00, 0x10, 0x04, 0x00, 0x04,
  0x02, 0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0x40, 0xC0, 0x00,
  0x10, 0x40, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x38, 0x07, 0x00,
  0x18, 0x00, 0x30, 0x08, 0x00, 0x06, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x10, 0x04, 0x00, 0x08, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10,
  0x00, 0x04, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x40,
  0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40,
  0x00, 0x10, 0x40, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x40, 0x40,
  0x00, 0x40, 0x40, 0x00, 0x80, 0x20, 0x01, 0x00, 0x18, 0x06, 0x00, 0x07,
  0xF8, 0x00, 0x80, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x60,
  0x00, 0x18, 0x20, 0x00, 0x10, 0x20, 0x00, 0x30, 0x20, 0x00, 0x20, 0x20,
  0x00, 0x60, 0x20, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x10,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x10, 0x02, 0x00, 0x18,
  0x06, 0x00, 0x08, 0x04, 0x00, 0x08, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x08,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x20, 0x00, 0x04,
  0x60, 0x00, 0x04, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x05,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x22, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x42, 0x00, 0x80, 0x20, 0x80, 0x60, 0x08, 0x20,
  0x18, 0x02, 0x10, 0x09, 0x00, 0x84, 0x02, 0x40, 0x41, 0x01, 0x90, 0x10,
  0x40, 0x44, 0x04, 0x10, 0x31, 0x03, 0x04, 0x08, 0x40, 0x81, 0x02, 0x10,
  0x20, 0x41, 0x06, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08,
  0x08, 0x40, 0x44, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04, 0x80, 0x22, 0x03,
  0x20, 0x08, 0x80, 0x90, 0x01, 0x60, 0x24, 0x00, 0x50, 0x0B, 0x00, 0x14,
  0x02, 0x80, 0x05, 0x00, 0xA0, 0x01, 0xC0, 0x30, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x40, 0x00, 0x40, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x40, 0x00, 0x10, 0x02, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x18, 0x04, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x02, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x08, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x08, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0x00,
  0x10, 0x01, 0x80, 0x04, 0x00, 0x10, 0x01, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x20, 0x18, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x20,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0xFF, 0xE0, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x88, 0x00, 0x03, 0x08, 0x00, 0x04, 0x10, 0x00, 0x10,
  0x10, 0x00, 0x40, 0x20, 0x01, 0x00, 0x60, 0x06, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x20, 0x00, 0x80, 0x80, 0x01, 0x03, 0x00, 0x01, 0x04, 0x00, 0x02,
  0x10, 0x00, 0x02, 0x40, 0x00, 0x05, 0x80, 0x00, 0x0C, 0xFF, 0xFF, 0xFE,
  0x86, 0x10, 0x42, 0x08, 0x41, 0x00, 0x7F, 0x00, 0x03, 0x01, 0x88, 0x08,
  0x00, 0x90, 0x20, 0x00, 0xA0, 0x80, 0x01, 0x43, 0x00, 0x01, 0x84, 0x00,
  0x03, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x11, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x21, 0x00, 0x00, 0x82,
  0x00, 0x01, 0x04, 0x00, 0x06, 0x08, 0x00, 0x14, 0x08, 0x00, 0x28, 0x10,
  0x00, 0x90, 0x10, 0x02, 0x40, 0x18, 0x18, 0x7C, 0x0F, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x83, 0xF0, 0x02, 0x30, 0x30, 0x09, 0x80, 0x20, 0x28,
  0x00, 0x40, 0xC0, 0x00, 0x85, 0x00, 0x02, 0x18, 0x00, 0x08, 0x60, 0x00,
  0x11, 0x00, 0x00, 0x44, 0x00, 0x01, 0x30, 0x00, 0x04, 0x80, 0x00, 0x12,
  0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x26, 0x00,
  0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x03,
  0x10, 0x00, 0x08, 0xE0, 0x00, 0x42, 0x40, 0x03, 0x09, 0x80, 0x18, 0x21,
  0x81, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x18, 0x18, 0x06, 0x00,
  0x60, 0xC0, 0x02, 0x18, 0x00, 0x11, 0x00, 0x01, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x04,
  0x60, 0x00, 0x82, 0x00, 0x18, 0x10, 0x03, 0x00, 0xC0, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x7F, 0x06, 0x01, 0x80,
  0xC4, 0x02, 0x00, 0x24, 0x04, 0x00, 0x14, 0x08, 0x00, 0x14, 0x18, 0x00,
  0x0C, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00,
  0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x10, 0x40, 0x00, 0x20, 0x40, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00,
  0x60, 0x20, 0x00, 0xA0, 0x20, 0x01, 0x20, 0x10, 0x02, 0x40, 0x0C, 0x0C,
  0x40, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0E, 0x06, 0x00, 0x80, 0x08,
  0x08, 0x00, 0x20, 0x80, 0x01, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x24, 0x00,
  0x03, 0x60, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x09, 0x80, 0x01, 0x88,
  0x00, 0x70, 0x40, 0x3C, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x24, 0x00, 0x02, 0x20,
  0x00, 0x11, 0x00, 0x01, 0x04, 0x00, 0x10, 0x10, 0x01, 0x00, 0x60, 0x30,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x80, 0x08, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0x80, 0xC4, 0x04, 0x00, 0x48, 0x10, 0x00, 0x50, 0x40, 0x00, 0xA1, 0x80,
  0x00, 0xC2, 0x00, 0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00,
  0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x10,
  0x80, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x03, 0x04, 0x00, 0x0A, 0x04,
  0x00, 0x14, 0x08, 0x00, 0x48, 0x08, 0x01, 0x20, 0x0C, 0x0C, 0x40, 0x07,
  0xE0, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x40, 0x01, 0x81, 0xC0, 0x06, 0x00, 0xE0, 0x30,
  0x00, 0x7F, 0x80, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x1F, 0x80, 0xC6, 0x0C, 0x08, 0x80,
  0x20, 0x90, 0x01, 0x0A, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x11, 0x80,
  0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10,
  0x00, 0x12, 0x00, 0x03, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22,
  0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x04,
  0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x40, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x80, 0xC0, 0x18, 0x04, 0x01, 0x00, 0x20, 0x30, 0x01, 0x03,
  0x00, 0x08, 0x60, 0x00, 0xC6, 0x00, 0x04, 0xC0, 0x00, 0x2C, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x08, 0x00,
  0x40, 0x40, 0x04, 0x03, 0x00, 0x80, 0x18, 0x08, 0x00, 0xC0, 0x80, 0x06,
  0x08, 0x00, 0x10, 0x80, 0x00, 0x98, 0x00, 0x05, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x1F, 0x80, 0x08, 0xE0, 0x60,
  0x09, 0x80, 0x10, 0x0A, 0x00, 0x10, 0x1C, 0x00, 0x08, 0x14, 0x00, 0x08,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x18, 0x10, 0x00, 0x10, 0x10, 0x00, 0x10,
  0x20, 0x00, 0x20, 0x20, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x20, 0x0C, 0x00,
  0x20, 0x70, 0x00, 0x21, 0x80, 0x00, 0x40, 0x80, 0x00, 0x40, 0x40, 0x00,
  0x40, 0x40, 0x01, 0x40, 0x20, 0x02, 0x40, 0x30, 0x04, 0x40, 0x10, 0x08,
  0xC0, 0x08, 0x10, 0x80, 0x08, 0x20, 0x80, 0x04, 0xC0, 0x80, 0x05, 0x80,
  0x00, 0x03, 0x00, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x01, 0x04, 0x00, 0x81, 0x00, 0xC0, 0x40,
  0x60, 0x20, 0x60, 0x08, 0x30, 0x02, 0x10, 0x00, 0x98, 0x00, 0x28, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x02, 0x61, 0x08, 0x60, 0xA0, 0x24,
  0x08, 0x30, 0x0A, 0x01, 0x0C, 0x03, 0x00, 0x46, 0x00, 0xC0, 0x11, 0x80,
  0x20, 0x04, 0x40, 0x08, 0x02, 0x10, 0x02, 0x00, 0x84, 0x01, 0x00, 0x21,
  0x00, 0x40, 0x08, 0x80, 0x10, 0x02, 0x20, 0x04, 0x00, 0x88, 0x01, 0x00,
  0x42, 0x00, 0x40, 0x10, 0x80, 0x20, 0x04, 0x20, 0x08, 0x01, 0x10, 0x02,
  0x00, 0x44, 0x00, 0x80, 0x11, 0x00, 0x20, 0x08, 0x40, 0x08, 0x02, 0x10,
  0x04, 0x00, 0x84, 0x01, 0x00, 0x23, 0x00, 0x40, 0x08, 0x80, 0x10, 0x02,
  0x20, 0x04, 0x01, 0x00, 0x00, 0x1F, 0x80, 0xC6, 0x0C, 0x08, 0x80, 0x20,
  0x90, 0x01, 0x0A, 0x00, 0x10, 0xC0, 0x01, 0x08, 0x00, 0x11, 0x80, 0x01,
  0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00,
  0x12, 0x00, 0x03, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00,
  0x02, 0x20, 0x00, 0x24, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40,
  0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x48, 0x00, 0x0C, 0x00, 0x7F, 0x00,
  0x0C, 0x0E, 0x01, 0x80, 0x18, 0x18, 0x00, 0x61, 0x80, 0x01, 0x08, 0x00,
  0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50,
  0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x05, 0x00,
  0x00, 0x28, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x04, 0x00, 0x10,
  0x10, 0x01, 0x00, 0x60, 0x70, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x02,
  0x30, 0x30, 0x02, 0x60, 0x08, 0x02, 0x80, 0x04, 0x03, 0x00, 0x02, 0x05,
  0x00, 0x02, 0x06, 0x00, 0x02, 0x06, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x10,
  0x00, 0x08, 0x18, 0x00, 0x10, 0x24, 0x00, 0x30, 0x26, 0x00, 0x60, 0x21,
  0x81, 0x80, 0x20, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x06,
  0x03, 0x10, 0x20, 0x02, 0x41, 0x00, 0x05, 0x08, 0x00, 0x14, 0x60, 0x00,
  0x31, 0x00, 0x00, 0xC8, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x24,
  0x00, 0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x19, 0x00, 0x00, 0x44, 0x00,
  0x01, 0x10, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x44, 0x00, 0x03,
  0x10, 0x00, 0x08, 0x40, 0x00, 0x61, 0x00, 0x02, 0x82, 0x00, 0x0A, 0x08,
  0x00, 0x48, 0x10, 0x02, 0x60, 0x30, 0x31, 0x00, 0x3F, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0xFF,
  0xC3, 0xFE, 0x00, 0x98, 0x00, 0x02, 0x40, 0x00, 0x05, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0x00, 0xE0, 0x18, 0x00, 0x20, 0x20, 0x00, 0x20, 0x80,
  0x00, 0x61, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x90,
  0x00, 0x01, 0x10, 0x00, 0x06, 0x30, 0x00, 0x08, 0x30, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x08, 0x01,
  0x00, 0x18, 0x01, 0x00, 0x60, 0x03, 0x00, 0x80, 0x02, 0x03, 0x00, 0x02,
  0x0C, 0x00, 0x02, 0x18, 0x00, 0x02, 0x60, 0x00, 0x02, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x12, 0x00, 0x03,
  0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00,
  0x24, 0x00, 0x06, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00,
  0x04, 0x40, 0x00, 0x48, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80,
  0x00, 0x88, 0x00, 0x38, 0x80, 0x02, 0x88, 0x00, 0x50, 0x40, 0x05, 0x06,
  0x00, 0x90, 0x30, 0x31, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x08, 0x08, 0x00,
  0x30, 0x20, 0x00, 0x40, 0x80, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10,
  0x20, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40,
  0x00, 0x81, 0x00, 0x02, 0x04, 0x00, 0x08, 0x20, 0x00, 0x40, 0x80, 0x01,
  0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x01, 0x00, 0x80, 0x08, 0x02,
  0x00, 0x60, 0x10, 0x03, 0x00, 0x40, 0x10, 0x01, 0x01, 0x80, 0x04, 0x38,
  0x00, 0x1F, 0x00, 0x00, 0x10, 0x04, 0x04, 0x10, 0x04, 0x02, 0x30, 0x04,
  0x02, 0x20, 0x04, 0x02, 0x20, 0x0C, 0x02, 0x20, 0x08, 0x02, 0x20, 0x08,
  0x01, 0x20, 0x08, 0x01, 0x60, 0x08, 0x01, 0x40, 0x08, 0x01, 0x40, 0x18,
  0x01, 0x40, 0x10, 0x01, 0x40, 0x10, 0x01, 0x40, 0x10, 0x02, 0xC0, 0x10,
  0x02, 0x80, 0x10, 0x02, 0x80, 0x30, 0x02, 0x80, 0x20, 0x02, 0x80, 0x20,
  0x04, 0x80, 0x20, 0x04, 0x80, 0x60, 0x0C, 0x80, 0x60, 0x08, 0x80, 0xA0,
  0x18, 0x81, 0x10, 0x30, 0xC3, 0x18, 0x60, 0x3C, 0x07, 0x80, 0x00, 0x70,
  0x07, 0x80, 0x19, 0x81, 0x84, 0x06, 0x08, 0x20, 0x21, 0x80, 0x84, 0x02,
  0x60, 0x04, 0x40, 0x20, 0x00, 0x48, 0x01, 0x00, 0x04, 0x80, 0x30, 0x00,
  0x50, 0x02, 0x00, 0x03, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x08, 0x01, 0x40, 0x00, 0x80, 0x14, 0x00, 0x08,
  0x01, 0x20, 0x00, 0x80, 0x22, 0x00, 0xC8, 0x06, 0x20, 0x30, 0x40, 0xC1,
  0x0C, 0x06, 0x18, 0x1B, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x02,
  0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x20, 0x00, 0x30, 0x40, 0x00, 0x40,
  0x80, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x10,
  0x00, 0x18, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0x80, 0x00, 0x81, 0x00,
  0x01, 0x02, 0x00, 0x02, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00,
  0x20, 0x40, 0x00, 0x40, 0x80, 0x03, 0x81, 0x00, 0x05, 0x02, 0x00, 0x14,
  0x02, 0x00, 0x28, 0x06, 0x00, 0x90, 0x06, 0x06, 0x20, 0x03, 0xF0, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x80, 0x40, 0x02, 0x00, 0x60, 0x38, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x1C, 0x04, 0x20, 0x06, 0x08, 0x80,
  0x03, 0x91, 0x00, 0x00, 0xE2, 0x00, 0x01, 0x08, 0x00, 0x04, 0x10, 0x00,
  0x10, 0x20, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x40, 0x10, 0x00, 0x40, 0x40, 0x00, 0x81,
  0x00, 0x01, 0x04, 0x00, 0x02, 0x30, 0x00, 0x04, 0x5F, 0x00, 0x08, 0x81,
  0xF0, 0x09, 0x00, 0x1F, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x84, 0x20, 0x00,
  0x84, 0x08, 0x00, 0x44, 0x02, 0x00, 0x44, 0x01, 0x80, 0x22, 0x00, 0x40,
  0x22, 0x00, 0x10, 0x31, 0x00, 0x06, 0x30, 0x80, 0x01, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 34, 29, 11, -34 },
  { 35, 9, 12, 29, 13, -36 },
  { 49, 29, 34, 29, 1, -34 },
  { 173, 26, 46, 29, 2, -40 },
  { 323, 33, 36, 29, -1, -35 },
  { 472, 28, 36, 29, 1, -35 },
  { 598, 3, 12, 29, 16, -36 },
  { 603, 15, 44, 29, 12, -37 },
  { 686, 15, 44, 29, 4, -37 },
  { 769, 25, 24, 29, 3, -27 },
  { 844, 24, 23, 29, 3, -26 },
  { 913, 6, 12, 29, 8, -4 },
  { 922, 13, 1, 29, 9, -15 },
  { 924, 3, 3, 29, 11, -3 },
  { 926, 26, 44, 29, 2, -37 },
  { 1069, 23, 36, 29, 4, -35 },
  { 1173, 23, 34, 29, 2, -34 },
  { 1271, 24, 35, 29, 2, -35 },
  { 1376, 24, 36, 29, 2, -35 },
  { 1484, 24, 34, 29, 2, -34 },
  { 1586, 24, 35, 29, 3, -34 },
  { 1691, 21, 35, 29, 4, -34 },
  { 1783, 23, 34, 29, 6, -34 },
  { 1881, 24, 36, 29, 3, -35 },
  { 1989, 21, 35, 29, 5, -35 },
  { 2081, 7, 26, 29, 11, -26 },
  { 2104, 10, 34, 29, 8, -26 },
  { 2147, 24, 26, 29, 4, -28 },
  { 2225, 25, 10, 29, 3, -20 },
  { 2257, 24, 26, 29, 2, -28 },
  { 2335, 20, 35, 29, 7, -35 },
  { 2423, 22, 40, 29, 4, -35 },
  { 2533, 25, 34, 29, 0, -34 },
  { 2640, 23, 34, 29, 3, -34 },
  { 2738, 23, 36, 29, 4, -35 },
  { 2842, 24, 34, 29, 3, -34 },
  { 2944, 26, 34, 29, 3, -34 },
  { 3055, 26, 34, 29, 3, -34 },
  { 3166, 23, 36, 29, 4, -35 },
  { 3270, 25, 34, 29, 3, -34 },
  { 3377, 26, 34, 29, 2, -34 },
  { 3488, 22, 35, 29, 4, -34 },
  { 3585, 27, 34, 29, 3, -34 },
  { 3700, 19, 34, 29, 5, -34 },
  { 3781, 27, 34, 29, 2, -34 },
  { 3896, 25, 34, 29, 3, -34 },
  { 4003, 23, 36, 29, 4, -35 },
  { 4107, 25, 34, 29, 3, -34 },
  { 4214, 23, 43, 29, 4, -35 },
  { 4338, 25, 34, 29, 3, -34 },
  { 4445, 26, 36, 29, 2, -35 },
  { 4562, 26, 34, 29, 5, -34 },
  { 4673, 24, 35, 29, 4, -34 },
  { 4778, 24, 34, 29, 6, -34 },
  { 4880, 26, 34, 29, 4, -34 },
  { 4991, 30, 34, 29, 0, -34 },
  { 5119, 27, 34, 29, 5, -34 },
  { 5234, 30, 34, 29, 0, -34 },
  { 5362, 19, 44, 29, 10, -37 },
  { 5467, 11, 44, 29, 10, -37 },
  { 5528, 19, 44, 29, 2, -37 },
  { 5633, 23, 18, 29, 4, -34 },
  { 5685, 23, 1, 29, 0, 6 },
  { 5688, 5, 8, 29, 12, -37 },
  { 5693, 23, 27, 29, 3, -26 },
  { 5771, 22, 37, 29, 4, -36 },
  { 5873, 20, 27, 29, 4, -26 },
  { 5941, 24, 37, 29, 3, -36 },
  { 6052, 21, 27, 29, 4, -26 },
  { 6123, 30, 46, 29, 0, -36 },
  { 6296, 23, 36, 29, 2, -26 },
  { 6400, 20, 36, 29, 4, -36 },
  { 6490, 21, 38, 29, 4, -37 },
  { 6590, 20, 47, 29, 5, -37 },
  { 6708, 24, 37, 29, 4, -36 },
  { 6819, 18, 37, 29, 6, -36 },
  { 6903, 26, 26, 29, 2, -26 },
  { 6988, 20, 26, 29, 4, -26 },
  { 7053, 21, 27, 29, 4, -26 },
  { 7124, 24, 36, 29, 2, -26 },
  { 7232, 22, 36, 29, 3, -26 },
  { 7331, 23, 25, 29, 6, -25 },
  { 7403, 23, 27, 29, 3, -26 },
  { 7481, 24, 35, 29, 4, -34 },
  { 7586, 20, 26, 29, 5, -25 },
  { 7651, 22, 25, 29, 4, -25 },
  { 7720, 24, 26, 29, 4, -25 },
  { 7798, 28, 27, 29, 1, -26 },
  { 7893, 23, 35, 29, 2, -25 },
  { 7994, 23, 27, 29, 3, -26 },
  { 8072, 22, 44, 29, 6, -37 },
  { 8193, 8, 44, 29, 11, -37 },
  { 8237, 22, 44, 29, 2, -37 },
  { 8358, 25, 9, 29, 3, -19 },
};

const GFXfont IBMPlexMono_ThinItalic49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_THINITALIC49PT7B_H_
