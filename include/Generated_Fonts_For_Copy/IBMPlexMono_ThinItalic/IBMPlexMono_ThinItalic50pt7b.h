#ifndef _IBMPLEXMONO_THINITALIC50PT7B_H_
#define _IBMPLEXMONO_THINITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x60,
  0x20, 0x48, 0x32, 0x0C, 0x82, 0x60, 0x90, 0x24, 0x09, 0x06, 0x41, 0x90,
  0x4C, 0x12, 0x04, 0x81, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x08, 0x04, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x04, 0x02, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x02,
  0x01, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x40, 0x20, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x04, 0x04, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x03, 0x01, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x20, 0x10, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0xC0,
  0x40, 0x00, 0x02, 0x01, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x01, 0x00, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x06, 0x08, 0xE0, 0x06, 0x02, 0x04, 0x03, 0x01, 0x00, 0x81, 0x80,
  0x40, 0x10, 0x40, 0x10, 0x00, 0x10, 0x04, 0x00, 0x08, 0x01, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x20, 0x08, 0x00, 0x08, 0x02, 0x00,
  0x03, 0x00, 0x80, 0x00, 0x40, 0x20, 0x00, 0x18, 0x08, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x71, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x04, 0x70, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x20, 0x10,
  0x00, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x20,
  0x08, 0x00, 0x08, 0x02, 0x00, 0x04, 0x00, 0x80, 0x01, 0x00, 0x20, 0x00,
  0x40, 0x18, 0x80, 0x10, 0x04, 0x10, 0x04, 0x03, 0x02, 0x01, 0x01, 0x80,
  0x60, 0x80, 0xC0, 0x0E, 0x20, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x40, 0x20,
  0x10, 0x00, 0x40, 0x20, 0x0C, 0x00, 0x40, 0x20, 0x02, 0x00, 0x60, 0x10,
  0x01, 0x00, 0x20, 0x18, 0x00, 0x80, 0x20, 0x08, 0x00, 0x40, 0x20, 0x04,
  0x00, 0x20, 0x30, 0x02, 0x00, 0x10, 0x10, 0x01, 0x00, 0x10, 0x10, 0x00,
  0x80, 0x08, 0x10, 0x00, 0x40, 0x04, 0x10, 0x00, 0x30, 0x04, 0x08, 0x00,
  0x08, 0x04, 0x08, 0x00, 0x03, 0x0C, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC1, 0x83, 0x00, 0x00, 0x41, 0x00,
  0xC0, 0x00, 0x41, 0x00, 0x20, 0x00, 0x40, 0x80, 0x10, 0x00, 0x40, 0x80,
  0x08, 0x00, 0x60, 0x40, 0x02, 0x00, 0x20, 0x20, 0x02, 0x00, 0x20, 0x10,
  0x01, 0x00, 0x20, 0x08, 0x00, 0x80, 0x30, 0x08, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x20, 0x10, 0x01, 0x00, 0x20, 0x10, 0x00, 0x80, 0x10, 0x18, 0x00,
  0x60, 0x10, 0x08, 0x00, 0x18, 0x30, 0x08, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x00,
  0x80, 0x01, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x08, 0x00, 0x08, 0x00, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x3E,
  0x0C, 0x00, 0x0C, 0x17, 0x00, 0x01, 0x01, 0x80, 0x00, 0x20, 0x08, 0x00,
  0x04, 0x00, 0x40, 0x00, 0x40, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x08, 0x00, 0x10, 0x00, 0x80, 0x00, 0x80, 0x08, 0x00, 0x08,
  0x00, 0x80, 0x00, 0xC0, 0x08, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xA0, 0x38,
  0x00, 0x11, 0x02, 0xC0, 0x01, 0x18, 0x44, 0x00, 0x20, 0x8C, 0x20, 0x04,
  0x0C, 0x81, 0x81, 0x80, 0x50, 0x07, 0xE0, 0x03, 0x00, 0x32, 0x22, 0x22,
  0x64, 0x44, 0x4C, 0xC0, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x02, 0x00, 0x63, 0xC0, 0x80, 0xE4, 0x1E, 0x23, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x10, 0x00, 0x08, 0x04, 0x00, 0x04,
  0x00, 0x80, 0x03, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x01, 0x80,
  0x20, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x18, 0x30, 0xC1, 0x82,
  0x0C, 0x10, 0x20, 0x81, 0x04, 0x08, 0x00, 0xFF, 0xF8, 0x7F, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x60,
  0x70, 0x01, 0x80, 0x18, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x04, 0x00,
  0x06, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00,
  0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x60, 0x00, 0x03, 0x40, 0x00,
  0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x18,
  0x02, 0x80, 0x38, 0x02, 0x80, 0x38, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x10, 0x80, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0x40, 0x20, 0x00,
  0x80, 0x30, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x80, 0x00, 0x19, 0x00, 0x00, 0x62, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x10, 0x00, 0x30, 0x20, 0x01, 0x80, 0x40, 0x06, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x00, 0x40, 0x10, 0x00, 0x10, 0x10, 0x00, 0x08, 0x18, 0x00,
  0x04, 0x08, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x70, 0x18, 0x00, 0x80, 0x04, 0x01, 0x00, 0x02, 0x02, 0x00, 0x03, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x80, 0x00, 0x08, 0x40, 0x00, 0x10, 0x20,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x0E, 0x01, 0x80, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x80, 0x00, 0x02, 0x40,
  0x00, 0x02, 0x60, 0x00, 0x02, 0x20, 0x00, 0x03, 0x10, 0x00, 0x01, 0x08,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x02, 0x00, 0x01, 0x03, 0x00, 0x01, 0x01,
  0x00, 0x01, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x80, 0x20, 0x00, 0x80,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x80,
  0x02, 0x00, 0xC0, 0x01, 0x00, 0x40, 0x00, 0x80, 0x40, 0x00, 0x40, 0x40,
  0x00, 0x40, 0x40, 0x00, 0x20, 0x40, 0x00, 0x10, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x21, 0xFC, 0x00,
  0x13, 0x01, 0x80, 0x0A, 0x00, 0x30, 0x0E, 0x00, 0x08, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x60, 0x40, 0x00, 0x60, 0x18, 0x00, 0x60, 0x07,
  0x00, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x07, 0xF0, 0x04,
  0xE0, 0x30, 0x24, 0x00, 0x20, 0xA0, 0x00, 0x45, 0x00, 0x01, 0x98, 0x00,
  0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0x44, 0x00, 0x03, 0x10, 0x00, 0x08, 0x20, 0x00,
  0x40, 0xC0, 0x06, 0x00, 0xC0, 0x60, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x80, 0x00, 0x05, 0x00, 0x00, 0x12, 0x00, 0x00, 0x64, 0x00, 0x00, 0x88,
  0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x10, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x60, 0x00, 0x40, 0x20, 0x00, 0x10, 0x20, 0x00, 0x08, 0x10, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x10, 0x18, 0x00,
  0x10, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0xE0,
  0x38, 0x01, 0x80, 0x02, 0x01, 0x80, 0x00, 0x81, 0x80, 0x00, 0x21, 0x80,
  0x00, 0x10, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x60, 0x00, 0x01, 0x20,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x64, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18, 0x10, 0x00, 0x18,
  0x04, 0x00, 0x18, 0x01, 0x80, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x0E, 0x03, 0x00, 0x60, 0x02, 0x02, 0x00, 0x04, 0x10, 0x00, 0x08,
  0xC0, 0x00, 0x22, 0x00, 0x00, 0xD0, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x90, 0x00, 0x06, 0x40, 0x00, 0x19, 0x80, 0x00, 0xC2,
  0x00, 0x05, 0x04, 0x00, 0x64, 0x0C, 0x07, 0x20, 0x0F, 0xE0, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0xF0, 0x60, 0x00, 0xC0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xC0, 0x60, 0x60, 0x02, 0x10, 0x00,
  0x24, 0x00, 0x06, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x80, 0x0F, 0x80,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x60, 0x03,
  0x00, 0x20, 0x08, 0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x00, 0x81, 0x00,
  0x00, 0x82, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x40, 0x00,
  0x08, 0x80, 0x3E, 0x11, 0x01, 0x83, 0x42, 0x06, 0x02, 0x88, 0x08, 0x03,
  0x10, 0x20, 0x02, 0x20, 0x40, 0x04, 0x41, 0x00, 0x09, 0x82, 0x00, 0x22,
  0x04, 0x00, 0x44, 0x08, 0x00, 0x88, 0x30, 0x01, 0x10, 0x40, 0x02, 0x20,
  0x80, 0x04, 0xC1, 0x00, 0x11, 0x02, 0x00, 0x22, 0x04, 0x00, 0xC4, 0x04,
  0x01, 0x88, 0x08, 0x05, 0x10, 0x18, 0x12, 0x20, 0x1C, 0xC8, 0x40, 0x04,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04,
  0x40, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01,
  0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0x80, 0x20, 0x00,
  0x40, 0x10, 0x00, 0x40, 0x08, 0x00, 0x20, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x00, 0x40, 0x08, 0x00, 0x20, 0x08, 0x00, 0x10,
  0x07, 0xFF, 0xF8, 0x04, 0x00, 0x04, 0x02, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x80, 0x00,
  0x08, 0x40, 0x00, 0x06, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x20, 0x03, 0xFF, 0xE0, 0x06, 0x00, 0x18, 0x04,
  0x00, 0x04, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04,
  0x00, 0x03, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00, 0x03, 0x08,
  0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x04, 0x18,
  0x00, 0x0C, 0x10, 0x00, 0x18, 0x10, 0x00, 0x60, 0x1F, 0xFF, 0x80, 0x10,
  0x00, 0x70, 0x10, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40,
  0x00, 0x08, 0x40, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x04, 0x03, 0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x08, 0x40, 0x00, 0x10, 0x20,
  0x00, 0x30, 0x20, 0x00, 0x60, 0x10, 0x00, 0x40, 0x18, 0x01, 0x80, 0x06,
  0x07, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0x00, 0x18, 0x00,
  0x80, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x20, 0x20, 0x00, 0x10,
  0x10, 0x00, 0x04, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x0C, 0x20, 0x00, 0x06, 0x30, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x08, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x80,
  0x60, 0x03, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x04,
  0x02, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x0F, 0xFC, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0x40, 0x00, 0x08,
  0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x60, 0x00, 0x30,
  0x20, 0x00, 0x50, 0x30, 0x00, 0xD0, 0x18, 0x01, 0x90, 0x0E, 0x06, 0x30,
  0x03, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x08, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x08, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x04, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x07, 0xFF,
  0xFF, 0x83, 0x00, 0x00, 0x20, 0x80, 0x00, 0x18, 0x20, 0x00, 0x04, 0x08,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04,
  0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x08, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x10, 0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x10, 0x00, 0x18, 0x20, 0x00,
  0x20, 0x40, 0x00, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x60,
  0x00, 0x7F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x10, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x40, 0x04, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x04, 0x00, 0x60, 0x00,
  0xC0, 0x0C, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00, 0x08, 0x06,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x10, 0x48, 0x00, 0x01, 0x08, 0x80, 0x00, 0x11, 0x04, 0x00, 0x01, 0x20,
  0x40, 0x00, 0x14, 0x02, 0x00, 0x03, 0x80, 0x20, 0x00, 0x30, 0x01, 0x00,
  0x02, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x06, 0x00, 0x04, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x10, 0x04, 0x00, 0x01, 0x00, 0x40, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x1C, 0x00, 0x03, 0x82, 0x80, 0x00, 0x50, 0x48, 0x00, 0x12,
  0x09, 0x00, 0x06, 0xC1, 0x20, 0x00, 0x90, 0x22, 0x00, 0x32, 0x0C, 0x40,
  0x04, 0x41, 0x08, 0x01, 0x08, 0x21, 0x00, 0x61, 0x04, 0x10, 0x08, 0x60,
  0x82, 0x02, 0x08, 0x10, 0x40, 0x41, 0x06, 0x08, 0x10, 0x20, 0x80, 0x86,
  0x04, 0x10, 0x10, 0x80, 0x82, 0x02, 0x20, 0x30, 0x40, 0x24, 0x04, 0x08,
  0x05, 0x00, 0x83, 0x00, 0xE0, 0x10, 0x40, 0x18, 0x02, 0x08, 0x02, 0x00,
  0x41, 0x00, 0x00, 0x18, 0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x08, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C,
  0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x41, 0x40, 0x00,
  0x30, 0x50, 0x00, 0x08, 0x14, 0x00, 0x02, 0x04, 0x80, 0x00, 0x81, 0x20,
  0x00, 0x20, 0xC8, 0x00, 0x08, 0x21, 0x00, 0x06, 0x08, 0x40, 0x01, 0x02,
  0x18, 0x00, 0x40, 0x82, 0x00, 0x10, 0x20, 0x80, 0x04, 0x18, 0x30, 0x01,
  0x04, 0x04, 0x00, 0xC1, 0x01, 0x00, 0x20, 0x40, 0x20, 0x08, 0x10, 0x08,
  0x02, 0x04, 0x02, 0x00, 0x83, 0x00, 0x40, 0x20, 0x80, 0x10, 0x18, 0x20,
  0x04, 0x04, 0x08, 0x00, 0x81, 0x02, 0x00, 0x20, 0x40, 0x80, 0x08, 0x10,
  0x60, 0x01, 0x04, 0x10, 0x00, 0x43, 0x04, 0x00, 0x10, 0x81, 0x00, 0x02,
  0x20, 0x40, 0x00, 0x88, 0x10, 0x00, 0x22, 0x0C, 0x00, 0x04, 0x82, 0x00,
  0x01, 0x60, 0x80, 0x00, 0x70, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x60, 0x70, 0x01, 0x80, 0x18, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x04, 0x04, 0x00, 0x06, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02,
  0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02,
  0x60, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x20, 0x40, 0x00, 0x60,
  0x40, 0x00, 0x40, 0x20, 0x00, 0x80, 0x30, 0x03, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00,
  0x30, 0x18, 0x00, 0x04, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x0C, 0x10, 0x00, 0x03, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x10, 0x60, 0x00, 0x08, 0x10, 0x00, 0x04, 0x04, 0x00,
  0x06, 0x01, 0xFF, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x60, 0x70, 0x01, 0x80, 0x18, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x04,
  0x04, 0x00, 0x06, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02,
  0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x60, 0x00, 0x03,
  0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x10,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x20, 0x40, 0x00, 0x60, 0x40, 0x00, 0x40,
  0x20, 0x00, 0x80, 0x30, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x18, 0x20,
  0x00, 0x0C, 0x40, 0x00, 0x05, 0x80, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0x30, 0x18, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x10, 0x00, 0x03, 0x04,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x60, 0x00,
  0x08, 0x10, 0x00, 0x04, 0x04, 0x00, 0x06, 0x01, 0xFF, 0xFE, 0x00, 0x40,
  0x20, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x01, 0x00, 0x02, 0x00, 0x20, 0x00,
  0x80, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x01, 0x80, 0x02, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x80, 0x40, 0x00, 0x10, 0x30, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x18, 0x03, 0x80, 0x18, 0x00,
  0x10, 0x0C, 0x00, 0x02, 0x06, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x0C, 0x08, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x38, 0x03, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x10, 0x40, 0x00, 0x08, 0x60, 0x00, 0x04, 0x20, 0x00, 0x06, 0x10,
  0x00, 0x02, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x30, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08,
  0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x18, 0x00, 0x01, 0x08, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x10, 0x40, 0x00, 0x08, 0x60, 0x00, 0x08, 0x20, 0x00, 0x04, 0x10, 0x00,
  0x02, 0x08, 0x00, 0x03, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x80, 0x40, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x90, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x44, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x30, 0x40, 0x00, 0x10, 0x20, 0x00, 0x18, 0x10, 0x00, 0x08, 0x08, 0x00,
  0x04, 0x04, 0x00, 0x04, 0x03, 0x00, 0x02, 0x00, 0x80, 0x02, 0x00, 0x40,
  0x01, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x06,
  0x00, 0x40, 0x01, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x40, 0x20, 0x00,
  0x20, 0x10, 0x00, 0x10, 0x10, 0x00, 0x08, 0x08, 0x00, 0x02, 0x08, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x24, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x84,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x06, 0x00, 0x82, 0x01, 0x40,
  0x20, 0x40, 0x28, 0x04, 0x08, 0x0D, 0x00, 0x83, 0x01, 0x20, 0x10, 0x40,
  0x64, 0x04, 0x08, 0x08, 0x80, 0x81, 0x01, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0x20, 0x80, 0x82, 0x04, 0x10, 0x10, 0x40, 0x82, 0x02, 0x10,
  0x10, 0xC0, 0x42, 0x02, 0x10, 0x08, 0x80, 0x42, 0x01, 0x10, 0x04, 0x40,
  0x26, 0x00, 0x98, 0x04, 0x80, 0x12, 0x00, 0xB0, 0x02, 0x40, 0x24, 0x00,
  0x48, 0x04, 0x80, 0x0A, 0x00, 0xA0, 0x01, 0x40, 0x14, 0x00, 0x28, 0x03,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x80, 0x04, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x20, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0x60, 0x40, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x00, 0x40,
  0x03, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x30, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x01, 0x03, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40, 0x08,
  0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x01, 0x80, 0x01, 0x00, 0x20,
  0x00, 0x20, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x19, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0xFF, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x01, 0xFF, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x0F, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x24, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x08, 0x00, 0x04, 0x08,
  0x00, 0x10, 0x10, 0x00, 0x60, 0x20, 0x00, 0x80, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x40, 0x30, 0x00, 0x80, 0x40, 0x00, 0x81, 0x00, 0x01, 0x04,
  0x00, 0x03, 0x10, 0x00, 0x02, 0x60, 0x00, 0x04, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0x82, 0x18, 0x41, 0x08, 0x21, 0x00, 0xFE,
  0x04, 0x0E, 0x06, 0x10, 0x60, 0x04, 0x42, 0x00, 0x0A, 0x10, 0x00, 0x18,
  0xC0, 0x00, 0x62, 0x00, 0x00, 0x98, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00,
  0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88,
  0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00, 0x62, 0x00, 0x03, 0x04, 0x00,
  0x14, 0x10, 0x00, 0x90, 0x20, 0x06, 0x40, 0x60, 0x61, 0xF0, 0x7F, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x0F, 0xE0, 0x08, 0x60,
  0x60, 0x26, 0x00, 0xC0, 0xB0, 0x01, 0x82, 0x80, 0x02, 0x1C, 0x00, 0x04,
  0x60, 0x00, 0x11, 0x80, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40,
  0x00, 0x13, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00,
  0x12, 0x00, 0x00, 0x48, 0x00, 0x03, 0x60, 0x00, 0x09, 0x00, 0x00, 0x24,
  0x00, 0x01, 0x90, 0x00, 0x04, 0x60, 0x00, 0x31, 0x80, 0x00, 0x89, 0x00,
  0x04, 0x22, 0x00, 0x60, 0x86, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x0C, 0x06, 0x01, 0x80, 0x18, 0x18, 0x00, 0x61, 0x80, 0x01, 0x08,
  0x00, 0x04, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x24, 0x00, 0x02, 0x20, 0x00, 0x31, 0x80, 0x03, 0x04, 0x00,
  0x30, 0x10, 0x03, 0x00, 0x60, 0x70, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0xFE, 0x04, 0x03, 0x81, 0x84,
  0x06, 0x00, 0x44, 0x08, 0x00, 0x28, 0x10, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x20, 0x00, 0x08, 0x60, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x10,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10,
  0x80, 0x00, 0x10, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20,
  0x80, 0x00, 0x20, 0x80, 0x00, 0x60, 0x80, 0x00, 0x60, 0x80, 0x00, 0xC0,
  0x40, 0x01, 0x40, 0x40, 0x03, 0x40, 0x20, 0x06, 0x40, 0x18, 0x1C, 0x40,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0E, 0x03, 0x00, 0xC0, 0x0C, 0x08,
  0x00, 0x30, 0x80, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x24, 0x00, 0x01,
  0x20, 0x00, 0x0A, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x01, 0x8C, 0x00,
  0x30, 0x40, 0x3E, 0x03, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00,
  0x11, 0x80, 0x01, 0x04, 0x00, 0x18, 0x10, 0x01, 0x80, 0x60, 0x30, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x40, 0x04,
  0x00, 0x00, 0xA0, 0x04, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3F, 0x81, 0x00, 0xE0, 0x61, 0x01, 0x80, 0x11, 0x02,
  0x00, 0x0A, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x02, 0x18,
  0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x20,
  0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x20,
  0x00, 0x18, 0x20, 0x00, 0x18, 0x20, 0x00, 0x30, 0x10, 0x00, 0x50, 0x10,
  0x00, 0x90, 0x08, 0x01, 0x90, 0x06, 0x06, 0x10, 0x01, 0xFC, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x80, 0xE0, 0x03, 0x00, 0x18,
  0x0E, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x3F,
  0x00, 0xC6, 0x06, 0x06, 0x40, 0x18, 0x24, 0x00, 0x41, 0x40, 0x03, 0x0C,
  0x00, 0x08, 0x60, 0x00, 0x46, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00, 0x00,
  0x88, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x02, 0x30, 0x00, 0x11, 0x00,
  0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x62, 0x00, 0x02, 0x10, 0x00, 0x11,
  0x80, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x03, 0x10, 0x00,
  0x10, 0x80, 0x00, 0x8C, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x01, 0x01, 0x00,
  0x60, 0x30, 0x08, 0x02, 0x03, 0x00, 0x20, 0x60, 0x02, 0x08, 0x00, 0x23,
  0x00, 0x06, 0x40, 0x00, 0x58, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x80, 0xA0, 0x04, 0x00, 0x80, 0x20, 0x02,
  0x03, 0x00, 0x08, 0x10, 0x00, 0x20, 0x80, 0x00, 0xC4, 0x00, 0x03, 0x20,
  0x00, 0x0D, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x03, 0xF8, 0x00, 0x86, 0x06, 0x00, 0x4C,
  0x00, 0x80, 0x2C, 0x00, 0x20, 0x18, 0x00, 0x10, 0x14, 0x00, 0x08, 0x0C,
  0x00, 0x04, 0x06, 0x00, 0x02, 0x02, 0x00, 0x01, 0x01, 0x00, 0x01, 0x00,
  0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x40, 0x03, 0x00, 0x20, 0x0E, 0x00,
  0x10, 0x38, 0x00, 0x08, 0x20, 0x00, 0x04, 0x18, 0x00, 0x04, 0x04, 0x00,
  0x02, 0x01, 0x00, 0x0D, 0x00, 0x80, 0x0C, 0x80, 0x20, 0x0C, 0x40, 0x10,
  0x0C, 0x20, 0x04, 0x08, 0x20, 0x03, 0x08, 0x10, 0x00, 0x88, 0x08, 0x00,
  0x28, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x06, 0x08, 0x01, 0x81, 0x00, 0x40, 0x20, 0x30, 0x04, 0x08, 0x01,
  0x86, 0x00, 0x21, 0x00, 0x04, 0xC0, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x78, 0x1F, 0x02, 0x61, 0x88, 0x20, 0xA0, 0x24, 0x04, 0x30, 0x0A,
  0x01, 0x0C, 0x03, 0x00, 0x46, 0x00, 0xC0, 0x11, 0x80, 0x20, 0x04, 0x40,
  0x08, 0x01, 0x10, 0x02, 0x00, 0x44, 0x00, 0x80, 0x11, 0x00, 0x20, 0x08,
  0xC0, 0x10, 0x02, 0x20, 0x04, 0x00, 0x88, 0x01, 0x00, 0x22, 0x00, 0x40,
  0x08, 0x80, 0x10, 0x02, 0x20, 0x04, 0x01, 0x18, 0x02, 0x00, 0x44, 0x00,
  0x80, 0x11, 0x00, 0x20, 0x04, 0x40, 0x08, 0x01, 0x10, 0x02, 0x00, 0x44,
  0x00, 0x80, 0x23, 0x00, 0x40, 0x08, 0x80, 0x10, 0x02, 0x20, 0x04, 0x00,
  0x80, 0x04, 0x1F, 0x80, 0x63, 0x03, 0x02, 0x20, 0x0C, 0x12, 0x00, 0x20,
  0xA0, 0x01, 0x86, 0x00, 0x04, 0x30, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00,
  0x08, 0x80, 0x00, 0x44, 0x00, 0x06, 0x20, 0x00, 0x21, 0x00, 0x01, 0x18,
  0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01,
  0x08, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00,
  0x01, 0x88, 0x00, 0x08, 0x40, 0x00, 0x46, 0x00, 0x02, 0x00, 0x00, 0x7F,
  0x00, 0x06, 0x03, 0x00, 0x60, 0x02, 0x03, 0x00, 0x04, 0x08, 0x00, 0x08,
  0x40, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x01, 0x60, 0x00, 0x05, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28,
  0x00, 0x01, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x31, 0x00, 0x00, 0x84, 0x00,
  0x04, 0x08, 0x00, 0x30, 0x10, 0x01, 0x80, 0x30, 0x18, 0x00, 0x3F, 0x80,
  0x00, 0x02, 0x0F, 0xE0, 0x02, 0x18, 0x18, 0x02, 0x60, 0x0C, 0x02, 0xC0,
  0x06, 0x02, 0x80, 0x02, 0x07, 0x00, 0x01, 0x06, 0x00, 0x01, 0x06, 0x00,
  0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x0C, 0x00,
  0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00,
  0x01, 0x08, 0x00, 0x03, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00,
  0x06, 0x10, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x34, 0x00,
  0x10, 0x22, 0x00, 0x60, 0x21, 0x81, 0xC0, 0x20, 0x7E, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x04, 0x0E, 0x06, 0x10, 0x60, 0x04, 0x42, 0x00, 0x0A,
  0x10, 0x00, 0x18, 0xC0, 0x00, 0x62, 0x00, 0x00, 0x98, 0x00, 0x02, 0x40,
  0x00, 0x09, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00,
  0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22,
  0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00, 0x62, 0x00,
  0x03, 0x04, 0x00, 0x14, 0x10, 0x00, 0x90, 0x20, 0x06, 0x40, 0x60, 0x61,
  0x00, 0x7F, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0xFF, 0xC3, 0xFF, 0x00, 0x46, 0x00, 0x00, 0x58,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0x80, 0x60, 0x08, 0x00, 0x30, 0x20, 0x00, 0x30, 0x80, 0x00,
  0x21, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x50, 0x00,
  0x01, 0x10, 0x00, 0x02, 0x30, 0x00, 0x08, 0x10, 0x00, 0x20, 0x1C, 0x03,
  0x80, 0x07, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x08, 0x01, 0x00, 0x1C, 0x01, 0x00, 0x60, 0x01, 0x00, 0x80, 0x03, 0x03,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x18, 0x00, 0x02, 0x60, 0x00, 0x02, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x18, 0x80, 0x00, 0x84, 0x00, 0x04,
  0x20, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00,
  0x04, 0x20, 0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44,
  0x00, 0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x08, 0x00, 0x08, 0x80, 0x00,
  0x44, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00, 0x01, 0x08, 0x00, 0x18, 0x40,
  0x01, 0x43, 0x00, 0x0A, 0x08, 0x00, 0x90, 0x60, 0x09, 0x81, 0x81, 0x88,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x04, 0x04, 0x00, 0x08, 0x08, 0x00, 0x10,
  0x10, 0x00, 0x20, 0x20, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x01, 0x81,
  0x00, 0x02, 0x04, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20,
  0x00, 0x20, 0x40, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x02, 0x04, 0x00,
  0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x40, 0x20, 0x01, 0x00, 0x40, 0x06,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x60, 0x04, 0x01, 0x80, 0x08, 0x0C, 0x00,
  0x10, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x10, 0x06, 0x02, 0x10, 0x04, 0x02,
  0x10, 0x04, 0x02, 0x30, 0x04, 0x01, 0x20, 0x04, 0x01, 0x20, 0x04, 0x01,
  0x20, 0x04, 0x01, 0x20, 0x08, 0x01, 0x20, 0x08, 0x01, 0x60, 0x08, 0x01,
  0x40, 0x08, 0x01, 0x40, 0x08, 0x01, 0x40, 0x08, 0x01, 0x40, 0x10, 0x01,
  0x40, 0x10, 0x01, 0xC0, 0x10, 0x01, 0x80, 0x10, 0x01, 0x80, 0x10, 0x02,
  0x80, 0x10, 0x02, 0x80, 0x30, 0x02, 0x80, 0x20, 0x06, 0x80, 0x60, 0x04,
  0x80, 0x60, 0x0C, 0x80, 0x90, 0x08, 0x80, 0x90, 0x10, 0x43, 0x08, 0x60,
  0x3C, 0x07, 0x80, 0x00, 0x70, 0x07, 0xC0, 0x1D, 0x81, 0x86, 0x06, 0x08,
  0x30, 0x21, 0x80, 0x42, 0x01, 0x60, 0x04, 0x40, 0x10, 0x00, 0x48, 0x01,
  0x00, 0x02, 0x80, 0x10, 0x00, 0x30, 0x01, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x00, 0xA0,
  0x00, 0x80, 0x12, 0x00, 0x08, 0x01, 0x20, 0x00, 0x80, 0x22, 0x00, 0xEC,
  0x02, 0x10, 0x18, 0x40, 0x41, 0x06, 0x06, 0x18, 0x09, 0x80, 0x1E, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x03, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x06, 0x04,
  0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08,
  0x00, 0x04, 0x08, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x08, 0x00, 0x08, 0x08,
  0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x18, 0x10,
  0x00, 0x10, 0x10, 0x00, 0x30, 0x10, 0x00, 0x50, 0x18, 0x00, 0x50, 0x08,
  0x00, 0x90, 0x0C, 0x01, 0x30, 0x06, 0x06, 0x20, 0x01, 0xF8, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x80, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30,
  0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0x06, 0x07, 0x81, 0x08,
  0x00, 0xF3, 0x10, 0x00, 0x1E, 0x10, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x10,
  0x00, 0x18, 0x20, 0x00, 0x30, 0x20, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x10, 0x06,
  0x00, 0x10, 0x08, 0x00, 0x10, 0x10, 0x00, 0x10, 0x20, 0x00, 0x08, 0xC0,
  0x00, 0x08, 0xBE, 0x00, 0x08, 0x81, 0xF8, 0x08, 0x80, 0x07, 0xC8, 0x00,
  0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x84, 0x30,
  0x00, 0x44, 0x0C, 0x00, 0x44, 0x02, 0x00, 0x24, 0x00, 0x80, 0x22, 0x00,
  0x60, 0x12, 0x00, 0x18, 0x11, 0x00, 0x06, 0x10, 0x80, 0x00, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 8, 35, 30, 11, -35 },
  { 36, 10, 13, 30, 13, -37 },
  { 53, 30, 35, 30, 1, -35 },
  { 185, 26, 47, 30, 2, -41 },
  { 338, 33, 37, 30, -1, -36 },
  { 491, 28, 37, 30, 1, -36 },
  { 621, 4, 13, 30, 16, -37 },
  { 628, 15, 45, 30, 12, -38 },
  { 713, 15, 45, 30, 4, -38 },
  { 798, 26, 25, 30, 3, -27 },
  { 880, 24, 25, 30, 3, -28 },
  { 955, 7, 13, 30, 8, -4 },
  { 967, 13, 1, 30, 9, -16 },
  { 969, 4, 3, 30, 11, -3 },
  { 971, 27, 45, 30, 2, -38 },
  { 1123, 24, 37, 30, 4, -36 },
  { 1234, 23, 35, 30, 2, -35 },
  { 1335, 25, 36, 30, 2, -36 },
  { 1448, 24, 37, 30, 2, -36 },
  { 1559, 25, 35, 30, 2, -35 },
  { 1669, 25, 36, 30, 3, -35 },
  { 1782, 22, 36, 30, 4, -35 },
  { 1881, 23, 35, 30, 6, -35 },
  { 1982, 25, 37, 30, 3, -36 },
  { 2098, 22, 36, 30, 5, -36 },
  { 2197, 8, 26, 30, 11, -26 },
  { 2223, 11, 35, 30, 8, -26 },
  { 2272, 23, 27, 30, 5, -29 },
  { 2350, 25, 10, 30, 3, -20 },
  { 2382, 24, 27, 30, 2, -29 },
  { 2463, 19, 36, 30, 8, -36 },
  { 2549, 23, 41, 30, 4, -36 },
  { 2667, 25, 35, 30, 0, -35 },
  { 2777, 24, 35, 30, 3, -35 },
  { 2882, 24, 37, 30, 4, -36 },
  { 2993, 25, 35, 30, 3, -35 },
  { 3103, 26, 35, 30, 3, -35 },
  { 3217, 27, 35, 30, 3, -35 },
  { 3336, 24, 37, 30, 4, -36 },
  { 3447, 26, 35, 30, 3, -35 },
  { 3561, 27, 35, 30, 2, -35 },
  { 3680, 23, 36, 30, 4, -35 },
  { 3784, 28, 35, 30, 3, -35 },
  { 3907, 19, 35, 30, 5, -35 },
  { 3991, 27, 35, 30, 2, -35 },
  { 4110, 26, 35, 30, 3, -35 },
  { 4224, 24, 37, 30, 4, -36 },
  { 4335, 26, 35, 30, 3, -35 },
  { 4449, 24, 44, 30, 4, -36 },
  { 4581, 26, 35, 30, 3, -35 },
  { 4695, 26, 37, 30, 2, -36 },
  { 4816, 26, 35, 30, 6, -35 },
  { 4930, 25, 36, 30, 4, -35 },
  { 5043, 25, 35, 30, 6, -35 },
  { 5153, 27, 35, 30, 4, -35 },
  { 5272, 31, 35, 30, 0, -35 },
  { 5408, 27, 35, 30, 5, -35 },
  { 5527, 30, 35, 30, 0, -35 },
  { 5659, 19, 45, 30, 10, -38 },
  { 5766, 11, 45, 30, 10, -38 },
  { 5828, 19, 45, 30, 2, -38 },
  { 5935, 23, 19, 30, 4, -35 },
  { 5990, 24, 1, 30, 0, 6 },
  { 5993, 5, 8, 30, 12, -38 },
  { 5998, 22, 27, 30, 4, -26 },
  { 6073, 22, 38, 30, 4, -37 },
  { 6178, 21, 27, 30, 4, -26 },
  { 6249, 24, 38, 30, 4, -37 },
  { 6363, 21, 27, 30, 4, -26 },
  { 6434, 32, 48, 30, -1, -37 },
  { 6626, 24, 37, 30, 2, -26 },
  { 6737, 21, 37, 30, 4, -37 },
  { 6835, 20, 39, 30, 5, -38 },
  { 6933, 21, 49, 30, 5, -38 },
  { 7062, 25, 38, 30, 4, -37 },
  { 7181, 19, 38, 30, 6, -37 },
  { 7272, 26, 26, 30, 2, -26 },
  { 7357, 21, 26, 30, 4, -26 },
  { 7426, 22, 27, 30, 4, -26 },
  { 7501, 24, 36, 30, 2, -26 },
  { 7609, 22, 36, 30, 4, -26 },
  { 7708, 24, 26, 30, 6, -26 },
  { 7786, 23, 27, 30, 3, -26 },
  { 7864, 24, 36, 30, 4, -35 },
  { 7972, 21, 27, 30, 5, -26 },
  { 8043, 23, 26, 30, 4, -26 },
  { 8118, 24, 27, 30, 4, -26 },
  { 8199, 28, 27, 30, 1, -26 },
  { 8294, 24, 37, 30, 2, -26 },
  { 8405, 24, 27, 30, 3, -26 },
  { 8486, 22, 45, 30, 6, -38 },
  { 8610, 9, 45, 30, 11, -38 },
  { 8661, 23, 45, 30, 2, -38 },
  { 8791, 25, 9, 30, 3, -20 },
};

const GFXfont IBMPlexMono_ThinItalic50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_THINITALIC50PT7B_H_
