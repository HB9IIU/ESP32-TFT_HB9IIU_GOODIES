#ifndef _IBMPLEXMONO_THINITALIC30PT7B_H_
#define _IBMPLEXMONO_THINITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x45, 0x18, 0xA2, 0x8A, 0x28, 0xA2, 0x00, 0x42, 0x00,
  0x42, 0x00, 0x21, 0x00, 0x10, 0x80, 0x10, 0x80, 0x08, 0x40, 0x04, 0x20,
  0x7C, 0x1F, 0x02, 0x10, 0x01, 0x08, 0x01, 0x08, 0x00, 0x84, 0x00, 0x82,
  0x07, 0xC1, 0xF0, 0x21, 0x00, 0x20, 0x80, 0x10, 0x80, 0x08, 0x40, 0x08,
  0x20, 0x04, 0x20, 0x02, 0x10, 0x00, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x03, 0xF8, 0x0C, 0x44, 0x08, 0x42, 0x10, 0x41, 0x20, 0x40, 0x20, 0x80,
  0x20, 0x80, 0x10, 0x80, 0x18, 0x80, 0x06, 0x80, 0x01, 0xE0, 0x01, 0x18,
  0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x01, 0x04, 0x82, 0x04,
  0x42, 0x08, 0x32, 0x30, 0x0F, 0xC0, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x07, 0x80, 0x21, 0x08, 0x08, 0x40, 0x82, 0x18, 0x10, 0x42, 0x02, 0x10,
  0x40, 0x44, 0x08, 0x11, 0x01, 0x02, 0x20, 0x10, 0x88, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x22, 0x10, 0x08, 0x82, 0x02, 0x20, 0x40,
  0x84, 0x0C, 0x10, 0x81, 0x04, 0x10, 0x21, 0x02, 0x04, 0x40, 0x21, 0x08,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x82, 0x00, 0x40, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x40, 0x10, 0x20, 0x02, 0x08, 0x01, 0x84,
  0x01, 0x9E, 0x00, 0x84, 0x00, 0x40, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0x80, 0x80, 0x30, 0x60, 0x14, 0x24, 0x04, 0x90, 0x82, 0x14, 0x1F,
  0x02, 0x00, 0x5A, 0xAA, 0x00, 0x81, 0x81, 0x01, 0x00, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x10, 0x10, 0x30, 0x00, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x10, 0x20, 0x5C, 0x47, 0x07, 0xF0, 0x03, 0x00, 0x0A,
  0x00, 0x22, 0x00, 0x82, 0x02, 0x04, 0x04, 0x04, 0x10, 0x08, 0x00, 0x00,
  0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x3F,
  0xFF, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x32, 0x24, 0x48, 0x80, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x80, 0x00, 0x03, 0xF0, 0x08, 0x30, 0x20, 0x10, 0x80, 0x22, 0x00, 0x44,
  0x00, 0x90, 0x01, 0x20, 0x03, 0x40, 0x05, 0x02, 0x0A, 0x04, 0x14, 0x00,
  0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x11, 0x00, 0x21,
  0x00, 0x81, 0x06, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x03, 0x80, 0x12, 0x00,
  0x88, 0x0C, 0x40, 0x61, 0x02, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0xFF, 0xFC, 0x01, 0xF0, 0x0C, 0x18, 0x20,
  0x10, 0x40, 0x11, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xF0, 0x0C, 0x18, 0x20, 0x10, 0x80, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x30, 0x1F, 0x80, 0x01, 0x80, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x09, 0x00, 0x11, 0x00, 0x41, 0x81,
  0x80, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x50, 0x01, 0x20, 0x04,
  0x80, 0x11, 0x00, 0x42, 0x01, 0x04, 0x02, 0x08, 0x08, 0x10, 0x20, 0x40,
  0x80, 0x82, 0x01, 0x08, 0x02, 0x20, 0x04, 0x7F, 0xFF, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0F, 0xFE, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x27, 0xC0,
  0x70, 0x60, 0x80, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x11, 0x00, 0x22, 0x00, 0x83, 0x02, 0x01, 0xF8, 0x00, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x27, 0xC2, 0xC1, 0x98, 0x02, 0x80, 0x14, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x90, 0x0C, 0x40, 0xC1, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x22, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x03,
  0xF0, 0x18, 0x10, 0x40, 0x10, 0x80, 0x22, 0x00, 0x24, 0x00, 0x48, 0x01,
  0x10, 0x02, 0x10, 0x08, 0x10, 0x20, 0x1F, 0x81, 0xC1, 0x84, 0x00, 0x90,
  0x01, 0x20, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x12, 0x00, 0x43, 0x03,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0xC1, 0x88, 0x04, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x90, 0x0C, 0x41, 0xA1, 0xF2,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x07,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCC, 0x0C, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x21, 0x04,
  0x20, 0x80, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x1F, 0x84, 0x09, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x30, 0x78, 0x08, 0x01, 0x00, 0x20, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x01, 0xF0, 0x18, 0x20, 0x80, 0x42, 0x01,
  0x10, 0x04, 0x80, 0x12, 0x0F, 0x48, 0x43, 0x42, 0x05, 0x10, 0x24, 0x40,
  0x91, 0x02, 0x44, 0x0A, 0x20, 0x28, 0x80, 0xA2, 0x04, 0x84, 0x32, 0x0F,
  0x48, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x03, 0x00, 0x07, 0xF0, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x11, 0x00, 0x42,
  0x00, 0x84, 0x02, 0x08, 0x04, 0x10, 0x10, 0x20, 0x20, 0x20, 0x80, 0x41,
  0xFF, 0x84, 0x01, 0x08, 0x02, 0x20, 0x04, 0x40, 0x05, 0x00, 0x0A, 0x00,
  0x18, 0x00, 0x20, 0x1F, 0xF0, 0x40, 0x21, 0x00, 0x48, 0x01, 0x20, 0x04,
  0x80, 0x12, 0x00, 0x48, 0x02, 0x20, 0x09, 0x00, 0x47, 0xFE, 0x10, 0x0C,
  0x40, 0x09, 0x00, 0x24, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x01,
  0x20, 0x0C, 0xFF, 0xC0, 0x03, 0xE0, 0x30, 0x41, 0x00, 0x88, 0x02, 0x20,
  0x05, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x12, 0x00, 0x84,
  0x04, 0x18, 0x20, 0x1F, 0x00, 0x1F, 0xE0, 0x20, 0x30, 0x40, 0x20, 0x80,
  0x22, 0x00, 0x44, 0x00, 0x88, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x09,
  0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x02, 0x40, 0x04, 0x80,
  0x09, 0x00, 0x22, 0x00, 0x84, 0x06, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0xFC, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F,
  0xF8, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x30,
  0x41, 0x00, 0x88, 0x02, 0x20, 0x05, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x7E, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0xC8, 0x05, 0x18, 0x28, 0x1F, 0x20, 0x10, 0x02,
  0x20, 0x04, 0x80, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x01, 0x10,
  0x02, 0x40, 0x04, 0x80, 0x09, 0xFF, 0xF2, 0x00, 0x44, 0x00, 0x88, 0x01,
  0x20, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x22, 0x00, 0x44, 0x00, 0x88,
  0x01, 0x00, 0x0F, 0xFF, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x22, 0x00, 0x88, 0x04, 0x18, 0x20, 0x1F, 0x00, 0x10, 0x01, 0x88,
  0x01, 0x04, 0x01, 0x02, 0x01, 0x02, 0x01, 0x01, 0x01, 0x00, 0x81, 0x00,
  0x41, 0x00, 0x21, 0x00, 0x13, 0x00, 0x12, 0x40, 0x0A, 0x20, 0x06, 0x08,
  0x02, 0x04, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x20, 0x40, 0x10, 0x20,
  0x04, 0x10, 0x02, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xFF, 0xF0, 0x08, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC2, 0x80, 0xA1, 0x40,
  0x51, 0x20, 0x48, 0x88, 0x44, 0x44, 0x24, 0x22, 0x22, 0x11, 0x11, 0x08,
  0x50, 0x88, 0x30, 0x44, 0x08, 0x22, 0x08, 0x21, 0x00, 0x10, 0x80, 0x08,
  0x40, 0x04, 0x40, 0x02, 0x20, 0x01, 0x10, 0x01, 0x08, 0x00, 0x80, 0x10,
  0x02, 0x30, 0x04, 0xA0, 0x09, 0x40, 0x12, 0x40, 0x24, 0x80, 0x89, 0x01,
  0x11, 0x02, 0x42, 0x04, 0x84, 0x09, 0x04, 0x12, 0x08, 0x44, 0x10, 0x88,
  0x11, 0x20, 0x22, 0x40, 0x24, 0x80, 0x49, 0x00, 0xA2, 0x00, 0xC4, 0x01,
  0x88, 0x01, 0x00, 0x03, 0xF0, 0x08, 0x30, 0x20, 0x10, 0x80, 0x22, 0x00,
  0x44, 0x00, 0x90, 0x01, 0x20, 0x03, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x50, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x11, 0x00,
  0x21, 0x00, 0x81, 0x06, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x20, 0x08, 0x40,
  0x08, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x04,
  0x40, 0x09, 0x00, 0x21, 0xFF, 0x84, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xF0, 0x08, 0x30, 0x20, 0x10, 0x80, 0x22, 0x00, 0x44, 0x00, 0x90, 0x01,
  0x20, 0x03, 0x40, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50,
  0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x11, 0x00, 0x21, 0x00, 0x81, 0x06,
  0x01, 0xF8, 0x00, 0x40, 0x00, 0x42, 0x00, 0x8C, 0x00, 0xA0, 0x00, 0x80,
  0x1F, 0xF8, 0x20, 0x08, 0x40, 0x08, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x90, 0x01, 0x20, 0x04, 0x40, 0x09, 0x00, 0x21, 0xFF, 0x84, 0x10,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x80, 0x41, 0x00, 0x42, 0x00, 0x84,
  0x00, 0x88, 0x01, 0x00, 0x03, 0xF0, 0x0C, 0x0C, 0x08, 0x02, 0x10, 0x01,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0xE0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x80, 0x04, 0x40, 0x08, 0x30, 0x30, 0x0F, 0xC0, 0xFF, 0xFF,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x20, 0x04, 0x80, 0x14, 0x00, 0x50, 0x01, 0x40,
  0x05, 0x00, 0x24, 0x00, 0x90, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x22, 0x00, 0x88,
  0x04, 0x30, 0x20, 0x3F, 0x00, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x24, 0x00,
  0x48, 0x01, 0x10, 0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x40, 0x80, 0x81,
  0x02, 0x02, 0x04, 0x02, 0x10, 0x04, 0x20, 0x08, 0x80, 0x11, 0x00, 0x24,
  0x00, 0x48, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x20, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x82, 0x41,
  0x82, 0x42, 0x84, 0x42, 0x84, 0x42, 0x84, 0x44, 0x88, 0x44, 0x88, 0x48,
  0x88, 0x48, 0x48, 0x50, 0x50, 0x90, 0x50, 0xA0, 0x50, 0xA0, 0x50, 0xC0,
  0x60, 0xC0, 0x20, 0x08, 0x00, 0x61, 0x00, 0x10, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x20, 0x20, 0x04, 0x08, 0x00, 0x42, 0x00, 0x08, 0x80, 0x00, 0xA0,
  0x00, 0x14, 0x00, 0x01, 0x00, 0x00, 0x50, 0x00, 0x12, 0x00, 0x04, 0x20,
  0x01, 0x04, 0x00, 0x20, 0x40, 0x08, 0x08, 0x02, 0x00, 0x80, 0x80, 0x10,
  0x20, 0x01, 0x0C, 0x00, 0x20, 0x80, 0x01, 0x80, 0x02, 0x40, 0x04, 0x40,
  0x08, 0x20, 0x08, 0x20, 0x10, 0x10, 0x20, 0x10, 0x40, 0x08, 0x80, 0x09,
  0x00, 0x05, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xF0, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xFE, 0x00, 0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x40, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x80, 0x81,
  0x02, 0x04, 0x08, 0x08, 0x0F, 0xF0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0xFE, 0x00, 0x00, 0xC0, 0x05,
  0x00, 0x12, 0x00, 0x88, 0x04, 0x20, 0x20, 0x40, 0x81, 0x04, 0x02, 0x20,
  0x09, 0x00, 0x1C, 0x00, 0x40, 0xFF, 0xFC, 0x89, 0x12, 0x07, 0xCC, 0x60,
  0xA2, 0x01, 0x90, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80,
  0x12, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x40, 0x61, 0x82, 0x81, 0xF1, 0xC0,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0xF8, 0x24, 0x10, 0xA0, 0x23, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80,
  0x14, 0x00, 0x50, 0x01, 0x40, 0x09, 0x00, 0x24, 0x01, 0x30, 0x04, 0x90,
  0x62, 0x3E, 0x00, 0x07, 0xC0, 0x41, 0x8C, 0x04, 0x40, 0x14, 0x00, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x04, 0x80, 0x44, 0x02,
  0x18, 0x60, 0x7C, 0x00, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x03, 0xE4, 0x18, 0x28, 0x40, 0x31, 0x00,
  0x22, 0x00, 0x48, 0x00, 0x90, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11,
  0x00, 0x22, 0x00, 0xC2, 0x03, 0x06, 0x0A, 0x03, 0xE4, 0x00, 0x03, 0xE0,
  0x60, 0xC4, 0x02, 0x40, 0x14, 0x00, 0xA0, 0x0A, 0x03, 0x8F, 0xE0, 0x80,
  0x04, 0x00, 0x20, 0x02, 0x80, 0x24, 0x02, 0x18, 0x20, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x3F, 0xFE, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x08, 0x10, 0x01, 0x04, 0x00, 0x21, 0x00, 0x04, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0xE6, 0x18, 0x28, 0x40, 0x31, 0x00, 0x22, 0x00, 0x48,
  0x00, 0x90, 0x02, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00,
  0xC2, 0x03, 0x06, 0x0A, 0x03, 0xE4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x42,
  0x00, 0x83, 0x06, 0x01, 0xF0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x7C, 0x28, 0x23, 0x01, 0x60, 0x16, 0x01,
  0x40, 0x14, 0x01, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02,
  0x80, 0x48, 0x04, 0x01, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x10, 0x82, 0x10, 0xC1, 0x30, 0x14, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x42,
  0x04, 0x0C, 0x20, 0x31, 0x00, 0x48, 0x01, 0x40, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0xF8, 0x26, 0x18, 0x50, 0x10, 0xC0, 0x21, 0x00, 0x42, 0x01, 0x04, 0x04,
  0x10, 0x70, 0x23, 0x00, 0x44, 0x00, 0x84, 0x05, 0x04, 0x14, 0x08, 0xC8,
  0x0B, 0x10, 0x08, 0x00, 0xFE, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x20, 0x24, 0x18, 0x8C, 0x13, 0x03, 0x80, 0x60, 0x00, 0x27,
  0x8E, 0x28, 0xB1, 0x30, 0xC1, 0x20, 0x41, 0x20, 0x81, 0x20, 0x81, 0x40,
  0x82, 0x40, 0x82, 0x40, 0x82, 0x41, 0x02, 0x41, 0x02, 0x41, 0x02, 0x81,
  0x04, 0x81, 0x04, 0x81, 0x04, 0x27, 0xC2, 0x82, 0x50, 0x16, 0x01, 0x60,
  0x14, 0x01, 0x40, 0x14, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x04, 0x80, 0x40, 0x07, 0xE0, 0x20, 0xC1, 0x00, 0x88, 0x02, 0x40,
  0x09, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0,
  0x04, 0x40, 0x20, 0x81, 0x01, 0xF8, 0x00, 0x09, 0xF0, 0x24, 0x10, 0x50,
  0x10, 0xC0, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00, 0x90, 0x01, 0x20, 0x02,
  0x40, 0x08, 0x80, 0x11, 0x00, 0x46, 0x00, 0x89, 0x06, 0x11, 0xF0, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xCC, 0x60, 0xA2, 0x01, 0x90, 0x02, 0x40, 0x0A, 0x00, 0x28, 0x01, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x40, 0x61, 0x82, 0x81,
  0xF2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0xFC, 0xFC, 0x2C, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x00, 0x07, 0xE0, 0x60, 0x62, 0x00, 0x48, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x80, 0x01, 0xF8, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x80, 0x11, 0x80, 0xC1, 0xFC, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x3F, 0xFF, 0x81, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x04,
  0x08, 0x18, 0x10, 0xC0, 0x26, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x40, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x68, 0x0C, 0x80, 0xC4, 0x14, 0x3E, 0x40, 0xF0, 0x08, 0x80,
  0x44, 0x02, 0x40, 0x12, 0x00, 0x90, 0x04, 0x80, 0x44, 0x02, 0x20, 0x11,
  0x01, 0x10, 0x08, 0x80, 0x84, 0x18, 0x23, 0x01, 0xE0, 0x00, 0x20, 0x84,
  0x41, 0x05, 0x02, 0x0A, 0x04, 0x14, 0x10, 0x28, 0x20, 0x50, 0x40, 0xA0,
  0x81, 0x81, 0x03, 0x04, 0x06, 0x08, 0x14, 0x30, 0x28, 0x60, 0x90, 0xA3,
  0x1C, 0x38, 0x00, 0x06, 0x0E, 0x19, 0x11, 0x61, 0x21, 0x81, 0x41, 0x01,
  0x81, 0x00, 0x81, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x81, 0x00, 0x83,
  0x00, 0x82, 0x82, 0x84, 0x85, 0x8C, 0x58, 0x70, 0x60, 0x10, 0x04, 0x40,
  0x11, 0x00, 0x44, 0x01, 0x10, 0x04, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20,
  0x08, 0x80, 0x22, 0x01, 0x88, 0x0C, 0x20, 0x30, 0x41, 0x40, 0xF9, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x88, 0x06, 0x10, 0x30, 0x3F, 0x00, 0x1F, 0x84,
  0x83, 0xD4, 0x01, 0xD0, 0x02, 0x40, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x43, 0x01, 0x10, 0x04, 0xE0, 0x12, 0xFE, 0x48, 0x0F,
  0x80, 0x03, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x60, 0x7C, 0x00,
  0x30, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xE0, 0x08, 0x44, 0x21,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x11, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10,
  0x84, 0x20, 0x07, 0xE0, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x80, 0x01, 0xF0, 0x18, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x0F,
  0xE0, 0x00, 0x1C, 0x02, 0x4C, 0x09, 0x08, 0x14, 0x08, 0x28, 0x08, 0x90,
  0x0E, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 5, 21, 18, 7, -21 },
  { 15, 6, 8, 18, 8, -22 },
  { 21, 17, 21, 18, 1, -21 },
  { 66, 16, 27, 18, 1, -24 },
  { 120, 19, 21, 18, 0, -21 },
  { 170, 18, 21, 18, 0, -21 },
  { 218, 2, 8, 18, 10, -22 },
  { 220, 9, 27, 18, 7, -23 },
  { 251, 9, 27, 18, 2, -23 },
  { 282, 15, 15, 18, 2, -16 },
  { 311, 14, 15, 18, 2, -17 },
  { 338, 4, 7, 18, 5, -2 },
  { 342, 8, 1, 18, 5, -10 },
  { 343, 2, 2, 18, 7, -2 },
  { 344, 16, 27, 18, 1, -23 },
  { 398, 15, 21, 18, 2, -21 },
  { 438, 14, 21, 18, 1, -21 },
  { 475, 15, 21, 18, 1, -21 },
  { 515, 15, 21, 18, 1, -21 },
  { 555, 15, 21, 18, 1, -21 },
  { 595, 15, 21, 18, 2, -21 },
  { 635, 13, 21, 18, 2, -21 },
  { 670, 14, 21, 18, 4, -21 },
  { 707, 15, 21, 18, 2, -21 },
  { 747, 13, 21, 18, 3, -21 },
  { 782, 4, 16, 18, 7, -16 },
  { 790, 6, 21, 18, 5, -16 },
  { 806, 14, 16, 18, 3, -17 },
  { 834, 15, 6, 18, 2, -12 },
  { 846, 15, 16, 18, 1, -17 },
  { 876, 11, 21, 18, 5, -21 },
  { 905, 14, 24, 18, 2, -21 },
  { 947, 15, 21, 18, 0, -21 },
  { 987, 14, 21, 18, 2, -21 },
  { 1024, 14, 21, 18, 3, -21 },
  { 1061, 15, 21, 18, 2, -21 },
  { 1101, 16, 21, 18, 2, -21 },
  { 1143, 16, 21, 18, 2, -21 },
  { 1185, 14, 21, 18, 3, -21 },
  { 1222, 15, 21, 18, 2, -21 },
  { 1262, 16, 21, 18, 1, -21 },
  { 1304, 14, 21, 18, 2, -21 },
  { 1341, 17, 21, 18, 2, -21 },
  { 1386, 12, 21, 18, 3, -21 },
  { 1418, 17, 21, 18, 1, -21 },
  { 1463, 15, 21, 18, 2, -21 },
  { 1503, 15, 21, 18, 2, -21 },
  { 1543, 15, 21, 18, 2, -21 },
  { 1583, 15, 26, 18, 2, -21 },
  { 1632, 15, 21, 18, 2, -21 },
  { 1672, 16, 21, 18, 1, -21 },
  { 1714, 16, 21, 18, 3, -21 },
  { 1756, 14, 21, 18, 3, -21 },
  { 1793, 15, 21, 18, 4, -21 },
  { 1833, 16, 21, 18, 2, -21 },
  { 1875, 19, 21, 18, 0, -21 },
  { 1925, 16, 21, 18, 3, -21 },
  { 1967, 18, 21, 18, 0, -21 },
  { 2015, 12, 27, 18, 6, -23 },
  { 2056, 7, 27, 18, 6, -23 },
  { 2080, 12, 27, 18, 1, -23 },
  { 2121, 14, 11, 18, 2, -21 },
  { 2141, 14, 1, 18, 0, 3 },
  { 2143, 3, 5, 18, 7, -23 },
  { 2145, 14, 15, 18, 2, -15 },
  { 2172, 14, 22, 18, 2, -22 },
  { 2211, 13, 15, 18, 2, -15 },
  { 2236, 15, 22, 18, 2, -22 },
  { 2278, 13, 15, 18, 2, -15 },
  { 2303, 18, 28, 18, 0, -22 },
  { 2366, 15, 21, 18, 1, -15 },
  { 2406, 12, 22, 18, 3, -22 },
  { 2439, 12, 22, 18, 3, -22 },
  { 2472, 13, 28, 18, 3, -22 },
  { 2518, 15, 22, 18, 2, -22 },
  { 2560, 11, 22, 18, 4, -22 },
  { 2591, 16, 15, 18, 1, -15 },
  { 2621, 12, 15, 18, 3, -15 },
  { 2644, 14, 15, 18, 2, -15 },
  { 2671, 15, 21, 18, 1, -15 },
  { 2711, 14, 21, 18, 2, -15 },
  { 2748, 14, 15, 18, 4, -15 },
  { 2775, 14, 15, 18, 2, -15 },
  { 2802, 15, 21, 18, 2, -21 },
  { 2842, 12, 15, 18, 3, -15 },
  { 2865, 13, 15, 18, 3, -15 },
  { 2890, 15, 15, 18, 2, -15 },
  { 2919, 16, 15, 18, 1, -15 },
  { 2949, 14, 21, 18, 1, -15 },
  { 2986, 14, 15, 18, 2, -15 },
  { 3013, 13, 27, 18, 4, -23 },
  { 3057, 5, 27, 18, 7, -23 },
  { 3074, 14, 27, 18, 1, -23 },
  { 3122, 15, 6, 18, 2, -12 },
};

const GFXfont IBMPlexMono_ThinItalic30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_THINITALIC30PT7B_H_
