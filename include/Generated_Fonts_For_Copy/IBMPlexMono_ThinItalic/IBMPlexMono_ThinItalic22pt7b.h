#ifndef _IBMPLEXMONO_THINITALIC22PT7B_H_
#define _IBMPLEXMONO_THINITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x49, 0x00, 0x20, 0x99, 0x99, 0xAA, 0x01, 0x10,
  0x11, 0x00, 0x88, 0x04, 0x80, 0x44, 0x1E, 0x3C, 0x11, 0x01, 0x10, 0x08,
  0x87, 0xC7, 0x84, 0x40, 0x22, 0x01, 0x20, 0x11, 0x00, 0x88, 0x00, 0x01,
  0x00, 0x40, 0x3E, 0x09, 0x22, 0x22, 0x84, 0x10, 0x81, 0x20, 0x14, 0x01,
  0xE0, 0x13, 0x02, 0x20, 0x84, 0x10, 0xA2, 0x12, 0x44, 0x3F, 0x01, 0x00,
  0x40, 0x00, 0x0E, 0x04, 0xC4, 0x22, 0x11, 0x10, 0x44, 0x41, 0x20, 0x89,
  0x01, 0xC8, 0x00, 0x00, 0x08, 0xE0, 0x44, 0x41, 0x21, 0x09, 0x04, 0x44,
  0x12, 0x08, 0x88, 0x1C, 0x00, 0x07, 0x80, 0x42, 0x04, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x20, 0x22, 0x07, 0xE0, 0x44, 0x04, 0x10, 0x20, 0x41, 0x01,
  0x18, 0x18, 0xA1, 0x28, 0xF0, 0x80, 0x6A, 0xA0, 0x06, 0x10, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x80,
  0x81, 0x80, 0x10, 0x40, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x20, 0x84, 0x10, 0x84, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0xC4,
  0x73, 0xB8, 0x0C, 0x01, 0x20, 0x11, 0x02, 0x10, 0x40, 0x80, 0x02, 0x00,
  0x40, 0x10, 0x02, 0x00, 0x40, 0xFF, 0xE1, 0x00, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x00, 0x25, 0x25, 0x00, 0xFC, 0x80, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x0F, 0x0C, 0x24, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x21, 0x80,
  0x60, 0x18, 0x0A, 0x02, 0x81, 0x30, 0x83, 0xC0, 0x03, 0x01, 0xC0, 0x90,
  0x48, 0x22, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x0F, 0xFC, 0x07, 0x81, 0x08, 0xC0, 0x90, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x3F, 0xF0,
  0x0F, 0x82, 0x08, 0x81, 0x00, 0x10, 0x04, 0x00, 0x80, 0x20, 0x78, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x28, 0x08, 0x83, 0x0F, 0x80, 0x00, 0x40, 0x18,
  0x05, 0x01, 0x20, 0x48, 0x11, 0x04, 0x21, 0x04, 0x20, 0x88, 0x22, 0x04,
  0x7F, 0xF0, 0x10, 0x02, 0x00, 0x40, 0x0F, 0xE2, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x5E, 0x0C, 0x22, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x28, 0x08,
  0x83, 0x0F, 0x80, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x01, 0x79, 0xC3,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x18, 0xF0, 0xFF, 0xE0, 0x28, 0x0A,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40,
  0x10, 0x08, 0x00, 0x07, 0x83, 0x0C, 0x80, 0x90, 0x12, 0x02, 0x40, 0x44,
  0x10, 0x7C, 0x30, 0x88, 0x0A, 0x01, 0x40, 0x28, 0x04, 0x81, 0x0F, 0xC0,
  0x1F, 0x08, 0x24, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x41, 0x8F,
  0xC0, 0x20, 0x08, 0x04, 0x06, 0x06, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0x08, 0x84, 0x22, 0x00, 0x00, 0x40,
  0x20, 0x30, 0x30, 0x30, 0x30, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x06, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60,
  0x00, 0x1E, 0x10, 0x90, 0x30, 0x10, 0x08, 0x08, 0x04, 0x1C, 0x10, 0x10,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x47,
  0x62, 0x39, 0x0A, 0x42, 0x90, 0xA8, 0x2A, 0x0A, 0x46, 0x8F, 0x20, 0x08,
  0x01, 0x00, 0x3E, 0x00, 0x00, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x48, 0x09,
  0x02, 0x10, 0x42, 0x10, 0x42, 0x08, 0x7F, 0x10, 0x14, 0x02, 0x80, 0x60,
  0x08, 0x1F, 0x84, 0x08, 0x80, 0x90, 0x12, 0x02, 0x80, 0x90, 0x11, 0xFC,
  0x40, 0xC8, 0x09, 0x01, 0x40, 0x28, 0x05, 0x01, 0x3F, 0xC0, 0x0F, 0x04,
  0x22, 0x05, 0x01, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x02, 0x81, 0x10, 0x83, 0xC0, 0x1F, 0x84, 0x08, 0x80, 0x90, 0x12, 0x02,
  0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x01, 0x40, 0x28, 0x09, 0x02,
  0x3F, 0x80, 0x1F, 0xF2, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x03, 0xFC, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF,
  0x80, 0x1F, 0xF2, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x03,
  0xFC, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00,
  0x0F, 0x04, 0x22, 0x05, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x87, 0xE0,
  0x28, 0x0A, 0x02, 0x80, 0x90, 0xE3, 0xD0, 0x20, 0x12, 0x02, 0x20, 0x22,
  0x02, 0x40, 0x24, 0x02, 0x40, 0x27, 0xFC, 0x40, 0x44, 0x04, 0x40, 0x48,
  0x04, 0x80, 0x48, 0x08, 0x80, 0x80, 0x1F, 0xF0, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x12, 0x04, 0x82, 0x21, 0x87, 0x80,
  0x20, 0x19, 0x01, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x01, 0x10, 0x0B,
  0x80, 0x62, 0x02, 0x10, 0x10, 0x40, 0x82, 0x08, 0x08, 0x40, 0x42, 0x01,
  0x00, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0x20, 0x13, 0x07, 0x30, 0x55, 0x0A,
  0x48, 0xA4, 0x92, 0x4A, 0x24, 0xA2, 0x84, 0x48, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x80, 0x10, 0x13, 0x02, 0x30, 0x22, 0x82, 0x48,
  0x24, 0x82, 0x44, 0x24, 0x44, 0x42, 0x44, 0x24, 0x82, 0x48, 0x14, 0x81,
  0x48, 0x18, 0x80, 0x80, 0x0F, 0x0C, 0x24, 0x05, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x81, 0x30, 0x83, 0xC0, 0x1F,
  0xC2, 0x02, 0x20, 0x22, 0x01, 0x20, 0x12, 0x02, 0x40, 0x24, 0x04, 0x3F,
  0x84, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F, 0x0C,
  0x24, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A,
  0x02, 0x81, 0x30, 0x83, 0xC0, 0x20, 0x08, 0x81, 0x40, 0x20, 0x1F, 0xC2,
  0x02, 0x20, 0x22, 0x01, 0x20, 0x12, 0x02, 0x40, 0x24, 0x04, 0x3F, 0x84,
  0x40, 0x42, 0x04, 0x10, 0x81, 0x08, 0x08, 0x80, 0xC0, 0x0F, 0x82, 0x08,
  0x80, 0xA0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x78, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x28, 0x04, 0x81, 0x0F, 0xC0, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x00, 0x40, 0x28, 0x09, 0x01, 0x20, 0x28, 0x05,
  0x00, 0xA0, 0x14, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x48, 0x11, 0x06,
  0x1F, 0x00, 0x80, 0x70, 0x0A, 0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0x82,
  0x10, 0x44, 0x08, 0x81, 0x20, 0x24, 0x05, 0x00, 0x60, 0x08, 0x00, 0x80,
  0x38, 0x02, 0x80, 0x28, 0x02, 0x84, 0x48, 0x44, 0x8C, 0x49, 0x44, 0x94,
  0x8A, 0x48, 0xA2, 0x8C, 0x30, 0xC3, 0x08, 0x30, 0x81, 0x00, 0x10, 0x0C,
  0x40, 0x40, 0x82, 0x02, 0x08, 0x04, 0x40, 0x12, 0x00, 0x30, 0x00, 0x80,
  0x05, 0x00, 0x24, 0x00, 0x88, 0x04, 0x20, 0x20, 0x41, 0x01, 0x08, 0x02,
  0x00, 0x80, 0x18, 0x02, 0x40, 0x44, 0x08, 0x21, 0x02, 0x10, 0x12, 0x01,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00,
  0x1F, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x03, 0xFF,
  0x80, 0x0F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0x80,
  0x84, 0x20, 0x84, 0x21, 0x08, 0x21, 0x08, 0x41, 0x08, 0x42, 0x08, 0x42,
  0x10, 0x1F, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0xF8, 0x02, 0x03, 0x80,
  0x90, 0x44, 0x21, 0x10, 0x24, 0x0A, 0x01, 0xFF, 0xE0, 0x91, 0x30, 0x1E,
  0xB0, 0xE0, 0x30, 0x18, 0x0C, 0x0A, 0x05, 0x02, 0x81, 0x43, 0x9E, 0x60,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x13, 0xC5, 0x09, 0x82, 0x40, 0x60,
  0x18, 0x06, 0x02, 0x80, 0xA0, 0x2C, 0x32, 0xF0, 0x1E, 0x10, 0x90, 0x30,
  0x08, 0x04, 0x02, 0x01, 0x03, 0x81, 0x21, 0x0F, 0x00, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x87, 0xA6, 0x1A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04,
  0x81, 0x20, 0x48, 0x71, 0xE4, 0x1F, 0x10, 0x50, 0x30, 0x18, 0x37, 0xE2,
  0x01, 0x02, 0x81, 0xA1, 0x0F, 0x00, 0x00, 0xF8, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x0F, 0xFC, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x10, 0x80, 0x84, 0x03, 0x20, 0x0E,
  0x00, 0x10, 0x00, 0x0F, 0x4C, 0x34, 0x05, 0x01, 0x80, 0x60, 0x28, 0x0A,
  0x02, 0x80, 0x90, 0xE3, 0xC8, 0x04, 0x01, 0x20, 0x87, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x79, 0x42, 0xC1, 0x40, 0xA0, 0x60, 0x30, 0x28,
  0x14, 0x0A, 0x05, 0x02, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x24, 0x32, 0x21, 0x60, 0x40, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x12, 0x10, 0x88, 0x24, 0x0E, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x00, 0x9E, 0x14, 0x23, 0x04, 0x40, 0x90, 0x22, 0x38, 0x48, 0x09,
  0x03, 0x11, 0xA1, 0x44, 0x10, 0xF8, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x41, 0x42, 0x4C, 0x50, 0x60, 0x5C, 0xE4, 0x65,
  0x08, 0xA1, 0x14, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x51, 0x0A, 0x21,
  0x00, 0x4F, 0x28, 0x58, 0x28, 0x14, 0x0C, 0x06, 0x05, 0x02, 0x81, 0x40,
  0xA0, 0x40, 0x1F, 0x10, 0x50, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0x21, 0x8F, 0x00, 0x27, 0x85, 0x08, 0xC1, 0x10, 0x14, 0x02, 0x80, 0x50,
  0x12, 0x02, 0x40, 0x54, 0x32, 0x78, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00,
  0x1E, 0xB0, 0xE0, 0x30, 0x18, 0x0C, 0x0A, 0x05, 0x02, 0x81, 0x43, 0x9E,
  0x40, 0x40, 0x20, 0x10, 0x08, 0xF3, 0xC7, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x00, 0x0F, 0x86, 0x08, 0x80, 0xA0,
  0x03, 0x00, 0x1F, 0x00, 0x10, 0x02, 0x80, 0x48, 0x10, 0xFC, 0x00, 0x08,
  0x02, 0x00, 0x80, 0x20, 0xFF, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x86, 0x22, 0x0B, 0x03, 0x00, 0x40, 0xA0, 0x50, 0x30, 0x18, 0x14,
  0x0A, 0x05, 0x02, 0x83, 0x42, 0x9E, 0x80, 0xE0, 0x88, 0x12, 0x04, 0x81,
  0x40, 0x90, 0x24, 0x09, 0x04, 0x42, 0x13, 0x07, 0x00, 0xC4, 0x61, 0x18,
  0x46, 0x11, 0x88, 0x62, 0x18, 0x86, 0x21, 0x88, 0x66, 0x2E, 0x70, 0x08,
  0xE3, 0x51, 0xC6, 0x10, 0x21, 0x04, 0x10, 0x40, 0x84, 0x08, 0x40, 0x8C,
  0x29, 0x2C, 0xE3, 0x00, 0x20, 0x48, 0x12, 0x05, 0x01, 0x40, 0x90, 0x24,
  0x09, 0x02, 0x41, 0x90, 0xA3, 0xD0, 0x04, 0x01, 0x20, 0x87, 0xC0, 0x1E,
  0x24, 0x3D, 0x01, 0x20, 0x40, 0x30, 0x08, 0x06, 0x01, 0x04, 0x40, 0x9F,
  0x8A, 0x1F, 0x00, 0x07, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x08, 0x3C, 0x01, 0x80, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x01, 0xF0, 0x12, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x88,
  0x88, 0x88, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20,
  0x04, 0x00, 0xF0, 0xC0, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x83, 0xE0, 0x38, 0x28, 0x86, 0x09, 0x40, 0xC0,
};

const GFXglyph IBMPlexMono_ThinItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 4, 6, 13, 6, -16 },
  { 10, 13, 15, 13, 0, -15 },
  { 35, 11, 19, 13, 1, -17 },
  { 62, 14, 15, 13, 0, -15 },
  { 89, 13, 15, 13, 0, -15 },
  { 114, 2, 6, 13, 7, -16 },
  { 116, 7, 20, 13, 5, -17 },
  { 134, 6, 20, 13, 2, -17 },
  { 149, 12, 11, 13, 1, -12 },
  { 166, 11, 11, 13, 1, -12 },
  { 182, 3, 6, 13, 3, -2 },
  { 185, 6, 1, 13, 4, -7 },
  { 186, 1, 1, 13, 5, -1 },
  { 187, 12, 20, 13, 1, -17 },
  { 217, 10, 15, 13, 2, -15 },
  { 236, 10, 15, 13, 1, -15 },
  { 255, 11, 15, 13, 1, -15 },
  { 276, 11, 15, 13, 1, -15 },
  { 297, 11, 15, 13, 1, -15 },
  { 318, 11, 15, 13, 1, -15 },
  { 339, 9, 15, 13, 2, -15 },
  { 356, 10, 15, 13, 3, -15 },
  { 375, 11, 15, 13, 1, -15 },
  { 396, 10, 15, 13, 2, -15 },
  { 415, 3, 11, 13, 5, -11 },
  { 420, 5, 15, 13, 3, -11 },
  { 430, 10, 12, 13, 2, -13 },
  { 445, 11, 5, 13, 1, -9 },
  { 452, 11, 12, 13, 1, -13 },
  { 469, 9, 15, 13, 3, -15 },
  { 486, 10, 17, 13, 2, -15 },
  { 508, 11, 15, 13, 0, -15 },
  { 529, 11, 15, 13, 1, -15 },
  { 550, 10, 15, 13, 2, -15 },
  { 569, 11, 15, 13, 1, -15 },
  { 590, 12, 15, 13, 1, -15 },
  { 613, 12, 15, 13, 1, -15 },
  { 636, 10, 15, 13, 2, -15 },
  { 655, 12, 15, 13, 1, -15 },
  { 678, 12, 15, 13, 1, -15 },
  { 701, 10, 15, 13, 2, -15 },
  { 720, 13, 15, 13, 1, -15 },
  { 745, 9, 15, 13, 2, -15 },
  { 762, 12, 15, 13, 1, -15 },
  { 785, 12, 15, 13, 1, -15 },
  { 808, 10, 15, 13, 2, -15 },
  { 827, 12, 15, 13, 1, -15 },
  { 850, 10, 19, 13, 2, -15 },
  { 874, 12, 15, 13, 1, -15 },
  { 897, 11, 15, 13, 1, -15 },
  { 918, 12, 15, 13, 2, -15 },
  { 941, 11, 15, 13, 2, -15 },
  { 962, 11, 15, 13, 3, -15 },
  { 983, 12, 15, 13, 2, -15 },
  { 1006, 14, 15, 13, 0, -15 },
  { 1033, 12, 15, 13, 2, -15 },
  { 1056, 13, 15, 13, 0, -15 },
  { 1081, 9, 20, 13, 4, -17 },
  { 1104, 5, 20, 13, 4, -17 },
  { 1117, 8, 20, 13, 1, -17 },
  { 1137, 10, 8, 13, 2, -15 },
  { 1147, 11, 1, 13, 0, 2 },
  { 1149, 3, 4, 13, 5, -17 },
  { 1151, 9, 11, 13, 2, -11 },
  { 1164, 10, 16, 13, 2, -16 },
  { 1184, 9, 11, 13, 2, -11 },
  { 1197, 10, 16, 13, 2, -16 },
  { 1217, 9, 11, 13, 2, -11 },
  { 1230, 13, 20, 13, 0, -16 },
  { 1263, 10, 15, 13, 1, -11 },
  { 1282, 9, 16, 13, 2, -16 },
  { 1300, 9, 15, 13, 2, -15 },
  { 1317, 9, 19, 13, 2, -15 },
  { 1339, 11, 16, 13, 2, -16 },
  { 1361, 8, 16, 13, 3, -16 },
  { 1377, 11, 11, 13, 1, -11 },
  { 1393, 9, 11, 13, 2, -11 },
  { 1406, 9, 11, 13, 2, -11 },
  { 1419, 11, 15, 13, 1, -11 },
  { 1440, 9, 15, 13, 2, -11 },
  { 1457, 10, 11, 13, 3, -11 },
  { 1471, 11, 11, 13, 1, -11 },
  { 1487, 10, 15, 13, 2, -15 },
  { 1506, 9, 11, 13, 2, -11 },
  { 1519, 10, 11, 13, 2, -11 },
  { 1533, 10, 11, 13, 2, -11 },
  { 1547, 12, 11, 13, 1, -11 },
  { 1564, 10, 15, 13, 1, -11 },
  { 1583, 11, 11, 13, 1, -11 },
  { 1599, 10, 20, 13, 3, -17 },
  { 1624, 4, 20, 13, 5, -17 },
  { 1634, 10, 20, 13, 1, -17 },
  { 1659, 11, 4, 13, 1, -9 },
};

const GFXfont IBMPlexMono_ThinItalic22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_THINITALIC22PT7B_H_
