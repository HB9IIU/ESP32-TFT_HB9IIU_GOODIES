#ifndef _IBMPLEXMONO_THINITALIC46PT7B_H_
#define _IBMPLEXMONO_THINITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0x60, 0x20, 0x90, 0x48,
  0x2C, 0x34, 0x12, 0x09, 0x04, 0x82, 0x41, 0x61, 0xA0, 0x90, 0x40, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x08, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x08, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x40,
  0x0F, 0xF8, 0x0F, 0xF0, 0x02, 0x02, 0x00, 0x00, 0x40, 0x40, 0x00, 0x10,
  0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x40, 0x00, 0x10, 0x10, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x40, 0x40, 0x0F, 0xF0, 0x1F, 0xF0, 0x02, 0x02,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x10, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x10, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x10, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xC2, 0x38, 0x03, 0x02, 0x04, 0x06,
  0x02, 0x02, 0x04, 0x02, 0x01, 0x08, 0x02, 0x00, 0x08, 0x04, 0x00, 0x08,
  0x04, 0x00, 0x08, 0x04, 0x00, 0x08, 0x04, 0x00, 0x08, 0x04, 0x00, 0x08,
  0x04, 0x00, 0x08, 0x08, 0x00, 0x04, 0x08, 0x00, 0x03, 0x08, 0x00, 0x01,
  0xC8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x10, 0x60, 0x00,
  0x10, 0x30, 0x00, 0x10, 0x10, 0x00, 0x10, 0x08, 0x00, 0x10, 0x08, 0x00,
  0x10, 0x08, 0x00, 0x10, 0x08, 0x00, 0x20, 0x08, 0x00, 0x20, 0x08, 0x00,
  0x20, 0x08, 0x80, 0x20, 0x10, 0x80, 0x20, 0x10, 0x40, 0x20, 0x20, 0x30,
  0x40, 0x40, 0x1C, 0x43, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0x86, 0x00, 0x0C, 0x04, 0x02, 0x00, 0x10, 0x10,
  0x04, 0x00, 0x40, 0x20, 0x08, 0x01, 0x00, 0x80, 0x08, 0x04, 0x01, 0x00,
  0x10, 0x10, 0x02, 0x00, 0x40, 0x20, 0x04, 0x00, 0x80, 0x80, 0x08, 0x01,
  0x02, 0x00, 0x10, 0x02, 0x08, 0x00, 0x20, 0x08, 0x10, 0x00, 0x60, 0x30,
  0x40, 0x00, 0x60, 0xC1, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x81, 0xF0, 0x00, 0x02, 0x04, 0x18, 0x00, 0x08, 0x30, 0x18,
  0x00, 0x20, 0x40, 0x10, 0x00, 0x41, 0x00, 0x20, 0x01, 0x02, 0x00, 0x40,
  0x04, 0x04, 0x00, 0x80, 0x10, 0x08, 0x01, 0x00, 0x60, 0x20, 0x02, 0x00,
  0x80, 0x40, 0x04, 0x02, 0x00, 0x80, 0x10, 0x08, 0x00, 0x80, 0x20, 0x20,
  0x01, 0x00, 0x80, 0x40, 0x01, 0x86, 0x01, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x18, 0x30, 0x00, 0x08, 0x02, 0x00, 0x04, 0x00, 0x80,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x40, 0x01, 0x00, 0x20, 0x00, 0x20, 0x08, 0x00, 0x08, 0x04, 0x00,
  0x03, 0x02, 0x00, 0x07, 0x63, 0x00, 0x06, 0x0F, 0x00, 0x02, 0x01, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x40, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x80, 0x03, 0x00, 0x20, 0x00, 0x40, 0x08,
  0x00, 0x18, 0x06, 0x00, 0x0A, 0x03, 0x80, 0x02, 0x40, 0xA0, 0x00, 0x98,
  0x44, 0x00, 0x42, 0x11, 0x80, 0x20, 0x48, 0x30, 0x30, 0x14, 0x03, 0xF0,
  0x03, 0x00, 0x24, 0xB4, 0x92, 0x52, 0x40, 0x00, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x80,
  0x10, 0x02, 0xE0, 0x20, 0x78, 0x38, 0x47, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x0A, 0x00, 0x00, 0x32, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x04,
  0x00, 0x04, 0x04, 0x00, 0x10, 0x08, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10,
  0x04, 0x00, 0x10, 0x10, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0E,
  0x18, 0x20, 0xC1, 0x82, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x00, 0xFF, 0xF0,
  0x6F, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x81, 0x80, 0x18,
  0x01, 0x00, 0x80, 0x02, 0x06, 0x00, 0x08, 0x10, 0x00, 0x10, 0x80, 0x00,
  0x46, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x12, 0x00, 0x00, 0x48,
  0x00, 0x01, 0x20, 0x00, 0x05, 0x80, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00,
  0x01, 0x40, 0x38, 0x05, 0x00, 0xC0, 0x14, 0x00, 0x00, 0x50, 0x00, 0x02,
  0x40, 0x00, 0x09, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x04, 0x80,
  0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x41, 0x80, 0x02, 0x02, 0x00, 0x18, 0x04, 0x00, 0xC0, 0x0C, 0x0C, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x02, 0x40, 0x00,
  0x62, 0x00, 0x06, 0x10, 0x00, 0x40, 0x80, 0x0C, 0x04, 0x00, 0xC0, 0x40,
  0x08, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0x80, 0xC0, 0x18, 0x01, 0x80,
  0xC0, 0x03, 0x02, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x42, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0x01, 0x80, 0x10, 0x01, 0x00, 0x80, 0x02, 0x04, 0x00, 0x04,
  0x10, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x23, 0x00, 0x00, 0x84, 0x00, 0x04, 0x0C,
  0x00, 0x20, 0x1C, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x24, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x88, 0x00, 0x01, 0x08, 0x00, 0x02, 0x08, 0x00,
  0x04, 0x08, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x30, 0x10, 0x00,
  0x20, 0x10, 0x00, 0x40, 0x10, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x20, 0x04, 0x00, 0x20, 0x0C, 0x00, 0x20, 0x08, 0x00, 0x20, 0x10,
  0x00, 0x20, 0x20, 0x00, 0x20, 0x40, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x43, 0xF8, 0x01, 0x30,
  0x18, 0x05, 0x00, 0x10, 0x18, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x41, 0x00, 0x02, 0x06, 0x00, 0x10, 0x06, 0x01, 0x80,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x0F, 0xC0, 0x27, 0x03, 0x02, 0x80, 0x08, 0x50, 0x00, 0x46, 0x00, 0x02,
  0xC0, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00,
  0x04, 0xC0, 0x00, 0x84, 0x00, 0x18, 0x20, 0x02, 0x01, 0x80, 0xC0, 0x07,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x00, 0x26, 0x00, 0x00, 0x90, 0x00,
  0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x84, 0x00, 0x04, 0x10, 0x00, 0x10,
  0x40, 0x00, 0x82, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x01, 0xC0,
  0x10, 0x01, 0x80, 0x80, 0x02, 0x04, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80,
  0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x60, 0x00, 0x10, 0x80, 0x00,
  0x42, 0x00, 0x03, 0x08, 0x00, 0x08, 0x30, 0x00, 0x40, 0x60, 0x02, 0x00,
  0x60, 0x30, 0x00, 0xFF, 0x00, 0x1C, 0x06, 0x01, 0x80, 0x06, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x11, 0x00, 0x00, 0x4C, 0x00, 0x00, 0xA0, 0x00, 0x02,
  0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x01, 0xA0, 0x00, 0x04, 0x80,
  0x00, 0x13, 0x00, 0x00, 0x84, 0x00, 0x04, 0x08, 0x00, 0x60, 0x1C, 0x07,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x38, 0x0C, 0x00, 0xC1,
  0x00, 0x04, 0x20, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x14, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x64, 0x00, 0x0A, 0x40, 0x01, 0x42, 0x00,
  0x24, 0x18, 0x0C, 0x80, 0x7F, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x3C, 0x30,
  0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x03, 0x01, 0x81, 0x00, 0x10, 0x80,
  0x02, 0x40, 0x00, 0xD0, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x06,
  0x00, 0x40, 0x08, 0x04, 0x00, 0x20, 0x40, 0x01, 0x02, 0x00, 0x08, 0x20,
  0x00, 0x21, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x07, 0xE4,
  0x40, 0x60, 0xA2, 0x04, 0x03, 0x10, 0x40, 0x19, 0x02, 0x00, 0x48, 0x20,
  0x02, 0x41, 0x00, 0x22, 0x08, 0x01, 0x10, 0x40, 0x08, 0x82, 0x00, 0x48,
  0x20, 0x02, 0x41, 0x00, 0x12, 0x08, 0x01, 0x10, 0x40, 0x08, 0x82, 0x00,
  0x44, 0x08, 0x06, 0x20, 0x40, 0x51, 0x01, 0x8C, 0x88, 0x07, 0xC4, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x44, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x08,
  0x20, 0x00, 0x10, 0x40, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x02, 0x01,
  0x00, 0x04, 0x02, 0x00, 0x10, 0x04, 0x00, 0x20, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x10, 0x04, 0x00, 0x20, 0x08, 0x00, 0x40, 0x3F, 0xFF, 0x80,
  0x40, 0x01, 0x01, 0x00, 0x01, 0x02, 0x00, 0x02, 0x08, 0x00, 0x04, 0x10,
  0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x22, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x07, 0xFF, 0xC0, 0x10, 0x01,
  0x80, 0x40, 0x01, 0x03, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20,
  0x80, 0x00, 0xC2, 0x00, 0x02, 0x08, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00,
  0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x10, 0x40, 0x00, 0x81, 0x00, 0x0C,
  0x0F, 0xFF, 0xC0, 0x20, 0x00, 0xC0, 0x80, 0x00, 0x82, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x20, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00,
  0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x01, 0x20, 0x00, 0x08,
  0x80, 0x00, 0x62, 0x00, 0x03, 0x08, 0x00, 0x38, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x03, 0x01, 0x80, 0x18, 0x03, 0x00, 0x80, 0x04, 0x04, 0x00,
  0x08, 0x30, 0x00, 0x20, 0x80, 0x00, 0x44, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x04, 0x10, 0x00, 0x18, 0x40, 0x00, 0x41, 0x00, 0x02, 0x02, 0x00, 0x10,
  0x04, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x10, 0x03, 0x00, 0x40, 0x03, 0x01, 0x00, 0x04, 0x04, 0x00, 0x08, 0x20,
  0x00, 0x20, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x11,
  0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00,
  0x00, 0x48, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00,
  0x90, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10,
  0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x0C, 0x08, 0x00, 0xE0, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0x03, 0x80, 0x10, 0x03, 0x00, 0x80, 0x04,
  0x04, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x44, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x07, 0xFC, 0x80, 0x00, 0x12, 0x00,
  0x00, 0x48, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00,
  0x88, 0x00, 0x02, 0x10, 0x00, 0x18, 0x40, 0x00, 0x41, 0x00, 0x03, 0x02,
  0x00, 0x14, 0x0C, 0x00, 0x90, 0x0C, 0x0C, 0x40, 0x1F, 0xC0, 0x00, 0x04,
  0x00, 0x02, 0x08, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80,
  0x00, 0x21, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x04, 0x00, 0x02, 0x10, 0x00,
  0x04, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x61, 0x00, 0x00,
  0x82, 0x00, 0x01, 0x08, 0x00, 0x02, 0x1F, 0xFF, 0xFC, 0x20, 0x00, 0x08,
  0x40, 0x00, 0x30, 0x80, 0x00, 0x41, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08,
  0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80,
  0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x0C, 0x20, 0x00, 0x10, 0x40, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0x82, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x04, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x60, 0x40, 0x01, 0x01, 0x00, 0x08, 0x02, 0x00, 0x40,
  0x06, 0x06, 0x00, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x81, 0x00, 0x01, 0x80, 0x80, 0x01, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01,
  0x80, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x01, 0x00, 0x04, 0x01,
  0x00, 0x02, 0x01, 0x00, 0x02, 0x01, 0x00, 0x01, 0x01, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x23, 0x20, 0x00, 0x13, 0x10, 0x00, 0x13,
  0x04, 0x00, 0x0B, 0x02, 0x00, 0x06, 0x00, 0x80, 0x02, 0x00, 0x40, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x02, 0x00, 0x40, 0x01, 0x00,
  0x20, 0x00, 0x40, 0x10, 0x00, 0x20, 0x08, 0x00, 0x08, 0x04, 0x00, 0x04,
  0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0xFF, 0xFF, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01,
  0x41, 0x80, 0x00, 0xA0, 0xA0, 0x00, 0xA0, 0x90, 0x00, 0x50, 0x48, 0x00,
  0x48, 0x22, 0x00, 0x44, 0x11, 0x00, 0x22, 0x08, 0x80, 0x21, 0x04, 0x40,
  0x21, 0x04, 0x10, 0x10, 0x82, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81,
  0x08, 0x10, 0x40, 0x88, 0x08, 0x20, 0x44, 0x08, 0x20, 0x24, 0x04, 0x10,
  0x0E, 0x02, 0x08, 0x06, 0x01, 0x04, 0x02, 0x00, 0x82, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08,
  0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x02, 0x0C, 0x00, 0x04, 0x28, 0x00, 0x08, 0x48, 0x00, 0x10, 0x90, 0x00,
  0x21, 0x20, 0x00, 0x42, 0x20, 0x01, 0x04, 0x40, 0x02, 0x10, 0x80, 0x04,
  0x20, 0x80, 0x08, 0x41, 0x00, 0x10, 0x82, 0x00, 0x21, 0x02, 0x00, 0x82,
  0x04, 0x01, 0x08, 0x08, 0x02, 0x10, 0x08, 0x04, 0x20, 0x10, 0x08, 0x40,
  0x30, 0x10, 0x80, 0x20, 0x41, 0x00, 0x40, 0x84, 0x00, 0x41, 0x08, 0x00,
  0x82, 0x10, 0x01, 0x04, 0x20, 0x01, 0x08, 0x40, 0x02, 0x20, 0x80, 0x04,
  0x42, 0x00, 0x04, 0x84, 0x00, 0x09, 0x08, 0x00, 0x12, 0x10, 0x00, 0x14,
  0x20, 0x00, 0x30, 0x40, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x03, 0x81, 0x80,
  0x18, 0x01, 0x00, 0x80, 0x02, 0x06, 0x00, 0x08, 0x10, 0x00, 0x10, 0x80,
  0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x12, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x20, 0x00, 0x05, 0x80, 0x00, 0x14, 0x00, 0x00, 0x50,
  0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00,
  0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x04,
  0x80, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40,
  0x00, 0x41, 0x80, 0x02, 0x02, 0x00, 0x18, 0x04, 0x00, 0xC0, 0x0C, 0x0C,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x08, 0x00, 0x30, 0x10, 0x00,
  0x30, 0x20, 0x00, 0x20, 0x40, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08,
  0x80, 0x00, 0x31, 0x00, 0x00, 0x42, 0x00, 0x01, 0x84, 0x00, 0x06, 0x08,
  0x00, 0x38, 0x1F, 0xFF, 0x80, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0x81, 0x80, 0x18, 0x01, 0x00, 0x80, 0x02, 0x06,
  0x00, 0x08, 0x10, 0x00, 0x10, 0x80, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00,
  0x04, 0x40, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x05,
  0x80, 0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x50, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xA0, 0x00, 0x04, 0x80, 0x00, 0x11, 0x00, 0x00, 0x44,
  0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x40, 0x80, 0x02, 0x02, 0x00,
  0x18, 0x04, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x04, 0x00, 0x10, 0x18, 0x00, 0x41, 0x80, 0x00, 0x8C, 0x00,
  0x01, 0x40, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xE0, 0x08, 0x00, 0x30, 0x10,
  0x00, 0x30, 0x20, 0x00, 0x20, 0x40, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00,
  0x08, 0x80, 0x00, 0x31, 0x00, 0x00, 0x42, 0x00, 0x01, 0x84, 0x00, 0x06,
  0x08, 0x00, 0x38, 0x1F, 0xFF, 0x80, 0x40, 0x20, 0x00, 0x80, 0x20, 0x01,
  0x00, 0x40, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x80, 0x20,
  0x01, 0x00, 0x40, 0x02, 0x00, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02, 0x00,
  0x04, 0x04, 0x00, 0x08, 0x10, 0x00, 0x08, 0x20, 0x00, 0x10, 0x40, 0x00,
  0x10, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x04, 0x06, 0x00,
  0x02, 0x04, 0x00, 0x01, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x40, 0x00, 0x20, 0x30, 0x00,
  0x40, 0x0C, 0x03, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x04, 0x20, 0x00,
  0x11, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x11,
  0x00, 0x00, 0x84, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00,
  0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x10, 0x80, 0x00, 0x46, 0x00, 0x01,
  0x10, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x02, 0x10,
  0x00, 0x08, 0xC0, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00,
  0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x20,
  0x80, 0x00, 0x81, 0x00, 0x04, 0x06, 0x00, 0x20, 0x0C, 0x03, 0x00, 0x0F,
  0xF0, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xB0, 0x00,
  0x02, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x02, 0x10, 0x00, 0x08,
  0x40, 0x00, 0x41, 0x00, 0x01, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20,
  0x01, 0x00, 0x80, 0x04, 0x02, 0x00, 0x20, 0x08, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x40, 0x10, 0x01, 0x00, 0x80, 0x04, 0x02, 0x00, 0x10, 0x10, 0x00,
  0x40, 0x40, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x40, 0x00, 0x21,
  0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x05, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01,
  0x20, 0x00, 0x01, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02,
  0x20, 0x00, 0x02, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04,
  0x40, 0x30, 0x04, 0x40, 0x30, 0x08, 0x40, 0x38, 0x08, 0x40, 0x48, 0x08,
  0x40, 0x48, 0x10, 0x40, 0x88, 0x10, 0x40, 0x88, 0x10, 0x41, 0x08, 0x10,
  0x41, 0x08, 0x20, 0x42, 0x08, 0x20, 0x42, 0x04, 0x20, 0x84, 0x04, 0x20,
  0x84, 0x04, 0x40, 0x8C, 0x04, 0x40, 0x88, 0x04, 0x40, 0x88, 0x04, 0x40,
  0x90, 0x04, 0x80, 0x90, 0x04, 0x80, 0xA0, 0x02, 0x80, 0xA0, 0x03, 0x80,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x02, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x08, 0x00, 0x80, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30,
  0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x00, 0x48, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x04, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x18, 0x02, 0x00, 0x01, 0x00, 0x10, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x80, 0x00, 0x80, 0x18, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x80, 0x40, 0x00, 0x80, 0x20, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x01, 0x00, 0x40, 0x00, 0x80, 0x40, 0x00,
  0x20, 0x40, 0x00, 0x10, 0x40, 0x00, 0x04, 0x60, 0x00, 0x02, 0x20, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20,
  0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x04, 0x80, 0x00, 0x44, 0x00, 0x04, 0x10, 0x00, 0x60,
  0x80, 0x02, 0x06, 0x00, 0x20, 0x10, 0x02, 0x00, 0x80, 0x30, 0x02, 0x01,
  0x00, 0x10, 0x10, 0x00, 0x41, 0x00, 0x02, 0x10, 0x00, 0x08, 0x80, 0x00,
  0x48, 0x00, 0x02, 0x80, 0x00, 0x08, 0xFF, 0xFF, 0xFC, 0x86, 0x10, 0x42,
  0x08, 0x41, 0x00, 0xFE, 0x08, 0x1C, 0x0C, 0x41, 0x80, 0x34, 0x10, 0x00,
  0xA1, 0x80, 0x03, 0x08, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x40,
  0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x02,
  0x40, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x30, 0x80, 0x02, 0x84, 0x00, 0x18, 0x10, 0x01, 0x40,
  0xC0, 0x12, 0x03, 0x03, 0x1F, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x7E, 0x01,
  0x18, 0x18, 0x13, 0x00, 0x41, 0x40, 0x02, 0x14, 0x00, 0x21, 0x80, 0x01,
  0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00,
  0x12, 0x00, 0x01, 0x20, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x4C, 0x00, 0x04, 0xC0,
  0x00, 0x8A, 0x00, 0x18, 0x90, 0x03, 0x08, 0xC0, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x60, 0x60, 0x30, 0x02, 0x0C, 0x00, 0x21, 0x00, 0x04,
  0x40, 0x00, 0xD8, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x01, 0x40, 0x00, 0x44,
  0x00, 0x10, 0xC0, 0x04, 0x0C, 0x01, 0x00, 0xC0, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x03, 0xF8, 0x20, 0x1C, 0x0C, 0x40, 0x60,
  0x0C, 0x81, 0x00, 0x0A, 0x06, 0x00, 0x0C, 0x08, 0x00, 0x08, 0x20, 0x00,
  0x10, 0x40, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x01, 0x04, 0x00, 0x02,
  0x08, 0x00, 0x04, 0x30, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21,
  0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x08,
  0x00, 0x28, 0x10, 0x00, 0x50, 0x10, 0x01, 0x40, 0x30, 0x04, 0x80, 0x30,
  0x31, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x70, 0x30, 0x18, 0x01,
  0x04, 0x00, 0x11, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x01,
  0x40, 0x00, 0x68, 0x00, 0x0A, 0x00, 0x06, 0x40, 0x03, 0x08, 0x0F, 0x01,
  0xFE, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x01, 0x40, 0x00, 0x64, 0x00, 0x08, 0xC0, 0x02, 0x0C, 0x00, 0x80,
  0xC0, 0x60, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x08, 0x01, 0x00, 0x00, 0x40,
  0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x32, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x7F, 0x04, 0x07, 0x03, 0x10, 0x30, 0x06, 0x81,
  0x00, 0x0A, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00,
  0x02, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x60, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x08, 0x40,
  0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x06, 0x08, 0x00, 0x28, 0x20, 0x00,
  0xA0, 0x40, 0x05, 0x01, 0x80, 0x24, 0x03, 0x03, 0x10, 0x03, 0xF0, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x08, 0x00, 0x30, 0x10, 0x01, 0x80, 0x30, 0x18, 0x00, 0x3F, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0xF8, 0x04, 0x60, 0xC0, 0x90, 0x04, 0x34, 0x00, 0x85, 0x00,
  0x08, 0xC0, 0x01, 0x18, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00,
  0x12, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x48, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01,
  0x10, 0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0x10, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x01, 0x80, 0x80, 0x60, 0x20, 0x10, 0x04, 0x0C, 0x00, 0x82, 0x00,
  0x11, 0x80, 0x02, 0x40, 0x00, 0xB0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x60, 0x08, 0x06,
  0x01, 0x00, 0x60, 0x20, 0x02, 0x04, 0x00, 0x20, 0x80, 0x02, 0x10, 0x00,
  0x24, 0x00, 0x02, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x83,
  0xF0, 0x04, 0x30, 0x30, 0x13, 0x00, 0x40, 0x50, 0x00, 0x81, 0x80, 0x02,
  0x06, 0x00, 0x08, 0x10, 0x00, 0x20, 0xC0, 0x00, 0x82, 0x00, 0x04, 0x08,
  0x00, 0x30, 0x20, 0x01, 0x80, 0x80, 0x18, 0x02, 0x01, 0x80, 0x10, 0x38,
  0x00, 0x41, 0x00, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x10, 0x01,
  0x40, 0x40, 0x0A, 0x00, 0x80, 0x48, 0x03, 0x02, 0x20, 0x04, 0x30, 0x80,
  0x09, 0x82, 0x00, 0x2C, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x61, 0x00, 0x40, 0x80, 0xC0, 0x40, 0x80,
  0x21, 0x80, 0x21, 0x00, 0x13, 0x00, 0x0B, 0x00, 0x06, 0x00, 0x00, 0x08,
  0xF0, 0x3C, 0x09, 0x08, 0xC2, 0x1E, 0x05, 0x01, 0x14, 0x06, 0x01, 0x18,
  0x06, 0x01, 0x10, 0x04, 0x01, 0x10, 0x04, 0x01, 0x10, 0x04, 0x01, 0x30,
  0x04, 0x02, 0x20, 0x08, 0x02, 0x20, 0x08, 0x02, 0x20, 0x08, 0x02, 0x20,
  0x08, 0x02, 0x20, 0x08, 0x02, 0x40, 0x18, 0x04, 0x40, 0x10, 0x04, 0x40,
  0x10, 0x04, 0x40, 0x10, 0x04, 0x40, 0x10, 0x04, 0x40, 0x10, 0x04, 0xC0,
  0x20, 0x08, 0x80, 0x20, 0x08, 0x80, 0x20, 0x08, 0x80, 0x20, 0x08, 0x08,
  0x3E, 0x01, 0x18, 0x30, 0x24, 0x01, 0x09, 0x00, 0x21, 0x40, 0x02, 0x30,
  0x00, 0x46, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x24, 0x00, 0x04, 0x80,
  0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x12, 0x00,
  0x02, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00,
  0x09, 0x00, 0x01, 0x20, 0x00, 0x44, 0x00, 0x08, 0x00, 0xFE, 0x00, 0x30,
  0x30, 0x0C, 0x00, 0xC1, 0x80, 0x04, 0x10, 0x00, 0x22, 0x00, 0x02, 0x20,
  0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x40, 0x00,
  0x84, 0x00, 0x10, 0x20, 0x02, 0x01, 0x80, 0xC0, 0x07, 0xF0, 0x00, 0x02,
  0x1F, 0x80, 0x11, 0x81, 0x80, 0x4C, 0x01, 0x01, 0x40, 0x02, 0x05, 0x00,
  0x08, 0x18, 0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x01, 0x08, 0x00, 0x04,
  0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x40,
  0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x21, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x20, 0xA0, 0x01, 0x82,
  0x40, 0x0C, 0x08, 0xC0, 0xC0, 0x20, 0xFC, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x08, 0x1C, 0x0C, 0x41,
  0x80, 0x34, 0x10, 0x00, 0xA1, 0x80, 0x03, 0x08, 0x00, 0x08, 0x80, 0x00,
  0x44, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80,
  0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00, 0x08,
  0x80, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x30, 0x80, 0x02, 0x84, 0x00,
  0x18, 0x10, 0x01, 0x40, 0xC0, 0x12, 0x03, 0x03, 0x10, 0x07, 0xE0, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0xFF, 0x87, 0xFC,
  0x02, 0x60, 0x00, 0x12, 0x00, 0x00, 0x50, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x07, 0x01, 0x00, 0x0C, 0x10,
  0x00, 0x10, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x28, 0x00, 0x02, 0x20, 0x00,
  0x10, 0xC0, 0x03, 0x03, 0x80, 0x70, 0x03, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x18, 0x02, 0x00, 0xC0,
  0x04, 0x02, 0x00, 0x08, 0x18, 0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x00,
  0x88, 0x00, 0x01, 0x60, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x64, 0x00,
  0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00,
  0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00,
  0x48, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x01,
  0x10, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x03, 0x08, 0x00, 0xA1, 0x00, 0x34,
  0x10, 0x04, 0x81, 0x03, 0x10, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x10, 0x20,
  0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x40, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x02, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x40, 0x80, 0x04,
  0x10, 0x00, 0x81, 0x00, 0x10, 0x10, 0x03, 0x01, 0x00, 0x60, 0x10, 0x0C,
  0x01, 0x03, 0x00, 0x10, 0xC0, 0x01, 0xF0, 0x00, 0x10, 0x04, 0x04, 0x20,
  0x08, 0x08, 0x40, 0x10, 0x10, 0x80, 0x20, 0x11, 0x00, 0x80, 0x22, 0x01,
  0x00, 0x48, 0x02, 0x00, 0x90, 0x04, 0x01, 0x20, 0x08, 0x02, 0x40, 0x10,
  0x04, 0x80, 0x40, 0x09, 0x00, 0x80, 0x14, 0x01, 0x00, 0x28, 0x02, 0x00,
  0x50, 0x04, 0x00, 0xA0, 0x08, 0x02, 0x40, 0x20, 0x04, 0x80, 0x40, 0x0A,
  0x00, 0x80, 0x34, 0x01, 0x00, 0x48, 0x06, 0x00, 0x90, 0x14, 0x02, 0x10,
  0x24, 0x08, 0x31, 0x8C, 0x20, 0x3E, 0x0F, 0x80, 0x00, 0xE0, 0x1E, 0x00,
  0xEC, 0x08, 0x60, 0xC1, 0x04, 0x08, 0xC0, 0x22, 0x01, 0x40, 0x09, 0x00,
  0x40, 0x02, 0x40, 0x10, 0x00, 0xA0, 0x04, 0x00, 0x18, 0x01, 0x00, 0x06,
  0x00, 0x40, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x80, 0x18, 0x00, 0x20, 0x06, 0x00, 0x08, 0x02, 0x80, 0x02, 0x00, 0x90,
  0x00, 0x80, 0x24, 0x01, 0x20, 0x11, 0x01, 0xA4, 0x08, 0x21, 0x81, 0x84,
  0x09, 0x80, 0x3E, 0x01, 0x80, 0x00, 0x04, 0x00, 0x0C, 0x10, 0x00, 0x20,
  0x40, 0x00, 0x81, 0x00, 0x02, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x80,
  0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00, 0x40, 0x80, 0x01,
  0x02, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x81, 0x00, 0x02, 0x04,
  0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x01, 0x81, 0x00, 0x06, 0x04, 0x00,
  0x30, 0x10, 0x01, 0x40, 0x40, 0x0D, 0x00, 0x80, 0x24, 0x01, 0x03, 0x10,
  0x03, 0xF0, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x08, 0x00, 0x20, 0x30, 0x01, 0x00, 0x30, 0x18,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x02, 0x0C, 0x0F, 0x04, 0x20, 0x03,
  0xD0, 0x40, 0x01, 0xE1, 0x00, 0x00, 0xC2, 0x00, 0x02, 0x04, 0x00, 0x08,
  0x08, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x10, 0x03, 0x00, 0x20, 0x08, 0x00, 0x40, 0x20, 0x00, 0x80, 0x80,
  0x00, 0x86, 0x00, 0x01, 0x0B, 0xC0, 0x02, 0x10, 0x7C, 0x04, 0x40, 0x07,
  0xC8, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0x80,
  0x1E, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x01, 0x0C, 0x60, 0x02, 0x10, 0x30,
  0x02, 0x20, 0x10, 0x02, 0x20, 0x08, 0x04, 0x40, 0x04, 0x08, 0x40, 0x02,
  0x10, 0x80, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_ThinItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 8, 32, 28, 10, -32 },
  { 33, 9, 12, 28, 12, -34 },
  { 47, 27, 32, 28, 1, -32 },
  { 155, 24, 44, 28, 2, -38 },
  { 287, 31, 34, 28, -1, -33 },
  { 419, 26, 34, 28, 1, -33 },
  { 530, 3, 12, 28, 15, -34 },
  { 535, 14, 41, 28, 11, -35 },
  { 607, 15, 41, 28, 3, -35 },
  { 684, 23, 23, 28, 3, -25 },
  { 751, 22, 23, 28, 3, -26 },
  { 815, 7, 12, 28, 7, -4 },
  { 826, 12, 1, 28, 8, -15 },
  { 828, 4, 3, 28, 10, -3 },
  { 830, 24, 41, 28, 2, -35 },
  { 953, 22, 34, 28, 3, -33 },
  { 1047, 21, 32, 28, 2, -32 },
  { 1131, 22, 33, 28, 2, -33 },
  { 1222, 22, 34, 28, 2, -33 },
  { 1316, 24, 32, 28, 1, -32 },
  { 1412, 22, 33, 28, 3, -32 },
  { 1503, 20, 33, 28, 4, -32 },
  { 1586, 22, 32, 28, 5, -32 },
  { 1674, 22, 34, 28, 3, -33 },
  { 1768, 20, 33, 28, 5, -33 },
  { 1851, 7, 24, 28, 10, -24 },
  { 1872, 10, 32, 28, 7, -24 },
  { 1912, 22, 25, 28, 4, -27 },
  { 1981, 24, 10, 28, 2, -19 },
  { 2011, 22, 25, 28, 2, -27 },
  { 2080, 18, 33, 28, 7, -33 },
  { 2155, 21, 38, 28, 4, -33 },
  { 2255, 23, 32, 28, 0, -32 },
  { 2347, 22, 32, 28, 3, -32 },
  { 2435, 22, 34, 28, 4, -33 },
  { 2529, 22, 32, 28, 3, -32 },
  { 2617, 24, 32, 28, 3, -32 },
  { 2713, 24, 32, 28, 3, -32 },
  { 2809, 22, 34, 28, 4, -33 },
  { 2903, 23, 32, 28, 3, -32 },
  { 2995, 25, 32, 28, 2, -32 },
  { 3095, 22, 33, 28, 3, -32 },
  { 3186, 25, 32, 28, 3, -32 },
  { 3286, 17, 32, 28, 5, -32 },
  { 3354, 25, 32, 28, 2, -32 },
  { 3454, 23, 32, 28, 3, -32 },
  { 3546, 22, 34, 28, 3, -33 },
  { 3640, 23, 32, 28, 3, -32 },
  { 3732, 22, 41, 28, 3, -33 },
  { 3845, 23, 32, 28, 3, -32 },
  { 3937, 24, 34, 28, 2, -33 },
  { 4039, 24, 32, 28, 5, -32 },
  { 4135, 22, 33, 28, 4, -32 },
  { 4226, 22, 32, 28, 6, -32 },
  { 4314, 24, 32, 28, 4, -32 },
  { 4410, 28, 32, 28, 0, -32 },
  { 4522, 25, 32, 28, 5, -32 },
  { 4622, 28, 32, 28, 0, -32 },
  { 4734, 18, 41, 28, 9, -35 },
  { 4827, 11, 41, 28, 9, -35 },
  { 4884, 18, 41, 28, 1, -35 },
  { 4977, 21, 17, 28, 4, -32 },
  { 5022, 22, 1, 28, 0, 6 },
  { 5025, 5, 8, 28, 11, -35 },
  { 5030, 21, 25, 28, 3, -24 },
  { 5096, 20, 35, 28, 4, -34 },
  { 5184, 19, 25, 28, 4, -24 },
  { 5244, 23, 35, 28, 3, -34 },
  { 5345, 19, 25, 28, 4, -24 },
  { 5405, 28, 44, 28, 0, -34 },
  { 5559, 22, 34, 28, 2, -24 },
  { 5653, 19, 34, 28, 4, -34 },
  { 5734, 19, 35, 28, 4, -34 },
  { 5818, 19, 44, 28, 5, -34 },
  { 5923, 22, 35, 28, 4, -34 },
  { 6020, 17, 35, 28, 6, -34 },
  { 6095, 24, 24, 28, 2, -24 },
  { 6167, 19, 24, 28, 4, -24 },
  { 6224, 20, 25, 28, 4, -24 },
  { 6287, 22, 33, 28, 2, -24 },
  { 6378, 21, 33, 28, 3, -24 },
  { 6465, 22, 24, 28, 6, -24 },
  { 6531, 21, 25, 28, 3, -24 },
  { 6597, 23, 33, 28, 3, -32 },
  { 6692, 19, 25, 28, 5, -24 },
  { 6752, 20, 24, 28, 4, -24 },
  { 6812, 23, 25, 28, 3, -24 },
  { 6884, 26, 25, 28, 1, -24 },
  { 6966, 22, 34, 28, 2, -24 },
  { 7060, 23, 25, 28, 2, -24 },
  { 7132, 20, 41, 28, 6, -35 },
  { 7235, 8, 41, 28, 10, -35 },
  { 7276, 21, 41, 28, 2, -35 },
  { 7384, 24, 8, 28, 2, -18 },
};

const GFXfont IBMPlexMono_ThinItalic46pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic46pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic46pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _IBMPLEXMONO_THINITALIC46PT7B_H_
