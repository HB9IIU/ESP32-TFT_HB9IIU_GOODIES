#ifndef _IBMPLEXMONO_THINITALIC47PT7B_H_
#define _IBMPLEXMONO_THINITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x70, 0xC0, 0x20, 0xC8, 0x22, 0x08, 0x82, 0x20,
  0x98, 0x24, 0x19, 0x04, 0x41, 0x10, 0x44, 0x13, 0x0C, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x20, 0x30, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x10, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x30, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x08, 0x08, 0x00, 0x00, 0x80, 0x80, 0x0F, 0xF8,
  0x0F, 0xF0, 0x01, 0x01, 0x80, 0x00, 0x10, 0x10, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04,
  0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x04, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0x04, 0x60, 0x06, 0x04, 0x0C, 0x06, 0x02, 0x03, 0x02, 0x01, 0x00,
  0x82, 0x00, 0x80, 0x21, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x40, 0x20,
  0x00, 0x20, 0x10, 0x00, 0x10, 0x08, 0x00, 0x08, 0x04, 0x00, 0x06, 0x02,
  0x00, 0x01, 0x01, 0x00, 0x00, 0x61, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x2F, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x10, 0x00,
  0x08, 0x04, 0x00, 0x04, 0x02, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00, 0x40,
  0x00, 0x80, 0x20, 0x00, 0x40, 0x10, 0x00, 0x40, 0x18, 0x00, 0x20, 0x08,
  0x40, 0x10, 0x04, 0x30, 0x08, 0x04, 0x0C, 0x04, 0x06, 0x03, 0x02, 0x06,
  0x00, 0x62, 0x0C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x02, 0x01, 0x82, 0x00, 0x08, 0x04, 0x02, 0x00, 0x20, 0x10,
  0x02, 0x00, 0x40, 0x20, 0x04, 0x01, 0x00, 0x80, 0x08, 0x04, 0x01, 0x00,
  0x10, 0x10, 0x02, 0x00, 0x20, 0x20, 0x04, 0x00, 0x40, 0x80, 0x08, 0x01,
  0x02, 0x00, 0x10, 0x02, 0x08, 0x00, 0x20, 0x08, 0x30, 0x00, 0x60, 0x30,
  0x40, 0x00, 0x60, 0xC1, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x83, 0x0C, 0x00, 0x02, 0x08, 0x04, 0x00, 0x08, 0x20, 0x08,
  0x00, 0x20, 0x40, 0x08, 0x00, 0x41, 0x00, 0x10, 0x01, 0x02, 0x00, 0x20,
  0x04, 0x04, 0x00, 0x40, 0x10, 0x08, 0x00, 0x80, 0x60, 0x10, 0x02, 0x00,
  0x80, 0x20, 0x04, 0x02, 0x00, 0x40, 0x08, 0x08, 0x00, 0x80, 0x20, 0x20,
  0x00, 0x80, 0xC0, 0x40, 0x01, 0x83, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x08,
  0x00, 0x10, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x80, 0x08, 0x00, 0x10, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x10,
  0x10, 0x00, 0x02, 0x04, 0x00, 0x07, 0xA3, 0x00, 0x03, 0x07, 0x80, 0x00,
  0x80, 0x40, 0x00, 0x20, 0x04, 0x00, 0x04, 0x00, 0x80, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x01, 0x00, 0x10,
  0x00, 0x30, 0x02, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xA0, 0x28, 0x00, 0x24,
  0x0D, 0x00, 0x04, 0x41, 0x10, 0x01, 0x0C, 0x43, 0x00, 0x60, 0x98, 0x38,
  0x38, 0x0A, 0x01, 0xFC, 0x01, 0x80, 0x24, 0x92, 0xD2, 0x49, 0x60, 0x00,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x70, 0x10, 0x0E, 0x0E, 0x10, 0xF0, 0x01, 0xD7,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x48, 0x00, 0x00, 0x84,
  0x00, 0x01, 0x04, 0x00, 0x02, 0x02, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x01,
  0x00, 0x18, 0x01, 0x80, 0x10, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x18, 0x30, 0x41, 0x82, 0x0C, 0x10,
  0x20, 0x81, 0x06, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0x03, 0x00, 0x30, 0x03, 0x01, 0x80, 0x04, 0x0C, 0x00, 0x08, 0x20, 0x00,
  0x21, 0x00, 0x00, 0x84, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x16,
  0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0A, 0x00, 0xC0, 0x28, 0x00, 0x00,
  0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0x20,
  0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00,
  0x10, 0x80, 0x00, 0xC1, 0x00, 0x02, 0x04, 0x00, 0x10, 0x08, 0x01, 0x80,
  0x18, 0x1C, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0xC8, 0x00, 0x06, 0x20, 0x00, 0x61, 0x00, 0x03, 0x04, 0x00, 0x18,
  0x10, 0x01, 0x80, 0x40, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x60, 0x02, 0x00, 0x20, 0x08, 0x00,
  0x20, 0x20, 0x00, 0x60, 0x80, 0x00, 0x41, 0x00, 0x00, 0x82, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x10, 0x00, 0x60,
  0x60, 0x00, 0x40, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x88, 0x00, 0x01, 0x08,
  0x00, 0x04, 0x10, 0x00, 0x18, 0x18, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x24, 0x00, 0x00, 0x44, 0x00, 0x00, 0x84, 0x00,
  0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x08, 0x00,
  0x08, 0x08, 0x00, 0x10, 0x08, 0x00, 0x20, 0x08, 0x00, 0x40, 0x10, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x10, 0x06, 0x00, 0x10, 0x04,
  0x00, 0x30, 0x08, 0x00, 0x20, 0x10, 0x00, 0x20, 0x20, 0x00, 0x20, 0x40,
  0x00, 0x20, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x01, 0xFF, 0xFE, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x3F, 0x80,
  0x09, 0x80, 0xC0, 0x14, 0x00, 0x60, 0x30, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x88, 0x00, 0x02, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x30, 0x10, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x0F, 0xE0, 0x27, 0x03, 0x82, 0xC0, 0x0C, 0x50,
  0x00, 0x66, 0x00, 0x02, 0x60, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x01,
  0x82, 0x00, 0x30, 0x18, 0x0C, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFD, 0x00,
  0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x22, 0x00, 0x01,
  0x88, 0x00, 0x04, 0x20, 0x00, 0x20, 0x80, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x60, 0x04, 0x00, 0x20,
  0x10, 0x00, 0x20, 0x40, 0x00, 0x41, 0x80, 0x00, 0x42, 0x00, 0x00, 0x84,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0x40,
  0x00, 0x20, 0x80, 0x00, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x60, 0x00, 0xFF, 0x00, 0x0E, 0x03, 0x80, 0x60, 0x00, 0x81, 0x80, 0x00,
  0x82, 0x00, 0x01, 0x88, 0x00, 0x01, 0x30, 0x00, 0x02, 0x40, 0x00, 0x04,
  0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x24, 0x00, 0x00, 0x48,
  0x00, 0x01, 0x08, 0x00, 0x06, 0x10, 0x00, 0x18, 0x18, 0x00, 0x60, 0x1C,
  0x07, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x30, 0x18, 0x0C, 0x00,
  0x41, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x24, 0x00, 0x06, 0x60, 0x00, 0xA3,
  0x00, 0x34, 0x18, 0x0E, 0x40, 0x7F, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x38, 0xC0, 0x00,
  0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x08,
  0x04, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xC0,
  0x60, 0x60, 0x02, 0x18, 0x00, 0x62, 0x00, 0x04, 0x80, 0x00, 0xA0, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0xE0, 0x03, 0xE0,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x03, 0x00, 0x60, 0x0C, 0x04,
  0x00, 0x20, 0x60, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00, 0x01,
  0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x03, 0xE2, 0x40, 0x60, 0x92, 0x06,
  0x02, 0x90, 0x20, 0x08, 0x82, 0x00, 0x48, 0x10, 0x02, 0x41, 0x00, 0x12,
  0x08, 0x00, 0x90, 0x40, 0x04, 0x82, 0x00, 0x44, 0x10, 0x02, 0x40, 0x80,
  0x12, 0x04, 0x00, 0x90, 0x20, 0x04, 0x81, 0x00, 0x64, 0x08, 0x06, 0x20,
  0x60, 0x51, 0x01, 0x84, 0x88, 0x07, 0xC4, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x02,
  0x20, 0x00, 0x02, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x10, 0x00, 0x08,
  0x10, 0x00, 0x08, 0x10, 0x00, 0x10, 0x10, 0x00, 0x10, 0x10, 0x00, 0x20,
  0x10, 0x00, 0x20, 0x08, 0x00, 0x40, 0x08, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x04, 0x03, 0xFF,
  0xFC, 0x02, 0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00, 0x04, 0x08, 0x00,
  0x04, 0x08, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x02, 0x20, 0x00,
  0x02, 0x20, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x07, 0xFF,
  0xC0, 0x10, 0x00, 0xC0, 0x40, 0x01, 0x81, 0x00, 0x02, 0x0C, 0x00, 0x04,
  0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x11, 0x80, 0x00, 0x44, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x41, 0x00, 0x02, 0x04, 0x00, 0x30, 0x3F, 0xFF, 0x00, 0x80, 0x03, 0x82,
  0x00, 0x03, 0x08, 0x00, 0x04, 0x20, 0x00, 0x18, 0x80, 0x00, 0x26, 0x00,
  0x00, 0x90, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x01,
  0x90, 0x00, 0x04, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x88, 0x00, 0x04, 0x20,
  0x00, 0x60, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x81, 0x80, 0x18,
  0x01, 0x00, 0xC0, 0x02, 0x06, 0x00, 0x08, 0x10, 0x00, 0x10, 0x80, 0x00,
  0x46, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00,
  0x41, 0x80, 0x03, 0x02, 0x00, 0x18, 0x04, 0x00, 0xC0, 0x0C, 0x0E, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x08, 0x01, 0xC0, 0x10, 0x00, 0xC0,
  0x20, 0x00, 0x40, 0x40, 0x00, 0x80, 0x80, 0x00, 0x83, 0x00, 0x01, 0x04,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0x40,
  0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00,
  0x01, 0x10, 0x00, 0x06, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04,
  0x60, 0x00, 0x08, 0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x01, 0x04,
  0x00, 0x04, 0x08, 0x00, 0x10, 0x30, 0x00, 0x40, 0x40, 0x03, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x82, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x82, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x80, 0x02, 0x04, 0x00, 0x08, 0x30, 0x00, 0x10, 0x80,
  0x00, 0x44, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x07,
  0xFE, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00, 0x04,
  0x80, 0x00, 0x12, 0x00, 0x00, 0x88, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40,
  0x00, 0x61, 0x00, 0x02, 0x82, 0x00, 0x0A, 0x04, 0x00, 0xD0, 0x0C, 0x0E,
  0x40, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00,
  0x01, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x08, 0x00,
  0x02, 0x08, 0x00, 0x02, 0x08, 0x00, 0x02, 0x18, 0x00, 0x04, 0x10, 0x00,
  0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00, 0x04, 0x10, 0x00,
  0x04, 0x30, 0x00, 0x08, 0x3F, 0xFF, 0xF8, 0x20, 0x00, 0x08, 0x20, 0x00,
  0x08, 0x20, 0x00, 0x08, 0x20, 0x00, 0x08, 0x60, 0x00, 0x10, 0x40, 0x00,
  0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x10, 0xC0, 0x00, 0x30, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x80, 0x00,
  0x20, 0x80, 0x00, 0x20, 0x80, 0x00, 0x20, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x81, 0x00,
  0x04, 0x04, 0x00, 0x30, 0x08, 0x01, 0x80, 0x18, 0x1C, 0x00, 0x1F, 0x80,
  0x00, 0x06, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40, 0x40, 0x00, 0x20, 0x10,
  0x00, 0x10, 0x04, 0x00, 0x08, 0x01, 0x00, 0x04, 0x00, 0x80, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x40, 0x00, 0x80, 0x20,
  0x00, 0x20, 0x30, 0x00, 0x10, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x06,
  0x00, 0x00, 0x43, 0x40, 0x00, 0x11, 0x90, 0x00, 0x04, 0x82, 0x00, 0x02,
  0x40, 0x80, 0x00, 0xA0, 0x10, 0x00, 0x30, 0x04, 0x00, 0x08, 0x00, 0x80,
  0x02, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x60, 0x01, 0x00, 0x10, 0x00,
  0x20, 0x04, 0x00, 0x08, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40, 0x10,
  0x00, 0x08, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x80, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x50,
  0x00, 0x18, 0x14, 0x00, 0x0A, 0x05, 0x00, 0x06, 0x83, 0x40, 0x01, 0x20,
  0x88, 0x00, 0x88, 0x22, 0x00, 0x24, 0x08, 0x80, 0x11, 0x02, 0x30, 0x0C,
  0x40, 0x84, 0x02, 0x10, 0x21, 0x01, 0x04, 0x10, 0x40, 0x41, 0x04, 0x08,
  0x20, 0x81, 0x02, 0x18, 0x20, 0x40, 0x84, 0x08, 0x10, 0x22, 0x02, 0x04,
  0x04, 0x80, 0x82, 0x01, 0x40, 0x20, 0x80, 0x60, 0x10, 0x20, 0x08, 0x04,
  0x08, 0x04, 0x01, 0x02, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x40, 0x00,
  0x04, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x08, 0x10, 0x00, 0x02, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x06, 0x00, 0x01, 0x06, 0x00,
  0x01, 0x09, 0x00, 0x02, 0x09, 0x00, 0x02, 0x09, 0x80, 0x02, 0x08, 0x80,
  0x02, 0x08, 0x80, 0x02, 0x08, 0x40, 0x02, 0x10, 0x40, 0x04, 0x10, 0x40,
  0x04, 0x10, 0x20, 0x04, 0x10, 0x20, 0x04, 0x10, 0x20, 0x04, 0x10, 0x10,
  0x04, 0x20, 0x10, 0x08, 0x20, 0x10, 0x08, 0x20, 0x08, 0x08, 0x20, 0x08,
  0x08, 0x20, 0x08, 0x08, 0x20, 0x04, 0x08, 0x40, 0x04, 0x10, 0x40, 0x04,
  0x10, 0x40, 0x02, 0x10, 0x40, 0x02, 0x10, 0x40, 0x02, 0x10, 0x40, 0x01,
  0x10, 0xC0, 0x01, 0x30, 0x80, 0x01, 0xA0, 0x80, 0x00, 0xA0, 0x80, 0x00,
  0xA0, 0x80, 0x00, 0xE0, 0x80, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x03, 0x03,
  0x00, 0x30, 0x03, 0x01, 0x80, 0x04, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x21,
  0x00, 0x00, 0x84, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x16, 0x00,
  0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xA0,
  0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0x20, 0x00,
  0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x10,
  0x80, 0x00, 0xC1, 0x00, 0x02, 0x04, 0x00, 0x10, 0x08, 0x01, 0x80, 0x18,
  0x1C, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x04, 0x00, 0x18, 0x04,
  0x00, 0x04, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08,
  0x00, 0x03, 0x08, 0x00, 0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x06, 0x10,
  0x00, 0x04, 0x10, 0x00, 0x08, 0x10, 0x00, 0x30, 0x1F, 0xFF, 0xC0, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0x03, 0x00, 0x30, 0x03, 0x01, 0x80, 0x04, 0x0C, 0x00, 0x08, 0x20, 0x00,
  0x21, 0x00, 0x00, 0x84, 0x00, 0x01, 0x20, 0x00, 0x04, 0x80, 0x00, 0x16,
  0x00, 0x00, 0x50, 0x00, 0x01, 0x40, 0x00, 0x05, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00,
  0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0x20,
  0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00,
  0x10, 0x80, 0x00, 0xC1, 0x00, 0x02, 0x04, 0x00, 0x10, 0x08, 0x01, 0x80,
  0x18, 0x1C, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x04, 0x00,
  0x20, 0x20, 0x00, 0x41, 0x00, 0x01, 0x88, 0x00, 0x02, 0xC0, 0x00, 0x06,
  0x00, 0x07, 0xFF, 0xF0, 0x04, 0x00, 0x18, 0x04, 0x00, 0x04, 0x04, 0x00,
  0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00,
  0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x03, 0x08, 0x00,
  0x02, 0x18, 0x00, 0x02, 0x10, 0x00, 0x06, 0x10, 0x00, 0x04, 0x10, 0x00,
  0x08, 0x10, 0x00, 0x30, 0x1F, 0xFF, 0xC0, 0x30, 0x10, 0x00, 0x20, 0x08,
  0x00, 0x20, 0x08, 0x00, 0x20, 0x04, 0x00, 0x20, 0x04, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x02, 0x00, 0x40, 0x01, 0x00, 0x40, 0x01, 0x00, 0x40, 0x00,
  0x80, 0x40, 0x00, 0x80, 0x40, 0x00, 0x40, 0xC0, 0x00, 0x40, 0x80, 0x00,
  0x20, 0x80, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x40, 0x00, 0x10, 0x40, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x0E, 0x01, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x08, 0xC0, 0x00, 0x21, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00,
  0x04, 0x60, 0x00, 0x18, 0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x84, 0x00, 0x01, 0x08, 0x00, 0x02, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x10,
  0x80, 0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x01, 0x08,
  0x00, 0x06, 0x20, 0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00,
  0x00, 0x42, 0x00, 0x01, 0x04, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x18, 0x00,
  0x10, 0x10, 0x00, 0x40, 0x30, 0x01, 0x80, 0x38, 0x0C, 0x00, 0x1F, 0xE0,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x12, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x10,
  0x40, 0x00, 0x20, 0x40, 0x00, 0x80, 0x80, 0x01, 0x01, 0x00, 0x04, 0x02,
  0x00, 0x08, 0x04, 0x00, 0x20, 0x08, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x08, 0x00, 0x40, 0x10, 0x00, 0x80, 0x40, 0x01, 0x00,
  0x80, 0x01, 0x02, 0x00, 0x02, 0x04, 0x00, 0x04, 0x10, 0x00, 0x08, 0x20,
  0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0x46, 0x00, 0x00, 0x48, 0x00,
  0x00, 0xB0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x11, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x04, 0x20, 0x00, 0x02, 0x20, 0x00, 0x02, 0x10, 0x06, 0x01, 0x08, 0x03,
  0x00, 0x84, 0x02, 0x80, 0x42, 0x01, 0x40, 0x41, 0x01, 0x20, 0x20, 0x80,
  0x90, 0x10, 0x40, 0x88, 0x08, 0x20, 0x44, 0x08, 0x10, 0x41, 0x04, 0x08,
  0x20, 0x82, 0x04, 0x20, 0x41, 0x02, 0x10, 0x21, 0x01, 0x18, 0x10, 0x80,
  0x88, 0x08, 0x40, 0x84, 0x04, 0x60, 0x44, 0x02, 0x20, 0x22, 0x00, 0x90,
  0x12, 0x00, 0x48, 0x09, 0x00, 0x28, 0x05, 0x00, 0x14, 0x02, 0x80, 0x0A,
  0x01, 0x80, 0x05, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x08, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x0C,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x04, 0x00,
  0x40, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x40, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x1A, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x01, 0x00, 0x80, 0x00, 0x18, 0x04, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x08, 0x00, 0x80, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x08,
  0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x00, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x40, 0x20, 0x00, 0x40, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x01, 0x00, 0x20, 0x00, 0x80, 0x20, 0x00, 0x20, 0x20,
  0x00, 0x10, 0x20, 0x00, 0x04, 0x30, 0x00, 0x02, 0x10, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x01, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x1F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x28, 0x00,
  0x01, 0x20, 0x00, 0x0C, 0x40, 0x00, 0x21, 0x00, 0x01, 0x04, 0x00, 0x08,
  0x08, 0x00, 0x40, 0x20, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x02,
  0x02, 0x00, 0x08, 0x18, 0x00, 0x30, 0x40, 0x00, 0x42, 0x00, 0x01, 0x10,
  0x00, 0x02, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFC, 0x82,
  0x18, 0x41, 0x08, 0x21, 0x00, 0x7E, 0x00, 0x0C, 0x0C, 0x41, 0x80, 0x12,
  0x18, 0x00, 0x50, 0x80, 0x02, 0x88, 0x00, 0x0C, 0xC0, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x24,
  0x00, 0x02, 0x60, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00,
  0x24, 0x00, 0x03, 0x20, 0x00, 0x10, 0x80, 0x00, 0x84, 0x00, 0x0C, 0x20,
  0x00, 0xA0, 0x80, 0x09, 0x02, 0x00, 0xC8, 0x0C, 0x18, 0x78, 0x3F, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x0F, 0xC0, 0x11, 0x83, 0x81, 0x90, 0x06, 0x09,
  0x00, 0x10, 0x50, 0x00, 0x43, 0x00, 0x02, 0x18, 0x00, 0x10, 0x80, 0x00,
  0x4C, 0x00, 0x02, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80,
  0x00, 0x24, 0x00, 0x03, 0x60, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04,
  0x80, 0x00, 0x64, 0x00, 0x02, 0x20, 0x00, 0x13, 0x00, 0x01, 0x14, 0x00,
  0x18, 0xA0, 0x01, 0x84, 0x80, 0x18, 0x23, 0x03, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x70, 0x30, 0x10, 0x03, 0x04, 0x00, 0x21, 0x00, 0x02,
  0x40, 0x00, 0x48, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x01, 0x40, 0x00, 0x34,
  0x00, 0x08, 0x80, 0x03, 0x08, 0x00, 0xC1, 0x80, 0x30, 0x1C, 0x1C, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x01, 0xF8, 0x20, 0x0C, 0x0C,
  0x40, 0x60, 0x04, 0x81, 0x80, 0x05, 0x02, 0x00, 0x0A, 0x08, 0x00, 0x0C,
  0x30, 0x00, 0x10, 0x40, 0x00, 0x20, 0x80, 0x00, 0x42, 0x00, 0x00, 0x84,
  0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x08, 0x60, 0x00, 0x10, 0x80,
  0x00, 0x21, 0x00, 0x00, 0x42, 0x00, 0x00, 0x84, 0x00, 0x03, 0x08, 0x00,
  0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x30, 0x20, 0x00, 0xA0, 0x20, 0x03,
  0x40, 0x20, 0x0C, 0x80, 0x30, 0x72, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x18, 0x1C, 0x06, 0x00, 0x60, 0x80, 0x02, 0x10, 0x00, 0x31, 0x00,
  0x01, 0x20, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x04, 0x80,
  0x00, 0x88, 0x00, 0x70, 0x80, 0x78, 0x0F, 0xF8, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x28, 0x00, 0x04,
  0x40, 0x00, 0x44, 0x00, 0x08, 0x20, 0x01, 0x03, 0x00, 0x20, 0x1C, 0x0C,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x01, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0x03, 0x10, 0x30, 0x02, 0x41, 0x80, 0x05, 0x04, 0x00,
  0x14, 0x20, 0x00, 0x31, 0x80, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08,
  0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x11, 0x80,
  0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00,
  0xC4, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x60, 0x80, 0x02, 0x81,
  0x00, 0x12, 0x02, 0x00, 0xC8, 0x06, 0x0C, 0x40, 0x0F, 0xE1, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x40, 0x60, 0x06, 0x00, 0xC0, 0x70, 0x00, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x20, 0xFC, 0x04, 0x60, 0x40, 0x90, 0x04, 0x14, 0x00, 0x43, 0x00, 0x08,
  0xC0, 0x01, 0x18, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x11,
  0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x03, 0x20, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x80, 0x01, 0x90,
  0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x03, 0x01, 0x00,
  0xC0, 0x10, 0x18, 0x02, 0x06, 0x00, 0x20, 0xC0, 0x02, 0x10, 0x00, 0x26,
  0x00, 0x02, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x0C, 0x00, 0x80, 0xC0, 0x10,
  0x04, 0x06, 0x00, 0x40, 0x80, 0x04, 0x10, 0x00, 0x62, 0x00, 0x06, 0x40,
  0x00, 0x68, 0x00, 0x06, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0xFC,
  0x00, 0x46, 0x06, 0x01, 0x10, 0x02, 0x02, 0x40, 0x04, 0x05, 0x00, 0x04,
  0x0C, 0x00, 0x08, 0x10, 0x00, 0x10, 0x20, 0x00, 0x60, 0xC0, 0x00, 0x81,
  0x00, 0x03, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x08, 0x01, 0x80, 0x10,
  0x1C, 0x00, 0x41, 0xC0, 0x00, 0x81, 0x00, 0x01, 0x02, 0x00, 0x02, 0x02,
  0x00, 0x14, 0x04, 0x00, 0x48, 0x04, 0x01, 0x20, 0x08, 0x04, 0x40, 0x08,
  0x10, 0x80, 0x18, 0x41, 0x00, 0x11, 0x02, 0x00, 0x14, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x20, 0x80,
  0x30, 0x80, 0x20, 0x40, 0x60, 0x20, 0x60, 0x10, 0xC0, 0x08, 0xC0, 0x08,
  0x80, 0x05, 0x80, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x3E, 0x04, 0x86, 0x21,
  0x82, 0x81, 0x20, 0x41, 0x80, 0xA0, 0x31, 0x80, 0x60, 0x08, 0xC0, 0x30,
  0x04, 0x40, 0x10, 0x04, 0x20, 0x08, 0x02, 0x10, 0x04, 0x01, 0x08, 0x02,
  0x00, 0x88, 0x01, 0x00, 0x44, 0x01, 0x00, 0x22, 0x00, 0x80, 0x21, 0x00,
  0x40, 0x10, 0x80, 0x20, 0x08, 0x40, 0x10, 0x04, 0x40, 0x08, 0x02, 0x20,
  0x08, 0x01, 0x10, 0x04, 0x01, 0x08, 0x02, 0x00, 0x84, 0x01, 0x00, 0x42,
  0x00, 0x80, 0x22, 0x00, 0x40, 0x11, 0x00, 0x40, 0x08, 0x80, 0x20, 0x08,
  0x00, 0x00, 0x3F, 0x01, 0x18, 0x10, 0x24, 0x01, 0x05, 0x00, 0x10, 0xC0,
  0x02, 0x30, 0x00, 0x46, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00,
  0x04, 0x40, 0x00, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00,
  0x11, 0x00, 0x02, 0x20, 0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00,
  0x64, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x24, 0x00, 0x04, 0x80, 0x00,
  0x80, 0x00, 0xFE, 0x00, 0x30, 0x18, 0x04, 0x00, 0x40, 0x80, 0x02, 0x10,
  0x00, 0x23, 0x00, 0x01, 0x20, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x04, 0x80, 0x00, 0x44, 0x00, 0x08, 0x60, 0x01, 0x03, 0x00,
  0x20, 0x1C, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x04, 0x60, 0xE0,
  0x09, 0x00, 0x60, 0x24, 0x00, 0x40, 0x50, 0x00, 0x40, 0xC0, 0x00, 0x81,
  0x80, 0x01, 0x02, 0x00, 0x01, 0x04, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20,
  0x00, 0x08, 0x40, 0x00, 0x10, 0x80, 0x00, 0x21, 0x00, 0x00, 0xC6, 0x00,
  0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x18, 0x40, 0x00,
  0x20, 0x80, 0x00, 0x43, 0x00, 0x01, 0x05, 0x00, 0x06, 0x0A, 0x00, 0x18,
  0x12, 0x00, 0x60, 0x23, 0x03, 0x80, 0x41, 0xF8, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0C,
  0x0C, 0x41, 0x80, 0x12, 0x18, 0x00, 0x50, 0x80, 0x02, 0x88, 0x00, 0x0C,
  0xC0, 0x00, 0x44, 0x00, 0x02, 0x20, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00,
  0x04, 0x80, 0x00, 0x24, 0x00, 0x02, 0x60, 0x00, 0x12, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x03, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x84, 0x00, 0x0C, 0x20, 0x00, 0xA0, 0x80, 0x09, 0x02, 0x00, 0xC8, 0x0C,
  0x18, 0x80, 0x3F, 0x84, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0xFF, 0x87, 0xFC, 0x02, 0x60, 0x00, 0x0A, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0E,
  0x03, 0x80, 0x60, 0x01, 0x02, 0x00, 0x02, 0x08, 0x00, 0x0C, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x44, 0x00, 0x02, 0x0C,
  0x00, 0x10, 0x0C, 0x03, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x60, 0x08,
  0x01, 0x80, 0x10, 0x0C, 0x00, 0x20, 0x20, 0x00, 0x41, 0x80, 0x00, 0x8C,
  0x00, 0x02, 0x20, 0x00, 0x05, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x24, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00,
  0x88, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x11, 0x00, 0x02,
  0x20, 0x00, 0x44, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x08,
  0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x02, 0x88, 0x00, 0x51,
  0x00, 0x14, 0x10, 0x04, 0x81, 0x83, 0x10, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x10, 0x10, 0x00, 0x80, 0x80, 0x02, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82,
  0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x08, 0x20, 0x00,
  0x82, 0x00, 0x04, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x10, 0x20,
  0x00, 0x81, 0x00, 0x08, 0x08, 0x00, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x40,
  0x20, 0x0C, 0x01, 0x00, 0xC0, 0x08, 0x1C, 0x00, 0x43, 0x80, 0x03, 0xE0,
  0x00, 0x08, 0x06, 0x04, 0x10, 0x04, 0x02, 0x10, 0x04, 0x02, 0x10, 0x04,
  0x02, 0x10, 0x04, 0x02, 0x10, 0x04, 0x02, 0x10, 0x08, 0x01, 0x20, 0x08,
  0x01, 0x20, 0x08, 0x01, 0x20, 0x08, 0x01, 0x20, 0x08, 0x01, 0x20, 0x08,
  0x03, 0x20, 0x10, 0x02, 0x40, 0x10, 0x02, 0x40, 0x10, 0x02, 0x40, 0x10,
  0x02, 0x40, 0x10, 0x02, 0x40, 0x10, 0x04, 0x40, 0x30, 0x04, 0x80, 0x60,
  0x04, 0x80, 0x60, 0x08, 0x80, 0x50, 0x18, 0x40, 0x90, 0x30, 0x61, 0x08,
  0x60, 0x3E, 0x07, 0x80, 0x00, 0x60, 0x0F, 0x00, 0x64, 0x0C, 0x20, 0xE1,
  0x84, 0x04, 0xC0, 0x22, 0x01, 0x40, 0x08, 0x80, 0x40, 0x02, 0x40, 0x10,
  0x00, 0x50, 0x04, 0x00, 0x18, 0x01, 0x00, 0x06, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x20,
  0x05, 0x00, 0x08, 0x01, 0x40, 0x02, 0x00, 0x50, 0x00, 0x80, 0x24, 0x00,
  0x20, 0x09, 0x00, 0x68, 0x04, 0x20, 0x61, 0x02, 0x08, 0x60, 0x61, 0x01,
  0x30, 0x07, 0x80, 0x70, 0x00, 0x02, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40,
  0x00, 0x41, 0x00, 0x02, 0x04, 0x00, 0x08, 0x10, 0x00, 0x20, 0x40, 0x00,
  0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x40, 0x80, 0x01, 0x02,
  0x00, 0x04, 0x08, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00,
  0x08, 0x10, 0x00, 0x20, 0x40, 0x00, 0x81, 0x00, 0x06, 0x04, 0x00, 0x28,
  0x10, 0x00, 0xA0, 0x40, 0x05, 0x00, 0x80, 0x24, 0x01, 0x83, 0x10, 0x03,
  0xF0, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x08, 0x00, 0x30, 0x10, 0x01, 0x80, 0x30, 0x18, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x1C, 0x04, 0x30, 0x07, 0x08,
  0x40, 0x01, 0x90, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x04, 0x00, 0x04, 0x08,
  0x00, 0x30, 0x10, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x10, 0x04, 0x00, 0x20, 0x10, 0x00, 0x40, 0x40, 0x00,
  0x81, 0x00, 0x01, 0x0C, 0x00, 0x02, 0x17, 0x80, 0x04, 0x20, 0xF8, 0x04,
  0x40, 0x0F, 0x89, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x0F, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x80, 0x0F,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x31, 0x80, 0x04,
  0x80, 0x80, 0x0B, 0x01, 0x80, 0x24, 0x01, 0x80, 0xD0, 0x01, 0x01, 0x20,
  0x01, 0x8C, 0x40, 0x01, 0xF0,
};

const GFXglyph IBMPlexMono_ThinItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 7, 33, 28, 11, -33 },
  { 30, 10, 12, 28, 12, -35 },
  { 45, 28, 33, 28, 1, -33 },
  { 161, 25, 44, 28, 2, -38 },
  { 299, 31, 34, 28, -1, -33 },
  { 431, 27, 34, 28, 1, -33 },
  { 546, 3, 12, 28, 15, -35 },
  { 551, 15, 42, 28, 11, -36 },
  { 630, 15, 42, 28, 3, -36 },
  { 709, 24, 23, 28, 3, -26 },
  { 778, 23, 23, 28, 3, -26 },
  { 845, 7, 12, 28, 7, -4 },
  { 856, 13, 1, 28, 8, -15 },
  { 858, 3, 3, 28, 11, -3 },
  { 860, 25, 42, 28, 2, -36 },
  { 992, 22, 34, 28, 4, -33 },
  { 1086, 22, 33, 28, 2, -33 },
  { 1177, 23, 33, 28, 2, -33 },
  { 1272, 23, 34, 28, 2, -33 },
  { 1370, 24, 33, 28, 1, -33 },
  { 1469, 23, 34, 28, 3, -33 },
  { 1567, 20, 34, 28, 4, -33 },
  { 1652, 22, 33, 28, 6, -33 },
  { 1743, 23, 34, 28, 3, -33 },
  { 1841, 20, 33, 28, 5, -33 },
  { 1924, 6, 25, 28, 11, -25 },
  { 1943, 10, 33, 28, 7, -25 },
  { 1985, 23, 25, 28, 4, -27 },
  { 2057, 24, 9, 28, 2, -19 },
  { 2084, 23, 25, 28, 2, -27 },
  { 2156, 19, 33, 28, 7, -33 },
  { 2235, 21, 38, 28, 4, -33 },
  { 2335, 24, 33, 28, 0, -33 },
  { 2434, 22, 33, 28, 3, -33 },
  { 2525, 22, 34, 28, 4, -33 },
  { 2619, 23, 33, 28, 3, -33 },
  { 2714, 25, 33, 28, 3, -33 },
  { 2818, 25, 33, 28, 3, -33 },
  { 2922, 22, 34, 28, 4, -33 },
  { 3016, 24, 33, 28, 3, -33 },
  { 3115, 25, 33, 28, 2, -33 },
  { 3219, 22, 34, 28, 3, -33 },
  { 3313, 26, 33, 28, 3, -33 },
  { 3421, 18, 33, 28, 5, -33 },
  { 3496, 26, 33, 28, 2, -33 },
  { 3604, 24, 33, 28, 3, -33 },
  { 3703, 22, 34, 28, 4, -33 },
  { 3797, 24, 33, 28, 3, -33 },
  { 3896, 22, 41, 28, 4, -33 },
  { 4009, 24, 33, 28, 3, -33 },
  { 4108, 25, 34, 28, 2, -33 },
  { 4215, 25, 33, 28, 5, -33 },
  { 4319, 23, 34, 28, 4, -33 },
  { 4417, 23, 33, 28, 6, -33 },
  { 4512, 25, 33, 28, 4, -33 },
  { 4616, 29, 33, 28, 0, -33 },
  { 4736, 25, 33, 28, 5, -33 },
  { 4840, 28, 33, 28, 0, -33 },
  { 4956, 19, 42, 28, 9, -36 },
  { 5056, 11, 42, 28, 9, -36 },
  { 5114, 19, 42, 28, 1, -36 },
  { 5214, 22, 18, 28, 4, -33 },
  { 5264, 22, 1, 28, 0, 6 },
  { 5267, 5, 8, 28, 11, -36 },
  { 5272, 21, 26, 28, 3, -25 },
  { 5341, 21, 36, 28, 4, -35 },
  { 5436, 19, 26, 28, 4, -25 },
  { 5498, 23, 36, 28, 3, -35 },
  { 5602, 20, 26, 28, 4, -25 },
  { 5667, 29, 45, 28, 0, -35 },
  { 5831, 22, 35, 28, 2, -25 },
  { 5928, 19, 35, 28, 4, -35 },
  { 6012, 20, 36, 28, 4, -35 },
  { 6102, 19, 45, 28, 5, -35 },
  { 6209, 23, 36, 28, 4, -35 },
  { 6313, 17, 36, 28, 6, -35 },
  { 6390, 25, 25, 28, 2, -25 },
  { 6469, 19, 25, 28, 4, -25 },
  { 6529, 20, 26, 28, 4, -25 },
  { 6594, 23, 34, 28, 2, -25 },
  { 6692, 21, 34, 28, 3, -25 },
  { 6782, 22, 24, 28, 6, -24 },
  { 6848, 22, 26, 28, 3, -25 },
  { 6920, 23, 34, 28, 4, -33 },
  { 7018, 19, 25, 28, 5, -24 },
  { 7078, 21, 24, 28, 4, -24 },
  { 7141, 24, 25, 28, 3, -24 },
  { 7216, 26, 26, 28, 1, -25 },
  { 7301, 22, 34, 28, 2, -24 },
  { 7395, 23, 26, 28, 2, -25 },
  { 7470, 21, 42, 28, 6, -36 },
  { 7581, 8, 42, 28, 11, -36 },
  { 7623, 21, 42, 28, 2, -36 },
  { 7734, 23, 8, 28, 3, -18 },
};

const GFXfont IBMPlexMono_ThinItalic47pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic47pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic47pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _IBMPLEXMONO_THINITALIC47PT7B_H_
