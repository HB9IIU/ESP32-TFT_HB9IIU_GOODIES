#ifndef _IBMPLEXMONO_THINITALIC66PT7B_H_
#define _IBMPLEXMONO_THINITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x18,
  0x08, 0x80, 0xC4, 0x06, 0x60, 0x33, 0x01, 0x98, 0x08, 0xC0, 0x44, 0x06,
  0x20, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x46, 0x02, 0x20, 0x31, 0x01, 0x98,
  0x0C, 0xC0, 0x60, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x18, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x20, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0x06, 0x3C, 0x00, 0x03, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x06, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x40, 0x03, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x04, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x00, 0x10, 0x02, 0x00, 0x00, 0x03, 0x00, 0x40, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x0F, 0x40, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0x3C, 0x00, 0x00, 0x00, 0x20, 0xE0,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x06, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0x40, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x20, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x01, 0x82, 0x00, 0x08, 0x00, 0x20, 0xE0, 0x01, 0x00, 0x0C, 0x04, 0x00,
  0x20, 0x03, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x30, 0x00,
  0x70, 0x30, 0x0C, 0x00, 0x03, 0xC4, 0x0E, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x80, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00, 0x30, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x04,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x00, 0x20, 0x18, 0x00,
  0x01, 0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x00, 0x40, 0x20, 0x00, 0x01,
  0x80, 0x0C, 0x04, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x80, 0x00, 0x00, 0x60,
  0x60, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x18, 0x0E, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x20, 0x00,
  0x00, 0x60, 0x20, 0x01, 0x00, 0x00, 0x04, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x20, 0x18, 0x00, 0x08, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x10, 0x00, 0x08, 0x00, 0x18, 0x01, 0x00, 0x00,
  0x80, 0x03, 0x00, 0x10, 0x00, 0x18, 0x00, 0x20, 0x01, 0x00, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x10, 0x00, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x01, 0x00, 0x01, 0x80, 0x02, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x30, 0x00, 0x00, 0x70, 0xC3,
  0x00, 0x00, 0x06, 0x01, 0x70, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x01,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0xA0, 0x00, 0x01, 0x30, 0x06, 0xC0, 0x00, 0x04, 0x40, 0x11, 0x00,
  0x00, 0x31, 0x80, 0x84, 0x00, 0x00, 0x83, 0x06, 0x08, 0x00, 0x04, 0x04,
  0x10, 0x30, 0x00, 0x30, 0x18, 0xC0, 0x60, 0x01, 0x80, 0x26, 0x00, 0x60,
  0x38, 0x00, 0xD0, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x33, 0x32, 0x26, 0x66,
  0x64, 0x4C, 0xCC, 0xC8, 0x80, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xCF, 0x00, 0x30, 0x07,
  0xC0, 0x78, 0x08, 0x0F, 0x80, 0x03, 0xC2, 0x1E, 0x00, 0x00, 0x1E, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x19,
  0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x30, 0x18, 0x18,
  0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x00, 0x40, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x70, 0x00, 0x50, 0x00, 0xE0,
  0x01, 0xA0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x04,
  0x80, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x10,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x80, 0xC0,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x38, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x04, 0x00,
  0x03, 0x80, 0x10, 0x00, 0x18, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x80, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x03, 0x01, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x08, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0xC0,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x01, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x01, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x40, 0x00, 0x01, 0x80, 0x20, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x80,
  0x02, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0x60, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC1, 0xFF, 0x00, 0x00,
  0x43, 0x80, 0x70, 0x00, 0x26, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x18, 0x1F, 0xF0, 0x00, 0x87, 0x00, 0xE0, 0x0C, 0xE0, 0x00, 0xC0, 0x4C,
  0x00, 0x03, 0x06, 0xC0, 0x00, 0x0C, 0x2C, 0x00, 0x00, 0x21, 0x40, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x04, 0xE0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x40, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x03, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x10, 0x30,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x02, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x40, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x0A, 0x60, 0x00, 0x01, 0x63, 0x00, 0x00, 0x34, 0x18,
  0x00, 0x06, 0xC0, 0xC0, 0x01, 0x8C, 0x07, 0x00, 0xE1, 0x80, 0x0F, 0xF8,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0, 0x78,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x00,
  0x40, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0x20, 0x0C,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x40, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x04, 0x10, 0x00, 0x00, 0x10, 0x40, 0x03, 0xF0, 0x43, 0x00, 0x30, 0x31,
  0x08, 0x01, 0x00, 0x2C, 0x20, 0x08, 0x00, 0xB1, 0x80, 0x40, 0x01, 0xC6,
  0x03, 0x00, 0x06, 0x10, 0x08, 0x00, 0x18, 0x40, 0x20, 0x00, 0x21, 0x01,
  0x80, 0x01, 0x8C, 0x04, 0x00, 0x06, 0x30, 0x10, 0x00, 0x18, 0x80, 0x40,
  0x00, 0x42, 0x03, 0x00, 0x01, 0x08, 0x0C, 0x00, 0x04, 0x60, 0x20, 0x00,
  0x31, 0x80, 0x80, 0x00, 0xC6, 0x02, 0x00, 0x03, 0x10, 0x08, 0x00, 0x08,
  0x40, 0x20, 0x00, 0x21, 0x00, 0x80, 0x01, 0x84, 0x02, 0x00, 0x06, 0x10,
  0x08, 0x00, 0x38, 0xC0, 0x30, 0x00, 0xE3, 0x00, 0x40, 0x05, 0x0C, 0x01,
  0x80, 0x24, 0x30, 0x03, 0x03, 0x10, 0xC0, 0x03, 0xF8, 0x43, 0x00, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x00, 0x20, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x40, 0x60, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x03, 0x00, 0x20, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x04, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x20, 0x00, 0x08, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0xC0, 0x20,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x08, 0x10, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06,
  0x01, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x00, 0x82, 0x00, 0x00, 0x01, 0x0C,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x04, 0x00, 0x01, 0x80, 0x10, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x06, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x00, 0x80, 0x40, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x10,
  0x01, 0x80, 0x00, 0x08, 0x01, 0x00, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x04,
  0x01, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01,
  0x06, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x02,
  0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x04,
  0x10, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x00, 0x80, 0x60, 0x00, 0x01, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x40, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x02, 0x06, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x07, 0xFF, 0xE4, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x42, 0x00, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x60, 0x40, 0x00, 0x01, 0x40, 0xC0,
  0x00, 0x02, 0x80, 0x80, 0x00, 0x0B, 0x01, 0x80, 0x00, 0x26, 0x01, 0x80,
  0x00, 0xC8, 0x01, 0x80, 0x02, 0x10, 0x00, 0xE0, 0x38, 0x20, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00,
  0x10, 0x18, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x30, 0x04, 0x00, 0x01, 0x80, 0x08, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x38, 0x04, 0x00, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x00, 0x40, 0x70,
  0x00, 0x00, 0x06, 0x06, 0xC0, 0x00, 0x00, 0x30, 0x62, 0x00, 0x00, 0x01,
  0x06, 0x18, 0x00, 0x00, 0x08, 0x60, 0x40, 0x00, 0x00, 0x44, 0x03, 0x00,
  0x00, 0x02, 0x40, 0x08, 0x00, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x40, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07, 0x01, 0x40, 0x00, 0x00, 0xE0,
  0x14, 0x00, 0x00, 0x1A, 0x01, 0x60, 0x00, 0x01, 0x20, 0x32, 0x00, 0x00,
  0x36, 0x03, 0x20, 0x00, 0x02, 0x60, 0x33, 0x00, 0x00, 0x66, 0x02, 0x10,
  0x00, 0x0C, 0x40, 0x21, 0x00, 0x00, 0x84, 0x02, 0x10, 0x00, 0x18, 0x40,
  0x61, 0x80, 0x03, 0x0C, 0x06, 0x08, 0x00, 0x20, 0xC0, 0x60, 0x80, 0x06,
  0x0C, 0x04, 0x0C, 0x00, 0x40, 0x80, 0x40, 0x40, 0x0C, 0x08, 0x04, 0x04,
  0x01, 0x80, 0x80, 0xC0, 0x40, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x20, 0x18, 0x08, 0x02, 0x04, 0x01, 0x00, 0x80, 0x30, 0xC0,
  0x10, 0x08, 0x01, 0x08, 0x01, 0x01, 0x80, 0x11, 0x80, 0x30, 0x18, 0x01,
  0x30, 0x03, 0x01, 0x80, 0x1A, 0x00, 0x30, 0x10, 0x00, 0xE0, 0x02, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x10, 0x00, 0xC0, 0x02, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x30, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x20, 0x00,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x00, 0x08, 0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x30, 0x14, 0x00,
  0x00, 0x0C, 0x05, 0x80, 0x00, 0x02, 0x01, 0x20, 0x00, 0x00, 0x80, 0xC8,
  0x00, 0x00, 0x20, 0x33, 0x00, 0x00, 0x18, 0x08, 0x40, 0x00, 0x06, 0x02,
  0x10, 0x00, 0x01, 0x80, 0x86, 0x00, 0x00, 0x40, 0x20, 0x80, 0x00, 0x10,
  0x18, 0x20, 0x00, 0x04, 0x06, 0x0C, 0x00, 0x03, 0x01, 0x01, 0x00, 0x00,
  0xC0, 0x40, 0x60, 0x00, 0x30, 0x10, 0x18, 0x00, 0x08, 0x04, 0x02, 0x00,
  0x02, 0x03, 0x00, 0xC0, 0x00, 0x80, 0xC0, 0x30, 0x00, 0x60, 0x20, 0x04,
  0x00, 0x18, 0x08, 0x01, 0x80, 0x06, 0x02, 0x00, 0x20, 0x01, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x60, 0x03, 0x00, 0x10, 0x18, 0x00, 0x40, 0x0C, 0x04,
  0x00, 0x10, 0x03, 0x01, 0x00, 0x06, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x20,
  0x10, 0x00, 0x20, 0x08, 0x0C, 0x00, 0x0C, 0x02, 0x03, 0x00, 0x01, 0x01,
  0x80, 0x80, 0x00, 0x40, 0x60, 0x20, 0x00, 0x18, 0x18, 0x08, 0x00, 0x02,
  0x04, 0x02, 0x00, 0x00, 0xC1, 0x01, 0x80, 0x00, 0x30, 0x40, 0x60, 0x00,
  0x04, 0x30, 0x10, 0x00, 0x01, 0x8C, 0x04, 0x00, 0x00, 0x63, 0x01, 0x00,
  0x00, 0x08, 0x80, 0x40, 0x00, 0x03, 0x20, 0x30, 0x00, 0x00, 0x48, 0x0C,
  0x00, 0x00, 0x16, 0x02, 0x00, 0x00, 0x07, 0x80, 0x80, 0x00, 0x00, 0xE0,
  0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x60, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x01, 0x00, 0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x02,
  0x06, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x00, 0x11, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x02, 0x40,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x10, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x08, 0x00,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x18,
  0x04, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x60, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x03, 0x01, 0x80, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x20, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x06, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x08,
  0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00,
  0x18, 0x04, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x04, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x18, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x00, 0x0C, 0x01, 0x00, 0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x00, 0x04, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x08,
  0x10, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x80,
  0x80, 0x00, 0x00, 0x80, 0x80, 0x00, 0x01, 0x80, 0x80, 0x00, 0x01, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x40, 0x00, 0x03, 0x00, 0x20, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x80, 0x00, 0x60, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x02, 0x01, 0x80, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x02, 0x10, 0x00,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x00, 0x21, 0x80, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x81, 0x00, 0x00, 0x00, 0x08, 0x10,
  0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x03, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x30, 0x01, 0xC0, 0x02, 0x03, 0x00, 0x16, 0x00, 0x20, 0x30,
  0x03, 0x60, 0x06, 0x03, 0x00, 0x26, 0x00, 0x40, 0x30, 0x06, 0x20, 0x04,
  0x03, 0x00, 0x42, 0x00, 0x40, 0x20, 0x0C, 0x20, 0x0C, 0x02, 0x00, 0x82,
  0x00, 0x80, 0x20, 0x18, 0x30, 0x08, 0x02, 0x01, 0x03, 0x01, 0x80, 0x20,
  0x10, 0x30, 0x18, 0x02, 0x03, 0x01, 0x01, 0x00, 0x20, 0x20, 0x10, 0x10,
  0x02, 0x06, 0x01, 0x03, 0x00, 0x20, 0x40, 0x10, 0x30, 0x06, 0x0C, 0x01,
  0x02, 0x00, 0x60, 0x80, 0x18, 0x20, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x00, 0x18, 0x60, 0x06, 0x30, 0x00, 0x84, 0x00, 0x62, 0x00, 0x08, 0x40,
  0x04, 0x60, 0x00, 0x8C, 0x00, 0x44, 0x00, 0x08, 0x80, 0x04, 0x40, 0x00,
  0x88, 0x00, 0x4C, 0x00, 0x0D, 0x80, 0x04, 0x80, 0x00, 0xD8, 0x00, 0x58,
  0x00, 0x0D, 0x00, 0x05, 0x00, 0x00, 0x50, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x82, 0x00,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x10, 0x00,
  0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x01, 0x80,
  0x04, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFE, 0x81, 0x81, 0x83, 0x03,
  0x02, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80,
  0x60, 0x40, 0x30, 0x00, 0xC2, 0x02, 0x00, 0x03, 0x30, 0x20, 0x00, 0x0D,
  0x82, 0x00, 0x00, 0x2C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x04,
  0x00, 0x00, 0x38, 0x20, 0x00, 0x02, 0xC1, 0x80, 0x00, 0x24, 0x04, 0x00,
  0x03, 0x20, 0x10, 0x00, 0x31, 0x00, 0x60, 0x03, 0x18, 0x01, 0xC0, 0x60,
  0x7E, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x1F,
  0xC0, 0x00, 0x83, 0x80, 0xC0, 0x02, 0x18, 0x00, 0xC0, 0x18, 0x80, 0x01,
  0x80, 0x64, 0x00, 0x02, 0x01, 0xA0, 0x00, 0x04, 0x05, 0x80, 0x00, 0x18,
  0x14, 0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x83, 0x80, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x42, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x04, 0x1C, 0x00,
  0x00, 0x30, 0x58, 0x00, 0x01, 0x81, 0x20, 0x00, 0x0C, 0x04, 0x40, 0x00,
  0x60, 0x10, 0xC0, 0x03, 0x00, 0xC1, 0xC0, 0x70, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x01, 0x80,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x40, 0x60, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x30, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x0F, 0xF0, 0x08, 0x00, 0x70, 0x0C, 0x08, 0x00,
  0xC0, 0x03, 0x08, 0x01, 0x00, 0x01, 0x98, 0x02, 0x00, 0x00, 0xD8, 0x04,
  0x00, 0x00, 0x50, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x10,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x20, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x40, 0x80,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x80, 0x80, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x80, 0x40, 0x00, 0x03, 0x80, 0x40,
  0x00, 0x05, 0x80, 0x60, 0x00, 0x0D, 0x00, 0x20, 0x00, 0x19, 0x00, 0x10,
  0x00, 0x31, 0x00, 0x0C, 0x00, 0x63, 0x00, 0x07, 0x01, 0x83, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x20, 0x20, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x0C, 0x04, 0x00, 0x0F, 0x00, 0x40, 0x3F, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x01, 0x01, 0x80, 0x00, 0x20, 0x0C, 0x00, 0x04, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x38, 0x06, 0x04, 0x00, 0xC0, 0x03, 0x08, 0x02, 0x00, 0x03, 0x30,
  0x08, 0x00, 0x03, 0x60, 0x20, 0x00, 0x02, 0xC0, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x20, 0x40, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x01, 0x00, 0x00, 0x0E,
  0x02, 0x00, 0x00, 0x2C, 0x06, 0x00, 0x00, 0x90, 0x04, 0x00, 0x03, 0x20,
  0x04, 0x00, 0x0C, 0x40, 0x06, 0x00, 0x31, 0x80, 0x07, 0x01, 0x83, 0x00,
  0x03, 0xFC, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0xFE, 0x00, 0x30, 0x60, 0x30,
  0x06, 0x30, 0x01, 0x80, 0xC8, 0x00, 0x10, 0x12, 0x00, 0x03, 0x02, 0x40,
  0x00, 0x20, 0x50, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0x60, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x08, 0x03, 0x00, 0x02, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x01, 0x00, 0x30, 0x00, 0x20, 0x08, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x81, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x20, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x20, 0x0E, 0x00, 0x04, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0x60, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x20, 0x10,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x07, 0xF8, 0x00, 0x04,
  0x0C, 0x03, 0x00, 0x02, 0x18, 0x00, 0x40, 0x03, 0x10, 0x00, 0x10, 0x01,
  0x90, 0x00, 0x0C, 0x00, 0x90, 0x00, 0x02, 0x00, 0x50, 0x00, 0x01, 0x00,
  0x28, 0x00, 0x00, 0x80, 0x18, 0x00, 0x00, 0x40, 0x1C, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x20, 0x00, 0x70, 0x00, 0x10, 0x00, 0xC0,
  0x00, 0x08, 0x07, 0x80, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x02, 0x40, 0x0C, 0x00, 0x02, 0x20, 0x02, 0x00, 0x06, 0x30, 0x00,
  0x80, 0x06, 0x18, 0x00, 0x60, 0x06, 0x0C, 0x00, 0x10, 0x06, 0x04, 0x00,
  0x0C, 0x06, 0x02, 0x00, 0x02, 0x06, 0x01, 0x00, 0x01, 0x86, 0x01, 0x80,
  0x00, 0x46, 0x00, 0xC0, 0x00, 0x16, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x0C, 0x04,
  0x00, 0x0C, 0x02, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x80, 0x10, 0x00,
  0xC0, 0x30, 0x00, 0x40, 0x20, 0x00, 0x20, 0x60, 0x00, 0x30, 0x40, 0x00,
  0x18, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x05, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x3E, 0x01, 0x8C, 0x30, 0x30, 0x40, 0x64, 0x02,
  0x10, 0x08, 0x12, 0x00, 0x88, 0x03, 0x05, 0x00, 0x14, 0x00, 0x41, 0x80,
  0x06, 0x00, 0x10, 0x60, 0x01, 0x80, 0x04, 0x30, 0x00, 0x40, 0x01, 0x0C,
  0x00, 0x30, 0x00, 0x42, 0x00, 0x0C, 0x00, 0x10, 0x80, 0x03, 0x00, 0x0C,
  0x20, 0x00, 0x80, 0x03, 0x08, 0x00, 0x20, 0x00, 0xC6, 0x00, 0x08, 0x00,
  0x21, 0x80, 0x06, 0x00, 0x08, 0x40, 0x01, 0x80, 0x02, 0x10, 0x00, 0x60,
  0x01, 0x84, 0x00, 0x10, 0x00, 0x61, 0x00, 0x04, 0x00, 0x18, 0xC0, 0x01,
  0x00, 0x04, 0x30, 0x00, 0xC0, 0x01, 0x08, 0x00, 0x30, 0x00, 0x42, 0x00,
  0x0C, 0x00, 0x30, 0x80, 0x02, 0x00, 0x0C, 0x20, 0x00, 0x80, 0x03, 0x18,
  0x00, 0x20, 0x00, 0x86, 0x00, 0x18, 0x00, 0x21, 0x00, 0x06, 0x00, 0x08,
  0x40, 0x01, 0x80, 0x06, 0x10, 0x00, 0x40, 0x01, 0x8C, 0x00, 0x10, 0x00,
  0x63, 0x00, 0x04, 0x00, 0x10, 0xC0, 0x03, 0x00, 0x04, 0x20, 0x00, 0xC0,
  0x01, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xC1, 0x80,
  0xC0, 0x18, 0xC0, 0x06, 0x02, 0x20, 0x00, 0x40, 0x48, 0x00, 0x0C, 0x09,
  0x00, 0x00, 0x81, 0x40, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02,
  0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x40, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x08, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x10,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x0C, 0x10, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x83, 0x80, 0xC0,
  0x00, 0x86, 0x00, 0x30, 0x00, 0x88, 0x00, 0x18, 0x01, 0x90, 0x00, 0x08,
  0x01, 0xA0, 0x00, 0x04, 0x01, 0x60, 0x00, 0x06, 0x01, 0x40, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x01,
  0x02, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x02, 0x04, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x10,
  0x1C, 0x00, 0x00, 0x30, 0x16, 0x00, 0x00, 0x60, 0x12, 0x00, 0x00, 0xC0,
  0x11, 0x00, 0x01, 0x80, 0x10, 0xC0, 0x03, 0x00, 0x30, 0x70, 0x1C, 0x00,
  0x30, 0x0F, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x60, 0x40,
  0x30, 0x00, 0xC2, 0x02, 0x00, 0x03, 0x30, 0x20, 0x00, 0x0D, 0x82, 0x00,
  0x00, 0x2C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x11, 0x00, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x04, 0x00, 0x00,
  0x38, 0x20, 0x00, 0x02, 0xC1, 0x80, 0x00, 0x24, 0x04, 0x00, 0x03, 0x20,
  0x10, 0x00, 0x31, 0x00, 0x60, 0x03, 0x18, 0x01, 0xC0, 0x60, 0xC0, 0x03,
  0xFC, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x08, 0x70, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x70, 0x07, 0x80, 0x03, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x40, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0xC0, 0x1C, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x10, 0x00, 0x20, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x60, 0x01, 0x80, 0x00, 0x40, 0x02, 0x00, 0x00, 0x40,
  0x0C, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x10, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x01, 0x08, 0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x20, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x10, 0x00, 0x01, 0xC2, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x0A, 0x08, 0x00, 0x02, 0x41, 0x80, 0x00, 0x58, 0x10,
  0x00, 0x13, 0x03, 0x00, 0x04, 0x60, 0x30, 0x01, 0x08, 0x03, 0x81, 0xC1,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x04, 0x01, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x20, 0x00, 0x01, 0x01, 0x00,
  0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x06, 0x02, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x40, 0x10, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0x20, 0x06, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x04, 0x08, 0x00, 0x20, 0x06, 0x08, 0x00, 0x20, 0x02, 0x08, 0x00, 0x20,
  0x02, 0x08, 0x00, 0x60, 0x03, 0x18, 0x00, 0x60, 0x03, 0x18, 0x00, 0x60,
  0x01, 0x10, 0x00, 0x40, 0x01, 0x10, 0x00, 0x40, 0x01, 0x10, 0x00, 0x40,
  0x01, 0x10, 0x00, 0xC0, 0x01, 0x30, 0x00, 0xC0, 0x01, 0x30, 0x00, 0xC0,
  0x01, 0x20, 0x00, 0x80, 0x01, 0x20, 0x00, 0x80, 0x01, 0x20, 0x00, 0x80,
  0x01, 0x20, 0x00, 0x80, 0x01, 0x60, 0x01, 0x80, 0x01, 0x60, 0x01, 0x80,
  0x01, 0x40, 0x01, 0x00, 0x03, 0x40, 0x01, 0x00, 0x03, 0x40, 0x01, 0x00,
  0x03, 0x40, 0x01, 0x00, 0x02, 0xC0, 0x03, 0x00, 0x02, 0xC0, 0x03, 0x00,
  0x06, 0x80, 0x02, 0x00, 0x04, 0x80, 0x02, 0x00, 0x04, 0x80, 0x06, 0x00,
  0x0C, 0x80, 0x0A, 0x00, 0x08, 0x80, 0x0A, 0x00, 0x18, 0x80, 0x0B, 0x00,
  0x30, 0xC0, 0x11, 0x00, 0x20, 0x40, 0x21, 0x80, 0xC0, 0x70, 0xC0, 0xC1,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0x30,
  0x03, 0x0C, 0x01, 0xC1, 0x80, 0xC0, 0x20, 0x70, 0x08, 0x18, 0x03, 0x1C,
  0x00, 0x81, 0x00, 0x16, 0x00, 0x0C, 0x20, 0x01, 0x00, 0x00, 0x46, 0x00,
  0x10, 0x00, 0x04, 0x40, 0x01, 0x00, 0x00, 0x6C, 0x00, 0x10, 0x00, 0x06,
  0x80, 0x01, 0x00, 0x00, 0x28, 0x00, 0x10, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x16,
  0x00, 0x00, 0x80, 0x01, 0x60, 0x00, 0x08, 0x00, 0x32, 0x00, 0x00, 0x80,
  0x02, 0x20, 0x00, 0x08, 0x00, 0x62, 0x00, 0x04, 0x80, 0x04, 0x30, 0x01,
  0xE8, 0x00, 0x81, 0x00, 0x70, 0xC0, 0x18, 0x18, 0x0C, 0x04, 0x03, 0x00,
  0x83, 0x00, 0x30, 0xC0, 0x0C, 0xC0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x10, 0x08, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0xC0, 0x20, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x08, 0x04, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x02, 0x01, 0x80, 0x00, 0x04,
  0x02, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x60,
  0x10, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x03, 0x00, 0x40, 0x00, 0x0A, 0x00,
  0x80, 0x00, 0x24, 0x01, 0x80, 0x00, 0x58, 0x01, 0x00, 0x01, 0x30, 0x03,
  0x00, 0x04, 0x60, 0x03, 0x00, 0x10, 0x80, 0x03, 0x81, 0xC1, 0x00, 0x01,
  0xFC, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00,
  0x40, 0x0C, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x60, 0x38,
  0x00, 0xC0, 0x40, 0x03, 0x80, 0x40, 0x40, 0x00, 0x30, 0x20, 0x60, 0x00,
  0x07, 0x10, 0x20, 0x00, 0x00, 0x78, 0x10, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x81, 0xE0, 0x00, 0x00,
  0x40, 0x8F, 0x80, 0x00, 0x30, 0x40, 0x3E, 0x00, 0x18, 0x20, 0x00, 0xF8,
  0x04, 0x10, 0x00, 0x03, 0xE2, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x83, 0x0E, 0x00, 0x00, 0xC3, 0x01, 0x80, 0x00,
  0x43, 0x00, 0x60, 0x00, 0x23, 0x00, 0x10, 0x00, 0x21, 0x00, 0x04, 0x00,
  0x11, 0x80, 0x03, 0x00, 0x10, 0x80, 0x00, 0xC0, 0x18, 0xC0, 0x00, 0x30,
  0x18, 0x40, 0x00, 0x0C, 0x30, 0x20, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 10, 46, 40, 15, -46 },
  { 59, 13, 17, 40, 17, -49 },
  { 87, 39, 46, 40, 1, -46 },
  { 312, 35, 62, 40, 2, -54 },
  { 584, 44, 48, 40, -1, -47 },
  { 848, 38, 48, 40, 1, -47 },
  { 1076, 4, 17, 40, 22, -49 },
  { 1085, 20, 59, 40, 16, -50 },
  { 1233, 20, 59, 40, 5, -50 },
  { 1381, 34, 33, 40, 4, -36 },
  { 1522, 32, 31, 40, 4, -36 },
  { 1646, 9, 16, 40, 10, -5 },
  { 1664, 18, 1, 40, 11, -21 },
  { 1667, 4, 4, 40, 15, -4 },
  { 1669, 35, 59, 40, 3, -50 },
  { 1928, 31, 48, 40, 5, -47 },
  { 2114, 30, 46, 40, 3, -46 },
  { 2287, 32, 47, 40, 3, -47 },
  { 2475, 32, 48, 40, 3, -47 },
  { 2667, 33, 46, 40, 2, -46 },
  { 2857, 33, 47, 40, 4, -46 },
  { 3051, 29, 47, 40, 5, -46 },
  { 3222, 31, 46, 40, 8, -46 },
  { 3401, 33, 48, 40, 4, -47 },
  { 3599, 28, 47, 40, 7, -47 },
  { 3764, 10, 35, 40, 15, -35 },
  { 3808, 15, 46, 40, 10, -35 },
  { 3895, 31, 35, 40, 6, -38 },
  { 4031, 34, 13, 40, 3, -27 },
  { 4087, 32, 35, 40, 3, -38 },
  { 4227, 26, 47, 40, 10, -47 },
  { 4380, 30, 54, 40, 5, -47 },
  { 4583, 32, 46, 40, 1, -46 },
  { 4767, 31, 46, 40, 4, -46 },
  { 4946, 31, 48, 40, 6, -47 },
  { 5132, 32, 46, 40, 4, -46 },
  { 5316, 35, 46, 40, 4, -46 },
  { 5518, 35, 46, 40, 4, -46 },
  { 5720, 31, 48, 40, 6, -47 },
  { 5906, 34, 46, 40, 4, -46 },
  { 6102, 35, 46, 40, 3, -46 },
  { 6304, 30, 47, 40, 5, -46 },
  { 6481, 37, 46, 40, 4, -46 },
  { 6694, 25, 46, 40, 7, -46 },
  { 6838, 36, 46, 40, 3, -46 },
  { 7045, 34, 46, 40, 4, -46 },
  { 7241, 31, 48, 40, 5, -47 },
  { 7427, 34, 46, 40, 4, -46 },
  { 7623, 31, 58, 40, 5, -47 },
  { 7848, 34, 46, 40, 4, -46 },
  { 8044, 35, 48, 40, 2, -47 },
  { 8254, 35, 46, 40, 7, -46 },
  { 8456, 32, 47, 40, 6, -46 },
  { 8644, 33, 46, 40, 8, -46 },
  { 8834, 36, 46, 40, 5, -46 },
  { 9041, 40, 46, 40, 1, -46 },
  { 9271, 36, 46, 40, 7, -46 },
  { 9478, 40, 46, 40, 0, -46 },
  { 9708, 26, 59, 40, 13, -50 },
  { 9900, 15, 59, 40, 13, -50 },
  { 10011, 26, 59, 40, 2, -50 },
  { 10203, 31, 25, 40, 5, -46 },
  { 10300, 31, 1, 40, 0, 8 },
  { 10304, 7, 11, 40, 16, -50 },
  { 10314, 29, 36, 40, 5, -35 },
  { 10445, 30, 50, 40, 5, -49 },
  { 10633, 28, 36, 40, 5, -35 },
  { 10759, 32, 50, 40, 5, -49 },
  { 10959, 28, 36, 40, 5, -35 },
  { 11085, 41, 63, 40, -1, -49 },
  { 11408, 31, 49, 40, 3, -35 },
  { 11598, 27, 49, 40, 6, -49 },
  { 11764, 27, 51, 40, 6, -50 },
  { 11937, 27, 64, 40, 7, -50 },
  { 12153, 33, 50, 40, 5, -49 },
  { 12360, 25, 50, 40, 8, -49 },
  { 12517, 34, 35, 40, 3, -35 },
  { 12666, 27, 35, 40, 6, -35 },
  { 12785, 29, 36, 40, 5, -35 },
  { 12916, 32, 48, 40, 3, -35 },
  { 13108, 29, 48, 40, 5, -35 },
  { 13282, 32, 34, 40, 8, -34 },
  { 13418, 31, 36, 40, 4, -35 },
  { 13558, 32, 47, 40, 5, -46 },
  { 13746, 27, 35, 40, 7, -34 },
  { 13865, 29, 34, 40, 6, -34 },
  { 13989, 32, 35, 40, 5, -34 },
  { 14129, 36, 36, 40, 2, -35 },
  { 14291, 31, 48, 40, 3, -34 },
  { 14477, 33, 36, 40, 3, -35 },
  { 14626, 29, 59, 40, 8, -50 },
  { 14840, 11, 59, 40, 15, -50 },
  { 14922, 30, 59, 40, 3, -50 },
  { 15144, 33, 11, 40, 4, -26 },
};

const GFXfont IBMPlexMono_ThinItalic66pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic66pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic66pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _IBMPLEXMONO_THINITALIC66PT7B_H_
