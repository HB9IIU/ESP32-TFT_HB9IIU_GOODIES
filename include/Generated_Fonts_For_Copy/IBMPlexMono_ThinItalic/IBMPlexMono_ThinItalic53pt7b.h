#ifndef _IBMPLEXMONO_THINITALIC53PT7B_H_
#define _IBMPLEXMONO_THINITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0xF0, 0xE0, 0x20, 0x48, 0x12, 0x04, 0x83, 0x60, 0xD0, 0x24, 0x09, 0x02,
  0x40, 0x90, 0x6C, 0x1A, 0x04, 0x81, 0x00, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x02, 0x01, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x10, 0x04, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x40, 0x20, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x02, 0x01, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10,
  0x0C, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x40, 0x20, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x02, 0x01, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x0C,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x01, 0x00, 0x80, 0x00, 0x02,
  0x01, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x20,
  0x10, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x47, 0x00, 0x0C, 0x04, 0x0C, 0x01,
  0x00, 0x40, 0x60, 0x20, 0x08, 0x03, 0x06, 0x00, 0x80, 0x20, 0x40, 0x08,
  0x00, 0x04, 0x00, 0x80, 0x00, 0x40, 0x08, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0xC0, 0x10, 0x00, 0x04, 0x01, 0x00, 0x00, 0x40, 0x10, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x60, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x18, 0x20, 0x00,
  0x00, 0xE2, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x23, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x40, 0x10, 0x00, 0x04, 0x01, 0x80, 0x00, 0x40, 0x08, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x80, 0x08, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80,
  0x18, 0x00, 0x08, 0x01, 0x08, 0x00, 0x80, 0x10, 0xC0, 0x08, 0x03, 0x04,
  0x01, 0x80, 0x60, 0x30, 0x10, 0x04, 0x01, 0x81, 0x01, 0x80, 0x07, 0x10,
  0x60, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x02, 0x00, 0x80, 0x01,
  0x00, 0x80, 0x10, 0x00, 0x40, 0x10, 0x01, 0x00, 0x18, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x80, 0x04, 0x00, 0x80, 0x10, 0x00, 0x80, 0x20, 0x06, 0x00,
  0x10, 0x08, 0x00, 0x80, 0x02, 0x01, 0x00, 0x10, 0x00, 0x40, 0x40, 0x02,
  0x00, 0x10, 0x10, 0x00, 0x40, 0x02, 0x04, 0x00, 0x0C, 0x00, 0xC1, 0x80,
  0x00, 0x80, 0x10, 0x20, 0x00, 0x18, 0x04, 0x08, 0x00, 0x01, 0x83, 0x02,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0x06, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x40, 0x00, 0x30, 0x60, 0x0C,
  0x00, 0x04, 0x08, 0x00, 0x80, 0x01, 0x02, 0x00, 0x10, 0x00, 0x40, 0x40,
  0x02, 0x00, 0x18, 0x08, 0x00, 0x40, 0x02, 0x03, 0x00, 0x08, 0x00, 0x80,
  0x60, 0x01, 0x00, 0x20, 0x08, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x0C, 0x01,
  0x00, 0x20, 0x01, 0x00, 0x40, 0x02, 0x00, 0x20, 0x10, 0x00, 0x40, 0x08,
  0x06, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x00, 0xC1, 0x80, 0x20, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x01, 0x00, 0x00, 0x80, 0x02, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x80, 0x00,
  0x80, 0x02, 0x00, 0x02, 0x00, 0x18, 0x00, 0x04, 0x00, 0x40, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x80, 0x40, 0x00, 0x1F, 0x06,
  0x00, 0x03, 0x86, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x10, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x20, 0x00, 0x30, 0x00, 0x80,
  0x00, 0x40, 0x02, 0x00, 0x00, 0x80, 0x08, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x14, 0x03, 0x80, 0x00, 0x58, 0x0A, 0x00, 0x02, 0x20, 0x44, 0x00, 0x08,
  0x41, 0x18, 0x00, 0x41, 0x88, 0x30, 0x02, 0x02, 0x60, 0x70, 0x30, 0x0D,
  0x00, 0x7F, 0x00, 0x18, 0x00, 0x33, 0x22, 0x22, 0x66, 0x44, 0x44, 0xC0,
  0x00, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x05, 0xC0, 0x10, 0x07, 0x87, 0x02, 0x07,
  0x80, 0x1C, 0x47, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x04, 0x00,
  0x00, 0xC0, 0x40, 0x00, 0x10, 0x0C, 0x00, 0x04, 0x00, 0x80, 0x01, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0x06, 0x0C, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x40, 0xC0, 0xFF, 0xFC, 0x6F, 0xE0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x38, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x20, 0x00, 0x40, 0x20, 0x00,
  0x30, 0x30, 0x00, 0x08, 0x10, 0x00, 0x04, 0x10, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x26, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x03, 0x00, 0x38, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x90, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x64, 0x00, 0x00, 0x22, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x10, 0x40, 0x00, 0x18, 0x20, 0x00, 0x08, 0x08, 0x00, 0x08, 0x04, 0x00,
  0x08, 0x01, 0x80, 0x18, 0x00, 0x60, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x40, 0x00, 0x06, 0x40, 0x00, 0x0C, 0x40, 0x00,
  0x30, 0x40, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x80, 0x06,
  0x00, 0x80, 0x0C, 0x00, 0x80, 0x10, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x06, 0x03, 0x80, 0x06, 0x00, 0x30,
  0x02, 0x00, 0x06, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x10, 0x20, 0x00,
  0x04, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0x40, 0x60, 0x00, 0x10, 0x20, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x04, 0x20, 0x00, 0x04, 0x08, 0x00, 0x06, 0x03, 0x00,
  0x06, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x34, 0x00, 0x00, 0x09,
  0x00, 0x00, 0x04, 0x40, 0x00, 0x02, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x60, 0x80, 0x00, 0x10, 0x20, 0x00, 0x08, 0x08, 0x00,
  0x04, 0x02, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00, 0xC0, 0x10,
  0x00, 0x60, 0x04, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x10, 0x02, 0x00, 0x0C, 0x01, 0x80, 0x02, 0x00, 0xC0, 0x00, 0x80, 0x60,
  0x00, 0x20, 0x10, 0x00, 0x08, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0xFE,
  0x00, 0x08, 0xC0, 0x70, 0x02, 0xC0, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x20,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x1F, 0xC0, 0x11,
  0xC0, 0x60, 0x2C, 0x00, 0x20, 0xB0, 0x00, 0x21, 0xC0, 0x00, 0x25, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x20, 0x00, 0x04, 0x40, 0x00, 0x08,
  0xC0, 0x00, 0x20, 0x80, 0x00, 0x80, 0xC0, 0x06, 0x00, 0xE0, 0x30, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x90, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x44, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x10, 0x40, 0x00, 0x10, 0x60, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x60, 0x00, 0x04, 0x10, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x30,
  0x00, 0x01, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x20, 0x60, 0x00, 0x10,
  0x08, 0x00, 0x0C, 0x01, 0x00, 0x04, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x81, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x10, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x02, 0x10, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x30, 0x03,
  0x80, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x0E, 0x03, 0x00,
  0x60, 0x03, 0x02, 0x00, 0x06, 0x10, 0x00, 0x08, 0x80, 0x00, 0x16, 0x00,
  0x00, 0x50, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x64, 0x00, 0x02, 0x98, 0x00,
  0x1A, 0x30, 0x01, 0xD0, 0x30, 0x1C, 0x40, 0x3F, 0x82, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x38, 0x0C, 0x03, 0x00, 0x18, 0x20, 0x00, 0x42, 0x00, 0x01, 0x30, 0x00,
  0x09, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x02, 0x01, 0x00, 0x01, 0x03, 0x00, 0x01, 0x02, 0x00, 0x01, 0x06, 0x00,
  0x01, 0x04, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x03,
  0xE1, 0x18, 0x0C, 0x19, 0x10, 0x18, 0x05, 0x10, 0x10, 0x05, 0x10, 0x20,
  0x03, 0x30, 0x20, 0x02, 0x20, 0x40, 0x02, 0x20, 0x40, 0x02, 0x20, 0x40,
  0x02, 0x20, 0xC0, 0x02, 0x60, 0x80, 0x06, 0x40, 0x80, 0x04, 0x40, 0x80,
  0x04, 0x40, 0x80, 0x04, 0x40, 0x80, 0x04, 0x40, 0x80, 0x0C, 0x40, 0x80,
  0x0C, 0x40, 0x80, 0x18, 0xC0, 0xC0, 0x18, 0x80, 0x40, 0x28, 0x80, 0x60,
  0x48, 0x80, 0x1F, 0x88, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x08, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00, 0x18, 0x04,
  0x00, 0x02, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x10, 0x02, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x10,
  0x01, 0x80, 0x02, 0x00, 0x20, 0x00, 0x40, 0x0C, 0x00, 0x08, 0x01, 0xFF,
  0xFF, 0x80, 0x60, 0x00, 0x10, 0x08, 0x00, 0x02, 0x03, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x08, 0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x46, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x30,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x03, 0xFF, 0xF8, 0x01, 0x00, 0x07,
  0x00, 0x80, 0x00, 0xC0, 0x40, 0x00, 0x20, 0x20, 0x00, 0x18, 0x30, 0x00,
  0x04, 0x10, 0x00, 0x02, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x21, 0x80, 0x00, 0x10, 0x80, 0x00, 0x18, 0x40,
  0x00, 0x08, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x08, 0x00, 0x0C, 0x0C,
  0x00, 0x1C, 0x07, 0xFF, 0xF8, 0x02, 0x00, 0x03, 0x01, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x60, 0x00, 0x06, 0x20, 0x00, 0x01,
  0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x13, 0x00, 0x00, 0x19, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04, 0x40, 0x00,
  0x04, 0x20, 0x00, 0x06, 0x10, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x30, 0x00, 0x08, 0x10, 0x00, 0x04,
  0x10, 0x00, 0x03, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x40, 0x00, 0x10, 0x20, 0x00, 0x18,
  0x18, 0x00, 0x08, 0x06, 0x00, 0x08, 0x01, 0x80, 0x18, 0x00, 0x70, 0x38,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x00, 0x60, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x01, 0x00, 0x80, 0x00, 0x20,
  0x60, 0x00, 0x08, 0x18, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x04, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x04, 0x60, 0x00, 0x03, 0x10, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x20,
  0x00, 0x02, 0x08, 0x00, 0x01, 0x86, 0x00, 0x00, 0x41, 0x80, 0x00, 0x20,
  0x40, 0x00, 0x18, 0x10, 0x00, 0x0C, 0x04, 0x00, 0x06, 0x01, 0x00, 0x0E,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x00, 0xC0, 0x20, 0x00, 0x20, 0x20, 0x00, 0x08, 0x30, 0x00, 0x04, 0x10,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x7F, 0xF2, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x08, 0x80, 0x00, 0x04, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x14, 0x18,
  0x00, 0x16, 0x04, 0x00, 0x1A, 0x01, 0x00, 0x19, 0x00, 0x60, 0x30, 0x80,
  0x0F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x83, 0x00, 0x00, 0x10, 0x60, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x08, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x60, 0x80, 0x00, 0x08, 0x10,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x30, 0x7F, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x30, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x18, 0x00, 0x00, 0x83, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x60, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x80,
  0x40, 0x01, 0x80, 0x20, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x40, 0x20, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x30, 0x02, 0x00, 0x01, 0x80, 0x08, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x10, 0x00,
  0xC0, 0x00, 0x40, 0x06, 0x00, 0x01, 0x00, 0x20, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x30, 0x08, 0x00, 0x00, 0x80, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x20, 0x90, 0x00, 0x01, 0x8C, 0x40, 0x00, 0x06,
  0x60, 0x80, 0x00, 0x13, 0x02, 0x00, 0x00, 0x58, 0x04, 0x00, 0x01, 0xC0,
  0x10, 0x00, 0x06, 0x00, 0x20, 0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x40, 0x06, 0x00, 0x01, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x08, 0x01, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0xC0, 0xA0, 0x00, 0x0A, 0x05, 0x00, 0x00, 0xF0,
  0x28, 0x00, 0x05, 0x03, 0x60, 0x00, 0x48, 0x11, 0x00, 0x06, 0x40, 0x88,
  0x00, 0x22, 0x04, 0x40, 0x03, 0x10, 0x21, 0x00, 0x11, 0x81, 0x08, 0x01,
  0x08, 0x18, 0x40, 0x18, 0x40, 0x83, 0x00, 0x82, 0x04, 0x08, 0x0C, 0x10,
  0x20, 0x40, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x08, 0x60, 0x40, 0xC0,
  0x42, 0x02, 0x04, 0x02, 0x20, 0x10, 0x20, 0x11, 0x00, 0x81, 0x00, 0x50,
  0x04, 0x08, 0x03, 0x80, 0x60, 0x40, 0x18, 0x02, 0x06, 0x00, 0x80, 0x10,
  0x20, 0x00, 0x00, 0x81, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0x40,
  0x00, 0x03, 0x02, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x04, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x02, 0x00, 0x00, 0x18,
  0x10, 0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x60, 0x00, 0x04, 0x0A, 0x00, 0x00, 0x83, 0x40,
  0x00, 0x10, 0x48, 0x00, 0x02, 0x08, 0x80, 0x00, 0xC1, 0x10, 0x00, 0x10,
  0x22, 0x00, 0x02, 0x04, 0x20, 0x00, 0x41, 0x84, 0x00, 0x08, 0x20, 0x80,
  0x01, 0x04, 0x08, 0x00, 0x60, 0x81, 0x00, 0x08, 0x10, 0x30, 0x01, 0x02,
  0x02, 0x00, 0x20, 0xC0, 0x40, 0x04, 0x10, 0x0C, 0x00, 0x82, 0x00, 0x80,
  0x30, 0x40, 0x10, 0x04, 0x08, 0x03, 0x00, 0x81, 0x00, 0x20, 0x10, 0x60,
  0x04, 0x02, 0x08, 0x00, 0x40, 0x41, 0x00, 0x08, 0x18, 0x20, 0x01, 0x02,
  0x04, 0x00, 0x10, 0x40, 0x80, 0x02, 0x08, 0x30, 0x00, 0x41, 0x04, 0x00,
  0x04, 0x20, 0x80, 0x00, 0x8C, 0x10, 0x00, 0x11, 0x02, 0x00, 0x01, 0x20,
  0x40, 0x00, 0x24, 0x18, 0x00, 0x06, 0x82, 0x00, 0x00, 0x50, 0x40, 0x00,
  0x0E, 0x08, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x0C, 0x00,
  0x30, 0x01, 0x00, 0x20, 0x00, 0x40, 0x20, 0x00, 0x30, 0x30, 0x00, 0x08,
  0x10, 0x00, 0x04, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x88, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x26, 0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x02, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x03, 0x40,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x31, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18,
  0x20, 0x00, 0x08, 0x08, 0x00, 0x08, 0x04, 0x00, 0x08, 0x01, 0x80, 0x18,
  0x00, 0x60, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x60,
  0x00, 0x60, 0x08, 0x00, 0x02, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x04, 0x08, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x60, 0x00, 0x38, 0x0F,
  0xFF, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x20, 0x00,
  0x40, 0x20, 0x00, 0x30, 0x30, 0x00, 0x08, 0x10, 0x00, 0x04, 0x10, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x12, 0x00, 0x00, 0x09, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x64, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18, 0x20, 0x00, 0x08, 0x08, 0x00,
  0x08, 0x04, 0x00, 0x08, 0x01, 0x80, 0x18, 0x00, 0x60, 0x38, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x02, 0x00, 0x0C, 0x03, 0x00,
  0x02, 0x03, 0x00, 0x00, 0x82, 0x00, 0x00, 0x62, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x60, 0x08, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00, 0x06, 0x04, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x04, 0x10, 0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x08, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x60, 0x60, 0x00, 0x38, 0x0F, 0xFF, 0xF8, 0x01, 0x00,
  0x40, 0x00, 0x20, 0x04, 0x00, 0x04, 0x00, 0x80, 0x00, 0x80, 0x08, 0x00,
  0x30, 0x01, 0x00, 0x06, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x20, 0x02, 0x00, 0x04, 0x00, 0x40, 0x00, 0x40, 0x18, 0x00, 0x08, 0x03,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x08, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x06, 0x02, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x18, 0x00, 0x70, 0x06, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11,
  0x80, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x20, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x04, 0x60, 0x00, 0x02, 0x20, 0x00, 0x03, 0x10, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00, 0x23, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x20, 0x40, 0x00, 0x20, 0x10, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x03, 0x80, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x0C, 0x18, 0x00, 0x02, 0x02, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x40, 0x20, 0x00, 0x30, 0x08, 0x00, 0x08, 0x02, 0x00, 0x06, 0x00, 0x80,
  0x01, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0x40, 0x04, 0x00, 0x10, 0x03, 0x00, 0x04, 0x00, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x20, 0x10, 0x00, 0x08, 0x0C, 0x00, 0x02, 0x02, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x04, 0x20, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x02, 0x08, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x10, 0x40, 0x0C, 0x01, 0x82, 0x00, 0x60, 0x08, 0x10, 0x05,
  0x00, 0x40, 0x80, 0x28, 0x02, 0x04, 0x02, 0x40, 0x30, 0x20, 0x12, 0x01,
  0x01, 0x01, 0x10, 0x08, 0x08, 0x08, 0xC0, 0x40, 0x40, 0xC2, 0x04, 0x02,
  0x04, 0x10, 0x20, 0x30, 0x60, 0x81, 0x01, 0x02, 0x04, 0x08, 0x08, 0x30,
  0x20, 0x80, 0x41, 0x01, 0x04, 0x02, 0x08, 0x08, 0x20, 0x10, 0x80, 0x63,
  0x00, 0x84, 0x01, 0x10, 0x04, 0x40, 0x08, 0x80, 0x22, 0x00, 0x44, 0x01,
  0x20, 0x02, 0x60, 0x09, 0x00, 0x12, 0x00, 0x58, 0x00, 0x90, 0x02, 0x80,
  0x04, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0x80, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x80, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x10, 0x04,
  0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x02, 0x00, 0xC0,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x0C,
  0x01, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x04, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x04, 0x00, 0x60, 0x00, 0x30, 0x02, 0x00, 0x00, 0x80,
  0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xF0,
  0x10, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x40, 0x00, 0x01, 0xA0, 0x00, 0x01, 0x88, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x81, 0x00, 0x00, 0xC0, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x40, 0x10, 0x00,
  0x40, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x60, 0x01, 0x00, 0x20, 0x00, 0x40,
  0x20, 0x00, 0x20, 0x20, 0x00, 0x08, 0x30, 0x00, 0x04, 0x10, 0x00, 0x03,
  0x10, 0x00, 0x00, 0x90, 0x00, 0x00, 0x58, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0x80, 0x86, 0x10, 0xC2, 0x18, 0x41, 0x08, 0x00, 0x7F, 0x00, 0x01,
  0xC0, 0xC3, 0x02, 0x00, 0x32, 0x04, 0x00, 0x12, 0x08, 0x00, 0x0A, 0x10,
  0x00, 0x0A, 0x30, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x30, 0x40, 0x00, 0x50, 0x40, 0x00, 0xB0, 0x20,
  0x01, 0x20, 0x10, 0x02, 0x20, 0x0C, 0x0C, 0x3F, 0x03, 0xF0, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x1F, 0xC0, 0x04,
  0x70, 0x30, 0x0C, 0xC0, 0x08, 0x09, 0x00, 0x04, 0x0B, 0x00, 0x06, 0x0A,
  0x00, 0x02, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x18,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x01, 0x10,
  0x00, 0x01, 0x30, 0x00, 0x01, 0x20, 0x00, 0x03, 0x20, 0x00, 0x02, 0x20,
  0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x06, 0x60, 0x00, 0x04, 0x60,
  0x00, 0x04, 0x60, 0x00, 0x08, 0x60, 0x00, 0x18, 0x50, 0x00, 0x10, 0x50,
  0x00, 0x20, 0xCC, 0x00, 0xC0, 0x87, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0x01, 0x80, 0x30, 0x01, 0x01, 0x80, 0x02, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x11, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x34,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0x20, 0x00, 0x20, 0x40, 0x03, 0x01, 0x80,
  0x18, 0x01, 0x81, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x0F, 0xE0, 0x60, 0x1C, 0x0C, 0x20,
  0x10, 0x01, 0x90, 0x10, 0x00, 0x48, 0x10, 0x00, 0x14, 0x10, 0x00, 0x0A,
  0x18, 0x00, 0x03, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x30, 0x40, 0x00, 0x28, 0x10, 0x00, 0x14, 0x08, 0x00, 0x16, 0x02,
  0x00, 0x12, 0x00, 0x80, 0x11, 0x00, 0x30, 0x30, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x60, 0x06, 0x00, 0x20, 0x10, 0x00, 0x20,
  0x40, 0x00, 0x41, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x88, 0x00, 0x03, 0x20,
  0x00, 0x04, 0x40, 0x00, 0x09, 0x80, 0x00, 0x32, 0x00, 0x00, 0xC4, 0x00,
  0x06, 0x08, 0x00, 0x30, 0x10, 0x0F, 0x80, 0x7F, 0xE0, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x88, 0x00, 0x01, 0x10, 0x00, 0x02, 0x30, 0x00, 0x08, 0x20, 0x00, 0x30,
  0x20, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x30, 0x18, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x30, 0xC0, 0x40, 0x06,
  0x40, 0x40, 0x01, 0x20, 0x40, 0x00, 0x50, 0x40, 0x00, 0x28, 0x60, 0x00,
  0x0C, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x46, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10,
  0x00, 0x03, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x50, 0x20, 0x00, 0x58, 0x08, 0x00, 0x48,
  0x02, 0x00, 0x44, 0x00, 0xC0, 0xC2, 0x00, 0x1F, 0x81, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x30, 0x10, 0x00, 0x10, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x60, 0x00, 0x3F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x3F,
  0x00, 0x86, 0x06, 0x04, 0x40, 0x08, 0x24, 0x00, 0x61, 0x40, 0x01, 0x1C,
  0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00,
  0x88, 0x00, 0x04, 0xC0, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00,
  0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x26, 0x00, 0x01, 0x20, 0x00, 0x09,
  0x00, 0x00, 0xC8, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x01, 0x30, 0x00,
  0x09, 0x00, 0x00, 0x48, 0x00, 0x06, 0x40, 0x00, 0x22, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x20, 0x18,
  0x00, 0xC0, 0x40, 0x0C, 0x01, 0x00, 0x40, 0x04, 0x06, 0x00, 0x10, 0x20,
  0x00, 0xC3, 0x00, 0x02, 0x18, 0x00, 0x09, 0x80, 0x00, 0x2C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x10, 0x03, 0x00, 0x40,
  0x06, 0x03, 0x00, 0x04, 0x08, 0x00, 0x08, 0x20, 0x00, 0x10, 0x80, 0x00,
  0x32, 0x00, 0x00, 0x68, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x3F, 0x80, 0x04,
  0x30, 0x18, 0x03, 0x30, 0x03, 0x00, 0x90, 0x00, 0x40, 0x28, 0x00, 0x18,
  0x0A, 0x00, 0x02, 0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x60, 0x00,
  0x10, 0x18, 0x00, 0x04, 0x04, 0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0x40,
  0x00, 0x80, 0x10, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x02, 0x03, 0x80, 0x00,
  0x83, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x08, 0x00, 0x02, 0x02, 0x00,
  0x05, 0x80, 0x40, 0x03, 0x40, 0x18, 0x01, 0x90, 0x02, 0x00, 0xC4, 0x00,
  0xC0, 0x61, 0x00, 0x10, 0x30, 0x40, 0x02, 0x18, 0x30, 0x00, 0x88, 0x08,
  0x00, 0x14, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x41, 0x00, 0x18, 0x20, 0x04, 0x04, 0x03,
  0x01, 0x80, 0x80, 0x20, 0x60, 0x04, 0x10, 0x00, 0x8C, 0x00, 0x13, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x4C, 0x21, 0x86,
  0x05, 0x01, 0x20, 0x20, 0xA0, 0x14, 0x01, 0x0C, 0x01, 0x40, 0x10, 0xC0,
  0x18, 0x01, 0x08, 0x01, 0x80, 0x10, 0x80, 0x10, 0x01, 0x18, 0x01, 0x00,
  0x31, 0x00, 0x10, 0x02, 0x10, 0x01, 0x00, 0x21, 0x00, 0x30, 0x02, 0x10,
  0x02, 0x00, 0x21, 0x00, 0x20, 0x02, 0x30, 0x02, 0x00, 0x62, 0x00, 0x20,
  0x04, 0x20, 0x02, 0x00, 0x42, 0x00, 0x60, 0x04, 0x20, 0x04, 0x00, 0x42,
  0x00, 0x40, 0x04, 0x60, 0x04, 0x00, 0xC4, 0x00, 0x40, 0x08, 0x40, 0x04,
  0x00, 0x84, 0x00, 0xC0, 0x08, 0x40, 0x08, 0x00, 0x84, 0x00, 0x80, 0x08,
  0xC0, 0x08, 0x01, 0x88, 0x00, 0x80, 0x10, 0x00, 0x1F, 0x80, 0x43, 0x03,
  0x02, 0x20, 0x04, 0x12, 0x00, 0x30, 0xA0, 0x00, 0x8E, 0x00, 0x04, 0x60,
  0x00, 0x23, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02,
  0x60, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x64,
  0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00,
  0x24, 0x00, 0x03, 0x20, 0x00, 0x11, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x80,
  0x01, 0x80, 0xC0, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x40, 0xC0, 0x00, 0x41,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x98, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40,
  0x00, 0x05, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x48, 0x00, 0x01,
  0x10, 0x00, 0x02, 0x20, 0x00, 0x08, 0x20, 0x00, 0x30, 0x60, 0x00, 0xC0,
  0x60, 0x03, 0x00, 0x30, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x47, 0x03, 0x00, 0x13, 0x00, 0x20, 0x09, 0x00, 0x04, 0x02, 0xC0,
  0x01, 0x80, 0xA0, 0x00, 0x20, 0x30, 0x00, 0x08, 0x08, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x40, 0x00, 0x04, 0x10, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x20, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20,
  0x00, 0x06, 0x08, 0x00, 0x01, 0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x20,
  0x60, 0x00, 0x18, 0x14, 0x00, 0x04, 0x05, 0x00, 0x02, 0x01, 0x30, 0x03,
  0x00, 0x87, 0x03, 0x80, 0x20, 0x3F, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0xC3, 0x02, 0x00,
  0x32, 0x04, 0x00, 0x12, 0x08, 0x00, 0x0A, 0x10, 0x00, 0x0A, 0x30, 0x00,
  0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00,
  0x04, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00,
  0x30, 0x40, 0x00, 0x50, 0x40, 0x00, 0xB0, 0x20, 0x01, 0x20, 0x10, 0x02,
  0x20, 0x0C, 0x0C, 0x20, 0x03, 0xF0, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x08, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x40, 0x00, 0x08, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x09, 0x80, 0x00, 0x04, 0x40, 0x00, 0x04, 0x10,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x00, 0xE0, 0x1C, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x04, 0x01, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x41, 0x80, 0x00, 0x10, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00,
  0x44, 0x00, 0x03, 0x10, 0x00, 0x08, 0x40, 0x00, 0x23, 0x00, 0x00, 0x88,
  0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x62, 0x00, 0x01, 0x08, 0x00,
  0x04, 0x60, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x0C,
  0x40, 0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x02, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0x63, 0x00, 0x03, 0x84, 0x00, 0x0C, 0x10, 0x00, 0x50, 0x40, 0x02,
  0x40, 0x80, 0x11, 0x01, 0x81, 0x84, 0x01, 0xF8, 0x20, 0x00, 0x00, 0x02,
  0x7F, 0x00, 0x03, 0x81, 0x00, 0x01, 0x01, 0x00, 0x01, 0x01, 0x00, 0x01,
  0x01, 0x00, 0x01, 0x01, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01,
  0x02, 0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02,
  0x06, 0x00, 0x02, 0x04, 0x00, 0x06, 0x04, 0x00, 0x04, 0x04, 0x00, 0x04,
  0x04, 0x00, 0x08, 0x04, 0x00, 0x18, 0x04, 0x00, 0x10, 0x0C, 0x00, 0x20,
  0x08, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x08, 0x02, 0x00,
  0x08, 0x0C, 0x00, 0x08, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x06, 0x00, 0x40, 0x21, 0x00, 0x30, 0x08, 0x40, 0x08, 0x02, 0x10, 0x02,
  0x00, 0xC4, 0x00, 0x80, 0x11, 0x00, 0x20, 0x04, 0xC0, 0x08, 0x01, 0x20,
  0x06, 0x00, 0x48, 0x01, 0x00, 0x12, 0x00, 0x40, 0x04, 0x80, 0x10, 0x01,
  0x20, 0x04, 0x00, 0x58, 0x01, 0x00, 0x14, 0x00, 0xC0, 0x05, 0x00, 0x20,
  0x01, 0x40, 0x08, 0x00, 0xD0, 0x02, 0x00, 0x24, 0x00, 0x80, 0x0B, 0x00,
  0x20, 0x02, 0x80, 0x18, 0x01, 0xA0, 0x04, 0x00, 0x48, 0x01, 0x00, 0x12,
  0x00, 0xC0, 0x08, 0x80, 0x30, 0x02, 0x20, 0x12, 0x01, 0x0C, 0x08, 0x80,
  0x81, 0x86, 0x10, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x03, 0xE0,
  0x03, 0x30, 0x10, 0x40, 0x30, 0x40, 0x80, 0x83, 0x01, 0x84, 0x03, 0x30,
  0x02, 0x20, 0x04, 0x00, 0x08, 0x80, 0x10, 0x00, 0x24, 0x00, 0x40, 0x00,
  0x50, 0x01, 0x00, 0x01, 0x80, 0x04, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x10, 0x01, 0x80, 0x00, 0xC0,
  0x06, 0x00, 0x02, 0x00, 0x24, 0x00, 0x08, 0x00, 0x90, 0x00, 0x20, 0x04,
  0x40, 0x04, 0xC0, 0x11, 0x00, 0x31, 0x00, 0x82, 0x03, 0x04, 0x04, 0x08,
  0x30, 0x08, 0x20, 0x13, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20, 0x40, 0x00, 0x30, 0x20, 0x00,
  0x10, 0x10, 0x00, 0x08, 0x18, 0x00, 0x04, 0x08, 0x00, 0x02, 0x04, 0x00,
  0x01, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0x80, 0x80, 0x00, 0x40, 0xC0,
  0x00, 0x20, 0x40, 0x00, 0x10, 0x20, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x08,
  0x00, 0x04, 0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x03, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x20, 0x00, 0x60, 0x10, 0x00, 0x50,
  0x08, 0x00, 0x48, 0x02, 0x00, 0x44, 0x00, 0xC0, 0xC2, 0x00, 0x1F, 0x83,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x03, 0x80, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0x81, 0xC0, 0x30, 0xC0, 0x0E, 0x08, 0x20, 0x00, 0x62, 0x18, 0x00, 0x07,
  0x84, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x60, 0x40, 0x00, 0x20, 0x10, 0x00,
  0x10, 0x04, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x20, 0x06, 0x00, 0x04, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x10, 0xF0, 0x00, 0x04, 0x23, 0xE0, 0x01, 0x08, 0x07, 0xC0, 0x62,
  0x00, 0x0F, 0x88, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x08, 0x04, 0x02, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x21,
  0x84, 0x00, 0x08, 0x40, 0x40, 0x01, 0x18, 0x04, 0x00, 0x62, 0x00, 0x40,
  0x08, 0x80, 0x0C, 0x02, 0x10, 0x00, 0xC0, 0xC4, 0x00, 0x0C, 0x30, 0x80,
  0x00, 0x78, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 37, 32, 12, -37 },
  { 38, 10, 13, 32, 14, -39 },
  { 55, 31, 37, 32, 1, -37 },
  { 199, 28, 49, 32, 2, -43 },
  { 371, 35, 39, 32, -1, -38 },
  { 542, 30, 39, 32, 1, -38 },
  { 689, 4, 13, 32, 17, -39 },
  { 696, 16, 47, 32, 13, -40 },
  { 790, 16, 47, 32, 4, -40 },
  { 884, 27, 26, 32, 3, -29 },
  { 972, 25, 25, 32, 4, -29 },
  { 1051, 8, 13, 32, 8, -4 },
  { 1064, 14, 1, 32, 9, -17 },
  { 1066, 4, 3, 32, 12, -3 },
  { 1068, 28, 47, 32, 2, -40 },
  { 1233, 25, 39, 32, 4, -38 },
  { 1355, 24, 37, 32, 3, -37 },
  { 1466, 26, 38, 32, 2, -38 },
  { 1590, 25, 39, 32, 3, -38 },
  { 1712, 26, 37, 32, 2, -37 },
  { 1833, 26, 38, 32, 3, -37 },
  { 1957, 23, 38, 32, 4, -37 },
  { 2067, 25, 37, 32, 6, -37 },
  { 2183, 26, 39, 32, 3, -38 },
  { 2310, 22, 38, 32, 6, -38 },
  { 2415, 8, 28, 32, 12, -28 },
  { 2443, 12, 37, 32, 8, -28 },
  { 2499, 25, 28, 32, 5, -30 },
  { 2587, 27, 10, 32, 3, -21 },
  { 2621, 25, 28, 32, 3, -30 },
  { 2709, 21, 38, 32, 8, -38 },
  { 2809, 24, 44, 32, 4, -38 },
  { 2941, 27, 37, 32, 0, -37 },
  { 3066, 25, 37, 32, 3, -37 },
  { 3182, 25, 39, 32, 5, -38 },
  { 3304, 26, 37, 32, 3, -37 },
  { 3425, 28, 37, 32, 3, -37 },
  { 3555, 28, 37, 32, 3, -37 },
  { 3685, 25, 39, 32, 5, -38 },
  { 3807, 27, 37, 32, 3, -37 },
  { 3932, 28, 37, 32, 3, -37 },
  { 4062, 24, 38, 32, 4, -37 },
  { 4176, 30, 37, 32, 3, -37 },
  { 4315, 21, 37, 32, 5, -37 },
  { 4413, 29, 37, 32, 2, -37 },
  { 4548, 27, 37, 32, 3, -37 },
  { 4673, 25, 39, 32, 4, -38 },
  { 4795, 27, 37, 32, 3, -37 },
  { 4920, 25, 47, 32, 4, -38 },
  { 5067, 27, 37, 32, 3, -37 },
  { 5192, 28, 39, 32, 2, -38 },
  { 5329, 28, 37, 32, 6, -37 },
  { 5459, 25, 38, 32, 5, -37 },
  { 5578, 26, 37, 32, 7, -37 },
  { 5699, 29, 37, 32, 4, -37 },
  { 5834, 33, 37, 32, 0, -37 },
  { 5987, 29, 37, 32, 5, -37 },
  { 6122, 32, 37, 32, 0, -37 },
  { 6270, 21, 47, 32, 10, -40 },
  { 6394, 12, 47, 32, 11, -40 },
  { 6465, 20, 47, 32, 2, -40 },
  { 6583, 25, 20, 32, 4, -37 },
  { 6646, 25, 1, 32, 0, 6 },
  { 6650, 5, 9, 32, 13, -41 },
  { 6656, 24, 29, 32, 4, -28 },
  { 6743, 24, 40, 32, 4, -39 },
  { 6863, 22, 29, 32, 4, -28 },
  { 6943, 25, 40, 32, 4, -39 },
  { 7068, 23, 29, 32, 4, -28 },
  { 7152, 33, 50, 32, -1, -39 },
  { 7359, 25, 39, 32, 3, -28 },
  { 7481, 21, 39, 32, 5, -39 },
  { 7584, 22, 40, 32, 5, -39 },
  { 7694, 22, 50, 32, 6, -39 },
  { 7832, 26, 40, 32, 4, -39 },
  { 7962, 19, 40, 32, 7, -39 },
  { 8057, 28, 28, 32, 2, -28 },
  { 8155, 21, 28, 32, 5, -28 },
  { 8229, 23, 29, 32, 4, -28 },
  { 8313, 26, 39, 32, 2, -28 },
  { 8440, 24, 39, 32, 4, -28 },
  { 8557, 26, 27, 32, 6, -27 },
  { 8645, 25, 29, 32, 3, -28 },
  { 8736, 26, 38, 32, 4, -37 },
  { 8860, 22, 28, 32, 5, -27 },
  { 8937, 24, 28, 32, 4, -28 },
  { 9021, 26, 29, 32, 4, -28 },
  { 9116, 30, 29, 32, 1, -28 },
  { 9225, 25, 38, 32, 2, -27 },
  { 9344, 26, 29, 32, 3, -28 },
  { 9439, 23, 47, 32, 7, -40 },
  { 9575, 9, 47, 32, 12, -40 },
  { 9628, 23, 47, 32, 3, -40 },
  { 9764, 27, 9, 32, 3, -21 },
};

const GFXfont IBMPlexMono_ThinItalic53pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic53pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic53pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _IBMPLEXMONO_THINITALIC53PT7B_H_
