#ifndef _IBMPLEXMONO_THINITALIC59PT7B_H_
#define _IBMPLEXMONO_THINITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x07, 0x03, 0xC0, 0x70, 0x00, 0x10, 0x11, 0x03, 0x10, 0x33, 0x03, 0x30,
  0x22, 0x02, 0x20, 0x22, 0x06, 0x20, 0x66, 0x04, 0x60, 0x44, 0x04, 0x40,
  0x44, 0x0C, 0xC0, 0xC0, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x10, 0x04, 0x00,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x30, 0x04,
  0x00, 0x00, 0x04, 0x01, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x30, 0x04, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x00, 0x30, 0x04, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x80, 0x20,
  0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x04, 0x01, 0x80, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x30, 0x04, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x04, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x04, 0x01,
  0x80, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x04,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x08, 0x70, 0x00,
  0x60, 0x10, 0x38, 0x01, 0x80, 0x20, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x08,
  0x01, 0x80, 0x10, 0x20, 0x02, 0x00, 0x00, 0x40, 0x04, 0x00, 0x01, 0x80,
  0x08, 0x00, 0x03, 0x00, 0x10, 0x00, 0x06, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x18, 0x01, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x20, 0x04,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x71, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x08, 0xE0, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x80, 0x20, 0x00, 0x01, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x80, 0x0C, 0x00,
  0x01, 0x00, 0x18, 0x00, 0x02, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x43, 0x00,
  0x10, 0x01, 0x82, 0x00, 0x20, 0x02, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x80, 0x20, 0x03, 0x01, 0x01, 0x80, 0x01, 0xC6, 0x0E, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C,
  0x01, 0x80, 0x60, 0x00, 0x10, 0x06, 0x00, 0x40, 0x00, 0x40, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x01, 0x80, 0x02, 0x00, 0x20, 0x02, 0x00, 0x04, 0x00, 0x80, 0x04, 0x00,
  0x08, 0x03, 0x00, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x40, 0x00, 0x40, 0x01, 0x01, 0x80, 0x00, 0x80,
  0x02, 0x06, 0x00, 0x01, 0x00, 0x08, 0x08, 0x00, 0x01, 0x00, 0x30, 0x20,
  0x00, 0x03, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x07, 0x03, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x06, 0x03, 0x06, 0x00, 0x00, 0x08, 0x18, 0x02, 0x00, 0x00, 0x20, 0x60,
  0x06, 0x00, 0x00, 0x80, 0x80, 0x04, 0x00, 0x03, 0x03, 0x00, 0x08, 0x00,
  0x04, 0x04, 0x00, 0x10, 0x00, 0x10, 0x08, 0x00, 0x20, 0x00, 0x40, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x40, 0x00, 0x80, 0x02, 0x00, 0x80, 0x01, 0x00,
  0x08, 0x01, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x04, 0x00, 0xC0, 0x04,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x20, 0x04, 0x00, 0x18, 0x00, 0xC0,
  0x10, 0x00, 0x10, 0x01, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x01, 0x00, 0x30, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x10, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x10, 0x00, 0x30, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x02, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0xFC, 0x18,
  0x00, 0x01, 0x81, 0x38, 0x00, 0x00, 0x80, 0x30, 0x00, 0x00, 0x40, 0x0C,
  0x00, 0x00, 0x20, 0x01, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0x00, 0x28, 0x00, 0x01, 0x40,
  0x0E, 0x00, 0x00, 0x48, 0x06, 0x80, 0x00, 0x23, 0x01, 0x10, 0x00, 0x08,
  0x40, 0x84, 0x00, 0x04, 0x18, 0x60, 0x80, 0x03, 0x02, 0x10, 0x10, 0x01,
  0x80, 0x48, 0x03, 0x01, 0x80, 0x1E, 0x00, 0x3F, 0x80, 0x03, 0x00, 0x11,
  0x33, 0x22, 0x26, 0x66, 0x44, 0x4C, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x30, 0x00, 0xB8, 0x00, 0x80, 0x0F, 0x1C, 0x02,
  0x01, 0xE0, 0x0E, 0x08, 0x78, 0x00, 0x07, 0x2F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x10, 0x00,
  0x00, 0x08, 0x20, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x02, 0x01, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x80, 0x04, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x07, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x40, 0xC0, 0xFF,
  0xFF, 0x77, 0xF7, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20,
  0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x11, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x11, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x07, 0x00,
  0x14, 0x00, 0x70, 0x01, 0x40, 0x07, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x08, 0x01, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x30, 0x20, 0x00, 0x0C, 0x04, 0x00, 0x03, 0x01, 0x80, 0x01, 0x80, 0x30,
  0x00, 0x60, 0x04, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x10, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x60, 0x01, 0x80, 0x08, 0x00, 0x04, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x80, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x02, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x18, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x04, 0x03, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x60, 0x02, 0x00, 0x03, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x60, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x10, 0x00, 0xC0, 0x00, 0x40, 0x06, 0x00, 0x01, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x00, 0x80, 0x30, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x7F, 0xC0, 0x00, 0x47, 0x01, 0xC0, 0x01, 0x20, 0x00, 0x80,
  0x07, 0x00, 0x01, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x08, 0x03, 0x00, 0x00, 0x40, 0x07,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x1F, 0xE0, 0x04, 0x70, 0x0C, 0x06, 0x60,
  0x01, 0x82, 0xC0, 0x00, 0x63, 0x40, 0x00, 0x19, 0x40, 0x00, 0x04, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x44, 0x00, 0x00, 0x43, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x40, 0x30, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF2, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0C, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x00, 0x30, 0x01, 0x00,
  0x00, 0xC0, 0x10, 0x00, 0x02, 0x01, 0x80, 0x00, 0x08, 0x08, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x18, 0x10, 0x00, 0x00, 0x80, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x40, 0x18, 0x00, 0x04, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x60, 0x10, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x02, 0x20, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x81, 0x80, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x00, 0x40, 0x18, 0x00, 0x08,
  0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0x63, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x02, 0x60, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x14, 0x20, 0x00, 0x0D, 0x0C, 0x00, 0x06, 0xC1, 0x80,
  0x03, 0x20, 0x1C, 0x07, 0x18, 0x01, 0xFE, 0x04, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0x07, 0x81, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0x00, 0xC0, 0x30, 0x00, 0x40,
  0xC0, 0x00, 0x43, 0x00, 0x00, 0x44, 0x00, 0x00, 0x90, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x40, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x10, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x30, 0x80, 0x1F, 0x84,
  0x30, 0x0E, 0x0C, 0x84, 0x03, 0x00, 0x50, 0x80, 0xC0, 0x0A, 0x30, 0x10,
  0x00, 0xC4, 0x06, 0x00, 0x18, 0x80, 0x80, 0x03, 0x10, 0x10, 0x00, 0x42,
  0x06, 0x00, 0x08, 0xC0, 0x80, 0x01, 0x18, 0x10, 0x00, 0x22, 0x02, 0x00,
  0x0C, 0x40, 0x40, 0x01, 0x88, 0x18, 0x00, 0x21, 0x03, 0x00, 0x04, 0x60,
  0x40, 0x00, 0x8C, 0x08, 0x00, 0x11, 0x01, 0x00, 0x06, 0x20, 0x30, 0x00,
  0xC4, 0x02, 0x00, 0x30, 0x80, 0x40, 0x0A, 0x10, 0x08, 0x01, 0x42, 0x00,
  0x80, 0x48, 0x40, 0x0C, 0x31, 0x08, 0x00, 0x78, 0x41, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x31, 0x00, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x06, 0x02, 0x00, 0x00, 0x20, 0x10, 0x00, 0x03, 0x00,
  0x80, 0x00, 0x10, 0x04, 0x00, 0x01, 0x80, 0x20, 0x00, 0x08, 0x01, 0x80,
  0x00, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x20, 0x00, 0x60, 0x01, 0x00, 0x02,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0xC0, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x22, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x01, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x40, 0x10, 0x00, 0x02, 0x01, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01,
  0x03, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x01, 0x02, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x04,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x60, 0x0F, 0xFF, 0xF8, 0x00, 0x80, 0x00, 0x70, 0x08, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x41, 0x00, 0x00, 0x06, 0x10, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x22, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x04, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x04, 0x00, 0x01, 0xC0, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x02, 0x00, 0x00, 0x40, 0x10, 0x00, 0x08, 0x01, 0x80, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x04, 0x00, 0x01,
  0x00, 0x20, 0x00, 0x04, 0x01, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x00, 0x82, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x00, 0x80, 0x80, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00, 0x38, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x40, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF,
  0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x02, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x0A, 0x01, 0x00, 0x01, 0x20, 0x0C, 0x00, 0x62, 0x00, 0x70, 0x1C, 0x20,
  0x00, 0xFE, 0x04, 0x00, 0x01, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x00, 0x80, 0x80, 0x00, 0x01, 0x01, 0x00, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0x80, 0x80, 0x00, 0x03, 0x01, 0x00,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0x20, 0x20, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0x03, 0x00, 0x00, 0x04, 0x06, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00,
  0x10, 0x10, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x02, 0x03, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0x01, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x30, 0x10, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x08,
  0x0C, 0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x04, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x0C, 0x02, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x60, 0x02, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x18, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x08, 0x03, 0x00, 0x00, 0x08, 0x06, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x08, 0x1C, 0x00, 0x00, 0x18, 0x26, 0x00, 0x00, 0x18, 0x42, 0x00,
  0x00, 0x10, 0x83, 0x00, 0x00, 0x11, 0x01, 0x00, 0x00, 0x12, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x80, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x04, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x80, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0x80, 0x50, 0x00, 0x01, 0xC0, 0x28, 0x00, 0x00, 0xA0,
  0x14, 0x00, 0x00, 0x90, 0x1B, 0x00, 0x00, 0xC8, 0x0C, 0x80, 0x00, 0x4C,
  0x04, 0x40, 0x00, 0x64, 0x02, 0x30, 0x00, 0x22, 0x01, 0x08, 0x00, 0x21,
  0x00, 0x84, 0x00, 0x30, 0x80, 0xC2, 0x00, 0x10, 0x40, 0x61, 0x80, 0x18,
  0x60, 0x20, 0x40, 0x18, 0x20, 0x10, 0x20, 0x08, 0x10, 0x08, 0x18, 0x0C,
  0x08, 0x04, 0x04, 0x04, 0x04, 0x06, 0x02, 0x04, 0x02, 0x02, 0x01, 0x06,
  0x03, 0x01, 0x00, 0xC2, 0x01, 0x00, 0x80, 0x23, 0x00, 0x80, 0x40, 0x11,
  0x00, 0x40, 0x20, 0x09, 0x00, 0x20, 0x30, 0x03, 0x80, 0x10, 0x10, 0x01,
  0x80, 0x18, 0x08, 0x00, 0x80, 0x08, 0x04, 0x00, 0x40, 0x04, 0x02, 0x00,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x00, 0xC0, 0x40, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x06, 0x02, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x03, 0x80, 0x00, 0x0C, 0x05, 0x00, 0x00, 0x18, 0x1A, 0x00, 0x00,
  0x20, 0x36, 0x00, 0x00, 0x40, 0x44, 0x00, 0x00, 0x80, 0x88, 0x00, 0x01,
  0x01, 0x18, 0x00, 0x06, 0x02, 0x10, 0x00, 0x0C, 0x0C, 0x20, 0x00, 0x10,
  0x18, 0x60, 0x00, 0x20, 0x20, 0x40, 0x00, 0x40, 0x40, 0x80, 0x00, 0x80,
  0x81, 0x80, 0x03, 0x01, 0x01, 0x00, 0x06, 0x06, 0x02, 0x00, 0x08, 0x0C,
  0x02, 0x00, 0x10, 0x10, 0x04, 0x00, 0x20, 0x20, 0x0C, 0x00, 0x40, 0x40,
  0x08, 0x01, 0x80, 0x80, 0x10, 0x03, 0x03, 0x00, 0x30, 0x04, 0x06, 0x00,
  0x20, 0x08, 0x08, 0x00, 0x40, 0x10, 0x10, 0x00, 0xC0, 0x20, 0x20, 0x00,
  0x80, 0xC0, 0x40, 0x01, 0x01, 0x81, 0x80, 0x03, 0x02, 0x03, 0x00, 0x02,
  0x04, 0x04, 0x00, 0x04, 0x08, 0x08, 0x00, 0x0C, 0x10, 0x10, 0x00, 0x08,
  0x60, 0x20, 0x00, 0x10, 0xC0, 0xC0, 0x00, 0x11, 0x01, 0x80, 0x00, 0x22,
  0x02, 0x00, 0x00, 0x64, 0x04, 0x00, 0x00, 0x48, 0x08, 0x00, 0x00, 0xB0,
  0x10, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x40, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x20, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x11, 0x00, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x08, 0x01, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x02, 0x00, 0x80, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x07, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x40, 0x10,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x12, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x14, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x04, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x20, 0x60,
  0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x30, 0x00, 0x08, 0x01, 0x80, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x04, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x30, 0x30, 0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x02, 0x00, 0x80, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x18, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x20,
  0xC0, 0x00, 0x01, 0x82, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x07, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x00, 0x04, 0x00, 0x40,
  0x00, 0x10, 0x01, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x03, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x02,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x60, 0x04, 0x00, 0x00, 0x80, 0x10, 0x00, 0x03, 0x00, 0x40, 0x00,
  0x04, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x01, 0x06, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0x41, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x41, 0x00, 0x00,
  0x02, 0x08, 0x00, 0x00, 0x30, 0x40, 0x00, 0x01, 0x82, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x41, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x10, 0x40,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C,
  0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x10, 0x60,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x02, 0x04, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x01, 0x80, 0x00, 0x08,
  0x04, 0x00, 0x00, 0x80, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x18, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x60, 0x20, 0x00, 0x04, 0x02, 0x00, 0x00, 0xC0,
  0x20, 0x00, 0x08, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x10, 0x03, 0x00,
  0x03, 0x00, 0x10, 0x00, 0x20, 0x01, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x80, 0x01, 0x80, 0x18, 0x00, 0x08,
  0x01, 0x00, 0x00, 0x80, 0x30, 0x00, 0x08, 0x02, 0x00, 0x00, 0x80, 0x60,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x41, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x43, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0x88, 0x00,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x08, 0x40, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x00, 0x61, 0x00, 0x00, 0x00, 0x82, 0x00, 0x30,
  0x01, 0x04, 0x00, 0x60, 0x06, 0x08, 0x01, 0x40, 0x08, 0x10, 0x02, 0x80,
  0x10, 0x20, 0x09, 0x00, 0x20, 0x40, 0x12, 0x00, 0xC1, 0x80, 0x64, 0x01,
  0x03, 0x00, 0x8C, 0x02, 0x06, 0x03, 0x08, 0x04, 0x08, 0x04, 0x10, 0x18,
  0x10, 0x18, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80,
  0x81, 0x01, 0x03, 0x01, 0x02, 0x03, 0x04, 0x02, 0x08, 0x06, 0x08, 0x04,
  0x10, 0x04, 0x30, 0x08, 0x40, 0x08, 0x40, 0x10, 0x80, 0x10, 0x80, 0x23,
  0x00, 0x21, 0x00, 0xC4, 0x00, 0x46, 0x01, 0x98, 0x00, 0x88, 0x03, 0x20,
  0x01, 0x90, 0x04, 0xC0, 0x03, 0x20, 0x09, 0x00, 0x02, 0xC0, 0x16, 0x00,
  0x05, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x50, 0x00, 0x14, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x04, 0x00, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x02, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x01, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x40, 0x01, 0x00, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x18, 0x02, 0x00, 0x00,
  0x00, 0x80, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x00, 0xC0, 0x08, 0x00, 0x01, 0x80, 0x04, 0x00, 0x01, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x10, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x00, 0x41, 0x80, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x00, 0x22, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x7F, 0xFE, 0x01,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x43, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x06, 0x06, 0x00, 0x00, 0x80, 0x40, 0x00, 0x20, 0x08, 0x00,
  0x0C, 0x00, 0x80, 0x03, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x10, 0x00,
  0x20, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00, 0x40, 0x60, 0x00, 0x08, 0x08,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xF0,
  0x43, 0x06, 0x08, 0x30, 0x41, 0x82, 0x04, 0x10, 0x00, 0x1F, 0xC0, 0x00,
  0x0C, 0x07, 0x0C, 0x06, 0x00, 0x31, 0x01, 0x80, 0x01, 0x20, 0x60, 0x00,
  0x34, 0x18, 0x00, 0x02, 0x82, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06, 0x10,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x44, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C,
  0x40, 0x00, 0x01, 0x88, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0E, 0x08, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x50, 0x10, 0x00, 0x12, 0x01, 0x00, 0x04, 0x40, 0x10, 0x01,
  0x08, 0x01, 0x80, 0xC1, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x03, 0xF8, 0x00, 0x43, 0x81, 0x80, 0x31, 0x00, 0x18,
  0x0C, 0x80, 0x03, 0x02, 0x40, 0x00, 0x40, 0xA0, 0x00, 0x08, 0x28, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x11, 0x80, 0x00, 0x04, 0x60,
  0x00, 0x01, 0x10, 0x00, 0x00, 0x44, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x48, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x04, 0x40, 0x00, 0x03, 0x18, 0x00, 0x00, 0x86,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x10, 0xD0, 0x00, 0x08, 0x26, 0x00, 0x04,
  0x08, 0xC0, 0x06, 0x02, 0x0C, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x06, 0x04,
  0x00, 0x02, 0x08, 0x00, 0x03, 0x10, 0x00, 0x01, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x08, 0x20, 0x00, 0x10, 0x10,
  0x00, 0x60, 0x08, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x0F,
  0xE0, 0x30, 0x01, 0x80, 0xE1, 0x00, 0x30, 0x01, 0x88, 0x03, 0x00, 0x02,
  0x40, 0x30, 0x00, 0x1A, 0x03, 0x00, 0x00, 0x50, 0x10, 0x00, 0x01, 0x81,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x80, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0x83,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x60, 0x80, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x07, 0x01, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x02, 0x80,
  0x20, 0x00, 0x34, 0x00, 0x80, 0x03, 0x20, 0x02, 0x00, 0x31, 0x00, 0x0C,
  0x06, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x10, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x06, 0x20, 0x00, 0x03, 0x30, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x48, 0x00, 0x00, 0x64, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x63, 0x00, 0x00, 0xC1, 0x00, 0x03, 0x80, 0x80, 0x7E, 0x00,
  0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x02, 0x20, 0x00, 0x02, 0x18, 0x00, 0x03, 0x04, 0x00, 0x03, 0x01, 0x00,
  0x03, 0x00, 0x40, 0x03, 0x00, 0x18, 0x06, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x80, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x20, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x00, 0x60, 0x08,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x06, 0x04, 0x00, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x00, 0x21, 0x00, 0x00, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0x01, 0xC3, 0x00, 0xC0, 0x06, 0x20, 0x18, 0x00,
  0x12, 0x03, 0x00, 0x01, 0xA0, 0x60, 0x00, 0x0A, 0x04, 0x00, 0x00, 0x60,
  0x80, 0x00, 0x06, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C,
  0x20, 0x00, 0x00, 0x86, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x01, 0x84, 0x00, 0x00, 0x18, 0x40, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x10, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x07, 0x02, 0x00, 0x00, 0x70, 0x30, 0x00, 0x0A, 0x01, 0x00, 0x01,
  0x20, 0x08, 0x00, 0x22, 0x00, 0x40, 0x04, 0x20, 0x03, 0x01, 0x86, 0x00,
  0x0F, 0xE0, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x07, 0xF0, 0x04, 0x18, 0x1C, 0x04, 0x60, 0x06, 0x04, 0x80, 0x02,
  0x05, 0x00, 0x03, 0x0D, 0x00, 0x01, 0x0E, 0x00, 0x01, 0x0C, 0x00, 0x01,
  0x0C, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01,
  0x18, 0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x03, 0x10, 0x00, 0x02,
  0x10, 0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02,
  0x20, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04,
  0x60, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08,
  0x40, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x40, 0x01, 0x00, 0x20, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x0C, 0x03, 0x00, 0x04, 0x02, 0x00, 0x02, 0x06, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x8C, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x04, 0x00, 0x18, 0x07,
  0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x01, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x04, 0x20,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x68, 0x00, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x03, 0xF8,
  0x00, 0x10, 0x60, 0x30, 0x01, 0x8C, 0x00, 0x40, 0x08, 0x80, 0x01, 0x00,
  0x48, 0x00, 0x08, 0x02, 0x80, 0x00, 0x60, 0x18, 0x00, 0x01, 0x00, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x20, 0x10, 0x00, 0x02, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x03, 0x80, 0x00, 0x80,
  0xE0, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x20, 0x20, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x04, 0x00, 0x04, 0x80, 0x30, 0x00, 0x34, 0x00, 0x80, 0x02,
  0x20, 0x06, 0x00, 0x21, 0x00, 0x10, 0x02, 0x18, 0x00, 0x40, 0x20, 0xC0,
  0x03, 0x02, 0x04, 0x00, 0x08, 0x60, 0x20, 0x00, 0x66, 0x01, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x80, 0x80, 0x0C, 0x02, 0x00, 0x60,
  0x08, 0x02, 0x00, 0x60, 0x30, 0x01, 0x81, 0x00, 0x04, 0x18, 0x00, 0x10,
  0x80, 0x00, 0x4C, 0x00, 0x01, 0x40, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x0C, 0xC3, 0x06, 0x18, 0x1A, 0x01, 0x10, 0x18, 0x28, 0x02,
  0x40, 0x10, 0x50, 0x05, 0x00, 0x20, 0xC0, 0x0A, 0x00, 0x41, 0x00, 0x18,
  0x00, 0x86, 0x00, 0x30, 0x01, 0x0C, 0x00, 0x40, 0x02, 0x10, 0x00, 0x80,
  0x04, 0x20, 0x01, 0x00, 0x18, 0x40, 0x02, 0x00, 0x30, 0x80, 0x0C, 0x00,
  0x43, 0x00, 0x10, 0x00, 0x84, 0x00, 0x20, 0x01, 0x08, 0x00, 0x40, 0x02,
  0x10, 0x00, 0x80, 0x0C, 0x20, 0x01, 0x00, 0x18, 0x40, 0x06, 0x00, 0x21,
  0x80, 0x08, 0x00, 0x42, 0x00, 0x10, 0x00, 0x84, 0x00, 0x20, 0x01, 0x08,
  0x00, 0x40, 0x06, 0x10, 0x00, 0x80, 0x0C, 0x20, 0x03, 0x00, 0x10, 0xC0,
  0x04, 0x00, 0x21, 0x00, 0x08, 0x00, 0x42, 0x00, 0x10, 0x00, 0x84, 0x00,
  0x20, 0x03, 0x08, 0x00, 0x40, 0x06, 0x30, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x07, 0xF0, 0x06, 0x18, 0x1C, 0x04, 0x60, 0x06, 0x04, 0x80, 0x02, 0x05,
  0x00, 0x03, 0x0D, 0x00, 0x01, 0x0E, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x0C,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x18, 0x00, 0x01, 0x18,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10,
  0x00, 0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20,
  0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x60,
  0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40,
  0x00, 0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0x00, 0x1F, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x04, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x41, 0x00, 0x00, 0x18, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0x48, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x08, 0xC0, 0x00, 0x06, 0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0x60, 0x18,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x10, 0xE0, 0x60, 0x01,
  0x10, 0x01, 0x80, 0x32, 0x00, 0x0C, 0x02, 0x40, 0x00, 0x40, 0x28, 0x00,
  0x02, 0x02, 0x80, 0x00, 0x20, 0x30, 0x00, 0x03, 0x02, 0x00, 0x00, 0x10,
  0x60, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x08, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x01, 0x03, 0x40, 0x00, 0x20, 0x26, 0x00, 0x04, 0x02, 0x30, 0x01,
  0x80, 0x20, 0xC0, 0x70, 0x02, 0x03, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0C, 0x07, 0x0C, 0x06, 0x00, 0x31, 0x01, 0x80, 0x01,
  0x20, 0x60, 0x00, 0x34, 0x18, 0x00, 0x02, 0x82, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x06, 0x10, 0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0x80, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x44, 0x00, 0x00, 0x18, 0x80, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x18, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x88, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x40, 0x00, 0x0E, 0x08,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x50, 0x10, 0x00, 0x12, 0x01, 0x00, 0x04,
  0x40, 0x10, 0x01, 0x08, 0x01, 0x80, 0xC3, 0x00, 0x0F, 0xE0, 0x60, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0x1C, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x06, 0x18, 0x00, 0x00, 0x82, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x90, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x18, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x30, 0x00, 0x10, 0x02, 0x00, 0x01, 0x80, 0x60, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x02, 0x18, 0x00, 0x00, 0x13, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0x18, 0x00,
  0x01, 0x10, 0x00, 0x01, 0x10, 0x00, 0x03, 0x10, 0x00, 0x02, 0x10, 0x00,
  0x02, 0x30, 0x00, 0x02, 0x30, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00,
  0x06, 0x20, 0x00, 0x04, 0x20, 0x00, 0x04, 0x60, 0x00, 0x04, 0x60, 0x00,
  0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x08, 0xC0, 0x00, 0x08, 0xC0, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x10, 0x80, 0x00, 0x30, 0x80, 0x00, 0x50, 0xC0, 0x00,
  0xD0, 0x40, 0x00, 0xB0, 0x40, 0x01, 0x30, 0x20, 0x02, 0x20, 0x18, 0x0C,
  0x20, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xBF, 0xE0, 0x00, 0x30, 0x18,
  0x00, 0x04, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x40, 0x00, 0x10,
  0x10, 0x00, 0x04, 0x04, 0x00, 0x01, 0x03, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x10, 0x20, 0x00, 0x04, 0x08, 0x00, 0x01, 0x02, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x20, 0x20, 0x00, 0x08, 0x18, 0x00, 0x02, 0x06, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x30, 0x10, 0x00, 0x08, 0x04, 0x00, 0x04,
  0x01, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x40, 0x08, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x20, 0x0C, 0x00, 0x08,
  0x0E, 0x00, 0x06, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x60, 0x02, 0x00, 0x82, 0x00, 0x30, 0x04, 0x10, 0x01, 0x80, 0x30,
  0x80, 0x08, 0x00, 0x84, 0x00, 0x40, 0x04, 0x60, 0x02, 0x00, 0x22, 0x00,
  0x10, 0x01, 0x10, 0x01, 0x80, 0x08, 0x80, 0x0C, 0x00, 0x44, 0x00, 0x40,
  0x02, 0x20, 0x02, 0x00, 0x13, 0x00, 0x10, 0x00, 0x90, 0x00, 0x80, 0x04,
  0x80, 0x0C, 0x00, 0x24, 0x00, 0x60, 0x01, 0x20, 0x02, 0x00, 0x09, 0x00,
  0x10, 0x00, 0x58, 0x00, 0x80, 0x02, 0x80, 0x04, 0x00, 0x34, 0x00, 0x60,
  0x01, 0x20, 0x03, 0x00, 0x09, 0x00, 0x10, 0x00, 0x48, 0x00, 0x80, 0x06,
  0xC0, 0x04, 0x00, 0x26, 0x00, 0x60, 0x03, 0x30, 0x05, 0x00, 0x11, 0x80,
  0x28, 0x01, 0x84, 0x02, 0x60, 0x18, 0x20, 0x31, 0x01, 0x80, 0xC3, 0x04,
  0x18, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x39, 0x00,
  0xC1, 0x80, 0x60, 0xC0, 0xC0, 0x40, 0xC0, 0x20, 0xC0, 0x11, 0x80, 0x18,
  0x40, 0x09, 0x00, 0x04, 0x40, 0x04, 0x00, 0x02, 0x20, 0x02, 0x00, 0x01,
  0x20, 0x01, 0x00, 0x00, 0xD0, 0x00, 0x80, 0x00, 0x70, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x0A, 0x00, 0x01, 0x80, 0x05, 0x00, 0x00, 0xC0, 0x02, 0xC0, 0x00,
  0x60, 0x02, 0x20, 0x00, 0x30, 0x01, 0x10, 0x00, 0xC8, 0x01, 0x0C, 0x01,
  0x84, 0x01, 0x02, 0x03, 0x03, 0x01, 0x81, 0x86, 0x00, 0xC3, 0x00, 0x4C,
  0x00, 0x1F, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x18, 0x00, 0x01,
  0x01, 0x00, 0x00, 0x10, 0x10, 0x00, 0x03, 0x01, 0x00, 0x00, 0x20, 0x10,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x20, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0x20, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x0C, 0x04, 0x00, 0x00, 0x80, 0x40, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x80,
  0xC0, 0x00, 0x08, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x18, 0x08, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x30, 0x08, 0x00, 0x05, 0x00, 0xC0, 0x00, 0xD0,
  0x04, 0x00, 0x0B, 0x00, 0x40, 0x01, 0x30, 0x02, 0x00, 0x22, 0x00, 0x18,
  0x0C, 0x20, 0x00, 0x7F, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x04, 0x00, 0x02,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x41, 0x80, 0x0E, 0x06, 0x08,
  0x00, 0x0C, 0x20, 0xC0, 0x00, 0x1D, 0x04, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x30, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x80, 0x0C, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x30, 0x08, 0x00, 0x00, 0x80, 0x80, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x20, 0xFC, 0x00, 0x01, 0x04, 0x1F, 0x00, 0x08, 0x60, 0x07, 0xC0,
  0x62, 0x00, 0x01, 0xF3, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x07, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x20, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x18,
  0x60, 0x00, 0x10, 0x80, 0xC0, 0x00, 0x84, 0x01, 0x80, 0x02, 0x30, 0x03,
  0x00, 0x10, 0x80, 0x04, 0x00, 0x46, 0x00, 0x08, 0x02, 0x10, 0x00, 0x30,
  0x10, 0x40, 0x00, 0x60, 0x82, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 10, 41, 35, 13, -41 },
  { 53, 12, 15, 35, 15, -44 },
  { 76, 35, 41, 35, 1, -41 },
  { 256, 31, 55, 35, 2, -48 },
  { 470, 39, 43, 35, -1, -42 },
  { 680, 34, 43, 35, 1, -42 },
  { 863, 4, 15, 35, 19, -44 },
  { 871, 18, 53, 35, 14, -45 },
  { 991, 19, 53, 35, 4, -45 },
  { 1117, 30, 29, 35, 4, -32 },
  { 1226, 28, 29, 35, 4, -33 },
  { 1328, 8, 15, 35, 9, -5 },
  { 1343, 16, 1, 35, 10, -18 },
  { 1345, 4, 4, 35, 13, -4 },
  { 1347, 32, 53, 35, 2, -45 },
  { 1559, 28, 43, 35, 4, -42 },
  { 1710, 27, 41, 35, 3, -41 },
  { 1849, 28, 42, 35, 3, -42 },
  { 1996, 28, 43, 35, 3, -42 },
  { 2147, 30, 41, 35, 2, -41 },
  { 2301, 30, 42, 35, 3, -41 },
  { 2459, 25, 42, 35, 5, -41 },
  { 2591, 28, 41, 35, 7, -41 },
  { 2735, 29, 43, 35, 4, -42 },
  { 2891, 26, 42, 35, 6, -42 },
  { 3028, 9, 31, 35, 13, -31 },
  { 3063, 13, 41, 35, 9, -31 },
  { 3130, 28, 32, 35, 5, -34 },
  { 3242, 30, 12, 35, 3, -24 },
  { 3287, 28, 32, 35, 3, -34 },
  { 3399, 23, 42, 35, 9, -42 },
  { 3520, 27, 48, 35, 5, -42 },
  { 3682, 29, 41, 35, 1, -41 },
  { 3831, 28, 41, 35, 3, -41 },
  { 3975, 28, 43, 35, 5, -42 },
  { 4126, 29, 41, 35, 4, -41 },
  { 4275, 31, 41, 35, 4, -41 },
  { 4434, 31, 41, 35, 4, -41 },
  { 4593, 28, 43, 35, 5, -42 },
  { 4744, 31, 41, 35, 3, -41 },
  { 4903, 31, 41, 35, 3, -41 },
  { 5062, 28, 42, 35, 4, -41 },
  { 5209, 32, 41, 35, 4, -41 },
  { 5373, 23, 41, 35, 6, -41 },
  { 5491, 33, 41, 35, 2, -41 },
  { 5661, 31, 41, 35, 3, -41 },
  { 5820, 28, 43, 35, 4, -42 },
  { 5971, 30, 41, 35, 4, -41 },
  { 6125, 28, 52, 35, 4, -42 },
  { 6307, 30, 41, 35, 4, -41 },
  { 6461, 31, 43, 35, 2, -42 },
  { 6628, 30, 41, 35, 7, -41 },
  { 6782, 29, 42, 35, 5, -41 },
  { 6935, 28, 41, 35, 8, -41 },
  { 7079, 31, 41, 35, 5, -41 },
  { 7238, 36, 41, 35, 0, -41 },
  { 7423, 32, 41, 35, 6, -41 },
  { 7587, 36, 41, 35, 0, -41 },
  { 7772, 23, 53, 35, 12, -45 },
  { 7925, 13, 53, 35, 12, -45 },
  { 8012, 23, 53, 35, 2, -45 },
  { 8165, 27, 22, 35, 5, -41 },
  { 8240, 28, 1, 35, 0, 7 },
  { 8244, 6, 10, 35, 14, -45 },
  { 8252, 27, 32, 35, 4, -31 },
  { 8360, 26, 45, 35, 5, -44 },
  { 8507, 24, 32, 35, 5, -31 },
  { 8603, 29, 45, 35, 4, -44 },
  { 8767, 25, 32, 35, 5, -31 },
  { 8867, 37, 57, 35, -1, -44 },
  { 9131, 28, 44, 35, 3, -31 },
  { 9285, 24, 44, 35, 5, -44 },
  { 9417, 25, 44, 35, 5, -43 },
  { 9555, 25, 56, 35, 6, -43 },
  { 9730, 29, 45, 35, 5, -44 },
  { 9894, 22, 45, 35, 7, -44 },
  { 10018, 31, 31, 35, 2, -31 },
  { 10139, 24, 31, 35, 5, -31 },
  { 10232, 26, 32, 35, 5, -31 },
  { 10336, 28, 43, 35, 3, -31 },
  { 10487, 27, 43, 35, 4, -31 },
  { 10633, 28, 30, 35, 7, -30 },
  { 10738, 27, 32, 35, 4, -31 },
  { 10846, 29, 42, 35, 4, -41 },
  { 10999, 24, 31, 35, 6, -30 },
  { 11092, 26, 31, 35, 5, -31 },
  { 11193, 29, 32, 35, 4, -31 },
  { 11309, 33, 32, 35, 1, -31 },
  { 11441, 28, 43, 35, 2, -30 },
  { 11592, 29, 32, 35, 3, -31 },
  { 11708, 27, 53, 35, 7, -45 },
  { 11887, 10, 53, 35, 13, -45 },
  { 11954, 26, 53, 35, 3, -45 },
  { 12127, 30, 10, 35, 3, -23 },
};

const GFXfont IBMPlexMono_ThinItalic59pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic59pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic59pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _IBMPLEXMONO_THINITALIC59PT7B_H_
