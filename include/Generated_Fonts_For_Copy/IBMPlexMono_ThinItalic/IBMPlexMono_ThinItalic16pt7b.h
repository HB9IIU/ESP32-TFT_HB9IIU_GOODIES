#ifndef _IBMPLEXMONO_THINITALIC16PT7B_H_
#define _IBMPLEXMONO_THINITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0xAA, 0x08, 0xB6, 0xD0, 0x05, 0x82, 0x40, 0xA1, 0xE7, 0x12,
  0x04, 0x82, 0x43, 0x8E, 0x24, 0x12, 0x04, 0x80, 0x08, 0x08, 0x3C, 0x4B,
  0x88, 0x90, 0x50, 0x3C, 0x12, 0x12, 0x92, 0xA2, 0x7C, 0x20, 0x20, 0x38,
  0x51, 0x24, 0x51, 0x24, 0x3A, 0x00, 0x01, 0x70, 0xA2, 0x48, 0xA2, 0x48,
  0x70, 0x1E, 0x11, 0x08, 0x84, 0x41, 0x23, 0xE2, 0x21, 0x10, 0x84, 0xC5,
  0x5E, 0x40, 0xF0, 0x19, 0x11, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x20,
  0x20, 0x84, 0x10, 0x84, 0x21, 0x08, 0x84, 0x44, 0x40, 0x08, 0x08, 0x10,
  0xD3, 0x3C, 0x28, 0x48, 0x84, 0x08, 0x08, 0x10, 0x10, 0xFF, 0x10, 0x10,
  0x10, 0x20, 0xEA, 0xF0, 0x80, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x80, 0x80, 0x80, 0x1E, 0x22, 0x41, 0x81, 0x81,
  0x91, 0x82, 0x82, 0x82, 0x84, 0x78, 0x0C, 0x30, 0xA2, 0x40, 0x81, 0x04,
  0x08, 0x10, 0x23, 0xF8, 0x1E, 0x22, 0x41, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x20, 0xC0, 0xFE, 0x1C, 0xC4, 0x08, 0x10, 0x27, 0x81, 0x01, 0x83, 0x09,
  0xE0, 0x01, 0x01, 0x81, 0x41, 0x41, 0x21, 0x11, 0x08, 0xFF, 0x82, 0x02,
  0x01, 0x00, 0x3F, 0x40, 0x40, 0x40, 0x7C, 0x42, 0x02, 0x02, 0x82, 0x84,
  0x78, 0x06, 0x30, 0x82, 0x07, 0xC8, 0x60, 0xC1, 0x83, 0x09, 0xE0, 0xFF,
  0x06, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x82, 0x00, 0x1E, 0x21, 0x41,
  0x41, 0x42, 0x3C, 0x62, 0x82, 0x82, 0x82, 0x7C, 0x38, 0x8A, 0x0C, 0x18,
  0x50, 0x9F, 0x04, 0x10, 0x43, 0x00, 0x40, 0x02, 0x20, 0x00, 0x06, 0x92,
  0x00, 0x01, 0x06, 0x18, 0x20, 0xC0, 0x40, 0x30, 0x08, 0x06, 0xFF, 0x00,
  0x00, 0xFF, 0x40, 0x40, 0x60, 0x20, 0x20, 0x86, 0x30, 0x80, 0x3C, 0x8A,
  0x08, 0x10, 0x41, 0x0C, 0x10, 0x40, 0x01, 0x00, 0x1E, 0x22, 0x41, 0x4D,
  0x92, 0xA2, 0xA2, 0xA2, 0x96, 0x8C, 0x80, 0x80, 0x7C, 0x04, 0x0C, 0x0A,
  0x12, 0x12, 0x22, 0x22, 0x3E, 0x41, 0x81, 0x81, 0x3E, 0x42, 0x41, 0x42,
  0x82, 0x7C, 0x82, 0x82, 0x82, 0x82, 0xFC, 0x1E, 0x22, 0x41, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x82, 0x44, 0x38, 0x3C, 0x42, 0x41, 0x41, 0x41, 0x81,
  0x81, 0x82, 0x82, 0x84, 0xF8, 0x3F, 0x40, 0x40, 0x40, 0x80, 0x7E, 0x80,
  0x80, 0x80, 0x80, 0xFE, 0x3F, 0x40, 0x40, 0x40, 0x80, 0x7E, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x1E, 0x22, 0x41, 0x80, 0x80, 0x80, 0x8E, 0x82, 0x82,
  0x42, 0x3E, 0x41, 0x41, 0x41, 0x81, 0x82, 0x7E, 0x82, 0x82, 0x82, 0x82,
  0x84, 0x3F, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xFC,
  0x1F, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x84, 0x84, 0x78, 0x41,
  0xA1, 0x11, 0x09, 0x09, 0x05, 0x81, 0x21, 0x10, 0x84, 0x42, 0x20, 0x80,
  0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x41, 0x43, 0xA5,
  0xA5, 0xA9, 0x9A, 0x92, 0x82, 0x82, 0x82, 0x82, 0x41, 0x61, 0x61, 0x91,
  0x92, 0x92, 0x8A, 0x8A, 0x8A, 0x86, 0x84, 0x1E, 0x22, 0x41, 0x81, 0x81,
  0x81, 0x82, 0x82, 0x82, 0x84, 0x78, 0x3E, 0x41, 0x41, 0x41, 0x41, 0x81,
  0x7E, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x22, 0x41, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x82, 0x84, 0x78, 0x12, 0x0A, 0x04, 0x3E, 0x41, 0x41, 0x41, 0x41,
  0x81, 0x7E, 0x88, 0x88, 0x84, 0x86, 0x3C, 0x42, 0x81, 0x80, 0x40, 0x3C,
  0x02, 0x02, 0x82, 0x82, 0x7C, 0xFF, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x41, 0x41, 0x41, 0x81, 0x82, 0x82, 0x82, 0x82,
  0x82, 0x84, 0x78, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x50, 0x50,
  0x60, 0x20, 0x80, 0xC0, 0xA0, 0x51, 0x28, 0x95, 0xD2, 0xA9, 0x54, 0xCA,
  0x66, 0x21, 0x00, 0x20, 0xC8, 0x21, 0x10, 0x48, 0x0C, 0x02, 0x01, 0x40,
  0x50, 0x22, 0x10, 0x88, 0x10, 0x81, 0x82, 0x84, 0x48, 0x48, 0x30, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x3F, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x0F, 0xF0, 0x3C, 0x82, 0x10, 0x41, 0x04, 0x10,
  0x82, 0x08, 0x20, 0x83, 0xC0, 0x88, 0x88, 0x44, 0x44, 0x22, 0x22, 0x21,
  0x1E, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x9E,
  0x00, 0x08, 0x14, 0x24, 0x22, 0x42, 0x81, 0xFF, 0xAC, 0x3E, 0x8E, 0x0C,
  0x18, 0x50, 0xA3, 0x3D, 0x20, 0x81, 0x02, 0x05, 0xCC, 0x50, 0xC1, 0x83,
  0x05, 0x15, 0xC0, 0x3C, 0x8A, 0x0C, 0x08, 0x10, 0xE1, 0x3C, 0x01, 0x01,
  0x02, 0x02, 0x3E, 0x46, 0x82, 0x82, 0x84, 0x84, 0x84, 0x7C, 0x1C, 0xC6,
  0x0F, 0xE8, 0x10, 0x51, 0x3C, 0x03, 0xC1, 0x00, 0x40, 0x10, 0x3F, 0x82,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x82, 0x40, 0x90, 0x1C, 0x01, 0x00,
  0x3E, 0x8E, 0x0C, 0x18, 0x30, 0xA3, 0x3E, 0x05, 0x11, 0xC0, 0x20, 0x41,
  0x02, 0x05, 0xCC, 0x50, 0xA1, 0x83, 0x0A, 0x14, 0x20, 0x08, 0x00, 0x07,
  0x81, 0x02, 0x08, 0x10, 0x26, 0x50, 0xC0, 0x04, 0x00, 0x3F, 0x08, 0x20,
  0x82, 0x08, 0x49, 0x24, 0x70, 0xC0, 0x60, 0x40, 0x40, 0x40, 0x5E, 0x62,
  0x42, 0x84, 0x98, 0x91, 0x8A, 0x84, 0xF0, 0x82, 0x08, 0x20, 0x84, 0x10,
  0x45, 0x37, 0x10, 0xB7, 0x49, 0x89, 0x91, 0x91, 0x92, 0x92, 0x92, 0x5C,
  0xC5, 0x0A, 0x18, 0x30, 0xA1, 0x42, 0x3C, 0x86, 0x0C, 0x18, 0x30, 0x61,
  0x3C, 0x5C, 0xC5, 0x0C, 0x18, 0x30, 0x51, 0x5C, 0x81, 0x02, 0x00, 0x3E,
  0x8E, 0x0C, 0x18, 0x30, 0xA3, 0x3E, 0x04, 0x08, 0x20, 0xEF, 0x10, 0x20,
  0x20, 0x40, 0x40, 0x40, 0x40, 0x3C, 0x85, 0x03, 0xC0, 0x60, 0x60, 0xBE,
  0x10, 0x10, 0x10, 0xFF, 0x10, 0x20, 0x20, 0x20, 0x26, 0x38, 0x20, 0x86,
  0x18, 0x61, 0x8A, 0x29, 0xBA, 0xE2, 0x45, 0x0A, 0x14, 0x28, 0x92, 0x38,
  0xC9, 0x89, 0x91, 0x91, 0x91, 0x91, 0xB2, 0xEC, 0x13, 0x96, 0x51, 0x21,
  0x18, 0x84, 0xC2, 0x66, 0xCC, 0x42, 0x86, 0x0C, 0x18, 0x50, 0xA3, 0x3A,
  0x05, 0x11, 0xC0, 0x7D, 0x82, 0x84, 0x08, 0x30, 0x44, 0xE2, 0x9E, 0x1E,
  0x20, 0x40, 0x81, 0x02, 0x38, 0x18, 0x10, 0x41, 0x02, 0x04, 0x0F, 0x00,
  0x55, 0x6A, 0xAA, 0xA0, 0x3C, 0x10, 0x20, 0x43, 0x02, 0x03, 0x98, 0x20,
  0x40, 0x40, 0x81, 0x1C, 0x00, 0x71, 0x9A, 0x8E,
};

const GFXglyph IBMPlexMono_ThinItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 11, 10, 4, -11 },
  { 4, 3, 4, 10, 4, -12 },
  { 6, 10, 11, 10, 0, -11 },
  { 20, 8, 15, 10, 1, -13 },
  { 35, 10, 11, 10, 0, -11 },
  { 49, 9, 11, 10, 0, -11 },
  { 62, 1, 4, 10, 5, -12 },
  { 63, 5, 14, 10, 4, -12 },
  { 72, 5, 14, 10, 1, -12 },
  { 81, 8, 8, 10, 1, -9 },
  { 89, 8, 9, 10, 1, -9 },
  { 98, 2, 4, 10, 3, -1 },
  { 99, 4, 1, 10, 3, -5 },
  { 100, 1, 1, 10, 4, -1 },
  { 101, 8, 14, 10, 1, -12 },
  { 115, 8, 11, 10, 1, -11 },
  { 126, 7, 11, 10, 1, -11 },
  { 136, 8, 11, 10, 1, -11 },
  { 147, 7, 11, 10, 1, -11 },
  { 157, 9, 11, 10, 0, -11 },
  { 170, 8, 11, 10, 1, -11 },
  { 181, 7, 11, 10, 1, -11 },
  { 191, 7, 11, 10, 2, -11 },
  { 201, 8, 11, 10, 1, -11 },
  { 212, 7, 11, 10, 2, -11 },
  { 222, 2, 8, 10, 4, -8 },
  { 224, 3, 11, 10, 3, -8 },
  { 229, 8, 9, 10, 1, -9 },
  { 238, 8, 4, 10, 1, -7 },
  { 242, 7, 9, 10, 1, -9 },
  { 250, 7, 11, 10, 2, -11 },
  { 260, 8, 13, 10, 1, -11 },
  { 273, 8, 11, 10, 0, -11 },
  { 284, 8, 11, 10, 1, -11 },
  { 295, 8, 11, 10, 1, -11 },
  { 306, 8, 11, 10, 1, -11 },
  { 317, 8, 11, 10, 1, -11 },
  { 328, 8, 11, 10, 1, -11 },
  { 339, 8, 11, 10, 1, -11 },
  { 350, 8, 11, 10, 1, -11 },
  { 361, 8, 11, 10, 1, -11 },
  { 372, 8, 11, 10, 1, -11 },
  { 383, 9, 11, 10, 1, -11 },
  { 396, 6, 11, 10, 2, -11 },
  { 405, 8, 11, 10, 1, -11 },
  { 416, 8, 11, 10, 1, -11 },
  { 427, 8, 11, 10, 1, -11 },
  { 438, 8, 11, 10, 1, -11 },
  { 449, 8, 14, 10, 1, -11 },
  { 463, 8, 11, 10, 1, -11 },
  { 474, 8, 11, 10, 1, -11 },
  { 485, 8, 11, 10, 2, -11 },
  { 496, 8, 11, 10, 1, -11 },
  { 507, 8, 11, 10, 2, -11 },
  { 518, 9, 11, 10, 1, -11 },
  { 531, 10, 11, 10, 0, -11 },
  { 545, 8, 11, 10, 2, -11 },
  { 556, 10, 11, 10, 0, -11 },
  { 570, 6, 14, 10, 3, -12 },
  { 581, 4, 14, 10, 3, -12 },
  { 588, 7, 14, 10, 0, -12 },
  { 601, 8, 6, 10, 1, -11 },
  { 607, 8, 1, 10, 0, 2 },
  { 608, 2, 3, 10, 4, -13 },
  { 609, 7, 8, 10, 1, -8 },
  { 616, 7, 12, 10, 1, -12 },
  { 627, 7, 8, 10, 1, -8 },
  { 634, 8, 12, 10, 1, -12 },
  { 646, 7, 8, 10, 1, -8 },
  { 653, 10, 15, 10, 0, -12 },
  { 672, 7, 11, 10, 1, -8 },
  { 682, 7, 12, 10, 1, -12 },
  { 693, 7, 11, 10, 1, -11 },
  { 703, 6, 14, 10, 2, -11 },
  { 714, 8, 12, 10, 1, -12 },
  { 726, 6, 12, 10, 2, -12 },
  { 735, 8, 8, 10, 1, -8 },
  { 743, 7, 8, 10, 1, -8 },
  { 750, 7, 8, 10, 1, -8 },
  { 757, 7, 11, 10, 1, -8 },
  { 767, 7, 11, 10, 1, -8 },
  { 777, 8, 8, 10, 2, -8 },
  { 785, 7, 8, 10, 1, -8 },
  { 792, 8, 11, 10, 1, -11 },
  { 803, 6, 8, 10, 2, -8 },
  { 809, 7, 8, 10, 1, -8 },
  { 816, 8, 8, 10, 1, -8 },
  { 824, 9, 8, 10, 0, -8 },
  { 833, 7, 11, 10, 1, -8 },
  { 843, 8, 8, 10, 1, -8 },
  { 851, 7, 14, 10, 2, -12 },
  { 864, 2, 14, 10, 4, -12 },
  { 868, 7, 14, 10, 1, -12 },
  { 881, 8, 3, 10, 1, -7 },
};

const GFXfont IBMPlexMono_ThinItalic16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_THINITALIC16PT7B_H_
