#ifndef _IBMPLEXMONO_THINITALIC57PT7B_H_
#define _IBMPLEXMONO_THINITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0x30, 0x24,
  0x04, 0x81, 0x90, 0x32, 0x04, 0xC0, 0x98, 0x12, 0x02, 0x40, 0xC8, 0x19,
  0x02, 0x60, 0x4C, 0x09, 0x03, 0x00, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00,
  0x08, 0x02, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x10, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x08, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x40, 0x10,
  0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x20, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x10,
  0x04, 0x00, 0x00, 0x04, 0x03, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x00, 0x20, 0x08, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x04, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x20, 0x08,
  0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x10, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x08,
  0x02, 0x00, 0x00, 0x02, 0x00, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x40, 0x10, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0E,
  0x08, 0x70, 0x00, 0x60, 0x20, 0x30, 0x02, 0x00, 0x80, 0x60, 0x10, 0x02,
  0x00, 0xC0, 0x80, 0x08, 0x01, 0x02, 0x00, 0x60, 0x00, 0x18, 0x01, 0x00,
  0x00, 0x40, 0x04, 0x00, 0x01, 0x00, 0x10, 0x00, 0x04, 0x00, 0x40, 0x00,
  0x10, 0x01, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x20, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x08, 0x02, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x47, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00, 0x04, 0x06,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x80, 0x10, 0x00, 0x02, 0x00, 0x40,
  0x00, 0x08, 0x01, 0x80, 0x00, 0x20, 0x02, 0x00, 0x00, 0x80, 0x08, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x10, 0x01, 0x80, 0x00, 0x40, 0x04, 0x00, 0x01,
  0x00, 0x10, 0x80, 0x04, 0x00, 0xC1, 0x00, 0x10, 0x02, 0x06, 0x00, 0xC0,
  0x18, 0x0C, 0x02, 0x00, 0xC0, 0x0C, 0x08, 0x06, 0x00, 0x1E, 0x20, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0x04, 0x01, 0x00, 0x01, 0x00, 0x20, 0x02, 0x00, 0x08, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x30, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x03, 0x00, 0x40, 0x02, 0x00, 0x08, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x18, 0x00, 0x20, 0x00, 0x80, 0xC0, 0x00, 0x80, 0x02, 0x02, 0x00,
  0x02, 0x00, 0x18, 0x10, 0x00, 0x08, 0x00, 0x40, 0x80, 0x00, 0x20, 0x01,
  0x06, 0x00, 0x00, 0x80, 0x08, 0x10, 0x00, 0x01, 0x00, 0x40, 0x80, 0x00,
  0x03, 0x06, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x01, 0x83, 0x00, 0x00, 0x08, 0x08,
  0x02, 0x00, 0x00, 0x40, 0x40, 0x0C, 0x00, 0x03, 0x02, 0x00, 0x10, 0x00,
  0x08, 0x08, 0x00, 0x40, 0x00, 0x40, 0x40, 0x01, 0x00, 0x02, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x04, 0x00, 0x10, 0x00, 0x40, 0x10, 0x00, 0x40, 0x02,
  0x00, 0xC0, 0x01, 0x00, 0x10, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x30, 0x02, 0x00, 0x30, 0x00, 0x80, 0x10, 0x00, 0x40, 0x06, 0x00, 0x80,
  0x01, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0x80, 0x10, 0x00, 0x06, 0x0C,
  0x00, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x02, 0x00,
  0x00, 0x20, 0x02, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x3F, 0x06, 0x00, 0x00, 0x60, 0xCC, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x40, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x04, 0x00, 0x01, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x01, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x28, 0x01, 0xC0, 0x00,
  0x12, 0x01, 0xA0, 0x00, 0x09, 0x80, 0x98, 0x00, 0x08, 0x40, 0x84, 0x00,
  0x04, 0x30, 0xC3, 0x00, 0x04, 0x08, 0x40, 0xC0, 0x04, 0x02, 0x60, 0x18,
  0x0C, 0x01, 0xA0, 0x03, 0xF8, 0x00, 0x60, 0x00, 0x24, 0xB6, 0x92, 0x5B,
  0x49, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x04, 0xE0, 0x0C, 0x01, 0xD0,
  0xE0, 0x40, 0xF0, 0x00, 0xE2, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x08, 0x01, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xC0,
  0x00, 0x80, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0x06, 0x0E, 0x0C, 0x0C, 0x18,
  0x18, 0x30, 0x30, 0x20, 0x60, 0x40, 0x40, 0x80, 0xFF, 0xFE, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0x01, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0x40, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10,
  0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x60, 0x00,
  0x00, 0x88, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x48,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0xA0, 0x03, 0x00, 0x14, 0x00, 0xE0, 0x02, 0x80,
  0x1C, 0x00, 0xD0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x09, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x10, 0x00,
  0x04, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00,
  0x30, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x19, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x20, 0x00,
  0x06, 0x08, 0x00, 0x06, 0x02, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x20,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x80, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x60, 0x00, 0x60, 0x18, 0x00, 0x04, 0x06, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0x01, 0xC0, 0x01, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x40, 0x10, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x08, 0x40, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x40, 0xC0, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02,
  0x20, 0x00, 0x00, 0x21, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x20, 0x00, 0x01, 0x01, 0x00, 0x00,
  0x10, 0x08, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x18, 0x01, 0x00, 0x01, 0x80, 0x08, 0x00, 0x08, 0x00, 0x40,
  0x00, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0xC0, 0x00, 0x40, 0x0C, 0x00, 0x02, 0x00, 0x40, 0x00,
  0x30, 0x04, 0x00, 0x01, 0x80, 0x40, 0x00, 0x08, 0x06, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x02, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0xFF, 0x00, 0x01, 0x18, 0x06,
  0x00, 0x0B, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC0, 0x80,
  0x00, 0x04, 0x06, 0x00, 0x00, 0x40, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x3F, 0x80,
  0x11, 0xC0, 0x70, 0x26, 0x00, 0x18, 0x2C, 0x00, 0x0C, 0x78, 0x00, 0x06,
  0x50, 0x00, 0x02, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18,
  0x20, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xD8, 0x00, 0x00, 0x34, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x01, 0x10, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x02, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x00, 0x30, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x02, 0x00, 0x80, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x02, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x04, 0x08, 0x00, 0x00, 0x20, 0x40, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x80, 0x40, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80,
  0x04, 0x00, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1E,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00,
  0x10, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x23, 0x00,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x03, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x03,
  0x01, 0x80, 0x00, 0x81, 0x80, 0x00, 0x20, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x04, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x05, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x60, 0x00, 0x03, 0x90,
  0x00, 0x01, 0x8C, 0x00, 0x01, 0x43, 0x00, 0x01, 0x60, 0xC0, 0x03, 0x20,
  0x38, 0x0E, 0x30, 0x03, 0xFC, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x0F, 0x0F, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0,
  0xF0, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1C, 0x03, 0x00,
  0xC0, 0x03, 0x04, 0x00, 0x04, 0x20, 0x00, 0x09, 0x80, 0x00, 0x34, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0E, 0x03, 0x00, 0x06, 0x00, 0x20, 0x02, 0x00, 0x04, 0x01, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x20, 0x20, 0x00, 0x08, 0x10, 0x00, 0x02, 0x04, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x30, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x10,
  0x03, 0xF0, 0x84, 0x01, 0x83, 0x21, 0x01, 0x80, 0x28, 0xC0, 0x40, 0x0A,
  0x20, 0x20, 0x01, 0x88, 0x08, 0x00, 0x62, 0x06, 0x00, 0x11, 0x81, 0x00,
  0x04, 0x40, 0x40, 0x01, 0x10, 0x30, 0x00, 0x44, 0x0C, 0x00, 0x31, 0x02,
  0x00, 0x0C, 0x40, 0x80, 0x02, 0x30, 0x20, 0x00, 0x88, 0x08, 0x00, 0x22,
  0x02, 0x00, 0x08, 0x80, 0x80, 0x06, 0x20, 0x20, 0x01, 0x88, 0x08, 0x00,
  0xC2, 0x03, 0x00, 0x50, 0x80, 0x40, 0x24, 0x20, 0x0C, 0x11, 0x08, 0x01,
  0xF8, 0xC2, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x44, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x08, 0x40, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x02, 0x02, 0x00, 0x00, 0x20, 0x20, 0x00, 0x04, 0x02, 0x00,
  0x00, 0x40, 0x20, 0x00, 0x08, 0x03, 0x00, 0x00, 0x80, 0x10, 0x00, 0x10,
  0x01, 0x00, 0x01, 0x00, 0x10, 0x00, 0x20, 0x01, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x80, 0x04, 0x00, 0x08, 0x00, 0x80, 0x00, 0x80, 0x08,
  0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xF8, 0x02, 0x00, 0x00,
  0xC0, 0x20, 0x00, 0x04, 0x04, 0x00, 0x00, 0x40, 0x40, 0x00, 0x04, 0x08,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x22, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x01, 0xFF,
  0xFC, 0x00, 0x20, 0x00, 0x60, 0x04, 0x00, 0x02, 0x01, 0x80, 0x00, 0x20,
  0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x10, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x10, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x30, 0x07, 0xFF, 0xF8, 0x00, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x60, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x01, 0x18, 0x00, 0x00, 0x23, 0x00, 0x00, 0x04,
  0x40, 0x00, 0x00, 0x88, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x18, 0x10, 0x00, 0x0E, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x01, 0xC0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x06, 0x00, 0x00, 0x80, 0x80, 0x00,
  0x10, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x04, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00, 0x60, 0x02, 0x00, 0x18,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x40, 0x03, 0x80, 0x08, 0x00, 0x18, 0x01, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x08, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x10, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x23, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x88, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x44, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x08,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x10, 0x60, 0x00, 0x04, 0x0C, 0x00, 0x03,
  0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x81,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x01,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xE4,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x04, 0x40, 0x00, 0x00, 0x88, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x84, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x06, 0x08, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x28, 0x30, 0x00, 0x07, 0x02, 0x00, 0x01, 0x40, 0x20,
  0x00, 0x48, 0x06, 0x00, 0x11, 0x00, 0x30, 0x1C, 0x20, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x01, 0x00, 0x00, 0x04, 0x04, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x08, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x80, 0x80, 0x00, 0x06,
  0x03, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0xC0, 0x40,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x80, 0x80, 0x00, 0x02, 0x02, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x01, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10,
  0x10, 0x00, 0x00, 0x40, 0x40, 0x00, 0x03, 0x01, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x40, 0x60,
  0x00, 0x18, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x04, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x60, 0x10, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x01, 0x80, 0x00, 0x40, 0x02,
  0x00, 0x01, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x10,
  0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x04, 0x03, 0x00, 0x00, 0x08, 0x0C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0xD0, 0x00, 0x00, 0x83, 0x20,
  0x00, 0x01, 0x08, 0x20, 0x00, 0x02, 0x20, 0x40, 0x00, 0x04, 0x80, 0x40,
  0x00, 0x1A, 0x00, 0x80, 0x00, 0x38, 0x00, 0x80, 0x00, 0x60, 0x01, 0x00,
  0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x18, 0x00, 0x04, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x80, 0x00, 0x10, 0x01, 0x00, 0x00, 0x10, 0x06,
  0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0x80, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0E, 0x03, 0x40, 0x00,
  0x1A, 0x02, 0x40, 0x00, 0x12, 0x02, 0x40, 0x00, 0x36, 0x02, 0x60, 0x00,
  0x24, 0x02, 0x20, 0x00, 0x44, 0x02, 0x20, 0x00, 0xC4, 0x06, 0x20, 0x00,
  0x84, 0x04, 0x10, 0x01, 0x84, 0x04, 0x10, 0x01, 0x0C, 0x04, 0x10, 0x02,
  0x08, 0x04, 0x18, 0x06, 0x08, 0x04, 0x08, 0x04, 0x08, 0x0C, 0x08, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x10, 0x18, 0x08, 0x04, 0x30,
  0x10, 0x08, 0x04, 0x20, 0x10, 0x08, 0x06, 0x40, 0x10, 0x18, 0x02, 0xC0,
  0x10, 0x18, 0x02, 0x80, 0x10, 0x10, 0x03, 0x80, 0x30, 0x10, 0x01, 0x00,
  0x20, 0x10, 0x02, 0x00, 0x20, 0x10, 0x00, 0x00, 0x20, 0x30, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00,
  0x40, 0x20, 0x00, 0x00, 0x40, 0x20, 0x00, 0x00, 0x40, 0x60, 0x00, 0x00,
  0x40, 0x60, 0x00, 0x00, 0x40, 0x40, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0x00, 0x80, 0x40, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x80, 0x90, 0x00, 0x02, 0x02, 0x40, 0x00, 0x08, 0x09, 0x80, 0x00, 0x20,
  0x22, 0x00, 0x01, 0x81, 0x88, 0x00, 0x06, 0x06, 0x30, 0x00, 0x10, 0x10,
  0x40, 0x00, 0x40, 0x41, 0x00, 0x01, 0x01, 0x06, 0x00, 0x04, 0x04, 0x08,
  0x00, 0x30, 0x30, 0x20, 0x00, 0xC0, 0xC0, 0xC0, 0x02, 0x02, 0x01, 0x00,
  0x08, 0x08, 0x04, 0x00, 0x20, 0x20, 0x18, 0x00, 0x80, 0x80, 0x20, 0x06,
  0x02, 0x00, 0x80, 0x18, 0x18, 0x03, 0x00, 0x40, 0x40, 0x04, 0x01, 0x01,
  0x00, 0x10, 0x04, 0x04, 0x00, 0x20, 0x10, 0x10, 0x00, 0x80, 0xC0, 0x40,
  0x02, 0x03, 0x03, 0x00, 0x04, 0x08, 0x08, 0x00, 0x10, 0x20, 0x20, 0x00,
  0x60, 0x80, 0x80, 0x00, 0x82, 0x02, 0x00, 0x02, 0x18, 0x08, 0x00, 0x0C,
  0x60, 0x60, 0x00, 0x11, 0x01, 0x00, 0x00, 0x44, 0x04, 0x00, 0x01, 0x90,
  0x10, 0x00, 0x02, 0x40, 0x40, 0x00, 0x09, 0x01, 0x00, 0x00, 0x3C, 0x0C,
  0x00, 0x00, 0x60, 0x20, 0x00, 0x01, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0x01, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x40, 0x10, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x81, 0x80, 0x00, 0x10, 0x20, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x88, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x48, 0x00, 0x00, 0x09, 0x00, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x08, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x10, 0x10, 0x00, 0x04, 0x02, 0x00, 0x01, 0x80,
  0x20, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x10, 0x04, 0x00, 0x00, 0x40, 0x20, 0x00, 0x03, 0x03, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x40, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00, 0x18, 0x20,
  0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x0C, 0x01, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x01, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x00, 0x40, 0x10, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x10, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x04, 0x60, 0x00, 0x00, 0x88, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x4C, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x10, 0x10, 0x00, 0x04, 0x02, 0x00, 0x01, 0x80, 0x20, 0x00, 0x60, 0x02,
  0x00, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x40, 0x10, 0x00,
  0x04, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x80, 0x00, 0x10, 0x04, 0x00, 0x00, 0x40, 0x20, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x08, 0x18, 0x00, 0x00, 0x40, 0x80, 0x00, 0x03, 0x04, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x01, 0x04, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x04, 0x08, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0x80, 0x08, 0x03, 0x00, 0x00,
  0x40, 0x08, 0x00, 0x06, 0x00, 0x60, 0x00, 0x20, 0x01, 0x00, 0x01, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x20, 0x01, 0x80, 0x00, 0x80, 0x08, 0x00, 0x04, 0x00,
  0x40, 0x00, 0x10, 0x02, 0x00, 0x00, 0x80, 0x10, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00,
  0x18, 0x10, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06, 0x01, 0x00, 0x00, 0x0C,
  0x08, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x08,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x41, 0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x82, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x82, 0x00, 0x00, 0x08,
  0x20, 0x00, 0x01, 0x82, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x06, 0x00,
  0x00, 0x10, 0x40, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x08, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x08, 0x0C,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x00,
  0x08, 0x01, 0x00, 0x01, 0x80, 0x10, 0x00, 0x10, 0x01, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x40, 0x00, 0x80,
  0x0C, 0x00, 0x08, 0x00, 0x80, 0x00, 0x80, 0x18, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x04, 0x02, 0x00, 0x00, 0x40, 0x60, 0x00, 0x04,
  0x04, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x04, 0x08, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x02, 0x10, 0x00, 0x00, 0x23, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x08, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02, 0x08, 0x00,
  0x00, 0x08, 0x20, 0x06, 0x00, 0x20, 0x80, 0x18, 0x01, 0x86, 0x00, 0xE0,
  0x04, 0x18, 0x02, 0x80, 0x10, 0x60, 0x1B, 0x00, 0x41, 0x00, 0x4C, 0x02,
  0x04, 0x01, 0x10, 0x08, 0x10, 0x08, 0x40, 0x20, 0x40, 0x21, 0x01, 0x81,
  0x01, 0x04, 0x04, 0x04, 0x04, 0x10, 0x10, 0x10, 0x30, 0x40, 0x40, 0x40,
  0x81, 0x83, 0x01, 0x06, 0x02, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0xC0,
  0x20, 0x80, 0x42, 0x00, 0x86, 0x03, 0x18, 0x02, 0x10, 0x0C, 0x40, 0x08,
  0x40, 0x21, 0x00, 0x21, 0x00, 0x88, 0x00, 0xCC, 0x02, 0x20, 0x01, 0x20,
  0x09, 0x00, 0x04, 0x80, 0x24, 0x00, 0x16, 0x00, 0xB0, 0x00, 0x58, 0x02,
  0x80, 0x01, 0x40, 0x0E, 0x00, 0x05, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x30, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x10, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x08, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x20, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00,
  0x04, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x08, 0x00, 0x03, 0x00, 0x18, 0x00, 0x04, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x20, 0x01, 0x80, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x40, 0x08, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x01, 0x03, 0x00, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x08, 0x00, 0x01, 0x03, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x60, 0x18, 0x00, 0x30, 0x02, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x10, 0x02, 0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x40, 0x00,
  0x20, 0x20, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xE0, 0x83, 0x06, 0x08, 0x30, 0x41, 0x82, 0x04, 0x00, 0x3F, 0xC0, 0x00,
  0x38, 0x1C, 0x30, 0x10, 0x00, 0x88, 0x08, 0x00, 0x12, 0x04, 0x00, 0x02,
  0x82, 0x00, 0x00, 0xA1, 0x80, 0x00, 0x18, 0x40, 0x00, 0x06, 0x20, 0x00,
  0x01, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0x40,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x02, 0x20, 0x00, 0x00, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x1C, 0x10, 0x00, 0x0A, 0x02, 0x00, 0x02, 0x80,
  0xC0, 0x01, 0x20, 0x18, 0x01, 0x88, 0x03, 0x81, 0xC3, 0xF0, 0x3F, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0xFE, 0x00, 0x61, 0x81, 0xC0, 0x23, 0x00, 0x30,
  0x13, 0x00, 0x0C, 0x0B, 0x00, 0x02, 0x05, 0x00, 0x00, 0x87, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x31, 0x80, 0x00, 0x08, 0x80, 0x00, 0x04, 0x40, 0x00,
  0x02, 0x20, 0x00, 0x01, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x12, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x04, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x03, 0x20, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x47, 0x00, 0x00, 0x42,
  0x80, 0x00, 0x61, 0x20, 0x00, 0x60, 0x8C, 0x00, 0x40, 0x43, 0x80, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0xE0, 0x0C, 0x00,
  0x60, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x43, 0x00, 0x00, 0x44, 0x00, 0x00,
  0x90, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x01, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x08, 0x80, 0x00, 0x20, 0x80, 0x00, 0x81, 0x80, 0x02,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xC0, 0xC0, 0x0E, 0x07, 0x08, 0x01,
  0x00, 0x08, 0x80, 0x20, 0x00, 0x48, 0x04, 0x00, 0x02, 0x80, 0x80, 0x00,
  0x28, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x10, 0x60, 0x00, 0x01, 0x04, 0x00, 0x00, 0x10, 0x40, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x02, 0x08, 0x00, 0x00, 0x20, 0x80, 0x00, 0x06, 0x08, 0x00,
  0x00, 0x40, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0x40, 0x80, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0xC0, 0x40, 0x00, 0x1C, 0x04, 0x00, 0x02, 0x80, 0x20,
  0x00, 0x28, 0x03, 0x00, 0x04, 0x80, 0x18, 0x01, 0x88, 0x00, 0xE0, 0x70,
  0x80, 0x03, 0xF8, 0x10, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0x38, 0x01,
  0x80, 0x0C, 0x02, 0x00, 0x06, 0x04, 0x00, 0x02, 0x08, 0x00, 0x03, 0x10,
  0x00, 0x01, 0x30, 0x00, 0x03, 0x20, 0x00, 0x03, 0x60, 0x00, 0x02, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x18, 0x80, 0x00, 0x70, 0x80,
  0x01, 0x80, 0x80, 0x7E, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x04, 0x40, 0x00, 0x08, 0x40, 0x00, 0x18, 0x20,
  0x00, 0x10, 0x30, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x00, 0x60, 0x20,
  0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x07, 0x0C,
  0x02, 0x00, 0x11, 0x00, 0x80, 0x01, 0x20, 0x20, 0x00, 0x14, 0x08, 0x00,
  0x02, 0x83, 0x00, 0x00, 0x30, 0x40, 0x00, 0x06, 0x10, 0x00, 0x00, 0x82,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x02, 0x18, 0x00, 0x00, 0x43, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01,
  0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x0E, 0x04, 0x00, 0x02, 0x80, 0x40, 0x00, 0x50,
  0x0C, 0x00, 0x12, 0x00, 0xC0, 0x0C, 0x40, 0x0E, 0x07, 0x08, 0x00, 0x7F,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x10, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0xFE, 0x00, 0x86, 0x07, 0x01, 0x10, 0x03, 0x06, 0x40,
  0x02, 0x0D, 0x00, 0x02, 0x14, 0x00, 0x04, 0x30, 0x00, 0x08, 0x60, 0x00,
  0x10, 0x80, 0x00, 0x23, 0x00, 0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x01,
  0x10, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x19, 0x80, 0x00, 0x22,
  0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20,
  0x00, 0x0C, 0xC0, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00,
  0x00, 0x88, 0x00, 0x03, 0x10, 0x00, 0x06, 0x60, 0x00, 0x08, 0x80, 0x00,
  0x11, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x04, 0x00, 0x80,
  0x18, 0x00, 0x80, 0x20, 0x00, 0x80, 0xC0, 0x01, 0x81, 0x00, 0x01, 0x86,
  0x00, 0x01, 0x08, 0x00, 0x01, 0x30, 0x00, 0x01, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x02, 0x00, 0x08, 0x02, 0x00, 0x04, 0x02,
  0x00, 0x02, 0x02, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x60, 0x7F, 0x80, 0x02, 0x0C, 0x06, 0x00, 0x11, 0x80,
  0x08, 0x00, 0x98, 0x00, 0x20, 0x05, 0x00, 0x01, 0x00, 0x28, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x20, 0x18, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x04,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x04, 0x01, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x04, 0x00, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x18, 0x00, 0x20, 0x03, 0x00,
  0x01, 0x00, 0xE0, 0x00, 0x08, 0x38, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x00, 0x40, 0x00, 0xC8, 0x03,
  0x00, 0x08, 0x40, 0x08, 0x00, 0x86, 0x00, 0x60, 0x08, 0x20, 0x01, 0x00,
  0x81, 0x00, 0x0C, 0x08, 0x08, 0x00, 0x20, 0x80, 0x40, 0x00, 0x88, 0x02,
  0x00, 0x04, 0x80, 0x20, 0x00, 0x18, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x08, 0x10, 0x01,
  0x81, 0x80, 0x10, 0x0C, 0x03, 0x00, 0x40, 0x20, 0x02, 0x06, 0x00, 0x10,
  0x40, 0x00, 0x8C, 0x00, 0x0C, 0x80, 0x00, 0x58, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x19, 0x86, 0x18, 0x60, 0x48, 0x08, 0x80, 0xC1,
  0x40, 0x14, 0x01, 0x06, 0x00, 0x60, 0x04, 0x18, 0x01, 0x80, 0x10, 0xC0,
  0x04, 0x00, 0x43, 0x00, 0x30, 0x01, 0x08, 0x00, 0xC0, 0x04, 0x20, 0x02,
  0x00, 0x10, 0x80, 0x08, 0x00, 0xC6, 0x00, 0x20, 0x02, 0x18, 0x00, 0x80,
  0x08, 0x40, 0x06, 0x00, 0x21, 0x00, 0x18, 0x00, 0x84, 0x00, 0x40, 0x02,
  0x10, 0x01, 0x00, 0x18, 0xC0, 0x04, 0x00, 0x43, 0x00, 0x10, 0x01, 0x08,
  0x00, 0xC0, 0x04, 0x20, 0x03, 0x00, 0x10, 0x80, 0x08, 0x00, 0x42, 0x00,
  0x20, 0x03, 0x18, 0x00, 0x80, 0x08, 0x60, 0x02, 0x00, 0x21, 0x00, 0x18,
  0x00, 0x84, 0x00, 0x60, 0x02, 0x10, 0x01, 0x00, 0x08, 0x40, 0x04, 0x00,
  0x63, 0x00, 0x10, 0x01, 0x00, 0x00, 0x0F, 0xE0, 0x08, 0x60, 0x70, 0x11,
  0x00, 0x30, 0x64, 0x00, 0x20, 0xD0, 0x00, 0x21, 0x40, 0x00, 0x43, 0x00,
  0x00, 0x86, 0x00, 0x01, 0x08, 0x00, 0x02, 0x30, 0x00, 0x04, 0x60, 0x00,
  0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01,
  0x98, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x11,
  0x00, 0x00, 0x22, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20,
  0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00, 0x31, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x60, 0x38, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x00, 0x80, 0xC0, 0x00, 0x20,
  0xC0, 0x00, 0x10, 0x40, 0x00, 0x04, 0x60, 0x00, 0x02, 0x20, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x90, 0x00, 0x00, 0x68, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x01, 0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x12, 0x00, 0x00, 0x11, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x08, 0x20, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x04, 0x00, 0x04, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x18, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x61, 0x81, 0xC0, 0x08, 0xC0, 0x0C, 0x01, 0x30, 0x00, 0xC0, 0x2C,
  0x00, 0x08, 0x05, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x10, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x20, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x02, 0x18, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08,
  0x40, 0x00, 0x01, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x07, 0x00, 0x00,
  0x40, 0xA0, 0x00, 0x18, 0x12, 0x00, 0x06, 0x02, 0x30, 0x01, 0x00, 0x43,
  0x80, 0xC0, 0x18, 0x1F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x1C, 0x30, 0x10,
  0x00, 0x88, 0x08, 0x00, 0x12, 0x04, 0x00, 0x02, 0x82, 0x00, 0x00, 0xA1,
  0x80, 0x00, 0x18, 0x40, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x46, 0x00, 0x00, 0x11, 0x00, 0x00, 0x04, 0x40, 0x00, 0x03, 0x10, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02, 0x20,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04,
  0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x1C, 0x10, 0x00, 0x0A, 0x02, 0x00, 0x02, 0x80, 0xC0, 0x01, 0x20, 0x18,
  0x01, 0x88, 0x03, 0x81, 0xC2, 0x00, 0x3F, 0x81, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x04, 0x70,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x14, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x30, 0x00, 0x30, 0x18, 0x00, 0x06, 0x04, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x10, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x04, 0x00, 0x08, 0x01, 0x80,
  0x00, 0x80, 0x60, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x83, 0x00, 0x00, 0x18,
  0x40, 0x00, 0x01, 0x98, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x02, 0x20, 0x00, 0x04, 0x40, 0x00, 0x08, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x02,
  0x20, 0x00, 0x04, 0x40, 0x00, 0x19, 0x80, 0x00, 0x23, 0x00, 0x00, 0x44,
  0x00, 0x00, 0x88, 0x00, 0x01, 0x10, 0x00, 0x02, 0x20, 0x00, 0x0C, 0xC0,
  0x00, 0x11, 0x80, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00,
  0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x18, 0x40, 0x00, 0x50, 0x80, 0x00,
  0xA1, 0x80, 0x02, 0x41, 0x00, 0x09, 0x83, 0x00, 0x23, 0x03, 0x81, 0x84,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0x7F, 0x80, 0x00, 0xC0, 0x40,
  0x00, 0x20, 0x20, 0x00, 0x10, 0x10, 0x00, 0x08, 0x08, 0x00, 0x04, 0x0C,
  0x00, 0x02, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0x40,
  0x80, 0x00, 0x20, 0x40, 0x00, 0x10, 0x60, 0x00, 0x18, 0x30, 0x00, 0x08,
  0x10, 0x00, 0x04, 0x08, 0x00, 0x06, 0x04, 0x00, 0x02, 0x02, 0x00, 0x01,
  0x01, 0x00, 0x01, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x40, 0x00,
  0x80, 0x20, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0xC0, 0x06, 0x00, 0x80, 0x02, 0x01, 0x80, 0x01, 0x07, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x80, 0x08, 0x02, 0x08, 0x00, 0x80,
  0x20, 0x80, 0x08, 0x03, 0x18, 0x01, 0x80, 0x31, 0x80, 0x18, 0x01, 0x10,
  0x01, 0x00, 0x11, 0x00, 0x10, 0x01, 0x10, 0x01, 0x00, 0x11, 0x00, 0x10,
  0x01, 0x30, 0x03, 0x00, 0x12, 0x00, 0x30, 0x01, 0x20, 0x02, 0x00, 0x12,
  0x00, 0x20, 0x01, 0x20, 0x02, 0x00, 0x12, 0x00, 0x20, 0x01, 0x60, 0x06,
  0x00, 0x14, 0x00, 0x60, 0x01, 0x40, 0x04, 0x00, 0x34, 0x00, 0x40, 0x02,
  0x40, 0x04, 0x00, 0x24, 0x00, 0x40, 0x02, 0xC0, 0x0C, 0x00, 0x68, 0x00,
  0xC0, 0x04, 0x80, 0x14, 0x00, 0x48, 0x01, 0x40, 0x08, 0x80, 0x24, 0x01,
  0x8C, 0x02, 0x40, 0x10, 0x40, 0x44, 0x02, 0x06, 0x08, 0x30, 0xC0, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x66, 0x01, 0x06, 0x03,
  0x82, 0x06, 0x02, 0x0E, 0x03, 0x04, 0x01, 0x38, 0x01, 0x08, 0x01, 0x40,
  0x01, 0x10, 0x01, 0x00, 0x01, 0x90, 0x01, 0x00, 0x00, 0xA0, 0x01, 0x00,
  0x00, 0xA0, 0x01, 0x00, 0x00, 0xA0, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x40, 0x02, 0x80, 0x00, 0xC0, 0x02, 0x80, 0x00, 0xC0,
  0x04, 0x80, 0x00, 0xC0, 0x04, 0x80, 0x00, 0xC0, 0x08, 0x80, 0x04, 0x40,
  0x18, 0x40, 0x1A, 0x40, 0x10, 0x40, 0x60, 0x60, 0x20, 0x61, 0x80, 0x30,
  0xC0, 0x37, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x20,
  0x00, 0x04, 0x04, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x30, 0x00, 0x04,
  0x06, 0x00, 0x00, 0x80, 0x80, 0x00, 0x10, 0x10, 0x00, 0x02, 0x02, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x18, 0x18, 0x00, 0x02, 0x03, 0x00, 0x00, 0x40,
  0x40, 0x00, 0x08, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x20, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x01, 0x80, 0x00, 0x20, 0x20, 0x00, 0x04, 0x04,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x10, 0x00, 0x06, 0x02, 0x00, 0x01,
  0x80, 0x40, 0x00, 0x50, 0x08, 0x00, 0x0A, 0x01, 0x80, 0x02, 0x40, 0x10,
  0x00, 0x98, 0x03, 0x00, 0x23, 0x00, 0x38, 0x18, 0x40, 0x01, 0xFC, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x08, 0x00, 0x03, 0x00,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x30, 0x38, 0x03, 0x04, 0x00, 0x70,
  0x30, 0xC0, 0x00, 0xC2, 0x08, 0x00, 0x03, 0xA0, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x30, 0x10, 0x00, 0x06, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0x20, 0x06, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x10, 0x10, 0x00, 0x01, 0x06, 0x00, 0x00, 0x10, 0x7C, 0x00, 0x01,
  0x0C, 0x3E, 0x00, 0x10, 0x80, 0x1F, 0x01, 0x88, 0x00, 0x0F, 0x98, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x08, 0x31, 0x80, 0x00, 0xC2, 0x02, 0x00, 0x04, 0x20, 0x08, 0x00, 0x23,
  0x00, 0x20, 0x02, 0x10, 0x01, 0x80, 0x11, 0x00, 0x04, 0x01, 0x08, 0x00,
  0x10, 0x10, 0xC0, 0x00, 0x61, 0x04, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 9, 40, 34, 13, -40 },
  { 46, 11, 14, 34, 15, -42 },
  { 66, 34, 40, 34, 1, -40 },
  { 236, 30, 53, 34, 2, -46 },
  { 435, 38, 41, 34, -1, -40 },
  { 630, 33, 41, 34, 1, -40 },
  { 800, 3, 14, 34, 19, -42 },
  { 806, 18, 51, 34, 13, -43 },
  { 921, 18, 51, 34, 4, -43 },
  { 1036, 29, 28, 34, 4, -31 },
  { 1138, 27, 27, 34, 4, -31 },
  { 1230, 8, 14, 34, 9, -4 },
  { 1244, 15, 1, 34, 10, -18 },
  { 1246, 4, 4, 34, 13, -4 },
  { 1248, 30, 51, 34, 2, -43 },
  { 1440, 27, 41, 34, 4, -40 },
  { 1579, 26, 40, 34, 3, -40 },
  { 1709, 27, 40, 34, 3, -40 },
  { 1844, 27, 41, 34, 3, -40 },
  { 1983, 29, 40, 34, 2, -40 },
  { 2128, 29, 41, 34, 3, -40 },
  { 2277, 24, 41, 34, 5, -40 },
  { 2400, 26, 40, 34, 7, -40 },
  { 2530, 29, 41, 34, 3, -40 },
  { 2679, 25, 40, 34, 6, -40 },
  { 2804, 8, 30, 34, 13, -30 },
  { 2834, 12, 40, 34, 9, -30 },
  { 2894, 27, 30, 34, 5, -32 },
  { 2996, 29, 11, 34, 3, -23 },
  { 3036, 27, 30, 34, 3, -32 },
  { 3138, 22, 40, 34, 9, -40 },
  { 3248, 26, 46, 34, 5, -40 },
  { 3398, 28, 40, 34, 1, -40 },
  { 3538, 27, 40, 34, 3, -40 },
  { 3673, 27, 41, 34, 5, -40 },
  { 3812, 27, 40, 34, 4, -40 },
  { 3947, 29, 40, 34, 4, -40 },
  { 4092, 30, 40, 34, 4, -40 },
  { 4242, 27, 41, 34, 5, -40 },
  { 4381, 30, 40, 34, 3, -40 },
  { 4531, 30, 40, 34, 3, -40 },
  { 4681, 27, 41, 34, 4, -40 },
  { 4820, 31, 40, 34, 4, -40 },
  { 4975, 22, 40, 34, 6, -40 },
  { 5085, 32, 40, 34, 2, -40 },
  { 5245, 30, 40, 34, 3, -40 },
  { 5395, 27, 41, 34, 4, -40 },
  { 5534, 29, 40, 34, 4, -40 },
  { 5679, 27, 50, 34, 4, -40 },
  { 5848, 29, 40, 34, 4, -40 },
  { 5993, 30, 41, 34, 2, -40 },
  { 6147, 30, 40, 34, 6, -40 },
  { 6297, 28, 41, 34, 5, -40 },
  { 6441, 28, 40, 34, 7, -40 },
  { 6581, 30, 40, 34, 5, -40 },
  { 6731, 35, 40, 34, 0, -40 },
  { 6906, 31, 40, 34, 6, -40 },
  { 7061, 34, 40, 34, 0, -40 },
  { 7231, 22, 51, 34, 11, -43 },
  { 7372, 13, 51, 34, 11, -43 },
  { 7455, 22, 51, 34, 2, -43 },
  { 7596, 26, 21, 34, 5, -40 },
  { 7665, 27, 1, 34, 0, 7 },
  { 7669, 6, 9, 34, 14, -43 },
  { 7676, 26, 31, 34, 4, -30 },
  { 7777, 25, 43, 34, 5, -42 },
  { 7912, 23, 31, 34, 5, -30 },
  { 8002, 28, 43, 34, 4, -42 },
  { 8153, 24, 31, 34, 5, -30 },
  { 8246, 36, 54, 34, -1, -42 },
  { 8489, 27, 42, 34, 3, -30 },
  { 8631, 23, 42, 34, 5, -42 },
  { 8752, 24, 43, 34, 5, -42 },
  { 8881, 24, 54, 34, 6, -42 },
  { 9043, 29, 43, 34, 4, -42 },
  { 9199, 21, 43, 34, 7, -42 },
  { 9312, 30, 30, 34, 2, -30 },
  { 9425, 23, 30, 34, 5, -30 },
  { 9512, 25, 31, 34, 5, -30 },
  { 9609, 27, 41, 34, 3, -30 },
  { 9748, 26, 41, 34, 4, -30 },
  { 9882, 27, 29, 34, 7, -29 },
  { 9980, 26, 31, 34, 4, -30 },
  { 10081, 28, 41, 34, 4, -40 },
  { 10225, 23, 30, 34, 6, -29 },
  { 10312, 25, 30, 34, 5, -30 },
  { 10406, 28, 31, 34, 4, -30 },
  { 10515, 32, 31, 34, 1, -30 },
  { 10639, 27, 41, 34, 2, -29 },
  { 10778, 28, 31, 34, 3, -30 },
  { 10887, 25, 51, 34, 7, -43 },
  { 11047, 9, 51, 34, 13, -43 },
  { 11105, 25, 51, 34, 3, -43 },
  { 11265, 29, 10, 34, 3, -22 },
};

const GFXfont IBMPlexMono_ThinItalic57pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic57pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic57pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _IBMPLEXMONO_THINITALIC57PT7B_H_
