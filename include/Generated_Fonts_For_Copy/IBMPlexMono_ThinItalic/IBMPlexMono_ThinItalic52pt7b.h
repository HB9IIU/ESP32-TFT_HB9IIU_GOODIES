#ifndef _IBMPLEXMONO_THINITALIC52PT7B_H_
#define _IBMPLEXMONO_THINITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0xE0, 0x20, 0x48, 0x36, 0x09, 0x02, 0x40, 0x90, 0x24, 0x09, 0x06, 0xC1,
  0x20, 0x48, 0x12, 0x04, 0x83, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01,
  0x00, 0x80, 0x00, 0x02, 0x01, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x10,
  0x08, 0x00, 0x00, 0x60, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x00,
  0x80, 0x00, 0x06, 0x01, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x10, 0x08,
  0x00, 0x00, 0x60, 0x10, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0x00, 0x80,
  0x00, 0x06, 0x01, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x10, 0x08, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x00, 0x80, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x10, 0x08, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0x80, 0x40, 0x00, 0x01, 0x00, 0x80, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40,
  0x30, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x00, 0x80, 0x00, 0x04, 0x03,
  0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1C,
  0x31, 0xC0, 0x04, 0x04, 0x0C, 0x01, 0x00, 0x80, 0x40, 0x40, 0x10, 0x04,
  0x10, 0x02, 0x00, 0x82, 0x00, 0x40, 0x00, 0x40, 0x18, 0x00, 0x18, 0x02,
  0x00, 0x02, 0x00, 0x40, 0x00, 0x40, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x10, 0x04, 0x00, 0x03, 0x01, 0x00, 0x00, 0x30, 0x20,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x83, 0x00, 0x00, 0x10, 0x10, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x08, 0x02, 0x00, 0x01, 0x00, 0x40, 0x00,
  0x40, 0x08, 0x00, 0x08, 0x01, 0x00, 0x01, 0x00, 0x20, 0x00, 0x20, 0x04,
  0x00, 0x04, 0x00, 0x88, 0x00, 0x80, 0x31, 0x00, 0x20, 0x04, 0x10, 0x04,
  0x01, 0x81, 0x00, 0x80, 0x60, 0x18, 0x10, 0x18, 0x01, 0xE2, 0x1C, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x02, 0x01, 0x80, 0x02, 0x00, 0x80, 0x10,
  0x00, 0xC0, 0x30, 0x01, 0x00, 0x10, 0x04, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x04, 0x01, 0x00, 0x30, 0x00, 0x80, 0x60, 0x04, 0x00, 0x30, 0x08, 0x00,
  0x80, 0x04, 0x02, 0x00, 0x10, 0x00, 0x80, 0x80, 0x02, 0x00, 0x10, 0x30,
  0x00, 0x40, 0x04, 0x04, 0x00, 0x04, 0x00, 0x81, 0x00, 0x00, 0x80, 0x20,
  0x40, 0x00, 0x0C, 0x18, 0x10, 0x00, 0x00, 0x7C, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0F, 0x80, 0x00, 0x04, 0x06, 0x0C,
  0x00, 0x00, 0x81, 0x00, 0xC0, 0x00, 0x20, 0x40, 0x08, 0x00, 0x08, 0x10,
  0x01, 0x00, 0x02, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x00, 0x10,
  0x10, 0x00, 0xC0, 0x04, 0x02, 0x00, 0x10, 0x01, 0x00, 0x40, 0x02, 0x00,
  0x60, 0x08, 0x00, 0x40, 0x08, 0x01, 0x00, 0x08, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x80, 0x02, 0x00, 0x40, 0x30, 0x00, 0x40, 0x10, 0x04, 0x00, 0x06,
  0x0C, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x04, 0x00, 0x80, 0x00, 0x20, 0x01, 0x00, 0x00, 0x80,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x00, 0x80, 0x04, 0x00, 0x02, 0x00, 0x10, 0x00,
  0x04, 0x00, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x00, 0x20, 0x10, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x79, 0x1C, 0x00, 0x02, 0x03, 0x80, 0x00, 0x30, 0x08,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x04, 0x00, 0x60, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x80, 0x00, 0x40, 0x02, 0x00, 0x01, 0x80, 0x28,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x24, 0x06, 0x80, 0x00, 0x88, 0x11, 0x00,
  0x04, 0x20, 0x84, 0x00, 0x10, 0x46, 0x08, 0x01, 0x81, 0x90, 0x18, 0x1C,
  0x02, 0x80, 0x1F, 0xC0, 0x06, 0x00, 0x24, 0x96, 0xD2, 0x4B, 0x68, 0x00,
  0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x80, 0x0F, 0xE0, 0x10, 0x0F, 0x07, 0x82, 0x0E, 0x00,
  0x1E, 0x5E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x08, 0x60, 0x00, 0x02, 0x04, 0x00, 0x00,
  0x80, 0x40, 0x00, 0x20, 0x08, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x10,
  0x00, 0xC0, 0x01, 0x00, 0x10, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x0C, 0x30, 0x61, 0x83, 0x04,
  0x18, 0x20, 0x41, 0x02, 0x08, 0x00, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x20, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x20,
  0x00, 0x18, 0x30, 0x00, 0x04, 0x10, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01,
  0x20, 0x0E, 0x00, 0xB0, 0x07, 0x00, 0x58, 0x03, 0x00, 0x28, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x42, 0x00, 0x00, 0x20, 0x80, 0x00, 0x20, 0x40,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x08, 0x00, 0x30, 0x02, 0x00, 0x30, 0x00,
  0xC0, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x80,
  0x00, 0x19, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x08, 0x00, 0x0C, 0x10, 0x00,
  0x60, 0x20, 0x01, 0x80, 0x40, 0x06, 0x00, 0x80, 0x30, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x00, 0x30,
  0x02, 0x00, 0x04, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x20, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x00, 0x20, 0x30, 0x00, 0x18, 0x10, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x04, 0x20, 0x00,
  0x04, 0x08, 0x00, 0x04, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x1C, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x13, 0x00, 0x00, 0x08, 0x80, 0x00, 0x06,
  0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x20, 0x60, 0x00, 0x10, 0x10, 0x00, 0x08, 0x04, 0x00, 0x06, 0x01, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x80, 0x10, 0x00, 0x40, 0x0C, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x20, 0x06, 0x00, 0x08, 0x03, 0x00,
  0x02, 0x00, 0x80, 0x01, 0x80, 0x40, 0x00, 0x40, 0x20, 0x00, 0x10, 0x10,
  0x00, 0x04, 0x08, 0x00, 0x01, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0xFE, 0x00, 0x09, 0xC0, 0x60, 0x02, 0x80, 0x06, 0x00, 0xC0, 0x00,
  0x80, 0x60, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x20, 0x40, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x3F, 0xC0, 0x11, 0x80,
  0xE0, 0x4C, 0x00, 0x60, 0xA0, 0x00, 0x23, 0x80, 0x00, 0x67, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x90, 0x00, 0x01, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50,
  0x00, 0x01, 0x90, 0x00, 0x02, 0x20, 0x00, 0x08, 0x40, 0x00, 0x30, 0x40,
  0x00, 0xC0, 0x40, 0x03, 0x00, 0x60, 0x38, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x20, 0x00, 0x01, 0x60, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x40, 0x00, 0x10, 0xC0,
  0x00, 0x30, 0x80, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x10, 0x00,
  0x01, 0x04, 0x00, 0x00, 0x43, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x10,
  0x08, 0x00, 0x08, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x06, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x08, 0x40, 0x00, 0x03, 0x10, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x23, 0x00, 0x00, 0x08, 0x40, 0x00, 0x04, 0x10, 0x00,
  0x03, 0x02, 0x00, 0x01, 0x80, 0x60, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x0E, 0x03, 0x00, 0xC0, 0x02, 0x06,
  0x00, 0x04, 0x30, 0x00, 0x08, 0x80, 0x00, 0x24, 0x00, 0x00, 0xD0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x80,
  0x00, 0x19, 0x00, 0x00, 0xA6, 0x00, 0x05, 0x0C, 0x00, 0x64, 0x1C, 0x07,
  0x20, 0x1F, 0xE0, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xC3, 0x80, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x60, 0x18, 0x08, 0x00, 0x41, 0x00, 0x02, 0x20, 0x00,
  0x34, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x30, 0x18, 0x00, 0x40, 0x04, 0x00, 0x80, 0x02, 0x01, 0x00, 0x02,
  0x02, 0x00, 0x02, 0x02, 0x00, 0x01, 0x04, 0x00, 0x01, 0x04, 0x00, 0x01,
  0x08, 0x00, 0x01, 0x08, 0x00, 0x01, 0x08, 0x03, 0xE1, 0x10, 0x0C, 0x1B,
  0x10, 0x10, 0x0A, 0x10, 0x20, 0x06, 0x30, 0x20, 0x06, 0x20, 0x40, 0x02,
  0x20, 0x40, 0x02, 0x20, 0x40, 0x06, 0x20, 0x80, 0x04, 0x60, 0x80, 0x04,
  0x40, 0x80, 0x04, 0x40, 0x80, 0x04, 0x40, 0x80, 0x04, 0x40, 0x80, 0x0C,
  0x40, 0x80, 0x08, 0x40, 0x80, 0x08, 0xC0, 0x80, 0x18, 0x80, 0x80, 0x28,
  0x80, 0xC0, 0x28, 0x80, 0x60, 0xD8, 0x80, 0x3F, 0x90, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x18, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03, 0x04, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x60, 0x40, 0x00, 0x10, 0x10, 0x00, 0x0C, 0x04,
  0x00, 0x02, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x40, 0x08, 0x00, 0x30,
  0x02, 0x00, 0x08, 0x00, 0x80, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x01, 0x00, 0x20, 0x00, 0x40, 0x18, 0x00, 0x10, 0x07, 0xFF, 0xFC,
  0x03, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x60, 0x00, 0x08, 0x10, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x21, 0x80, 0x00, 0x08, 0x40,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x48, 0x00, 0x00, 0x14, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x03, 0xFF, 0xF0, 0x01, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x10, 0x00,
  0x02, 0x08, 0x00, 0x01, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x41, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x10, 0x20,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x10, 0x00, 0x30, 0x0F, 0xFF, 0xE0, 0x04,
  0x00, 0x0E, 0x02, 0x00, 0x01, 0x81, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10,
  0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01,
  0x08, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x44, 0x00, 0x00, 0x22, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x08, 0x60, 0x00,
  0x08, 0x20, 0x00, 0x18, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x70, 0x30, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x04, 0x02, 0x00, 0x02, 0x04,
  0x00, 0x02, 0x08, 0x00, 0x01, 0x08, 0x00, 0x02, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x10, 0x40, 0x00, 0x20, 0x60,
  0x00, 0x60, 0x20, 0x00, 0xC0, 0x10, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x80, 0x0E, 0x00, 0x20, 0x00, 0xC0,
  0x08, 0x00, 0x08, 0x02, 0x00, 0x01, 0x01, 0x80, 0x00, 0x40, 0x60, 0x00,
  0x08, 0x10, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x04, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x04, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0x84, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x04,
  0x18, 0x00, 0x03, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x20, 0x10, 0x00, 0x30, 0x04, 0x00, 0x38, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x60, 0x30, 0x01, 0x80, 0x08, 0x03, 0x00, 0x04, 0x06,
  0x00, 0x02, 0x04, 0x00, 0x02, 0x08, 0x00, 0x01, 0x18, 0x00, 0x02, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x0F, 0xFC, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x10, 0x40,
  0x00, 0x30, 0x40, 0x00, 0x50, 0x20, 0x00, 0x90, 0x10, 0x01, 0x10, 0x0C,
  0x06, 0x30, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x08, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x10, 0x20, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00,
  0x08, 0x10, 0x00, 0x03, 0x06, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x10,
  0x00, 0x01, 0x03, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x04, 0x08, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x81, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x10,
  0x20, 0x00, 0x02, 0x04, 0x00, 0x00, 0x40, 0x80, 0x00, 0x08, 0x10, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x10, 0x00, 0x01, 0x02,
  0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x40, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x80,
  0x40, 0x01, 0x00, 0x60, 0x02, 0x00, 0x18, 0x1C, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x10, 0x00, 0x01, 0x80, 0x80, 0x00, 0x10, 0x04,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x10, 0x03, 0x00, 0x01, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x20, 0x03, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x04,
  0x03, 0x00, 0x00, 0x20, 0x30, 0x00, 0x01, 0x03, 0x00, 0x00, 0x08, 0x28,
  0x00, 0x00, 0xC2, 0x20, 0x00, 0x04, 0x21, 0x00, 0x00, 0x22, 0x04, 0x00,
  0x01, 0x20, 0x20, 0x00, 0x0E, 0x00, 0x80, 0x00, 0x60, 0x04, 0x00, 0x06,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x40, 0x02, 0x00, 0x02, 0x00, 0x30, 0x00, 0x08,
  0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x01, 0x00, 0x40, 0x00, 0x08, 0x02,
  0x00, 0x00, 0x20, 0x10, 0x00, 0x01, 0x01, 0x80, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x14, 0x05, 0x00, 0x00, 0xA0, 0x68, 0x00, 0x09, 0x02,
  0x40, 0x00, 0x88, 0x11, 0x00, 0x04, 0xC0, 0x88, 0x00, 0x44, 0x04, 0x40,
  0x04, 0x20, 0x21, 0x00, 0x21, 0x03, 0x08, 0x02, 0x08, 0x10, 0x40, 0x10,
  0x40, 0x82, 0x01, 0x06, 0x04, 0x08, 0x10, 0x20, 0x20, 0x40, 0x81, 0x01,
  0x02, 0x08, 0x08, 0x18, 0x08, 0x80, 0x40, 0x80, 0x44, 0x02, 0x04, 0x02,
  0x40, 0x20, 0x20, 0x16, 0x01, 0x01, 0x00, 0x60, 0x08, 0x08, 0x02, 0x00,
  0x40, 0xC0, 0x10, 0x02, 0x04, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x81, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00,
  0x40, 0x40, 0x00, 0x02, 0x02, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x81,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x20, 0x60, 0x00, 0x04, 0x1C,
  0x00, 0x01, 0x82, 0x40, 0x00, 0x20, 0x48, 0x00, 0x04, 0x09, 0x80, 0x00,
  0x81, 0x10, 0x00, 0x10, 0x22, 0x00, 0x02, 0x0C, 0x60, 0x00, 0xC1, 0x04,
  0x00, 0x10, 0x20, 0x80, 0x02, 0x04, 0x08, 0x00, 0x40, 0x81, 0x00, 0x08,
  0x10, 0x20, 0x01, 0x06, 0x02, 0x00, 0x40, 0x80, 0x40, 0x08, 0x10, 0x08,
  0x01, 0x02, 0x00, 0x80, 0x20, 0x40, 0x10, 0x04, 0x08, 0x02, 0x00, 0x83,
  0x00, 0x20, 0x20, 0x40, 0x04, 0x04, 0x08, 0x00, 0xC0, 0x81, 0x00, 0x08,
  0x10, 0x20, 0x01, 0x02, 0x04, 0x00, 0x30, 0x41, 0x80, 0x02, 0x10, 0x20,
  0x00, 0x42, 0x04, 0x00, 0x04, 0x40, 0x80, 0x00, 0x88, 0x10, 0x00, 0x11,
  0x02, 0x00, 0x01, 0x20, 0xC0, 0x00, 0x28, 0x10, 0x00, 0x05, 0x02, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x20, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x20, 0x00,
  0x18, 0x30, 0x00, 0x04, 0x10, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01, 0x20,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x04, 0x80, 0x00, 0x02,
  0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x42, 0x00, 0x00, 0x20, 0x80, 0x00, 0x20, 0x40, 0x00,
  0x30, 0x30, 0x00, 0x30, 0x08, 0x00, 0x30, 0x02, 0x00, 0x30, 0x00, 0xC0,
  0x60, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0x60,
  0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x04, 0x0C, 0x00,
  0x00, 0x81, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20, 0x80, 0x00,
  0x04, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x08,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xC0, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x20, 0x03, 0x00, 0x20, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x20,
  0x00, 0x18, 0x30, 0x00, 0x04, 0x10, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x32, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x02, 0x40, 0x00, 0x01,
  0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x02, 0x40, 0x00, 0x01, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x42, 0x00, 0x00, 0x20, 0x80, 0x00, 0x20, 0x40,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x08, 0x00, 0x30, 0x02, 0x00, 0x30, 0x00,
  0xC0, 0x60, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x04, 0x04, 0x00, 0x03, 0x04, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x40,
  0x00, 0x60, 0x08, 0x00, 0x06, 0x01, 0x00, 0x00, 0x60, 0x20, 0x00, 0x04,
  0x0C, 0x00, 0x00, 0x81, 0x00, 0x00, 0x18, 0x20, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x86, 0x00, 0x00, 0x20,
  0x80, 0x00, 0x04, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x08, 0x08, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xC0, 0x08,
  0x02, 0x00, 0x01, 0x00, 0x60, 0x00, 0x20, 0x04, 0x00, 0x04, 0x00, 0xC0,
  0x01, 0x80, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x20, 0x02, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x40,
  0x10, 0x00, 0x08, 0x02, 0x00, 0x00, 0x80, 0x40, 0x00, 0x10, 0x08, 0x00,
  0x03, 0x01, 0x00, 0x00, 0x20, 0x60, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0E, 0x00, 0xE0, 0x02, 0x00, 0x06, 0x00, 0x80, 0x00, 0x20, 0x20,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x02,
  0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x84,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x62, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x21, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0x80, 0x00, 0x08, 0x40, 0x00,
  0x04, 0x20, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x8C, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x00, 0x10, 0x80,
  0x00, 0x08, 0x40, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x10, 0x00, 0x02, 0x08,
  0x00, 0x01, 0x04, 0x00, 0x01, 0x02, 0x00, 0x00, 0x81, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x40, 0x60, 0x00, 0x40, 0x18, 0x00, 0x60, 0x07, 0x00, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x22, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x10, 0x80, 0x00, 0x10, 0x40, 0x00, 0x08, 0x20, 0x00, 0x08, 0x18,
  0x00, 0x04, 0x04, 0x00, 0x04, 0x02, 0x00, 0x02, 0x01, 0x00, 0x02, 0x00,
  0x80, 0x01, 0x00, 0x40, 0x01, 0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x40, 0x01, 0x00, 0x20, 0x00, 0x80, 0x20,
  0x00, 0x40, 0x10, 0x00, 0x10, 0x10, 0x00, 0x08, 0x08, 0x00, 0x04, 0x08,
  0x00, 0x02, 0x04, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x11, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x21, 0x00, 0x00, 0x02, 0x30,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x42, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x42, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x82,
  0x00, 0xC0, 0x08, 0x20, 0x0C, 0x00, 0x82, 0x00, 0xA0, 0x10, 0x20, 0x12,
  0x01, 0x02, 0x01, 0x20, 0x10, 0x20, 0x22, 0x03, 0x02, 0x02, 0x20, 0x20,
  0x20, 0x42, 0x02, 0x06, 0x04, 0x20, 0x20, 0x40, 0x83, 0x06, 0x04, 0x08,
  0x10, 0x40, 0x41, 0x81, 0x04, 0x04, 0x10, 0x10, 0x40, 0x43, 0x01, 0x08,
  0x04, 0x20, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x40, 0x10, 0x80, 0x44,
  0x01, 0x90, 0x04, 0x80, 0x09, 0x00, 0x48, 0x00, 0x90, 0x05, 0x00, 0x0B,
  0x00, 0x50, 0x00, 0xA0, 0x0E, 0x00, 0x0A, 0x00, 0xA0, 0x00, 0xA0, 0x0E,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x40, 0x00, 0x08, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x80, 0x00, 0x08, 0x01, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00,
  0x04, 0x04, 0x00, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00,
  0x10, 0x10, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x80, 0x04, 0x00, 0x01, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x40, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x18, 0x40, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x04, 0x00, 0x40, 0x00, 0x20,
  0x04, 0x00, 0x00, 0x80, 0x60, 0x00, 0x04, 0x02, 0x00, 0x00, 0x10, 0x20,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x02, 0x20, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x01, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x04, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00,
  0x20, 0x20, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x18, 0x02, 0x00, 0x08, 0x06, 0x00, 0x08, 0x0C, 0x00, 0x04, 0x08,
  0x00, 0x04, 0x10, 0x00, 0x02, 0x20, 0x00, 0x02, 0x60, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x84, 0x30, 0x82,
  0x10, 0x42, 0x08, 0x00, 0x7F, 0x02, 0x03, 0x01, 0x84, 0x18, 0x00, 0x88,
  0x60, 0x00, 0xA1, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x88, 0x00, 0x03, 0x10,
  0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00, 0x11, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00,
  0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22, 0x00, 0x00, 0x44, 0x00, 0x01,
  0x88, 0x00, 0x03, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x20, 0x00, 0x50,
  0x20, 0x01, 0x20, 0x60, 0x04, 0x40, 0x70, 0x30, 0xF8, 0x3F, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0xFE, 0x00, 0xC6,
  0x07, 0x01, 0x10, 0x03, 0x02, 0x40, 0x03, 0x05, 0x00, 0x02, 0x0C, 0x00,
  0x02, 0x18, 0x00, 0x04, 0x60, 0x00, 0x08, 0xC0, 0x00, 0x11, 0x00, 0x00,
  0x22, 0x00, 0x00, 0x44, 0x00, 0x00, 0x88, 0x00, 0x01, 0x30, 0x00, 0x02,
  0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x98, 0x00, 0x01, 0x30, 0x00, 0x04, 0x60, 0x00, 0x08, 0xC0,
  0x00, 0x21, 0x80, 0x00, 0xC2, 0x80, 0x03, 0x0C, 0x80, 0x0C, 0x10, 0xC0,
  0x60, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x03, 0x80, 0x30,
  0x03, 0x01, 0x00, 0x06, 0x08, 0x00, 0x08, 0x40, 0x00, 0x31, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x09, 0x00, 0x00, 0x44, 0x00, 0x02, 0x08, 0x00, 0x18, 0x30,
  0x00, 0xC0, 0x60, 0x06, 0x00, 0xE0, 0x60, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xE0, 0x40,
  0x18, 0x0C, 0x20, 0x30, 0x01, 0x10, 0x30, 0x00, 0x50, 0x30, 0x00, 0x18,
  0x10, 0x00, 0x0C, 0x10, 0x00, 0x06, 0x08, 0x00, 0x01, 0x08, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x82, 0x00, 0x00, 0x43, 0x00, 0x00, 0x21, 0x00, 0x00,
  0x10, 0x80, 0x00, 0x08, 0x40, 0x00, 0x04, 0x20, 0x00, 0x04, 0x10, 0x00,
  0x02, 0x08, 0x00, 0x01, 0x04, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x60, 0x60, 0x00, 0x50, 0x10, 0x00, 0x28, 0x04,
  0x00, 0x24, 0x03, 0x00, 0x22, 0x00, 0xE0, 0x63, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0x01, 0xC0, 0x30, 0x01, 0x81, 0x80, 0x03, 0x0C,
  0x00, 0x04, 0x20, 0x00, 0x11, 0x00, 0x00, 0x48, 0x00, 0x01, 0x20, 0x00,
  0x05, 0x80, 0x00, 0x24, 0x00, 0x01, 0x10, 0x00, 0x18, 0x40, 0x01, 0x83,
  0x00, 0xF8, 0x0F, 0xFC, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x02, 0x40, 0x00, 0x09, 0x00, 0x00,
  0x46, 0x00, 0x01, 0x08, 0x00, 0x08, 0x30, 0x00, 0x40, 0x60, 0x06, 0x00,
  0xE0, 0x70, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x40, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x00, 0x50, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0x00, 0xC0, 0x61, 0x03, 0x00,
  0x11, 0x06, 0x00, 0x0A, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06, 0x10, 0x00,
  0x06, 0x10, 0x00, 0x02, 0x20, 0x00, 0x02, 0x20, 0x00, 0x04, 0x20, 0x00,
  0x04, 0x60, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00, 0x04, 0x40, 0x00,
  0x04, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00, 0x08, 0x40, 0x00,
  0x08, 0x40, 0x00, 0x18, 0x40, 0x00, 0x18, 0x40, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x20, 0x00, 0x50, 0x10, 0x00, 0x90, 0x18, 0x01, 0x10, 0x0E, 0x06,
  0x10, 0x03, 0xF8, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x80, 0x01,
  0x80, 0xC0, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x0F, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x7F, 0x00, 0x86, 0x0E, 0x04, 0xC0, 0x18, 0x28,
  0x00, 0x43, 0x80, 0x03, 0x14, 0x00, 0x08, 0xC0, 0x00, 0x46, 0x00, 0x02,
  0x20, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00, 0x0C, 0x80, 0x00, 0x44, 0x00,
  0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x98, 0x00, 0x04, 0x80, 0x00, 0x64,
  0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0xC0, 0x00,
  0x24, 0x00, 0x03, 0x20, 0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40,
  0x00, 0x20, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x04, 0x04, 0x00, 0x60,
  0x20, 0x04, 0x01, 0x00, 0xC0, 0x08, 0x0C, 0x00, 0xC1, 0x80, 0x04, 0x18,
  0x00, 0x21, 0x00, 0x01, 0x30, 0x00, 0x0A, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x80, 0x04, 0x03, 0x00,
  0x60, 0x0C, 0x02, 0x00, 0x30, 0x10, 0x00, 0xC0, 0x80, 0x03, 0x04, 0x00,
  0x04, 0x20, 0x00, 0x13, 0x00, 0x00, 0x50, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x3F, 0x80, 0x0C, 0x70, 0x30, 0x02, 0x20, 0x02, 0x00, 0x90, 0x00, 0x40,
  0x28, 0x00, 0x10, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x40, 0x60, 0x00, 0x10, 0x10, 0x00, 0x08, 0x04, 0x00, 0x06, 0x01, 0x00,
  0x03, 0x00, 0x40, 0x01, 0x00, 0x30, 0x03, 0x00, 0x08, 0x03, 0x00, 0x02,
  0x0F, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x40, 0x00, 0x08, 0x08, 0x00,
  0x04, 0x03, 0x00, 0x0D, 0x00, 0x40, 0x04, 0x40, 0x18, 0x02, 0x10, 0x02,
  0x01, 0x04, 0x00, 0x40, 0x81, 0x00, 0x10, 0x40, 0x80, 0x02, 0x20, 0x20,
  0x00, 0xD0, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xF8, 0x08, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x03, 0x02, 0x00, 0x40,
  0x60, 0x18, 0x04, 0x02, 0x00, 0x40, 0xC0, 0x04, 0x10, 0x00, 0x46, 0x00,
  0x0C, 0x80, 0x00, 0xB0, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x7C, 0x0F, 0x81,
  0x90, 0x42, 0x08, 0x24, 0x04, 0x80, 0x85, 0x00, 0xA0, 0x10, 0xC0, 0x18,
  0x02, 0x10, 0x03, 0x00, 0x42, 0x00, 0x40, 0x08, 0xC0, 0x08, 0x01, 0x10,
  0x01, 0x00, 0x22, 0x00, 0x60, 0x04, 0x40, 0x08, 0x00, 0x88, 0x01, 0x00,
  0x21, 0x00, 0x20, 0x04, 0x60, 0x04, 0x00, 0x88, 0x00, 0x80, 0x11, 0x00,
  0x30, 0x02, 0x20, 0x04, 0x00, 0x44, 0x00, 0x80, 0x10, 0x80, 0x10, 0x02,
  0x30, 0x02, 0x00, 0x44, 0x00, 0x40, 0x08, 0x80, 0x18, 0x01, 0x10, 0x02,
  0x00, 0x62, 0x00, 0x40, 0x08, 0x40, 0x08, 0x01, 0x18, 0x01, 0x00, 0x22,
  0x00, 0x60, 0x04, 0x00, 0x08, 0x3F, 0x80, 0x43, 0x07, 0x02, 0x60, 0x0C,
  0x34, 0x00, 0x21, 0xC0, 0x01, 0x8A, 0x00, 0x04, 0x60, 0x00, 0x23, 0x00,
  0x01, 0x10, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00, 0x06, 0x40, 0x00, 0x22,
  0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00,
  0x32, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x60,
  0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02,
  0x20, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x03, 0x80, 0xC0, 0x0C, 0x00, 0x40,
  0x20, 0x00, 0x40, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x84, 0x00, 0x01, 0x10,
  0x00, 0x01, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x88, 0x00, 0x02, 0x10, 0x00, 0x04, 0x10, 0x00, 0x10,
  0x20, 0x00, 0x40, 0x30, 0x01, 0x00, 0x38, 0x1C, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0x07, 0xF0, 0x01, 0x8C, 0x0E, 0x00, 0x88, 0x01, 0x80, 0x48, 0x00,
  0x60, 0x28, 0x00, 0x10, 0x18, 0x00, 0x04, 0x0C, 0x00, 0x02, 0x0C, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x82, 0x00, 0x00, 0x41, 0x00, 0x00, 0x20, 0x80,
  0x00, 0x10, 0x40, 0x00, 0x08, 0x60, 0x00, 0x04, 0x20, 0x00, 0x02, 0x10,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x21, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x10,
  0x30, 0x00, 0x18, 0x14, 0x00, 0x18, 0x19, 0x00, 0x18, 0x08, 0x60, 0x30,
  0x04, 0x0F, 0xE0, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x02, 0x03,
  0x01, 0x84, 0x18, 0x00, 0x88, 0x60, 0x00, 0xA1, 0x80, 0x00, 0xC2, 0x00,
  0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x02, 0x40, 0x00, 0x04, 0x80, 0x00,
  0x11, 0x00, 0x00, 0x26, 0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x01,
  0x20, 0x00, 0x02, 0x40, 0x00, 0x08, 0x80, 0x00, 0x11, 0x00, 0x00, 0x22,
  0x00, 0x00, 0x44, 0x00, 0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x20, 0x00, 0x50, 0x20, 0x01, 0x20, 0x60, 0x04, 0x40, 0x70,
  0x30, 0x80, 0x3F, 0x82, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x33,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x06, 0x06, 0x00, 0x03, 0x04, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x80, 0x00, 0x04, 0x40, 0x00, 0x04, 0x20, 0x00, 0x08, 0x18,
  0x00, 0x30, 0x0E, 0x00, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x10, 0x01, 0x80, 0x08, 0x01, 0x00, 0x04, 0x03, 0x00, 0x02, 0x02, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x21, 0x00, 0x00,
  0x84, 0x00, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x22, 0x00, 0x01, 0x88,
  0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x01, 0x08, 0x00,
  0x04, 0x40, 0x00, 0x31, 0x00, 0x00, 0x84, 0x00, 0x02, 0x10, 0x00, 0x08,
  0x40, 0x00, 0x21, 0x00, 0x00, 0x8C, 0x00, 0x06, 0x20, 0x00, 0x10, 0x80,
  0x00, 0x42, 0x00, 0x03, 0x0C, 0x00, 0x14, 0x10, 0x00, 0x90, 0x40, 0x02,
  0xC0, 0x80, 0x12, 0x01, 0x81, 0x88, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x02,
  0x01, 0x00, 0x02, 0x01, 0x00, 0x02, 0x01, 0x00, 0x02, 0x03, 0x00, 0x03,
  0x02, 0x00, 0x01, 0x02, 0x00, 0x03, 0x02, 0x00, 0x03, 0x02, 0x00, 0x02,
  0x02, 0x00, 0x02, 0x02, 0x00, 0x02, 0x06, 0x00, 0x02, 0x04, 0x00, 0x06,
  0x04, 0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00, 0x08, 0x04, 0x00, 0x08,
  0x04, 0x00, 0x10, 0x0C, 0x00, 0x10, 0x08, 0x00, 0x20, 0x08, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x08, 0x06, 0x00, 0x08, 0x0C, 0x00,
  0x18, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x10, 0x02, 0x01, 0x08, 0x01, 0x00,
  0x84, 0x00, 0x80, 0x62, 0x00, 0x40, 0x11, 0x00, 0x20, 0x09, 0x80, 0x30,
  0x04, 0x80, 0x10, 0x02, 0x40, 0x08, 0x01, 0x20, 0x04, 0x00, 0x90, 0x02,
  0x00, 0x48, 0x01, 0x00, 0x2C, 0x01, 0x80, 0x14, 0x00, 0x80, 0x0A, 0x00,
  0x40, 0x05, 0x00, 0x20, 0x02, 0x80, 0x10, 0x01, 0x40, 0x08, 0x00, 0xE0,
  0x0C, 0x00, 0x60, 0x04, 0x00, 0x50, 0x02, 0x00, 0x28, 0x01, 0x00, 0x14,
  0x01, 0x80, 0x1A, 0x00, 0xC0, 0x09, 0x00, 0xA0, 0x0C, 0x80, 0x50, 0x0C,
  0x40, 0x44, 0x04, 0x18, 0x43, 0x0C, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x30,
  0x03, 0xE0, 0x06, 0x40, 0x61, 0x81, 0xC1, 0x06, 0x06, 0x38, 0x08, 0x60,
  0x16, 0x00, 0x22, 0x00, 0x80, 0x01, 0x20, 0x04, 0x00, 0x09, 0x00, 0x20,
  0x00, 0x50, 0x01, 0x00, 0x02, 0x80, 0x08, 0x00, 0x14, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x10, 0x01, 0x80, 0x01, 0x80, 0x14, 0x00, 0x08, 0x00,
  0xA0, 0x00, 0x40, 0x05, 0x00, 0x02, 0x00, 0x44, 0x00, 0x90, 0x02, 0x20,
  0x0E, 0x40, 0x21, 0x01, 0x82, 0x02, 0x04, 0x30, 0x08, 0x60, 0x37, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x01, 0x81, 0x00, 0x00, 0x80, 0x80,
  0x00, 0x40, 0x40, 0x00, 0x20, 0x20, 0x00, 0x10, 0x10, 0x00, 0x08, 0x10,
  0x00, 0x0C, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02, 0x02, 0x00, 0x01, 0x01,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x40, 0x80, 0x00, 0x60, 0x40, 0x00, 0x20,
  0x20, 0x00, 0x10, 0x10, 0x00, 0x08, 0x08, 0x00, 0x04, 0x04, 0x00, 0x02,
  0x06, 0x00, 0x03, 0x02, 0x00, 0x01, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0xA0, 0x10, 0x00, 0x90, 0x08, 0x00, 0x58, 0x02, 0x00,
  0x48, 0x00, 0xC0, 0xC4, 0x00, 0x3F, 0x82, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x60, 0x03, 0x80, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x83, 0x03, 0xE0, 0x42, 0x00, 0x3E,
  0x61, 0x00, 0x03, 0xF1, 0x00, 0x00, 0x30, 0x80, 0x00, 0x10, 0x40, 0x00,
  0x30, 0x20, 0x00, 0x30, 0x10, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0xC0, 0x02, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x80, 0x00, 0x40,
  0x80, 0x00, 0x11, 0xC0, 0x00, 0x08, 0x9F, 0x00, 0x04, 0x40, 0x7C, 0x02,
  0x20, 0x01, 0xF1, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x43, 0x18, 0x00, 0x11, 0x01, 0x00, 0x08, 0x80, 0x20,
  0x02, 0x20, 0x0C, 0x01, 0x90, 0x01, 0x00, 0x44, 0x00, 0x20, 0x22, 0x00,
  0x06, 0x30, 0x80, 0x00, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 36, 31, 12, -36 },
  { 37, 10, 13, 31, 14, -38 },
  { 54, 31, 36, 31, 1, -36 },
  { 194, 27, 48, 31, 2, -42 },
  { 356, 35, 38, 31, -1, -37 },
  { 523, 30, 38, 31, 1, -37 },
  { 666, 3, 13, 31, 17, -38 },
  { 671, 16, 47, 31, 12, -40 },
  { 765, 16, 47, 31, 4, -40 },
  { 859, 27, 26, 31, 3, -29 },
  { 947, 25, 25, 31, 4, -28 },
  { 1026, 7, 13, 31, 8, -4 },
  { 1038, 14, 1, 31, 9, -16 },
  { 1040, 3, 3, 31, 12, -3 },
  { 1042, 28, 47, 31, 2, -40 },
  { 1207, 25, 38, 31, 4, -37 },
  { 1326, 23, 36, 31, 3, -36 },
  { 1430, 26, 37, 31, 2, -37 },
  { 1551, 25, 38, 31, 2, -37 },
  { 1670, 26, 36, 31, 2, -36 },
  { 1787, 26, 37, 31, 3, -36 },
  { 1908, 23, 37, 31, 4, -36 },
  { 2015, 24, 36, 31, 6, -36 },
  { 2123, 26, 38, 31, 3, -37 },
  { 2247, 22, 37, 31, 6, -37 },
  { 2349, 7, 27, 31, 12, -27 },
  { 2373, 11, 36, 31, 8, -27 },
  { 2423, 24, 28, 31, 5, -30 },
  { 2507, 26, 10, 31, 3, -21 },
  { 2540, 25, 28, 31, 2, -30 },
  { 2628, 20, 37, 31, 8, -37 },
  { 2721, 24, 43, 31, 4, -37 },
  { 2850, 26, 36, 31, 0, -36 },
  { 2967, 25, 36, 31, 3, -36 },
  { 3080, 24, 38, 31, 5, -37 },
  { 3194, 26, 36, 31, 3, -36 },
  { 3311, 28, 36, 31, 3, -36 },
  { 3437, 28, 36, 31, 3, -36 },
  { 3563, 24, 38, 31, 5, -37 },
  { 3677, 27, 36, 31, 3, -36 },
  { 3799, 27, 36, 31, 3, -36 },
  { 3921, 24, 37, 31, 4, -36 },
  { 4032, 29, 36, 31, 3, -36 },
  { 4163, 20, 36, 31, 5, -36 },
  { 4253, 29, 36, 31, 2, -36 },
  { 4384, 27, 36, 31, 3, -36 },
  { 4506, 25, 38, 31, 4, -37 },
  { 4625, 27, 36, 31, 3, -36 },
  { 4747, 25, 46, 31, 4, -37 },
  { 4891, 27, 36, 31, 3, -36 },
  { 5013, 27, 38, 31, 2, -37 },
  { 5142, 27, 36, 31, 6, -36 },
  { 5264, 25, 37, 31, 5, -36 },
  { 5380, 25, 36, 31, 7, -36 },
  { 5493, 28, 36, 31, 4, -36 },
  { 5619, 32, 36, 31, 0, -36 },
  { 5763, 29, 36, 31, 5, -36 },
  { 5894, 31, 36, 31, 0, -36 },
  { 6034, 20, 47, 31, 10, -40 },
  { 6152, 12, 47, 31, 10, -40 },
  { 6223, 20, 47, 31, 2, -40 },
  { 6341, 24, 20, 31, 4, -36 },
  { 6401, 25, 1, 31, 0, 6 },
  { 6405, 5, 9, 31, 13, -40 },
  { 6411, 23, 28, 31, 4, -27 },
  { 6492, 23, 39, 31, 4, -38 },
  { 6605, 22, 28, 31, 4, -27 },
  { 6682, 25, 39, 31, 4, -38 },
  { 6804, 22, 28, 31, 4, -27 },
  { 6881, 33, 49, 31, -1, -38 },
  { 7084, 24, 38, 31, 3, -27 },
  { 7198, 21, 38, 31, 5, -38 },
  { 7298, 21, 40, 31, 5, -39 },
  { 7403, 21, 50, 31, 6, -39 },
  { 7535, 26, 39, 31, 4, -38 },
  { 7662, 20, 39, 31, 6, -38 },
  { 7760, 27, 27, 31, 2, -27 },
  { 7852, 21, 27, 31, 5, -27 },
  { 7923, 23, 28, 31, 4, -27 },
  { 8004, 25, 37, 31, 2, -27 },
  { 8120, 23, 37, 31, 4, -27 },
  { 8227, 25, 27, 31, 6, -27 },
  { 8312, 24, 28, 31, 3, -27 },
  { 8396, 25, 37, 31, 4, -36 },
  { 8512, 22, 28, 31, 5, -27 },
  { 8589, 24, 27, 31, 4, -27 },
  { 8670, 25, 28, 31, 4, -27 },
  { 8758, 29, 28, 31, 1, -27 },
  { 8860, 25, 38, 31, 2, -27 },
  { 8979, 25, 28, 31, 3, -27 },
  { 9067, 24, 47, 31, 6, -40 },
  { 9208, 8, 47, 31, 12, -40 },
  { 9255, 24, 47, 31, 2, -40 },
  { 9396, 26, 9, 31, 3, -20 },
};

const GFXfont IBMPlexMono_ThinItalic52pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic52pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic52pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _IBMPLEXMONO_THINITALIC52PT7B_H_
