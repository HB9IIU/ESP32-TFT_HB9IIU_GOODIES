#ifndef _IBMPLEXMONO_THINITALIC54PT7B_H_
#define _IBMPLEXMONO_THINITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0x07, 0x00, 0x30, 0x64, 0x0C, 0x81,
  0x10, 0x22, 0x04, 0xC0, 0x98, 0x32, 0x06, 0x40, 0x88, 0x11, 0x02, 0x60,
  0x4C, 0x19, 0x03, 0x00, 0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x80, 0x40,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x80, 0x00, 0x02, 0x01, 0x80, 0x00, 0x02, 0x01, 0x00,
  0x00, 0x04, 0x01, 0x00, 0x00, 0x04, 0x03, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x08, 0x02, 0x00, 0x00, 0x08, 0x04, 0x00, 0x00, 0x08, 0x04, 0x00,
  0x00, 0x10, 0x04, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x10, 0x08, 0x00,
  0x00, 0x20, 0x08, 0x00, 0x00, 0x20, 0x10, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x00, 0x40, 0x10, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xC0, 0x20, 0x00,
  0x00, 0x80, 0x20, 0x00, 0x00, 0x80, 0x40, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x01, 0x00, 0x80, 0x00, 0x03, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x02, 0x01, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00,
  0x04, 0x01, 0x00, 0x00, 0x04, 0x02, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xE1,
  0x0E, 0x00, 0x18, 0x08, 0x18, 0x01, 0x80, 0x40, 0x20, 0x18, 0x02, 0x00,
  0x80, 0x80, 0x10, 0x06, 0x08, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x10, 0x02, 0x00, 0x00, 0x80, 0x10, 0x00, 0x04, 0x00,
  0x80, 0x00, 0x20, 0x08, 0x00, 0x01, 0x00, 0x40, 0x00, 0x0C, 0x02, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x03, 0x84, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x11, 0xC0, 0x00, 0x00,
  0x81, 0x80, 0x00, 0x04, 0x06, 0x00, 0x00, 0x20, 0x10, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x10, 0x02, 0x00, 0x00, 0x80, 0x10, 0x00, 0x04, 0x00, 0x80,
  0x00, 0x20, 0x04, 0x00, 0x01, 0x00, 0x20, 0x00, 0x10, 0x01, 0x00, 0x00,
  0x80, 0x08, 0x40, 0x04, 0x00, 0x83, 0x00, 0x20, 0x04, 0x0C, 0x01, 0x00,
  0x40, 0x30, 0x08, 0x06, 0x00, 0xC0, 0x80, 0x40, 0x01, 0xC4, 0x1C, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x30, 0x06, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x20, 0x00, 0x40,
  0x18, 0x01, 0x00, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x10, 0x02, 0x00, 0x20, 0x01, 0x00, 0x40, 0x06, 0x00,
  0x10, 0x08, 0x00, 0x60, 0x01, 0x01, 0x80, 0x04, 0x00, 0x10, 0x10, 0x00,
  0x40, 0x01, 0x02, 0x00, 0x04, 0x00, 0x20, 0x40, 0x00, 0x20, 0x02, 0x0C,
  0x00, 0x02, 0x00, 0x40, 0x80, 0x00, 0x30, 0x0C, 0x10, 0x00, 0x01, 0x83,
  0x02, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0C, 0x0C, 0x18, 0x00, 0x01, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x20, 0x04, 0x00, 0x02, 0x04, 0x00, 0x40, 0x00, 0x40, 0x40, 0x02, 0x00,
  0x08, 0x08, 0x00, 0x20, 0x01, 0x80, 0x80, 0x02, 0x00, 0x10, 0x08, 0x00,
  0x60, 0x02, 0x00, 0x80, 0x06, 0x00, 0x40, 0x08, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x04, 0x00, 0x80, 0x08, 0x00, 0x40, 0x10, 0x00, 0x80, 0x08, 0x02,
  0x00, 0x08, 0x01, 0x80, 0x60, 0x00, 0x40, 0x30, 0x04, 0x00, 0x02, 0x06,
  0x00, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x01, 0x80, 0x10, 0x00, 0x02, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x08, 0x00, 0x20, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x10, 0x01, 0x80, 0x00, 0x20, 0x02, 0x00, 0x00, 0x20, 0x08, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x07, 0xC1, 0x80, 0x00, 0x30, 0x4C, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x04, 0x00, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x20,
  0x01, 0x80, 0x00, 0x40, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x02, 0x00, 0x08, 0x00, 0x06, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x2C, 0x02, 0x80, 0x00,
  0x48, 0x0D, 0x00, 0x00, 0x98, 0x11, 0x00, 0x02, 0x10, 0x43, 0x00, 0x08,
  0x11, 0x83, 0x00, 0x20, 0x32, 0x03, 0x81, 0x80, 0x28, 0x01, 0xFC, 0x00,
  0x30, 0x00, 0x25, 0xB4, 0x92, 0xDA, 0x49, 0x00, 0x00, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0xF0, 0x02, 0x00, 0xF1, 0xE0, 0x60, 0x78, 0x03, 0xC4, 0x38, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x12,
  0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x41, 0x80, 0x00, 0x08, 0x08, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x06, 0x00, 0x20, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x10, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x10,
  0x60, 0x81, 0x04, 0x08, 0x00, 0xFF, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x01, 0x80, 0x00, 0x60, 0x40,
  0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x24, 0x00, 0xC0, 0x09, 0x00, 0x70, 0x02, 0xC0, 0x0C, 0x00, 0xB0,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x48, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x02, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x08, 0x10, 0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xA0, 0x00, 0x07, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x18,
  0x40, 0x00, 0x30, 0x40, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x40, 0x03, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x80, 0xC0, 0x01,
  0x80, 0x04, 0x00, 0x60, 0x00, 0x40, 0x18, 0x00, 0x04, 0x02, 0x00, 0x00,
  0x80, 0xC0, 0x00, 0x18, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x60,
  0x00, 0x20, 0x20, 0x00, 0x18, 0x20, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x40, 0x00, 0x06, 0x30,
  0x00, 0x02, 0x0C, 0x00, 0x02, 0x03, 0x00, 0x06, 0x00, 0x70, 0x0E, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0A, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x98, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x0C, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00, 0x41, 0x00, 0x00, 0x10,
  0x20, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x18, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0x80, 0x10, 0x00, 0x20, 0x06,
  0x00, 0x08, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x30,
  0x00, 0x40, 0x0C, 0x00, 0x08, 0x03, 0x00, 0x03, 0x00, 0x40, 0x00, 0x40,
  0x10, 0x00, 0x08, 0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0x20, 0x60, 0x00,
  0x04, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x3F, 0xC0, 0x01, 0x98, 0x06,
  0x00, 0x2C, 0x00, 0x20, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x10, 0x00, 0x00, 0x81, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x08, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x3F, 0x80,
  0x11, 0xC0, 0x60, 0x13, 0x00, 0x18, 0x24, 0x00, 0x0C, 0x28, 0x00, 0x04,
  0x30, 0x00, 0x02, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02,
  0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x04,
  0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x20, 0x00, 0x10, 0x30, 0x00, 0x20,
  0x18, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC8, 0x00, 0x00, 0x22, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x60, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x08, 0x30, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x40, 0x10, 0x00, 0x04, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00,
  0x18, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x10,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x20, 0x40, 0x00, 0x04, 0x08, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x20, 0x10, 0x00, 0x08, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x03, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x18, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x11, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x08, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00, 0x41, 0x80, 0x00, 0x10, 0x18,
  0x00, 0x04, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x07, 0x01, 0xC0, 0x18, 0x00, 0x40, 0x40, 0x00,
  0x41, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x98, 0x00, 0x01, 0xA0, 0x00, 0x01,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x39, 0x00, 0x00, 0x61, 0x00, 0x03, 0x43, 0x00,
  0x0C, 0x81, 0x80, 0xE2, 0x00, 0xFF, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xE0, 0x00, 0xE0, 0x3C, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x40, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xFF, 0xFF,
  0xE8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x18, 0x0E, 0x03,
  0x00, 0x18, 0x30, 0x00, 0x23, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x00, 0x80, 0x18, 0x00, 0x60, 0x18,
  0x00, 0x10, 0x08, 0x00, 0x08, 0x08, 0x00, 0x02, 0x04, 0x00, 0x01, 0x04,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x42, 0x00, 0x00, 0x21, 0x00, 0x7E, 0x10,
  0x80, 0x60, 0x98, 0x80, 0x40, 0x28, 0x40, 0x40, 0x0C, 0x20, 0x40, 0x06,
  0x10, 0x20, 0x01, 0x10, 0x30, 0x00, 0x88, 0x10, 0x00, 0xC4, 0x08, 0x00,
  0x42, 0x04, 0x00, 0x21, 0x02, 0x00, 0x11, 0x83, 0x00, 0x08, 0x81, 0x00,
  0x04, 0x40, 0x80, 0x06, 0x20, 0x40, 0x02, 0x10, 0x20, 0x01, 0x08, 0x10,
  0x00, 0x84, 0x08, 0x00, 0xC2, 0x02, 0x00, 0xA3, 0x01, 0x00, 0x91, 0x80,
  0x40, 0x90, 0xC0, 0x1F, 0x88, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x88,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x04, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x08, 0x08, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x20,
  0x00, 0x08, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x40, 0x18, 0x00, 0x10,
  0x01, 0x00, 0x02, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x03, 0x00, 0x20, 0x00, 0x20, 0x04, 0x00,
  0x04, 0x01, 0xFF, 0xFF, 0x80, 0x20, 0x00, 0x10, 0x08, 0x00, 0x02, 0x01,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0x82, 0x00, 0x00,
  0x10, 0x40, 0x00, 0x02, 0x10, 0x00, 0x00, 0x42, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x00, 0x90, 0x00, 0x00, 0x16, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x40, 0x03, 0xFF, 0xF8, 0x00, 0x80, 0x01, 0x80, 0x20, 0x00, 0x30, 0x08,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x60, 0x00, 0x04,
  0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x0C, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x80,
  0x00, 0x10, 0x20, 0x00, 0x08, 0x08, 0x00, 0x06, 0x02, 0x00, 0x06, 0x01,
  0xFF, 0xFE, 0x00, 0x40, 0x00, 0x60, 0x10, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x10, 0x40, 0x00, 0x04, 0x30, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x41, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x70, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x01, 0x00, 0x30, 0x00, 0x40, 0x30, 0x00, 0x10, 0x30, 0x00, 0x08,
  0x10, 0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x21, 0x80, 0x00, 0x18, 0x40, 0x00, 0x08,
  0x20, 0x00, 0x08, 0x08, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x18, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x80,
  0x0E, 0x00, 0x60, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x04, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x10, 0x00, 0x02, 0x0C, 0x00, 0x00,
  0x82, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x11, 0x80, 0x00, 0x04, 0x40, 0x00, 0x01, 0x10,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02,
  0x30, 0x00, 0x00, 0x88, 0x00, 0x00, 0x22, 0x00, 0x00, 0x08, 0x80, 0x00,
  0x06, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x46, 0x00, 0x00, 0x11, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x41,
  0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x04, 0x08, 0x00, 0x06,
  0x02, 0x00, 0x03, 0x00, 0x80, 0x03, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x01, 0x00, 0x20,
  0x00, 0x40, 0x20, 0x00, 0x10, 0x20, 0x00, 0x08, 0x30, 0x00, 0x02, 0x10,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x7F, 0xF2, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x04, 0x80, 0x00, 0x06, 0x40, 0x00, 0x02, 0x20, 0x00,
  0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x44, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x31, 0x00, 0x00, 0x10, 0x40, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x18,
  0x00, 0x0A, 0x04, 0x00, 0x09, 0x01, 0x80, 0x09, 0x80, 0x70, 0x38, 0x80,
  0x0F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x30, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20, 0x60, 0x00, 0x02,
  0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x40,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x04, 0x08, 0x00, 0x00,
  0x40, 0x80, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x81, 0x80, 0x00, 0x08, 0x1F, 0xFF, 0xFF, 0x81, 0x00, 0x00,
  0x08, 0x10, 0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x10, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x10, 0x20, 0x00, 0x01, 0x02, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x30, 0x20, 0x00, 0x02, 0x06, 0x00, 0x00, 0x20,
  0x40, 0x00, 0x02, 0x04, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x04, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x04, 0x0C, 0x00, 0x00, 0x40, 0x80, 0x00, 0x04,
  0x08, 0x00, 0x00, 0x40, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x80, 0x00, 0x20,
  0x40, 0x00, 0x30, 0x30, 0x00, 0x30, 0x08, 0x00, 0x30, 0x02, 0x00, 0x30,
  0x00, 0xC0, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0x40, 0x00,
  0x18, 0x02, 0x00, 0x01, 0x80, 0x10, 0x00, 0x18, 0x00, 0x80, 0x01, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x10, 0x00, 0x10,
  0x01, 0x00, 0x00, 0x80, 0x10, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x10, 0x38, 0x00, 0x00, 0x83, 0x40, 0x00,
  0x04, 0x33, 0x00, 0x00, 0x23, 0x08, 0x00, 0x03, 0x30, 0x40, 0x00, 0x13,
  0x01, 0x00, 0x00, 0xA0, 0x08, 0x00, 0x06, 0x00, 0x20, 0x00, 0x20, 0x01,
  0x00, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x00, 0x80,
  0x04, 0x00, 0x04, 0x00, 0x20, 0x00, 0x10, 0x01, 0x00, 0x00, 0x80, 0x08,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0x10, 0x04, 0x00, 0x00, 0x40, 0x20, 0x00,
  0x02, 0x01, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x40, 0x40, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x28, 0x00, 0x03, 0x80,
  0xA0, 0x00, 0x0A, 0x02, 0x80, 0x00, 0x68, 0x09, 0x00, 0x01, 0x20, 0x64,
  0x00, 0x08, 0x81, 0x10, 0x00, 0x66, 0x04, 0x60, 0x01, 0x10, 0x10, 0x80,
  0x0C, 0x40, 0x42, 0x00, 0x21, 0x01, 0x08, 0x01, 0x04, 0x0C, 0x10, 0x0C,
  0x10, 0x20, 0x40, 0x20, 0xC0, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x20, 0x20, 0x20, 0x21, 0x80, 0x81, 0x80, 0x84, 0x02, 0x04,
  0x01, 0x20, 0x18, 0x10, 0x05, 0x80, 0x40, 0x40, 0x14, 0x01, 0x01, 0x00,
  0x70, 0x04, 0x04, 0x00, 0x80, 0x10, 0x30, 0x04, 0x00, 0x40, 0x80, 0x00,
  0x03, 0x02, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x20, 0x20, 0x00, 0x00,
  0x80, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x01, 0x01, 0x00, 0x00, 0x04, 0x04, 0x00, 0x00, 0x10, 0x10,
  0x00, 0x00, 0x40, 0xC0, 0x00, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x38, 0x00, 0x01, 0x02, 0x80, 0x00, 0x30, 0x28, 0x00,
  0x02, 0x06, 0xC0, 0x00, 0x20, 0x44, 0x00, 0x02, 0x04, 0x40, 0x00, 0x20,
  0x46, 0x00, 0x02, 0x04, 0x20, 0x00, 0x20, 0x42, 0x00, 0x06, 0x0C, 0x30,
  0x00, 0x40, 0xC1, 0x00, 0x04, 0x08, 0x10, 0x00, 0x40, 0x81, 0x80, 0x04,
  0x08, 0x08, 0x00, 0x40, 0x80, 0x80, 0x0C, 0x18, 0x04, 0x00, 0x81, 0x80,
  0x40, 0x08, 0x10, 0x04, 0x00, 0x81, 0x00, 0x20, 0x08, 0x10, 0x02, 0x00,
  0x81, 0x00, 0x20, 0x18, 0x10, 0x01, 0x01, 0x03, 0x00, 0x10, 0x10, 0x20,
  0x01, 0x81, 0x02, 0x00, 0x08, 0x10, 0x20, 0x00, 0x81, 0x02, 0x00, 0x0C,
  0x30, 0x20, 0x00, 0x42, 0x06, 0x00, 0x04, 0x20, 0x40, 0x00, 0x62, 0x04,
  0x00, 0x02, 0x20, 0x40, 0x00, 0x22, 0x04, 0x00, 0x03, 0x60, 0x40, 0x00,
  0x14, 0x0C, 0x00, 0x01, 0x40, 0x80, 0x00, 0x1C, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x01, 0x80, 0x00, 0x60, 0x40, 0x00, 0x08, 0x20,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x20, 0x00, 0x00, 0x48, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x80, 0x00, 0x02, 0x20, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30, 0x40, 0x00, 0x08, 0x10,
  0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x03, 0x81, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x40,
  0x00, 0xE0, 0x18, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04,
  0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x20, 0x00, 0x01, 0x0C, 0x00,
  0x00, 0x21, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x84, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x86, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x04, 0x10, 0x00, 0x01, 0x02, 0x00, 0x00, 0x40, 0x40, 0x00, 0x30, 0x0F,
  0xFF, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x01, 0x80, 0x00, 0x60,
  0x40, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x09, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x01, 0x20, 0x00, 0x00, 0x48, 0x00, 0x00, 0x32, 0x00, 0x00, 0x08, 0x80,
  0x00, 0x02, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x41, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x08, 0x10, 0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x10, 0x02, 0x00, 0x02, 0x00, 0xC0, 0x00, 0xC0, 0x40,
  0x00, 0x10, 0x60, 0x00, 0x02, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x18,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x02,
  0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x08, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x21, 0x00, 0x00, 0x04, 0x20,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x10, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04, 0x10, 0x00, 0x01, 0x02, 0x00,
  0x00, 0x40, 0x40, 0x00, 0x30, 0x0F, 0xFF, 0xF8, 0x03, 0x00, 0x40, 0x00,
  0x40, 0x08, 0x00, 0x08, 0x01, 0x80, 0x01, 0x00, 0x10, 0x00, 0x20, 0x03,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x20, 0x00, 0x40, 0x04,
  0x00, 0x08, 0x00, 0x80, 0x00, 0x80, 0x10, 0x00, 0x10, 0x02, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x20, 0x10, 0x00, 0x02, 0x02, 0x00, 0x00, 0x40, 0x40,
  0x00, 0x0C, 0x08, 0x00, 0x00, 0x81, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x40, 0x30, 0x00, 0x01, 0x01, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x80, 0x00, 0x01, 0x06, 0x00, 0x00,
  0x08, 0x18, 0x00, 0x00, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x80,
  0x03, 0x80, 0x38, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x42, 0x00, 0x00, 0x10, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x02, 0x18, 0x00,
  0x00, 0x86, 0x00, 0x00, 0x21, 0x00, 0x00, 0x08, 0x40, 0x00, 0x02, 0x10,
  0x00, 0x01, 0x84, 0x00, 0x00, 0x61, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04,
  0x20, 0x00, 0x01, 0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x30, 0x80, 0x00,
  0x0C, 0x20, 0x00, 0x02, 0x18, 0x00, 0x00, 0x84, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x08, 0x40, 0x00, 0x02, 0x10, 0x00, 0x01, 0x84, 0x00, 0x00, 0x43,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x08, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x40, 0x80, 0x00, 0x10, 0x20, 0x00, 0x08, 0x0C,
  0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0x60, 0x01, 0x80, 0x06, 0x01, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x06, 0x40, 0x00, 0x01, 0x10, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x18, 0x60, 0x00, 0x04, 0x18, 0x00, 0x03,
  0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60, 0x20, 0x00, 0x10, 0x08, 0x00,
  0x0C, 0x02, 0x00, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x00, 0x40, 0x04,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x06, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x20, 0x08, 0x00, 0x08, 0x04,
  0x00, 0x02, 0x01, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x20, 0x00, 0x04,
  0x10, 0x00, 0x01, 0x04, 0x00, 0x00, 0x42, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x04, 0x40, 0x00, 0x01, 0x10, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x80, 0x00, 0x00, 0x44, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x21, 0x00,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x04, 0x30, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x08, 0x00, 0x00, 0x10,
  0x40, 0x00, 0x00, 0x82, 0x00, 0x60, 0x04, 0x10, 0x03, 0x00, 0x20, 0x80,
  0x28, 0x02, 0x04, 0x01, 0x40, 0x10, 0x20, 0x1B, 0x00, 0x81, 0x00, 0x88,
  0x0C, 0x08, 0x0C, 0x40, 0x40, 0x40, 0x42, 0x02, 0x02, 0x06, 0x10, 0x10,
  0x10, 0x20, 0x81, 0x80, 0x83, 0x04, 0x08, 0x0C, 0x10, 0x20, 0x40, 0x60,
  0x81, 0x82, 0x02, 0x08, 0x04, 0x30, 0x10, 0x40, 0x21, 0x00, 0x84, 0x01,
  0x08, 0x04, 0x20, 0x08, 0x40, 0x22, 0x00, 0x46, 0x01, 0x10, 0x02, 0x20,
  0x09, 0x80, 0x19, 0x00, 0x48, 0x00, 0x48, 0x02, 0xC0, 0x02, 0x80, 0x14,
  0x00, 0x14, 0x00, 0xE0, 0x00, 0xA0, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x40, 0x00, 0x00, 0x80, 0x30,
  0x00, 0x00, 0x80, 0x08, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x40, 0x00, 0x04, 0x00, 0x40, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0x80, 0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x00, 0x10, 0x20, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x18, 0x40,
  0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00, 0x08, 0x04,
  0x00, 0x00, 0x08, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x40, 0x06, 0x00,
  0x00, 0x10, 0x06, 0x00, 0x00, 0x08, 0x02, 0x00, 0x00, 0x02, 0x06, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x40, 0x40, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x18, 0x02, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x00, 0x80, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x04, 0x00, 0x80, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x20, 0x30, 0x00, 0x00, 0x81, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x04,
  0x20, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x88, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x40,
  0xC0, 0x00, 0x40, 0x20, 0x00, 0x40, 0x10, 0x00, 0x60, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x00, 0x80, 0x20, 0x00, 0x40, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x08, 0x10, 0x00, 0x06, 0x10, 0x00, 0x01, 0x18, 0x00, 0x00, 0x98,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xC0, 0x83, 0x04,
  0x08, 0x30, 0x41, 0x82, 0x04, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0xE1, 0x03,
  0x00, 0x31, 0x04, 0x00, 0x0B, 0x08, 0x00, 0x0A, 0x18, 0x00, 0x06, 0x10,
  0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00, 0x06, 0x40,
  0x00, 0x04, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x10, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x50, 0x40, 0x00, 0xD0, 0x20,
  0x00, 0x90, 0x10, 0x03, 0x30, 0x0C, 0x0E, 0x1F, 0x03, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x81, 0xF8,
  0x00, 0x43, 0x03, 0x00, 0x22, 0x00, 0x60, 0x12, 0x00, 0x10, 0x1A, 0x00,
  0x04, 0x0A, 0x00, 0x03, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x40, 0x00, 0x06, 0x20,
  0x00, 0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x22, 0x00, 0x00, 0x11, 0x00, 0x00, 0x18, 0x80, 0x00, 0x08,
  0x40, 0x00, 0x04, 0x20, 0x00, 0x06, 0x30, 0x00, 0x02, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x05, 0x00, 0x01, 0x02, 0x40, 0x01, 0x01, 0x30, 0x01,
  0x01, 0x86, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xC0, 0xC0, 0x04, 0x00, 0x60, 0x30, 0x00, 0x40, 0xC0, 0x00, 0x41, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x88, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x01, 0x10,
  0x00, 0x03, 0x20, 0x00, 0x04, 0x20, 0x00, 0x10, 0x40, 0x00, 0x40, 0x40,
  0x01, 0x00, 0x40, 0x04, 0x00, 0x60, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0xFE, 0x04, 0x01, 0xC0, 0xE1, 0x00, 0xC0, 0x0C, 0x40, 0x40, 0x00, 0xB0,
  0x20, 0x00, 0x28, 0x18, 0x00, 0x06, 0x04, 0x00, 0x01, 0x82, 0x00, 0x00,
  0x60, 0x80, 0x00, 0x08, 0x60, 0x00, 0x06, 0x10, 0x00, 0x01, 0x04, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x20, 0x00, 0x01, 0x08,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x82, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x20, 0x00,
  0x04, 0x0C, 0x00, 0x03, 0x01, 0x00, 0x01, 0x40, 0x40, 0x00, 0xD0, 0x08,
  0x00, 0x24, 0x01, 0x00, 0x31, 0x00, 0x30, 0x38, 0x80, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x70, 0x06, 0x00, 0x30, 0x10, 0x00,
  0x20, 0x40, 0x00, 0x21, 0x00, 0x00, 0x46, 0x00, 0x00, 0x88, 0x00, 0x01,
  0x20, 0x00, 0x02, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x12, 0x00, 0x00, 0xC4,
  0x00, 0x03, 0x08, 0x00, 0x38, 0x10, 0x0F, 0x80, 0x3F, 0xE0, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x90, 0x00, 0x03, 0x30, 0x00, 0x04, 0x20, 0x00,
  0x10, 0x60, 0x00, 0x60, 0x40, 0x01, 0x80, 0x40, 0x06, 0x00, 0x60, 0x30,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x20, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x0C,
  0x04, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x02, 0x10, 0x00, 0x00, 0x00, 0x44, 0x00, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x38, 0x40,
  0x60, 0x06, 0x20, 0x40, 0x00, 0xB0, 0x40, 0x00, 0x50, 0x60, 0x00, 0x18,
  0x20, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x10, 0x00, 0x01, 0x18, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x84, 0x00, 0x00, 0x46, 0x00, 0x00, 0x23, 0x00, 0x00,
  0x11, 0x00, 0x00, 0x08, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x04, 0x20, 0x00,
  0x02, 0x10, 0x00, 0x01, 0x08, 0x00, 0x00, 0x84, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x61, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x20, 0x00, 0x28, 0x10,
  0x00, 0x34, 0x04, 0x00, 0x12, 0x01, 0x00, 0x33, 0x00, 0x60, 0x71, 0x00,
  0x0F, 0xE0, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x08, 0x00, 0x08,
  0x02, 0x00, 0x18, 0x00, 0xE0, 0x38, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x07, 0xF0, 0x08, 0x60, 0x60, 0x22, 0x00,
  0x40, 0x90, 0x00, 0x82, 0x80, 0x02, 0x0C, 0x00, 0x04, 0x70, 0x00, 0x11,
  0x80, 0x00, 0x46, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00,
  0x00, 0xCC, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00,
  0x88, 0x00, 0x02, 0x20, 0x00, 0x19, 0x80, 0x00, 0x44, 0x00, 0x01, 0x10,
  0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x03, 0x30, 0x00,
  0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x40, 0x20, 0x02, 0x01, 0x80, 0x30, 0x04, 0x01, 0x00, 0x10, 0x18,
  0x00, 0x40, 0xC0, 0x01, 0x04, 0x00, 0x0C, 0x60, 0x00, 0x22, 0x00, 0x00,
  0xB0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x80, 0x06, 0x03, 0x00, 0x10,
  0x02, 0x00, 0x40, 0x04, 0x01, 0x00, 0x08, 0x04, 0x00, 0x18, 0x10, 0x00,
  0x30, 0xC0, 0x00, 0x62, 0x00, 0x00, 0xC8, 0x00, 0x01, 0xA0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x02, 0x07, 0xF0, 0x00, 0x43, 0x81, 0x80, 0x08, 0x80,
  0x08, 0x03, 0x60, 0x01, 0x80, 0x48, 0x00, 0x10, 0x0A, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x40, 0x30, 0x00, 0x08, 0x04, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x08, 0x04, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x10,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x10, 0x38, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x08, 0x08, 0x00, 0x01, 0x00,
  0x80, 0x01, 0x60, 0x10, 0x00, 0x48, 0x01, 0x00, 0x11, 0x00, 0x30, 0x04,
  0x20, 0x02, 0x01, 0x04, 0x00, 0x60, 0x40, 0x80, 0x04, 0x30, 0x30, 0x00,
  0x4C, 0x06, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x10, 0x40, 0x06, 0x04, 0x00, 0x80, 0x40, 0x30, 0x04, 0x06,
  0x00, 0xC0, 0x80, 0x08, 0x30, 0x00, 0x84, 0x00, 0x09, 0x80, 0x00, 0xA0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x26, 0x18, 0x41, 0x01,
  0x40, 0x44, 0x04, 0x1C, 0x01, 0x40, 0x20, 0xA0, 0x0C, 0x01, 0x86, 0x00,
  0x60, 0x0C, 0x20, 0x02, 0x00, 0x61, 0x00, 0x30, 0x02, 0x08, 0x01, 0x00,
  0x10, 0xC0, 0x08, 0x00, 0x84, 0x00, 0x40, 0x04, 0x20, 0x02, 0x00, 0x21,
  0x00, 0x10, 0x03, 0x08, 0x01, 0x80, 0x10, 0x40, 0x08, 0x00, 0x86, 0x00,
  0x40, 0x04, 0x20, 0x02, 0x00, 0x21, 0x00, 0x10, 0x01, 0x08, 0x00, 0x80,
  0x18, 0x40, 0x04, 0x00, 0x82, 0x00, 0x60, 0x04, 0x30, 0x02, 0x00, 0x21,
  0x00, 0x10, 0x01, 0x08, 0x00, 0x80, 0x08, 0x40, 0x04, 0x00, 0xC2, 0x00,
  0x20, 0x04, 0x10, 0x03, 0x00, 0x21, 0x80, 0x10, 0x01, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x00, 0x1F, 0xC0, 0x31, 0x81, 0x80, 0x88, 0x01, 0x02, 0x40,
  0x02, 0x0A, 0x00, 0x08, 0x30, 0x00, 0x11, 0xC0, 0x00, 0x46, 0x00, 0x01,
  0x18, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00, 0x03, 0x30,
  0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00,
  0x08, 0x80, 0x00, 0x66, 0x00, 0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x11,
  0x00, 0x00, 0x44, 0x00, 0x01, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x22, 0x00,
  0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x20, 0x00, 0x3F,
  0x80, 0x00, 0xC0, 0x70, 0x01, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x04, 0x00,
  0x04, 0x08, 0x00, 0x02, 0x10, 0x00, 0x02, 0x10, 0x00, 0x03, 0x20, 0x00,
  0x01, 0x20, 0x00, 0x01, 0x20, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00,
  0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08, 0x60, 0x00,
  0x18, 0x20, 0x00, 0x10, 0x10, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x06, 0x03,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x86, 0x06, 0x00, 0x22,
  0x00, 0x60, 0x09, 0x00, 0x08, 0x06, 0x80, 0x01, 0x01, 0x40, 0x00, 0x60,
  0x60, 0x00, 0x08, 0x18, 0x00, 0x02, 0x04, 0x00, 0x00, 0x81, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x82, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x08, 0x20, 0x00, 0x02, 0x18, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x21, 0x00, 0x00, 0x18, 0x40, 0x00, 0x04, 0x10, 0x00, 0x01,
  0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x04, 0x0A, 0x00, 0x02, 0x02, 0x40, 0x01, 0x00, 0x98, 0x00, 0x80, 0x61,
  0x80, 0xC0, 0x10, 0x1F, 0xC0, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0xE1, 0x03, 0x00, 0x31, 0x04,
  0x00, 0x0B, 0x08, 0x00, 0x0A, 0x18, 0x00, 0x06, 0x10, 0x00, 0x06, 0x20,
  0x00, 0x06, 0x20, 0x00, 0x02, 0x60, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40,
  0x00, 0x04, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80, 0x00, 0x08, 0x80,
  0x00, 0x08, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x30, 0x40, 0x00, 0x50, 0x40, 0x00, 0xD0, 0x20, 0x00, 0x90, 0x10,
  0x03, 0x10, 0x0C, 0x0E, 0x30, 0x03, 0xF8, 0x20, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x08, 0xC0, 0x00, 0x02, 0x40, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x40, 0x00, 0x80, 0x40, 0x00, 0x30, 0x40, 0x00,
  0x08, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x03, 0x00, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0E,
  0x00, 0x20, 0x03, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x20,
  0x30, 0x00, 0x04, 0x18, 0x00, 0x00, 0x86, 0x00, 0x00, 0x13, 0x00, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x0C, 0xC0, 0x00,
  0x22, 0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22,
  0x00, 0x01, 0x88, 0x00, 0x04, 0x40, 0x00, 0x11, 0x00, 0x00, 0x44, 0x00,
  0x01, 0x10, 0x00, 0x04, 0x40, 0x00, 0x31, 0x00, 0x00, 0x8C, 0x00, 0x02,
  0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00, 0x06, 0x20,
  0x00, 0x10, 0x80, 0x00, 0x42, 0x00, 0x03, 0x08, 0x00, 0x14, 0x20, 0x00,
  0x50, 0x80, 0x02, 0xC3, 0x00, 0x1A, 0x04, 0x00, 0xC8, 0x0C, 0x0C, 0x20,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x02, 0x02, 0x00, 0x02, 0x02, 0x00, 0x02,
  0x02, 0x00, 0x02, 0x02, 0x00, 0x03, 0x02, 0x00, 0x01, 0x02, 0x00, 0x01,
  0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x04, 0x00, 0x02, 0x04, 0x00, 0x02,
  0x04, 0x00, 0x02, 0x04, 0x00, 0x02, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x04,
  0x08, 0x00, 0x04, 0x08, 0x00, 0x08, 0x08, 0x00, 0x08, 0x08, 0x00, 0x10,
  0x08, 0x00, 0x30, 0x08, 0x00, 0x60, 0x18, 0x00, 0x40, 0x10, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x10, 0x06, 0x00, 0x10, 0x18, 0x00, 0x10, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x08, 0x01, 0x00, 0x83, 0x00, 0x20, 0x10, 0x40, 0x04,
  0x01, 0x08, 0x01, 0x80, 0x21, 0x00, 0x20, 0x04, 0x20, 0x04, 0x00, 0x84,
  0x00, 0x80, 0x11, 0x80, 0x10, 0x02, 0x20, 0x02, 0x00, 0x64, 0x00, 0xC0,
  0x0C, 0x80, 0x10, 0x01, 0x90, 0x02, 0x00, 0x32, 0x00, 0x40, 0x04, 0xC0,
  0x08, 0x00, 0x90, 0x01, 0x00, 0x12, 0x00, 0x60, 0x02, 0x40, 0x08, 0x00,
  0x48, 0x01, 0x00, 0x09, 0x00, 0x20, 0x03, 0x60, 0x04, 0x00, 0x48, 0x00,
  0x80, 0x09, 0x00, 0x30, 0x01, 0x20, 0x0A, 0x00, 0x64, 0x01, 0x40, 0x08,
  0x80, 0x28, 0x02, 0x10, 0x09, 0x00, 0xC3, 0x02, 0x20, 0x30, 0x30, 0xC3,
  0x0C, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x03, 0x30, 0x18,
  0x60, 0x30, 0x40, 0xC0, 0xC3, 0x00, 0x86, 0x01, 0x30, 0x02, 0x10, 0x04,
  0x00, 0x08, 0x80, 0x10, 0x00, 0x12, 0x00, 0x40, 0x00, 0x50, 0x01, 0x00,
  0x01, 0x40, 0x04, 0x00, 0x06, 0x00, 0x10, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x40, 0x00, 0x40, 0x05, 0x00, 0x03,
  0x00, 0x14, 0x00, 0x0C, 0x00, 0x90, 0x00, 0x20, 0x02, 0x40, 0x00, 0x80,
  0x09, 0x00, 0x0B, 0x00, 0x42, 0x00, 0xC4, 0x02, 0x08, 0x0C, 0x10, 0x18,
  0x30, 0xC0, 0x30, 0xC0, 0x4C, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x20, 0x20, 0x00, 0x08, 0x08, 0x00, 0x02, 0x02,
  0x00, 0x00, 0x80, 0x80, 0x00, 0x20, 0x20, 0x00, 0x18, 0x08, 0x00, 0x04,
  0x04, 0x00, 0x01, 0x01, 0x00, 0x00, 0x40, 0x40, 0x00, 0x10, 0x10, 0x00,
  0x04, 0x04, 0x00, 0x03, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x20,
  0x00, 0x08, 0x08, 0x00, 0x02, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x60,
  0x20, 0x00, 0x10, 0x08, 0x00, 0x04, 0x02, 0x00, 0x03, 0x00, 0x80, 0x01,
  0x40, 0x20, 0x00, 0x50, 0x08, 0x00, 0x2C, 0x03, 0x00, 0x1A, 0x00, 0x40,
  0x0C, 0x80, 0x0C, 0x0C, 0x20, 0x00, 0xFC, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0x60, 0x01, 0x80, 0x06, 0x01,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x01, 0x80, 0xC0, 0x10,
  0x40, 0x0E, 0x04, 0x20, 0x00, 0x61, 0x08, 0x00, 0x07, 0x84, 0x00, 0x00,
  0x41, 0x00, 0x00, 0x20, 0x40, 0x00, 0x10, 0x10, 0x00, 0x18, 0x04, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x10, 0x03, 0x00,
  0x04, 0x01, 0x00, 0x01, 0x00, 0x80, 0x00, 0x40, 0x40, 0x00, 0x10, 0x60,
  0x00, 0x02, 0x3E, 0x00, 0x00, 0x88, 0x7C, 0x00, 0x22, 0x00, 0xF8, 0x08,
  0x80, 0x01, 0xE2, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x21, 0x86, 0x00, 0x04, 0x60, 0x60, 0x01, 0x98,
  0x06, 0x00, 0x22, 0x00, 0x40, 0x0C, 0x80, 0x04, 0x01, 0x10, 0x00, 0x40,
  0x44, 0x00, 0x04, 0x30, 0x80, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 9, 38, 32, 12, -38 },
  { 44, 11, 14, 32, 14, -40 },
  { 64, 32, 38, 32, 1, -38 },
  { 216, 29, 49, 32, 2, -43 },
  { 394, 36, 39, 32, -1, -38 },
  { 570, 31, 39, 32, 1, -38 },
  { 722, 3, 14, 32, 18, -40 },
  { 728, 16, 48, 32, 13, -41 },
  { 824, 17, 48, 32, 4, -41 },
  { 926, 28, 27, 32, 3, -30 },
  { 1021, 26, 27, 32, 4, -30 },
  { 1109, 7, 13, 32, 9, -4 },
  { 1121, 15, 1, 32, 9, -17 },
  { 1123, 4, 3, 32, 12, -3 },
  { 1125, 29, 48, 32, 2, -41 },
  { 1299, 26, 39, 32, 4, -38 },
  { 1426, 24, 38, 32, 3, -38 },
  { 1540, 27, 38, 32, 2, -38 },
  { 1669, 25, 39, 32, 3, -38 },
  { 1791, 27, 38, 32, 2, -38 },
  { 1920, 27, 39, 32, 3, -38 },
  { 2052, 24, 39, 32, 4, -38 },
  { 2169, 26, 38, 32, 6, -38 },
  { 2293, 27, 39, 32, 3, -38 },
  { 2425, 23, 38, 32, 6, -38 },
  { 2535, 8, 28, 32, 12, -28 },
  { 2563, 11, 37, 32, 9, -28 },
  { 2614, 26, 29, 32, 5, -31 },
  { 2709, 27, 11, 32, 3, -22 },
  { 2747, 25, 29, 32, 3, -31 },
  { 2838, 21, 38, 32, 8, -38 },
  { 2938, 25, 44, 32, 4, -38 },
  { 3076, 27, 38, 32, 0, -38 },
  { 3205, 26, 38, 32, 3, -38 },
  { 3329, 25, 39, 32, 5, -38 },
  { 3451, 26, 38, 32, 4, -38 },
  { 3575, 28, 38, 32, 4, -38 },
  { 3708, 28, 38, 32, 4, -38 },
  { 3841, 25, 39, 32, 5, -38 },
  { 3963, 28, 38, 32, 3, -38 },
  { 4096, 28, 38, 32, 3, -38 },
  { 4229, 25, 39, 32, 4, -38 },
  { 4351, 29, 38, 32, 4, -38 },
  { 4489, 20, 38, 32, 6, -38 },
  { 4584, 30, 38, 32, 2, -38 },
  { 4727, 28, 38, 32, 3, -38 },
  { 4860, 26, 39, 32, 4, -38 },
  { 4987, 27, 38, 32, 4, -38 },
  { 5116, 26, 47, 32, 4, -38 },
  { 5269, 27, 38, 32, 4, -38 },
  { 5398, 29, 39, 32, 2, -38 },
  { 5540, 28, 38, 32, 6, -38 },
  { 5673, 26, 39, 32, 5, -38 },
  { 5800, 26, 38, 32, 7, -38 },
  { 5924, 29, 38, 32, 4, -38 },
  { 6062, 33, 38, 32, 0, -38 },
  { 6219, 30, 38, 32, 5, -38 },
  { 6362, 33, 38, 32, 0, -38 },
  { 6519, 21, 48, 32, 11, -41 },
  { 6645, 12, 48, 32, 11, -41 },
  { 6717, 21, 48, 32, 2, -41 },
  { 6843, 25, 20, 32, 4, -38 },
  { 6906, 26, 1, 32, 0, 7 },
  { 6910, 6, 9, 32, 13, -41 },
  { 6917, 24, 30, 32, 4, -29 },
  { 7007, 25, 41, 32, 4, -40 },
  { 7136, 23, 30, 32, 4, -29 },
  { 7223, 26, 41, 32, 4, -40 },
  { 7357, 23, 30, 32, 4, -29 },
  { 7444, 34, 51, 32, -1, -40 },
  { 7661, 25, 40, 32, 3, -29 },
  { 7786, 22, 40, 32, 5, -40 },
  { 7896, 22, 41, 32, 5, -40 },
  { 8009, 22, 51, 32, 6, -40 },
  { 8150, 27, 41, 32, 4, -40 },
  { 8289, 20, 41, 32, 7, -40 },
  { 8392, 29, 29, 32, 2, -29 },
  { 8498, 22, 29, 32, 5, -29 },
  { 8578, 24, 30, 32, 4, -29 },
  { 8668, 26, 40, 32, 3, -29 },
  { 8798, 24, 40, 32, 4, -29 },
  { 8918, 26, 28, 32, 6, -28 },
  { 9009, 25, 30, 32, 3, -29 },
  { 9103, 27, 39, 32, 4, -38 },
  { 9235, 22, 29, 32, 6, -28 },
  { 9315, 24, 28, 32, 5, -28 },
  { 9399, 27, 29, 32, 4, -28 },
  { 9497, 30, 30, 32, 1, -29 },
  { 9610, 26, 39, 32, 2, -28 },
  { 9737, 26, 30, 32, 3, -29 },
  { 9835, 24, 48, 32, 7, -41 },
  { 9979, 9, 48, 32, 12, -41 },
  { 10033, 24, 48, 32, 3, -41 },
  { 10177, 27, 9, 32, 3, -21 },
};

const GFXfont IBMPlexMono_ThinItalic54pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic54pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic54pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _IBMPLEXMONO_THINITALIC54PT7B_H_
