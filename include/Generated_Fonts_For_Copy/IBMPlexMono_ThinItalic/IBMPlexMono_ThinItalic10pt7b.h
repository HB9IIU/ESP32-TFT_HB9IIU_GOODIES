#ifndef _IBMPLEXMONO_THINITALIC10PT7B_H_
#define _IBMPLEXMONO_THINITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x5A, 0x88, 0xE8, 0x38, 0xA6, 0xD4, 0xC9, 0x4A, 0x00, 0x10, 0xE5,
  0x99, 0x38, 0xAA, 0x9C, 0x20, 0x66, 0x66, 0x80, 0x5A, 0xB9, 0x80, 0x31,
  0x24, 0x9C, 0xA2, 0x56, 0x80, 0xE0, 0x2A, 0x49, 0x24, 0x40, 0x48, 0x92,
  0x52, 0x80, 0x22, 0x3F, 0x4A, 0x00, 0x64, 0xF4, 0x40, 0xE0, 0xC0, 0x80,
  0x0C, 0x21, 0x04, 0x20, 0x84, 0x20, 0x80, 0x74, 0xA7, 0xA9, 0x4B, 0x80,
  0x11, 0x94, 0x42, 0x13, 0xE0, 0x3A, 0x42, 0x11, 0x33, 0xE0, 0x3A, 0x42,
  0x60, 0xC5, 0xC0, 0x09, 0xD2, 0xA7, 0xC8, 0x40, 0x7C, 0x19, 0x21, 0x49,
  0x80, 0x34, 0x8F, 0x99, 0xE0, 0xFC, 0x84, 0x44, 0x22, 0x00, 0x74, 0x64,
  0xC9, 0x4B, 0x80, 0x79, 0x9F, 0x12, 0xC0, 0x40, 0x20, 0x40, 0x2A, 0x1B,
  0x20, 0x83, 0x00, 0xF8, 0x3C, 0x41, 0x82, 0x6C, 0x00, 0x74, 0xA8, 0x20,
  0x79, 0xBD, 0x9F, 0x8E, 0x11, 0x94, 0xA7, 0xC6, 0x20, 0x79, 0x9E, 0x99,
  0xF0, 0x74, 0xA3, 0x08, 0x4B, 0x80, 0x74, 0xA3, 0x29, 0x4B, 0x80, 0x7C,
  0x21, 0xE8, 0x43, 0xC0, 0x7C, 0x21, 0xE8, 0x42, 0x00, 0x74, 0xA3, 0x69,
  0x4B, 0xC0, 0x8C, 0x65, 0xE9, 0x4A, 0x40, 0x3C, 0x42, 0x08, 0x20, 0x8F,
  0x80, 0x71, 0x11, 0x1A, 0xE0, 0x8C, 0xA9, 0x8A, 0x52, 0x40, 0x88, 0x88,
  0x88, 0xF0, 0x4D, 0x1B, 0xAA, 0x8A, 0x28, 0x80, 0x8E, 0x75, 0xAB, 0x5A,
  0x40, 0x74, 0xA7, 0x29, 0x4B, 0x80, 0x74, 0x63, 0x1F, 0x42, 0x00, 0x74,
  0xA7, 0x29, 0x4B, 0x8A, 0x20, 0x74, 0x63, 0x1F, 0x52, 0xC0, 0x31, 0x24,
  0x4E, 0x0A, 0x27, 0x00, 0xF9, 0x08, 0x84, 0x21, 0x00, 0x8C, 0x65, 0x29,
  0x4B, 0x80, 0x8C, 0xA5, 0x4A, 0x61, 0x00, 0x8C, 0x6D, 0x6F, 0x4A, 0x80,
  0x45, 0x23, 0x08, 0x51, 0x48, 0x80, 0x8C, 0xA4, 0xC4, 0x21, 0x00, 0x7C,
  0x21, 0x08, 0x42, 0x0F, 0x80, 0x74, 0x88, 0x88, 0x88, 0xC0, 0xAA, 0xA5,
  0x40, 0x31, 0x11, 0x22, 0x22, 0xE0, 0x65, 0x99, 0xF8, 0xC0, 0x79, 0x9A,
  0xF0, 0x88, 0x79, 0x99, 0xE0, 0x69, 0x8B, 0xE0, 0x18, 0x9D, 0x29, 0x4B,
  0x80, 0x79, 0xE9, 0xE0, 0x0C, 0x47, 0xC8, 0x20, 0x8A, 0x28, 0x40, 0x3A,
  0x63, 0x17, 0x49, 0xC0, 0x88, 0xBD, 0x99, 0xA0, 0x20, 0xC4, 0x4B, 0x40,
  0x10, 0xF2, 0x22, 0xAE, 0x20, 0x84, 0x1D, 0x2E, 0x66, 0xC0, 0xE4, 0x44,
  0x4B, 0x40, 0xAD, 0x5A, 0xAA, 0xA8, 0xBD, 0x99, 0xA0, 0x79, 0x99, 0xE0,
  0x3A, 0x63, 0x1F, 0x42, 0x00, 0x79, 0x99, 0xE2, 0x20, 0xDB, 0x10, 0x88,
  0x00, 0x78, 0x71, 0xE0, 0x42, 0x3E, 0x84, 0x59, 0x00, 0x99, 0x99, 0xE0,
  0x99, 0x99, 0xE0, 0xAE, 0x73, 0xAB, 0x00, 0x2B, 0x5A, 0x6A, 0x50, 0x4A,
  0x63, 0x17, 0x49, 0xC0, 0xF9, 0x69, 0xF0, 0x39, 0x08, 0x4C, 0x11, 0x10,
  0x60, 0x56, 0xAA, 0x80, 0x30, 0x84, 0x41, 0x90, 0x84, 0xE0, 0xCE, 0xAC,
};

const GFXglyph IBMPlexMono_ThinItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 2, 3, 6, 3, -7 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 6, 9, 6, 0, -8 },
  { 17, 6, 7, 6, 0, -7 },
  { 23, 6, 7, 6, 0, -7 },
  { 29, 1, 3, 6, 3, -7 },
  { 30, 3, 9, 6, 2, -8 },
  { 34, 3, 9, 6, 1, -8 },
  { 38, 5, 5, 6, 1, -5 },
  { 42, 4, 5, 6, 1, -6 },
  { 45, 1, 3, 6, 2, -1 },
  { 46, 2, 1, 6, 2, -4 },
  { 47, 1, 1, 6, 2, -1 },
  { 48, 6, 9, 6, 0, -8 },
  { 55, 5, 7, 6, 1, -7 },
  { 60, 5, 7, 6, 0, -7 },
  { 65, 5, 7, 6, 0, -7 },
  { 70, 5, 7, 6, 0, -7 },
  { 75, 5, 7, 6, 0, -7 },
  { 80, 5, 7, 6, 1, -7 },
  { 85, 4, 7, 6, 1, -7 },
  { 89, 5, 7, 6, 1, -7 },
  { 94, 5, 7, 6, 1, -7 },
  { 99, 4, 7, 6, 1, -7 },
  { 103, 2, 6, 6, 2, -6 },
  { 105, 2, 8, 6, 2, -6 },
  { 107, 5, 5, 6, 1, -6 },
  { 111, 5, 3, 6, 1, -5 },
  { 113, 5, 5, 6, 0, -6 },
  { 117, 3, 7, 6, 2, -7 },
  { 120, 4, 8, 6, 1, -7 },
  { 124, 5, 7, 6, 0, -7 },
  { 129, 4, 7, 6, 1, -7 },
  { 133, 5, 7, 6, 1, -7 },
  { 138, 5, 7, 6, 1, -7 },
  { 143, 5, 7, 6, 1, -7 },
  { 148, 5, 7, 6, 1, -7 },
  { 153, 5, 7, 6, 1, -7 },
  { 158, 5, 7, 6, 1, -7 },
  { 163, 6, 7, 6, 0, -7 },
  { 169, 4, 7, 6, 1, -7 },
  { 173, 5, 7, 6, 1, -7 },
  { 178, 4, 7, 6, 1, -7 },
  { 182, 6, 7, 6, 0, -7 },
  { 188, 5, 7, 6, 1, -7 },
  { 193, 5, 7, 6, 1, -7 },
  { 198, 5, 7, 6, 1, -7 },
  { 203, 5, 9, 6, 1, -7 },
  { 209, 5, 7, 6, 1, -7 },
  { 214, 6, 7, 6, 0, -7 },
  { 220, 5, 7, 6, 1, -7 },
  { 225, 5, 7, 6, 1, -7 },
  { 230, 5, 7, 6, 1, -7 },
  { 235, 5, 7, 6, 1, -7 },
  { 240, 6, 7, 6, 0, -7 },
  { 246, 5, 7, 6, 1, -7 },
  { 251, 6, 7, 6, 0, -7 },
  { 257, 4, 9, 6, 2, -8 },
  { 262, 2, 9, 6, 2, -8 },
  { 265, 4, 9, 6, 0, -8 },
  { 270, 4, 4, 6, 1, -7 },
  { 272, 5, 1, 6, 0, 1 },
  { 273, 1, 2, 6, 2, -9 },
  { 274, 4, 5, 6, 1, -5 },
  { 277, 4, 7, 6, 1, -7 },
  { 281, 4, 5, 6, 1, -5 },
  { 284, 5, 7, 6, 1, -7 },
  { 289, 4, 5, 6, 1, -5 },
  { 292, 6, 9, 6, 0, -7 },
  { 299, 5, 7, 6, 0, -5 },
  { 304, 4, 7, 6, 1, -7 },
  { 308, 4, 7, 6, 1, -7 },
  { 312, 4, 9, 6, 1, -7 },
  { 317, 5, 7, 6, 1, -7 },
  { 322, 4, 7, 6, 1, -7 },
  { 326, 6, 5, 6, 0, -5 },
  { 330, 4, 5, 6, 1, -5 },
  { 333, 4, 5, 6, 1, -5 },
  { 336, 5, 7, 6, 0, -5 },
  { 341, 4, 7, 6, 1, -5 },
  { 345, 5, 5, 6, 1, -5 },
  { 349, 4, 5, 6, 1, -5 },
  { 352, 5, 7, 6, 1, -7 },
  { 357, 4, 5, 6, 1, -5 },
  { 360, 4, 5, 6, 1, -5 },
  { 363, 5, 5, 6, 1, -5 },
  { 367, 6, 5, 6, 0, -5 },
  { 371, 5, 7, 6, 0, -5 },
  { 376, 4, 5, 6, 1, -5 },
  { 379, 5, 9, 6, 1, -8 },
  { 385, 2, 9, 6, 2, -8 },
  { 388, 5, 9, 6, 0, -8 },
  { 394, 5, 3, 6, 1, -4 },
};

const GFXfont IBMPlexMono_ThinItalic10pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic10pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _IBMPLEXMONO_THINITALIC10PT7B_H_
