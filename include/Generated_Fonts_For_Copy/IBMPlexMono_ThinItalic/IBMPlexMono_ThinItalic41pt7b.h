#ifndef _IBMPLEXMONO_THINITALIC41PT7B_H_
#define _IBMPLEXMONO_THINITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-ThinItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_ThinItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x87, 0x0E, 0x00, 0x41, 0x41, 0x42, 0x42, 0x42, 0x42, 0x82, 0x82, 0x84,
  0x84, 0x00, 0x04, 0x08, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08,
  0x10, 0x00, 0x10, 0x20, 0x00, 0x10, 0x20, 0x00, 0x20, 0x20, 0x00, 0x20,
  0x40, 0x00, 0x20, 0x40, 0x00, 0x40, 0x40, 0x1F, 0xC0, 0xFF, 0x00, 0x40,
  0x80, 0x00, 0x80, 0x80, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x01, 0x01,
  0x00, 0x01, 0x02, 0x00, 0x01, 0x02, 0x00, 0xFE, 0x03, 0xF8, 0x02, 0x04,
  0x00, 0x02, 0x04, 0x00, 0x04, 0x04, 0x00, 0x04, 0x08, 0x00, 0x04, 0x08,
  0x00, 0x08, 0x08, 0x00, 0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x10, 0x10,
  0x00, 0x10, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xF0, 0x01, 0x84, 0x70, 0x10, 0x20, 0x41, 0x01,
  0x01, 0x08, 0x08, 0x08, 0x80, 0x40, 0x04, 0x02, 0x00, 0x20, 0x20, 0x01,
  0x01, 0x00, 0x08, 0x08, 0x00, 0x60, 0x40, 0x01, 0x02, 0x00, 0x06, 0x20,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x46, 0x00, 0x02, 0x08, 0x00,
  0x10, 0x20, 0x01, 0x01, 0x00, 0x08, 0x04, 0x00, 0x40, 0x20, 0x02, 0x01,
  0x00, 0x10, 0x08, 0x00, 0x80, 0x88, 0x08, 0x04, 0x60, 0x40, 0x41, 0x82,
  0x04, 0x03, 0x10, 0xC0, 0x07, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x78, 0x00, 0x20, 0x30, 0xC0,
  0x08, 0x08, 0x08, 0x01, 0x02, 0x00, 0x80, 0x40, 0x40, 0x10, 0x10, 0x08,
  0x02, 0x04, 0x02, 0x00, 0x40, 0x80, 0x40, 0x08, 0x20, 0x08, 0x02, 0x08,
  0x01, 0x00, 0x42, 0x00, 0x20, 0x08, 0x80, 0x02, 0x02, 0x10, 0x00, 0x21,
  0x84, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0x04, 0x00, 0x0C, 0x40, 0x40, 0x02, 0x10, 0x08, 0x00, 0x42,
  0x00, 0x80, 0x10, 0x80, 0x10, 0x04, 0x10, 0x04, 0x01, 0x02, 0x00, 0x80,
  0x40, 0x40, 0x10, 0x08, 0x08, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x10,
  0x10, 0x20, 0x03, 0x0C, 0x0C, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0x06, 0x00, 0x0C, 0x02, 0x00, 0x10, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x01,
  0x00, 0x08, 0x02, 0x00, 0x08, 0x04, 0x00, 0x10, 0x10, 0x00, 0xF0, 0xC0,
  0x06, 0x1E, 0x00, 0x10, 0x20, 0x00, 0x40, 0x20, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0xC0, 0x10, 0x00, 0x80, 0x20,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x09, 0x05, 0x00, 0x11, 0x11, 0x00,
  0x42, 0x21, 0x83, 0x02, 0x81, 0xF8, 0x02, 0x00, 0x24, 0x94, 0x92, 0x58,
  0x00, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x08, 0x02, 0x01, 0x70, 0x40, 0xE0, 0xE4, 0x70, 0x01, 0xF8,
  0x00, 0x0C, 0x00, 0x01, 0xA0, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x40,
  0x80, 0x08, 0x08, 0x01, 0x00, 0x40, 0x20, 0x04, 0x04, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x03, 0xFF,
  0xFF, 0x80, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x0C, 0x21, 0x84, 0x10, 0x82, 0x10, 0x42, 0x00, 0xFF, 0xE0, 0x7F,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x18, 0x18, 0x02, 0x00, 0x40, 0x40,
  0x04, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x22, 0x00, 0x02, 0x20,
  0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x02, 0x40, 0x00, 0x24,
  0x00, 0x02, 0x80, 0x60, 0x28, 0x06, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00, 0x08, 0x80, 0x00,
  0x88, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x20, 0x20, 0x04, 0x01, 0x81,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xD0, 0x00,
  0x62, 0x00, 0x18, 0x40, 0x06, 0x08, 0x01, 0x01, 0x00, 0xC0, 0x40, 0x10,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0x00, 0x18, 0x0C, 0x02, 0x00, 0x60, 0x40, 0x02, 0x04,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x18, 0x18, 0x02, 0x00, 0x40, 0x40, 0x02,
  0x08, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x1F,
  0xC0, 0x02, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x80, 0x00, 0x84, 0x00, 0x10, 0x60, 0x02, 0x01, 0x80, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x02, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x40, 0x00, 0x12, 0x00, 0x01, 0x10, 0x00, 0x10, 0x80, 0x01, 0x04,
  0x00, 0x10, 0x40, 0x01, 0x02, 0x00, 0x08, 0x10, 0x00, 0x80, 0x80, 0x08,
  0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x08, 0x00, 0x80,
  0x80, 0x04, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x10, 0x7F, 0xFF,
  0xFC, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xF8, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x11, 0xF8, 0x01, 0x30, 0x30, 0x0A, 0x00, 0x40, 0x60, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x82, 0x00, 0x08, 0x08, 0x00, 0xC0, 0x30, 0x18, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x31, 0xFC, 0x09, 0x81, 0x82, 0x80, 0x11, 0x40,
  0x02, 0x60, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x01, 0x10, 0x00, 0x42,
  0x00, 0x60, 0x60, 0x70, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xE8, 0x00, 0x09,
  0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x84,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0E, 0x06, 0x00, 0x80, 0x0C,
  0x08, 0x00, 0x20, 0x40, 0x01, 0x04, 0x00, 0x04, 0x20, 0x00, 0x21, 0x00,
  0x01, 0x08, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x08, 0x08, 0x00, 0x80,
  0x30, 0x18, 0x00, 0x7F, 0x00, 0x1C, 0x0C, 0x03, 0x00, 0x10, 0x30, 0x00,
  0x41, 0x00, 0x01, 0x10, 0x00, 0x08, 0x80, 0x00, 0x44, 0x00, 0x02, 0x40,
  0x00, 0x12, 0x00, 0x00, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x42, 0x00, 0x04,
  0x08, 0x00, 0x40, 0x30, 0x1C, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x01,
  0x81, 0x80, 0x80, 0x10, 0x40, 0x02, 0x20, 0x00, 0x50, 0x00, 0x14, 0x00,
  0x05, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0x90, 0x00, 0x64, 0x00, 0x38, 0x80, 0x1C, 0x18, 0x19, 0x01,
  0xF8, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x70, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xE3, 0x80, 0x01, 0x81, 0xC0, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x0C, 0x0C, 0x10, 0x02, 0x20, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x00, 0x7E, 0x00, 0x30, 0x30, 0x0C, 0x01, 0x03, 0x00, 0x20, 0x40,
  0x02, 0x10, 0x00, 0x42, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x03,
  0xC4, 0x81, 0x86, 0x90, 0x60, 0x62, 0x08, 0x04, 0x42, 0x00, 0x90, 0x40,
  0x12, 0x08, 0x02, 0x42, 0x00, 0x48, 0x40, 0x11, 0x08, 0x02, 0x21, 0x00,
  0x48, 0x20, 0x09, 0x04, 0x03, 0x20, 0xC0, 0xA4, 0x08, 0x38, 0x80, 0xFD,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x88, 0x00, 0x04, 0x40,
  0x00, 0x42, 0x00, 0x02, 0x10, 0x00, 0x20, 0x80, 0x01, 0x04, 0x00, 0x10,
  0x10, 0x00, 0x80, 0x80, 0x08, 0x04, 0x00, 0x40, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x02, 0x00, 0x20, 0x10, 0x01, 0x00, 0xFF, 0xF8, 0x08, 0x00,
  0x40, 0x80, 0x02, 0x04, 0x00, 0x10, 0x40, 0x00, 0x42, 0x00, 0x02, 0x10,
  0x00, 0x11, 0x00, 0x00, 0x88, 0x00, 0x04, 0x80, 0x00, 0x2C, 0x00, 0x00,
  0x80, 0x07, 0xFF, 0x80, 0x40, 0x0C, 0x04, 0x00, 0x20, 0x40, 0x02, 0x08,
  0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10,
  0x80, 0x02, 0x10, 0x00, 0x21, 0x00, 0x06, 0x10, 0x00, 0x41, 0x00, 0x18,
  0x1F, 0xFE, 0x01, 0x00, 0x18, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00,
  0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x04, 0x40, 0x00, 0x44, 0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x30, 0xFF,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x30, 0x60, 0x18, 0x02, 0x06, 0x00, 0x20,
  0x80, 0x04, 0x20, 0x00, 0x48, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80,
  0x02, 0x08, 0x00, 0x80, 0x80, 0x30, 0x0C, 0x18, 0x00, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x80, 0x30, 0x08, 0x00, 0x80, 0x80, 0x04, 0x08, 0x00, 0x21,
  0x00, 0x02, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x11, 0x00, 0x01,
  0x10, 0x00, 0x12, 0x00, 0x01, 0x20, 0x00, 0x12, 0x00, 0x02, 0x20, 0x00,
  0x22, 0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x08, 0x80,
  0x01, 0x08, 0x00, 0x20, 0x80, 0x04, 0x08, 0x01, 0x80, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xFF, 0xFF, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x60, 0x60, 0x18, 0x02, 0x04, 0x00, 0x21, 0x80, 0x04, 0x20, 0x00,
  0x48, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x7F, 0x90, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x03, 0x08, 0x00, 0xA1,
  0x80, 0x24, 0x18, 0x18, 0x80, 0xFE, 0x20, 0x04, 0x00, 0x04, 0x10, 0x00,
  0x20, 0x40, 0x00, 0x82, 0x00, 0x02, 0x08, 0x00, 0x08, 0x20, 0x00, 0x20,
  0x80, 0x00, 0x82, 0x00, 0x04, 0x08, 0x00, 0x10, 0x40, 0x00, 0x41, 0x00,
  0x01, 0x04, 0x00, 0x04, 0x10, 0x00, 0x10, 0x40, 0x00, 0x81, 0xFF, 0xFE,
  0x08, 0x00, 0x08, 0x20, 0x00, 0x20, 0x80, 0x00, 0x82, 0x00, 0x02, 0x08,
  0x00, 0x10, 0x20, 0x00, 0x41, 0x00, 0x01, 0x04, 0x00, 0x04, 0x10, 0x00,
  0x10, 0x40, 0x00, 0x41, 0x00, 0x02, 0x04, 0x00, 0x08, 0x20, 0x00, 0x20,
  0x80, 0x00, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x00, 0x84, 0x00, 0x10, 0x80, 0x04, 0x10, 0x01,
  0x81, 0x00, 0x60, 0x18, 0x18, 0x01, 0xFC, 0x00, 0x08, 0x00, 0x04, 0x20,
  0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x40, 0x06,
  0x01, 0x00, 0x30, 0x04, 0x01, 0x00, 0x10, 0x08, 0x00, 0x40, 0x40, 0x01,
  0x02, 0x00, 0x08, 0x10, 0x00, 0x20, 0x80, 0x00, 0x85, 0x00, 0x02, 0x24,
  0x00, 0x09, 0x08, 0x00, 0x28, 0x20, 0x01, 0x40, 0x40, 0x06, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x04, 0x00, 0x40, 0x20,
  0x00, 0x80, 0x80, 0x02, 0x02, 0x00, 0x04, 0x08, 0x00, 0x10, 0x20, 0x00,
  0x20, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00,
  0xFF, 0xFF, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC2, 0x80,
  0x05, 0x0A, 0x00, 0x28, 0x48, 0x01, 0xA1, 0x10, 0x04, 0x84, 0x40, 0x32,
  0x11, 0x00, 0x88, 0x44, 0x04, 0x21, 0x08, 0x11, 0x08, 0x20, 0x84, 0x20,
  0x84, 0x10, 0x82, 0x10, 0x42, 0x04, 0x81, 0x08, 0x12, 0x04, 0x20, 0x50,
  0x21, 0x00, 0x80, 0x84, 0x02, 0x02, 0x10, 0x00, 0x08, 0x40, 0x00, 0x21,
  0x00, 0x00, 0x84, 0x00, 0x04, 0x10, 0x00, 0x10, 0x80, 0x00, 0x42, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x10, 0x80, 0x00, 0x80, 0x06, 0x00,
  0x04, 0x18, 0x00, 0x20, 0xA0, 0x00, 0x82, 0x40, 0x02, 0x09, 0x00, 0x08,
  0x24, 0x00, 0x20, 0x88, 0x00, 0x82, 0x20, 0x04, 0x10, 0x80, 0x10, 0x41,
  0x00, 0x41, 0x04, 0x01, 0x04, 0x10, 0x04, 0x10, 0x20, 0x10, 0x40, 0x80,
  0x81, 0x02, 0x02, 0x08, 0x04, 0x08, 0x20, 0x10, 0x20, 0x80, 0x40, 0x82,
  0x00, 0x82, 0x08, 0x02, 0x10, 0x20, 0x08, 0x41, 0x00, 0x11, 0x04, 0x00,
  0x44, 0x10, 0x01, 0x10, 0x40, 0x02, 0x41, 0x00, 0x0A, 0x04, 0x00, 0x18,
  0x20, 0x00, 0x60, 0x80, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x18, 0x18, 0x02,
  0x00, 0x40, 0x40, 0x04, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10, 0x00, 0x22,
  0x00, 0x02, 0x20, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x02,
  0x40, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00,
  0x08, 0x80, 0x00, 0x88, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00, 0x20, 0x20,
  0x04, 0x01, 0x81, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x80, 0x04,
  0x08, 0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00,
  0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x12, 0x00,
  0x03, 0x20, 0x00, 0x22, 0x00, 0x04, 0x20, 0x01, 0x83, 0xFF, 0xE0, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x18,
  0x18, 0x02, 0x00, 0x40, 0x40, 0x04, 0x08, 0x00, 0x21, 0x00, 0x02, 0x10,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x12, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00,
  0x48, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x10, 0x40, 0x01, 0x04, 0x00,
  0x20, 0x20, 0x04, 0x01, 0x81, 0x80, 0x07, 0xE0, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x04, 0x00, 0x20, 0x80, 0x02, 0x30, 0x00, 0x16, 0x00,
  0x00, 0x80, 0x0F, 0xFF, 0x80, 0x80, 0x04, 0x08, 0x00, 0x20, 0x80, 0x01,
  0x08, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00,
  0x11, 0x00, 0x01, 0x10, 0x00, 0x12, 0x00, 0x03, 0x20, 0x00, 0x22, 0x00,
  0x04, 0x20, 0x01, 0x83, 0xFF, 0xE0, 0x20, 0x20, 0x02, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x04, 0x00, 0x80, 0x40, 0x08, 0x04,
  0x00, 0x40, 0x80, 0x04, 0x08, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x10,
  0x80, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x18, 0x07, 0x01, 0x00, 0x0C, 0x10,
  0x00, 0x10, 0x80, 0x00, 0x88, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x08, 0x80, 0x00, 0x46, 0x00, 0x04, 0x18,
  0x00, 0x40, 0x30, 0x0C, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x11, 0x00, 0x02, 0x10, 0x00, 0x22, 0x00, 0x02, 0x20,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x04, 0x20, 0x00, 0x44,
  0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x44, 0x00, 0x08,
  0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01,
  0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00,
  0x20, 0x80, 0x02, 0x08, 0x00, 0x40, 0xC0, 0x08, 0x06, 0x03, 0x00, 0x1F,
  0xC0, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x02,
  0x40, 0x00, 0x44, 0x00, 0x04, 0x40, 0x00, 0x84, 0x00, 0x08, 0x20, 0x01,
  0x02, 0x00, 0x10, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x04, 0x02, 0x00,
  0x40, 0x20, 0x08, 0x01, 0x00, 0x80, 0x10, 0x10, 0x01, 0x01, 0x00, 0x10,
  0x20, 0x01, 0x02, 0x00, 0x10, 0x40, 0x00, 0x84, 0x00, 0x08, 0x80, 0x00,
  0x88, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x0A, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x04, 0x80, 0x00, 0x12, 0x00, 0x00, 0x48,
  0x00, 0x02, 0x20, 0x00, 0x08, 0x80, 0x00, 0x22, 0x00, 0x00, 0x88, 0x00,
  0x04, 0x20, 0x00, 0x10, 0x80, 0x80, 0x42, 0x03, 0x01, 0x10, 0x14, 0x08,
  0x40, 0x50, 0x21, 0x02, 0x40, 0x84, 0x09, 0x04, 0x10, 0x44, 0x10, 0x41,
  0x10, 0x41, 0x08, 0x41, 0x04, 0x20, 0x88, 0x11, 0x02, 0x20, 0x44, 0x08,
  0x81, 0x20, 0x22, 0x04, 0x80, 0x90, 0x12, 0x02, 0x40, 0x50, 0x09, 0x01,
  0x40, 0x14, 0x0A, 0x00, 0x60, 0x28, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x00, 0x81, 0x00, 0x00, 0x80, 0x40, 0x00, 0x80, 0x20, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x01, 0x00, 0x40, 0x00, 0x80, 0x40,
  0x00, 0x20, 0x40, 0x00, 0x10, 0x60, 0x00, 0x04, 0x20, 0x00, 0x02, 0x20,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x11, 0x00, 0x00, 0x10, 0x40, 0x00, 0x10,
  0x20, 0x00, 0x10, 0x08, 0x00, 0x18, 0x04, 0x00, 0x08, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x20, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x04, 0x04,
  0x00, 0x02, 0x0C, 0x00, 0x00, 0x80, 0x80, 0x00, 0x05, 0x00, 0x00, 0x24,
  0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x20, 0x40, 0x01, 0x01, 0x00,
  0x08, 0x02, 0x00, 0x60, 0x08, 0x01, 0x00, 0x10, 0x08, 0x00, 0x40, 0x40,
  0x01, 0x02, 0x00, 0x02, 0x18, 0x00, 0x08, 0x40, 0x00, 0x12, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xC0, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x03, 0xFF,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x90, 0x00, 0x22, 0x00, 0x08, 0x20,
  0x01, 0x04, 0x00, 0x40, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x10,
  0x20, 0x02, 0x08, 0x00, 0x22, 0x00, 0x04, 0xC0, 0x00, 0x70, 0x00, 0x08,
  0xFF, 0xFF, 0xF0, 0x88, 0x42, 0x21, 0x10, 0x01, 0xF8, 0x41, 0x81, 0x90,
  0x80, 0x14, 0x40, 0x05, 0x20, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x09, 0x00,
  0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x06, 0x10, 0x01, 0x86,
  0x00, 0xA0, 0xC0, 0xC8, 0x0F, 0xC3, 0xC0, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x0F, 0x80, 0x46, 0x0C, 0x09, 0x00, 0x41,
  0x40, 0x04, 0x30, 0x00, 0x84, 0x00, 0x10, 0x80, 0x01, 0x30, 0x00, 0x24,
  0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x22, 0x00, 0x04, 0x40, 0x00, 0x90,
  0x00, 0x12, 0x00, 0x04, 0x40, 0x00, 0x88, 0x00, 0x21, 0x80, 0x04, 0x28,
  0x03, 0x08, 0xC1, 0xC1, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0x83, 0x03,
  0x00, 0x42, 0x00, 0x12, 0x00, 0x09, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x02, 0x80, 0x02, 0x40, 0x02, 0x30, 0x03, 0x08, 0x03, 0x03,
  0x03, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x1F, 0x84, 0x06, 0x06, 0x40, 0x80, 0x14, 0x10, 0x01,
  0x42, 0x00, 0x0C, 0x20, 0x00, 0x84, 0x00, 0x08, 0x40, 0x00, 0x88, 0x00,
  0x08, 0x80, 0x00, 0x88, 0x00, 0x08, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x10, 0x80, 0x03, 0x08, 0x00, 0x50, 0x40, 0x06, 0x06,
  0x00, 0xA0, 0x30, 0x32, 0x00, 0xFC, 0x20, 0x00, 0xFC, 0x00, 0xC0, 0xC0,
  0x40, 0x08, 0x20, 0x02, 0x10, 0x00, 0x48, 0x00, 0x12, 0x00, 0x09, 0x00,
  0x02, 0x40, 0x01, 0x10, 0x01, 0x88, 0x0F, 0x83, 0xFC, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x40, 0x01, 0x10, 0x00, 0x82,
  0x00, 0x60, 0x60, 0x60, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0xFF, 0x81, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x02, 0x00, 0x80, 0x00, 0x80, 0x40, 0x00, 0x20,
  0x40, 0x00, 0x08, 0x20, 0x00, 0x03, 0x10, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFC, 0x20, 0x60, 0x64, 0x10,
  0x02, 0x84, 0x00, 0x51, 0x00, 0x06, 0x20, 0x00, 0x88, 0x00, 0x11, 0x00,
  0x02, 0x40, 0x00, 0x48, 0x00, 0x09, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00,
  0x08, 0x80, 0x01, 0x10, 0x00, 0x22, 0x00, 0x0C, 0x40, 0x03, 0x04, 0x00,
  0x60, 0xC0, 0x14, 0x0C, 0x0C, 0x80, 0x7E, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x10, 0x00, 0x83, 0x00, 0x20, 0x10, 0x18,
  0x01, 0xFC, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0xF8, 0x13,
  0x06, 0x14, 0x01, 0x18, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x06, 0x08, 0x06, 0x04, 0x0C, 0x02, 0x08, 0x01, 0x18,
  0x00, 0x90, 0x00, 0xB0, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x80, 0x20, 0xC0, 0x40, 0x20,
  0x40, 0x10, 0x40, 0x08, 0x40, 0x06, 0x40, 0x03, 0x40, 0x01, 0x80, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x43,
  0xF0, 0x04, 0x60, 0x60, 0x24, 0x01, 0x01, 0x40, 0x04, 0x0C, 0x00, 0x20,
  0x40, 0x01, 0x02, 0x00, 0x10, 0x30, 0x00, 0x81, 0x00, 0x08, 0x08, 0x01,
  0x80, 0x40, 0x70, 0x02, 0x3C, 0x00, 0x10, 0x80, 0x01, 0x02, 0x00, 0x08,
  0x10, 0x03, 0x40, 0x40, 0x22, 0x02, 0x02, 0x10, 0x08, 0x20, 0x80, 0x22,
  0x08, 0x01, 0x60, 0x40, 0x06, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x84, 0x06, 0x08, 0x18, 0x10, 0xC0, 0x43, 0x00, 0x98, 0x01, 0x40,
  0x03, 0x00, 0x00, 0x11, 0xE1, 0xF0, 0xB1, 0x90, 0xC6, 0x05, 0x02, 0x30,
  0x30, 0x13, 0x01, 0x80, 0x90, 0x08, 0x04, 0x80, 0x40, 0x24, 0x02, 0x01,
  0x20, 0x10, 0x09, 0x01, 0x00, 0x90, 0x08, 0x04, 0x80, 0x40, 0x24, 0x02,
  0x01, 0x20, 0x10, 0x09, 0x00, 0x80, 0x48, 0x08, 0x04, 0x80, 0x40, 0x24,
  0x02, 0x01, 0x20, 0x10, 0x09, 0x00, 0x80, 0x48, 0x04, 0x04, 0x00, 0x10,
  0xF8, 0x13, 0x06, 0x14, 0x01, 0x18, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x01, 0xFC, 0x01, 0x80, 0xC0, 0xC0, 0x18,
  0x40, 0x02, 0x30, 0x00, 0x48, 0x00, 0x12, 0x00, 0x05, 0x00, 0x01, 0x40,
  0x00, 0x50, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x28, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x01, 0x10, 0x00, 0x82, 0x00, 0x40,
  0x60, 0x60, 0x07, 0xE0, 0x00, 0x04, 0x3E, 0x00, 0x8C, 0x18, 0x09, 0x00,
  0x40, 0xA0, 0x02, 0x0C, 0x00, 0x20, 0x80, 0x02, 0x08, 0x00, 0x11, 0x80,
  0x01, 0x10, 0x00, 0x11, 0x00, 0x01, 0x10, 0x00, 0x21, 0x00, 0x02, 0x10,
  0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x42, 0x00, 0x04, 0x20, 0x00, 0x83,
  0x00, 0x08, 0x48, 0x03, 0x04, 0x60, 0xE0, 0x43, 0xF8, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x41, 0x81, 0x90, 0x80,
  0x14, 0x40, 0x05, 0x20, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x01, 0x20,
  0x00, 0x48, 0x00, 0x12, 0x00, 0x0C, 0x80, 0x05, 0x10, 0x01, 0x86, 0x00,
  0xA0, 0xC0, 0xC8, 0x0F, 0xC2, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0xFF, 0x0F, 0xF0, 0x13, 0x00, 0x01, 0x40, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0x70, 0x20, 0x03,
  0x08, 0x00, 0x31, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x80, 0x00, 0x90, 0x00, 0x11,
  0x00, 0x04, 0x1C, 0x07, 0x00, 0x7F, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x04, 0x02, 0x01, 0x80, 0x20, 0x20, 0x04, 0x0C, 0x00, 0x43, 0x00,
  0x04, 0x40, 0x00, 0x58, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x90, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x22, 0x00, 0x11, 0x00, 0x09, 0x00, 0x04, 0x80,
  0x02, 0x40, 0x01, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x48, 0x00, 0x24,
  0x00, 0x12, 0x00, 0x19, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x0A, 0x10, 0x09,
  0x04, 0x08, 0x81, 0xF8, 0x40, 0xFE, 0x00, 0x40, 0x80, 0x08, 0x10, 0x00,
  0x82, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x02,
  0x08, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x40, 0x80, 0x08,
  0x10, 0x02, 0x04, 0x00, 0x40, 0x80, 0x10, 0x10, 0x04, 0x02, 0x01, 0x00,
  0x40, 0xC0, 0x08, 0x60, 0x01, 0xF0, 0x00, 0x10, 0x10, 0x22, 0x01, 0x02,
  0x20, 0x10, 0x12, 0x01, 0x01, 0x20, 0x10, 0x12, 0x02, 0x01, 0x20, 0x20,
  0x14, 0x02, 0x01, 0x40, 0x20, 0x14, 0x02, 0x01, 0x40, 0x40, 0x14, 0x04,
  0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x28, 0x04, 0x02, 0x80,
  0xC0, 0x68, 0x14, 0x04, 0x81, 0x40, 0x84, 0x22, 0x10, 0x3C, 0x1E, 0x00,
  0x01, 0xC0, 0x78, 0x0C, 0xC3, 0x08, 0x60, 0x8C, 0x13, 0x01, 0x10, 0x10,
  0x01, 0x40, 0x20, 0x02, 0x80, 0x40, 0x06, 0x00, 0x80, 0x0C, 0x01, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x10, 0x06, 0x00, 0x20, 0x14, 0x00, 0x40, 0x28, 0x00, 0x80, 0x50,
  0x09, 0x01, 0x20, 0x3A, 0x04, 0x21, 0x82, 0x18, 0x6C, 0x03, 0xC0, 0x60,
  0x00, 0x0C, 0x00, 0x21, 0x00, 0x04, 0x20, 0x00, 0x84, 0x00, 0x20, 0x80,
  0x04, 0x10, 0x00, 0x84, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x42, 0x00,
  0x10, 0x40, 0x02, 0x08, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00,
  0x61, 0x00, 0x08, 0x20, 0x03, 0x04, 0x00, 0xA0, 0x40, 0x24, 0x04, 0x08,
  0x80, 0x7E, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04,
  0x10, 0x01, 0x82, 0x00, 0x60, 0x30, 0x38, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x10, 0xC1, 0xF1, 0x10, 0x03, 0xD1, 0x00, 0x07, 0x20, 0x00, 0x42, 0x00,
  0x08, 0x20, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x08, 0x0C, 0x00, 0x81,
  0x00, 0x08, 0x20, 0x00, 0x86, 0x00, 0x08, 0xFF, 0x80, 0x48, 0x1F, 0xC4,
  0x80, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x0F, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x1F, 0xF0, 0x00, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x08, 0xC6, 0x00, 0x48, 0x10, 0x04, 0x40, 0x40, 0x24, 0x01,
  0x02, 0x20, 0x04, 0x22, 0x00, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_ThinItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 29, 25, 9, -29 },
  { 27, 8, 10, 25, 11, -30 },
  { 37, 24, 29, 25, 1, -29 },
  { 124, 21, 37, 25, 2, -33 },
  { 222, 27, 29, 25, -1, -29 },
  { 320, 23, 29, 25, 1, -29 },
  { 404, 3, 10, 25, 13, -30 },
  { 408, 12, 37, 25, 10, -31 },
  { 464, 13, 37, 25, 3, -31 },
  { 525, 20, 20, 25, 3, -23 },
  { 575, 19, 21, 25, 3, -23 },
  { 625, 6, 10, 25, 6, -3 },
  { 633, 11, 1, 25, 7, -13 },
  { 635, 3, 3, 25, 9, -3 },
  { 637, 21, 37, 25, 2, -31 },
  { 735, 20, 29, 25, 3, -29 },
  { 808, 19, 29, 25, 2, -29 },
  { 877, 20, 29, 25, 2, -29 },
  { 950, 20, 29, 25, 2, -29 },
  { 1023, 21, 29, 25, 1, -29 },
  { 1100, 21, 29, 25, 2, -29 },
  { 1177, 18, 29, 25, 3, -29 },
  { 1243, 19, 29, 25, 5, -29 },
  { 1312, 21, 29, 25, 2, -29 },
  { 1389, 18, 29, 25, 4, -29 },
  { 1455, 6, 22, 25, 9, -22 },
  { 1472, 9, 29, 25, 6, -22 },
  { 1505, 19, 22, 25, 4, -24 },
  { 1558, 21, 9, 25, 2, -17 },
  { 1582, 19, 22, 25, 2, -24 },
  { 1635, 16, 29, 25, 6, -29 },
  { 1693, 19, 33, 25, 3, -29 },
  { 1772, 21, 29, 25, 0, -29 },
  { 1849, 20, 29, 25, 2, -29 },
  { 1922, 19, 29, 25, 4, -29 },
  { 1991, 20, 29, 25, 3, -29 },
  { 2064, 21, 29, 25, 3, -29 },
  { 2141, 21, 29, 25, 3, -29 },
  { 2218, 19, 29, 25, 4, -29 },
  { 2287, 22, 29, 25, 2, -29 },
  { 2367, 22, 29, 25, 2, -29 },
  { 2447, 19, 29, 25, 3, -29 },
  { 2516, 22, 29, 25, 3, -29 },
  { 2596, 16, 29, 25, 4, -29 },
  { 2654, 22, 29, 25, 2, -29 },
  { 2734, 22, 29, 25, 2, -29 },
  { 2814, 20, 29, 25, 3, -29 },
  { 2887, 20, 29, 25, 3, -29 },
  { 2960, 20, 36, 25, 3, -29 },
  { 3050, 20, 29, 25, 3, -29 },
  { 3123, 21, 29, 25, 2, -29 },
  { 3200, 21, 29, 25, 5, -29 },
  { 3277, 20, 29, 25, 4, -29 },
  { 3350, 20, 29, 25, 5, -29 },
  { 3423, 22, 29, 25, 3, -29 },
  { 3503, 25, 29, 25, 0, -29 },
  { 3594, 22, 29, 25, 4, -29 },
  { 3674, 25, 29, 25, 0, -29 },
  { 3765, 16, 37, 25, 8, -31 },
  { 3839, 10, 37, 25, 8, -31 },
  { 3886, 16, 37, 25, 1, -31 },
  { 3960, 19, 15, 25, 3, -29 },
  { 3996, 20, 1, 25, 0, 5 },
  { 3999, 4, 7, 25, 10, -31 },
  { 4003, 18, 21, 25, 3, -21 },
  { 4051, 19, 30, 25, 3, -30 },
  { 4123, 17, 21, 25, 3, -21 },
  { 4168, 20, 30, 25, 3, -30 },
  { 4243, 18, 21, 25, 3, -21 },
  { 4291, 25, 38, 25, 0, -30 },
  { 4410, 19, 29, 25, 2, -21 },
  { 4479, 16, 30, 25, 4, -30 },
  { 4539, 17, 30, 25, 4, -30 },
  { 4603, 16, 38, 25, 5, -30 },
  { 4679, 21, 30, 25, 3, -30 },
  { 4758, 15, 30, 25, 5, -30 },
  { 4815, 21, 21, 25, 2, -21 },
  { 4871, 16, 21, 25, 4, -21 },
  { 4913, 18, 21, 25, 3, -21 },
  { 4961, 20, 29, 25, 2, -21 },
  { 5034, 18, 29, 25, 3, -21 },
  { 5100, 20, 21, 25, 5, -21 },
  { 5153, 19, 21, 25, 3, -21 },
  { 5203, 20, 29, 25, 3, -29 },
  { 5276, 17, 21, 25, 4, -21 },
  { 5321, 19, 21, 25, 3, -21 },
  { 5371, 20, 21, 25, 3, -21 },
  { 5424, 23, 21, 25, 1, -21 },
  { 5485, 19, 29, 25, 2, -21 },
  { 5554, 20, 21, 25, 2, -21 },
  { 5607, 18, 37, 25, 5, -31 },
  { 5691, 7, 37, 25, 9, -31 },
  { 5724, 18, 37, 25, 2, -31 },
  { 5808, 21, 7, 25, 2, -16 },
};

const GFXfont IBMPlexMono_ThinItalic41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_ThinItalic41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_ThinItalic41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_THINITALIC41PT7B_H_
