#ifndef _NOTOSANS_EXTRALIGHT28PT7B_H_
#define _NOTOSANS_EXTRALIGHT28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight28pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x54, 0x0F, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x02,
  0x0C, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x04, 0x08, 0x04, 0x10, 0x7F,
  0xFF, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08,
  0x20, 0xFF, 0xFE, 0x08, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x04, 0x00, 0x80, 0xFF, 0xA2, 0x08, 0x41, 0x08, 0x21,
  0x04, 0x20, 0xC4, 0x0C, 0x80, 0x70, 0x03, 0x80, 0x4C, 0x08, 0x41, 0x08,
  0x21, 0x04, 0x20, 0x84, 0x11, 0xFF, 0xC0, 0xC0, 0x08, 0x01, 0x00, 0x7C,
  0x02, 0x18, 0xC0, 0x82, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81, 0x04,
  0x20, 0x20, 0x84, 0x04, 0x11, 0x00, 0x82, 0x27, 0x90, 0x49, 0x0B, 0x13,
  0x61, 0x3E, 0x48, 0x10, 0x11, 0x02, 0x02, 0x20, 0x40, 0x84, 0x08, 0x10,
  0x81, 0x04, 0x10, 0x20, 0x83, 0x08, 0x20, 0x21, 0x0C, 0x03, 0xC0, 0x0F,
  0x80, 0x08, 0x20, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x03, 0x00,
  0x41, 0x00, 0x33, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0C, 0xC0, 0x08, 0x30,
  0x28, 0x0C, 0x14, 0x03, 0x12, 0x00, 0xC9, 0x00, 0x38, 0x80, 0x0C, 0x60,
  0x0F, 0x18, 0x08, 0xC7, 0xF8, 0x30, 0xFE, 0x08, 0x84, 0x42, 0x21, 0x08,
  0xC4, 0x21, 0x08, 0x42, 0x10, 0x42, 0x10, 0xC2, 0x10, 0x41, 0xC2, 0x08,
  0x41, 0x08, 0x61, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0xC4, 0x23, 0x11,
  0x98, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xE4, 0x71, 0xF8, 0x06, 0x00,
  0xA0, 0x11, 0x03, 0x08, 0x20, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x6D, 0x25, 0x20, 0xFE, 0xF0, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x18, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0x20, 0x10, 0x18, 0x00, 0x1F, 0x82, 0x04, 0x40, 0x24, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x24, 0x02, 0x20, 0x41, 0xF8,
  0x04, 0x73, 0x71, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x3F, 0x8C, 0x0C, 0x80, 0x40, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFF, 0x1F, 0xC3, 0x01,
  0x10, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40,
  0xFC, 0x00, 0x38, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xA0, 0x08, 0xFF, 0x80, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x80,
  0x09, 0x00, 0x12, 0x00, 0x44, 0x01, 0x08, 0x06, 0x10, 0x08, 0x20, 0x20,
  0x40, 0x80, 0x83, 0x01, 0x04, 0x02, 0x10, 0x04, 0x3F, 0xFF, 0x80, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x7F, 0xE4, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x7F, 0x84, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x80,
  0x47, 0xF8, 0x07, 0xE1, 0x80, 0x30, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x9F, 0xCA, 0x02, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x16, 0x02, 0x30, 0x61, 0xFC, 0xFF, 0xF0, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x1F, 0x86, 0x06, 0x40, 0x2C, 0x02, 0x80, 0x3C, 0x02, 0x40,
  0x22, 0x04, 0x19, 0x80, 0xF0, 0x31, 0xC6, 0x06, 0xC0, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x03, 0x60, 0x63, 0xF8, 0x3F, 0x86, 0x0C, 0xC0,
  0x68, 0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x40,
  0x53, 0xF9, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x01,
  0x87, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xD2,
  0x52, 0x00, 0x00, 0x10, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x10, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06,
  0x00, 0x80, 0x00, 0xFF, 0x20, 0x60, 0x08, 0x03, 0x00, 0x40, 0x30, 0x08,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x04, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x40, 0x00, 0x7E, 0x00, 0x0E, 0x07, 0x00, 0x40, 0x02,
  0x02, 0x00, 0x04, 0x10, 0x00, 0x08, 0x80, 0x00, 0x22, 0x07, 0xF0, 0x50,
  0x20, 0x41, 0x41, 0x01, 0x05, 0x04, 0x04, 0x14, 0x20, 0x10, 0x60, 0x80,
  0x41, 0x82, 0x03, 0x05, 0x08, 0x0C, 0x14, 0x10, 0x30, 0x90, 0x61, 0x46,
  0x40, 0xF8, 0xF0, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20, 0x04, 0x20, 0x04, 0x10,
  0x04, 0x10, 0x08, 0x18, 0x08, 0x08, 0x10, 0x08, 0x1F, 0xFC, 0x10, 0x04,
  0x20, 0x04, 0x20, 0x02, 0x60, 0x02, 0x40, 0x03, 0x40, 0x01, 0x80, 0x01,
  0xFF, 0x84, 0x03, 0x20, 0x0D, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x06, 0x80, 0x67, 0xFC, 0x20, 0x19, 0x00, 0x28, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x14, 0x00, 0xA0, 0x19, 0xFF, 0x00, 0x07, 0xFC, 0x30,
  0x13, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x41, 0xFF, 0xFF, 0x81, 0x01, 0xC2,
  0x00, 0x44, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xA0, 0x01,
  0x40, 0x06, 0x80, 0x09, 0x00, 0x62, 0x03, 0x87, 0xF8, 0x00, 0xFF, 0xF0,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFA,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x7F, 0xF0, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x03, 0xFF, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x03, 0xFE, 0x0C, 0x03, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0x40, 0x01, 0x60, 0x01, 0x30, 0x01, 0x18, 0x01, 0x07, 0xFE, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x09, 0xF0, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x86, 0xF8, 0x80, 0x1C, 0x01, 0x20,
  0x11, 0x01, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00, 0x98, 0x05, 0x40,
  0x31, 0x01, 0x0C, 0x08, 0x20, 0x40, 0x82, 0x02, 0x10, 0x18, 0x80, 0x44,
  0x01, 0x20, 0x05, 0x00, 0x30, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xF0, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x16, 0x80, 0x05, 0xA0, 0x03, 0x64, 0x00, 0x99, 0x00,
  0x26, 0x60, 0x11, 0x88, 0x04, 0x62, 0x03, 0x18, 0x40, 0x86, 0x10, 0x21,
  0x86, 0x10, 0x60, 0x84, 0x18, 0x23, 0x06, 0x04, 0x81, 0x81, 0x20, 0x60,
  0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x68,
  0x01, 0x90, 0x06, 0x60, 0x18, 0x80, 0x61, 0x01, 0x86, 0x06, 0x08, 0x18,
  0x10, 0x60, 0x61, 0x80, 0x86, 0x01, 0x18, 0x06, 0x60, 0x09, 0x80, 0x16,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0x07, 0xF8, 0x0C, 0x06, 0x0C, 0x00, 0x8C,
  0x00, 0x24, 0x00, 0x16, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x02, 0x80, 0x02, 0x60, 0x01, 0x18, 0x01, 0x06, 0x03, 0x00, 0xFF, 0x00,
  0xFF, 0x08, 0x0C, 0x80, 0x68, 0x02, 0x80, 0x38, 0x01, 0x80, 0x38, 0x02,
  0x80, 0x28, 0x04, 0x87, 0x8F, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0xF8, 0x0C, 0x06, 0x0C, 0x00,
  0x8C, 0x00, 0x24, 0x00, 0x16, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x02, 0x80, 0x02, 0x60, 0x01, 0x18, 0x01, 0x06, 0x03, 0x00, 0xFF,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0xFF, 0x84, 0x06, 0x20, 0x09, 0x00, 0x48, 0x03, 0x40, 0x0A, 0x00, 0xD0,
  0x04, 0x80, 0x64, 0x06, 0x3F, 0xC1, 0x06, 0x08, 0x10, 0x40, 0x42, 0x02,
  0x10, 0x08, 0x80, 0x64, 0x01, 0x20, 0x05, 0x00, 0x30, 0x3F, 0xE6, 0x02,
  0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x80, 0x4F, 0xF8, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x23, 0x01, 0x07,
  0xF8, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x20, 0x04, 0x20,
  0x04, 0x30, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x08,
  0x10, 0x04, 0x20, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0F, 0x00,
  0xE0, 0x12, 0x01, 0x40, 0x24, 0x06, 0x80, 0x48, 0x09, 0x01, 0x08, 0x11,
  0x02, 0x10, 0x22, 0x04, 0x20, 0x84, 0x18, 0x41, 0x0C, 0x20, 0x42, 0x08,
  0x40, 0x84, 0x10, 0x81, 0x10, 0x23, 0x03, 0x20, 0x24, 0x02, 0x40, 0x48,
  0x05, 0x80, 0xB0, 0x0A, 0x01, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x40, 0x10, 0x80, 0x60, 0x80, 0x81, 0x82,
  0x01, 0x04, 0x01, 0x10, 0x03, 0x40, 0x02, 0x80, 0x02, 0x00, 0x0E, 0x00,
  0x34, 0x00, 0x44, 0x01, 0x0C, 0x02, 0x08, 0x08, 0x08, 0x20, 0x10, 0x40,
  0x11, 0x00, 0x16, 0x00, 0x30, 0xC0, 0x05, 0x00, 0x36, 0x00, 0x88, 0x06,
  0x30, 0x10, 0x40, 0xC0, 0x82, 0x02, 0x10, 0x04, 0x40, 0x12, 0x00, 0x28,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x7F, 0xFC, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C,
  0x00, 0x3F, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0xC0, 0x20, 0x10,
  0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40,
  0x30, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0xF8, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3F, 0x03,
  0x00, 0x0C, 0x00, 0x48, 0x01, 0x20, 0x08, 0x40, 0x21, 0x01, 0x02, 0x04,
  0x08, 0x20, 0x10, 0x80, 0x44, 0x00, 0xB0, 0x03, 0xFF, 0xE0, 0xC1, 0x04,
  0x10, 0x1F, 0x84, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0xFD,
  0x60, 0x28, 0x07, 0x00, 0xC0, 0x1C, 0x06, 0x81, 0x4F, 0xC8, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x3F, 0x1A, 0x0C, 0xE0,
  0x36, 0x00, 0xB0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xA8, 0x0D, 0x60, 0xC9, 0xFC, 0x00, 0x0F, 0xCC, 0x16,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x01, 0xFC, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x1F, 0x92, 0x05, 0x40, 0x3C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x40, 0x36, 0x05, 0x3F, 0x90,
  0x1F, 0x83, 0x0C, 0x40, 0x6C, 0x02, 0x80, 0x28, 0x03, 0x80, 0x3F, 0xFF,
  0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x02, 0x1F, 0xE0, 0x0F,
  0xC2, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0xF0, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x00, 0x1F, 0x92, 0x05, 0x40, 0x3C, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x40, 0x36, 0x05, 0x1F,
  0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0xF1, 0xC0, 0xF0, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF, 0xCD, 0x06, 0xA0,
  0x2C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x10, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x18, 0xC0, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x15, 0xB0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x1E, 0x04, 0xC1, 0x98, 0x63, 0x18, 0x62, 0x0C, 0x81, 0xB8,
  0x39, 0x06, 0x10, 0xC1, 0x18, 0x33, 0x02, 0x60, 0x2C, 0x02, 0xFF, 0xFF,
  0xF8, 0x8F, 0x87, 0xCB, 0x0D, 0x82, 0xE0, 0x50, 0x3C, 0x02, 0x01, 0xC0,
  0x20, 0x1C, 0x02, 0x01, 0xC0, 0x20, 0x1C, 0x02, 0x01, 0xC0, 0x20, 0x1C,
  0x02, 0x01, 0xC0, 0x20, 0x1C, 0x02, 0x01, 0xC0, 0x20, 0x1C, 0x02, 0x01,
  0xC0, 0x20, 0x10, 0x8F, 0xC9, 0x06, 0xA0, 0x2C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x10, 0x1F, 0x81, 0x83, 0x10, 0x09, 0x80, 0x28, 0x01, 0x40, 0x0A,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xA0, 0x05, 0x00, 0x24, 0x02, 0x10,
  0x30, 0x7E, 0x00, 0x9F, 0x8A, 0x0C, 0xC0, 0x28, 0x02, 0x80, 0x38, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0xC0, 0x6E, 0x0C,
  0x9F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x1F, 0x92, 0x05, 0x40, 0x3C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x40, 0x36, 0x05, 0x3F, 0x90, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x9F, 0xC3, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x00, 0x1F,
  0xCC, 0x09, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x05, 0x01, 0x9F, 0xE0, 0x10, 0x10, 0x10, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x0F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03, 0x40, 0x36, 0x0D, 0x3F,
  0x90, 0x80, 0x14, 0x01, 0x40, 0x34, 0x02, 0x20, 0x22, 0x04, 0x30, 0x41,
  0x04, 0x10, 0x80, 0x88, 0x09, 0x80, 0x90, 0x05, 0x00, 0x60, 0x02, 0x00,
  0xC0, 0x60, 0x28, 0x0C, 0x05, 0x01, 0x80, 0xB0, 0x68, 0x22, 0x09, 0x04,
  0x41, 0x20, 0x88, 0x62, 0x10, 0x88, 0x44, 0x11, 0x08, 0x82, 0x61, 0x90,
  0x48, 0x16, 0x05, 0x02, 0x80, 0xA0, 0x50, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x80, 0x34, 0x06, 0x20, 0x43, 0x08, 0x11, 0x80, 0x90, 0x0E, 0x00, 0x60,
  0x0E, 0x00, 0x90, 0x11, 0x82, 0x08, 0x60, 0x44, 0x02, 0x80, 0x30, 0x80,
  0x14, 0x01, 0x40, 0x34, 0x02, 0x20, 0x22, 0x04, 0x30, 0x41, 0x04, 0x10,
  0x80, 0x88, 0x09, 0x80, 0x90, 0x05, 0x00, 0x60, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x0E, 0x00, 0x7F, 0xE0, 0x08, 0x03,
  0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10,
  0x06, 0x00, 0x80, 0x3F, 0xF8, 0x07, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x60, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x18, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x30, 0x18,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x07, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0xE0, 0xFC, 0x18, 0x3F,
};

const GFXglyph NotoSans_ExtraLight28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 20, 7, 2, -20 },
  { 6, 5, 7, 9, 2, -20 },
  { 11, 16, 20, 18, 1, -20 },
  { 51, 11, 23, 16, 2, -21 },
  { 83, 19, 20, 22, 2, -20 },
  { 131, 17, 20, 20, 2, -20 },
  { 174, 1, 7, 5, 2, -20 },
  { 175, 5, 24, 7, 1, -20 },
  { 190, 5, 24, 7, 1, -20 },
  { 205, 12, 11, 15, 2, -21 },
  { 222, 12, 13, 16, 2, -16 },
  { 242, 3, 7, 6, 1, -3 },
  { 245, 7, 1, 9, 1, -8 },
  { 246, 2, 2, 6, 2, -2 },
  { 247, 9, 20, 9, 0, -20 },
  { 270, 12, 20, 16, 2, -20 },
  { 300, 6, 20, 16, 3, -20 },
  { 315, 12, 20, 16, 2, -20 },
  { 345, 13, 20, 16, 1, -20 },
  { 378, 15, 20, 16, 1, -20 },
  { 416, 12, 20, 16, 2, -20 },
  { 446, 12, 20, 16, 2, -20 },
  { 476, 12, 20, 16, 2, -20 },
  { 506, 12, 20, 16, 2, -20 },
  { 536, 12, 20, 16, 2, -20 },
  { 566, 2, 15, 6, 2, -15 },
  { 570, 3, 19, 6, 1, -15 },
  { 578, 12, 13, 16, 2, -17 },
  { 598, 12, 6, 16, 2, -13 },
  { 607, 12, 13, 16, 2, -17 },
  { 627, 10, 20, 12, 1, -20 },
  { 652, 22, 23, 25, 1, -20 },
  { 716, 16, 20, 17, 0, -20 },
  { 756, 13, 20, 17, 3, -20 },
  { 789, 14, 20, 17, 2, -20 },
  { 824, 15, 20, 20, 3, -20 },
  { 862, 11, 20, 15, 3, -20 },
  { 890, 11, 20, 14, 3, -20 },
  { 918, 16, 20, 20, 2, -20 },
  { 958, 14, 20, 20, 3, -20 },
  { 993, 5, 20, 8, 2, -20 },
  { 1006, 7, 25, 7, -3, -20 },
  { 1028, 13, 20, 16, 3, -20 },
  { 1061, 11, 20, 14, 3, -20 },
  { 1089, 18, 20, 24, 3, -20 },
  { 1134, 14, 20, 20, 3, -20 },
  { 1169, 17, 20, 21, 2, -20 },
  { 1212, 12, 20, 16, 3, -20 },
  { 1242, 17, 25, 21, 2, -20 },
  { 1296, 13, 20, 16, 3, -20 },
  { 1329, 12, 20, 15, 2, -20 },
  { 1359, 14, 20, 14, 0, -20 },
  { 1394, 14, 20, 20, 3, -20 },
  { 1429, 16, 20, 16, 0, -20 },
  { 1469, 23, 20, 25, 1, -20 },
  { 1527, 15, 20, 15, 0, -20 },
  { 1565, 14, 20, 14, 0, -20 },
  { 1600, 14, 20, 16, 1, -20 },
  { 1635, 6, 24, 9, 2, -20 },
  { 1653, 9, 20, 9, 0, -20 },
  { 1676, 5, 24, 9, 1, -20 },
  { 1691, 14, 12, 16, 1, -20 },
  { 1712, 11, 1, 11, 0, 3 },
  { 1714, 5, 4, 7, 1, -21 },
  { 1717, 11, 15, 15, 1, -15 },
  { 1738, 13, 21, 17, 2, -21 },
  { 1773, 10, 15, 13, 2, -15 },
  { 1792, 12, 21, 17, 2, -21 },
  { 1824, 12, 15, 15, 2, -15 },
  { 1847, 10, 21, 8, 0, -21 },
  { 1874, 12, 22, 17, 2, -15 },
  { 1907, 12, 21, 16, 2, -21 },
  { 1939, 2, 20, 6, 2, -20 },
  { 1944, 5, 27, 6, -1, -20 },
  { 1961, 11, 21, 13, 2, -21 },
  { 1990, 1, 21, 6, 3, -21 },
  { 1993, 20, 15, 24, 2, -15 },
  { 2031, 12, 15, 16, 2, -15 },
  { 2054, 13, 15, 16, 2, -15 },
  { 2079, 12, 22, 17, 3, -15 },
  { 2112, 12, 22, 17, 2, -15 },
  { 2145, 7, 15, 11, 3, -15 },
  { 2159, 11, 15, 13, 1, -15 },
  { 2180, 8, 18, 9, 0, -18 },
  { 2198, 12, 15, 16, 2, -15 },
  { 2221, 12, 15, 12, 0, -15 },
  { 2244, 19, 15, 20, 0, -15 },
  { 2280, 12, 15, 14, 1, -15 },
  { 2303, 12, 22, 12, 0, -15 },
  { 2336, 11, 15, 13, 1, -15 },
  { 2357, 8, 24, 10, 1, -20 },
  { 2381, 1, 28, 15, 7, -21 },
  { 2385, 8, 24, 10, 1, -20 },
  { 2409, 12, 2, 16, 2, -11 },
};

const GFXfont NotoSans_ExtraLight28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRALIGHT28PT7B_H_
