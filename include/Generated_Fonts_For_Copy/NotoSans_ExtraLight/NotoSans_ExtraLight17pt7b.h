#ifndef _NOTOSANS_EXTRALIGHT17PT7B_H_
#define _NOTOSANS_EXTRALIGHT17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight17pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x83, 0x99, 0x99, 0x08, 0x81, 0x10, 0x22, 0x37, 0xF1,
  0x10, 0x22, 0x04, 0x47, 0xEE, 0x12, 0x04, 0x40, 0x88, 0x11, 0x00, 0x10,
  0xFE, 0x44, 0x89, 0x1A, 0x0C, 0x0E, 0x12, 0x24, 0x4C, 0xB7, 0x82, 0x00,
  0x70, 0xC8, 0x88, 0x89, 0x08, 0x90, 0x8A, 0x48, 0xBA, 0x55, 0x12, 0x91,
  0x09, 0x11, 0x11, 0x11, 0x12, 0x0E, 0x3C, 0x08, 0x41, 0x08, 0x21, 0x02,
  0xC0, 0x60, 0x12, 0x14, 0x22, 0x82, 0x90, 0x32, 0x06, 0x3F, 0x30, 0xF0,
  0x2A, 0x49, 0x24, 0x92, 0x44, 0x88, 0x89, 0x22, 0x49, 0x24, 0xA5, 0x20,
  0x10, 0x22, 0x4B, 0xE1, 0x05, 0x11, 0x00, 0x10, 0x10, 0x10, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0xF0, 0xF0, 0xC0, 0x08, 0x42, 0x21, 0x10, 0x84, 0x42,
  0x11, 0x00, 0x3C, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x42, 0x3C, 0x35, 0x91, 0x11, 0x11, 0x11, 0x11, 0xFC, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x04, 0x10, 0x41, 0x07, 0xF0, 0xFC, 0x04, 0x08, 0x10, 0x67,
  0x01, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0x02, 0x03, 0x02, 0x81, 0x41, 0x21,
  0x10, 0x88, 0x84, 0xFF, 0x81, 0x00, 0x80, 0x40, 0x7E, 0x40, 0x40, 0x40,
  0x80, 0x7C, 0x02, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x3E, 0x40, 0x40, 0x80,
  0x98, 0xE6, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFF, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x7C, 0x82, 0x82, 0x82,
  0x64, 0x18, 0x64, 0x82, 0x81, 0x81, 0x82, 0x7C, 0x7C, 0x82, 0x82, 0x81,
  0x81, 0x83, 0x6D, 0x11, 0x02, 0x02, 0x04, 0xF8, 0xC0, 0x00, 0xC0, 0xC0,
  0x02, 0xA8, 0x03, 0x0C, 0x30, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x70, 0x0C, 0x03, 0x06, 0x18, 0x60, 0x80, 0xF8, 0x42,
  0x10, 0x88, 0x88, 0x40, 0x00, 0x80, 0x0F, 0xC1, 0x81, 0x10, 0x04, 0x8F,
  0x18, 0x88, 0xC4, 0x46, 0x42, 0x32, 0x11, 0x90, 0x8C, 0x7B, 0xA0, 0x00,
  0x80, 0x03, 0x04, 0x07, 0xC0, 0x04, 0x03, 0x00, 0xA0, 0x48, 0x12, 0x08,
  0x42, 0x10, 0xFC, 0x40, 0x90, 0x28, 0x06, 0x01, 0xFC, 0x82, 0x82, 0x82,
  0x82, 0xFC, 0x86, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x1F, 0x90, 0x10, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x20, 0x18, 0x03, 0xF0, 0xFC, 0x41,
  0x20, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x9F, 0x80,
  0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20,
  0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20, 0x1F, 0xC8, 0x04, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x7E, 0x01, 0x80, 0x50, 0x12, 0x04, 0x7F, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92,
  0x49, 0x70, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xE0, 0x83, 0x84,
  0x88, 0x90, 0xA0, 0xE0, 0x90, 0x90, 0x88, 0x84, 0x82, 0x83, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x70, 0x0F, 0x02, 0xE0,
  0x5A, 0x0B, 0x42, 0x64, 0x4C, 0x91, 0x92, 0x31, 0x46, 0x30, 0xC2, 0x10,
  0x81, 0x81, 0xC1, 0xA1, 0x91, 0x91, 0x89, 0x85, 0x85, 0x83, 0x81, 0x81,
  0x3F, 0x88, 0x09, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x28, 0x09, 0x02, 0x1F, 0x80, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0xBE, 0x40,
  0x81, 0x02, 0x04, 0x00, 0x3F, 0x88, 0x09, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x28, 0x09, 0x02, 0x1F, 0x80, 0x20, 0x02, 0x00,
  0x20, 0xFC, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x88, 0x84, 0x84, 0x82,
  0x83, 0x7F, 0x02, 0x04, 0x04, 0x06, 0x03, 0x01, 0x02, 0x04, 0x0F, 0xE0,
  0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xA0, 0x4F, 0xC0, 0x80, 0x60, 0x24, 0x09, 0x04, 0x21, 0x08, 0x42,
  0x20, 0x48, 0x12, 0x05, 0x00, 0xC0, 0x20, 0xC1, 0x02, 0x86, 0x09, 0x0A,
  0x12, 0x14, 0x22, 0x28, 0x84, 0x89, 0x09, 0x12, 0x12, 0x24, 0x14, 0x50,
  0x30, 0x60, 0x60, 0xC0, 0x41, 0x00, 0xC1, 0xA0, 0x88, 0x82, 0x81, 0x40,
  0x40, 0x50, 0x28, 0x22, 0x21, 0x10, 0x50, 0x10, 0x80, 0xA0, 0x90, 0x84,
  0x42, 0x40, 0xA0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x02,
  0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0xFF, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x82, 0x10, 0x82, 0x10, 0x42, 0x10,
  0x42, 0x10, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18, 0x18,
  0x24, 0x24, 0x42, 0x42, 0x81, 0xFE, 0x88, 0x80, 0x7C, 0x10, 0x41, 0x7E,
  0x18, 0x61, 0xFC, 0x80, 0x80, 0x80, 0x80, 0xBE, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xC2, 0xBC, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x20, 0x20, 0x3C,
  0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83,
  0x7D, 0x3C, 0x86, 0x0C, 0x1F, 0xF0, 0x20, 0x20, 0x3E, 0x1C, 0x82, 0x08,
  0xF8, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x3D, 0x43, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x7D, 0x01, 0x01, 0x02, 0x7C, 0x82, 0x08, 0x20, 0xFE,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x9F, 0xF0, 0x20, 0x12, 0x49, 0x24,
  0x92, 0x4F, 0x82, 0x08, 0x20, 0x8E, 0x49, 0x28, 0xE2, 0x49, 0x22, 0x84,
  0xFF, 0xF8, 0xFB, 0xF0, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C,
  0x21, 0x84, 0x20, 0xFE, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x3C, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xFD, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC2, 0xF9, 0x02, 0x04, 0x08, 0x00, 0x3E, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x7E, 0x04, 0x08, 0x10, 0x20, 0xF8, 0x88, 0x88, 0x88, 0x80,
  0x7E, 0x08, 0x30, 0x38, 0x10, 0x41, 0xF8, 0x42, 0x3E, 0x84, 0x21, 0x08,
  0x42, 0x0E, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xA1, 0x7E, 0x81, 0x82,
  0x42, 0x44, 0x24, 0x24, 0x28, 0x18, 0x10, 0x82, 0x14, 0x61, 0x46, 0x24,
  0x92, 0x49, 0x22, 0x94, 0x30, 0xC3, 0x0C, 0x10, 0x80, 0x43, 0x22, 0x24,
  0x18, 0x08, 0x18, 0x24, 0x42, 0xC1, 0x81, 0x82, 0x42, 0x44, 0x24, 0x24,
  0x28, 0x18, 0x10, 0x10, 0x10, 0x20, 0xC0, 0xFC, 0x20, 0x84, 0x20, 0x84,
  0x20, 0xFC, 0x19, 0x08, 0x42, 0x10, 0x98, 0x21, 0x08, 0x42, 0x08, 0x20,
  0xFF, 0xFF, 0x80, 0xC2, 0x22, 0x22, 0x21, 0x22, 0x22, 0x24, 0x80, 0x71,
  0x8E,
};

const GFXglyph NotoSans_ExtraLight17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 4, 4, 6, 1, -12 },
  { 6, 11, 12, 11, 0, -12 },
  { 23, 7, 14, 10, 1, -13 },
  { 36, 12, 12, 14, 1, -12 },
  { 54, 11, 12, 12, 1, -12 },
  { 71, 1, 4, 3, 1, -12 },
  { 72, 3, 15, 4, 1, -12 },
  { 78, 3, 15, 4, 1, -12 },
  { 84, 7, 7, 9, 1, -13 },
  { 91, 8, 8, 10, 1, -10 },
  { 99, 1, 4, 3, 1, -2 },
  { 100, 4, 1, 5, 1, -5 },
  { 101, 2, 1, 4, 1, -1 },
  { 102, 5, 12, 6, 0, -12 },
  { 110, 8, 12, 10, 1, -12 },
  { 122, 4, 12, 10, 2, -12 },
  { 128, 7, 12, 10, 1, -12 },
  { 139, 7, 12, 10, 1, -12 },
  { 150, 9, 12, 10, 0, -12 },
  { 164, 8, 12, 10, 1, -12 },
  { 176, 8, 12, 10, 1, -12 },
  { 188, 8, 12, 10, 1, -12 },
  { 200, 8, 12, 10, 1, -12 },
  { 212, 8, 12, 10, 1, -12 },
  { 224, 2, 9, 4, 1, -9 },
  { 227, 2, 11, 4, 1, -9 },
  { 230, 8, 8, 10, 1, -10 },
  { 238, 8, 4, 10, 1, -8 },
  { 242, 8, 8, 10, 1, -10 },
  { 250, 5, 12, 7, 1, -12 },
  { 258, 13, 14, 15, 1, -12 },
  { 281, 10, 12, 10, 0, -12 },
  { 296, 8, 12, 11, 2, -12 },
  { 308, 9, 12, 11, 1, -12 },
  { 322, 9, 12, 12, 2, -12 },
  { 336, 6, 12, 9, 2, -12 },
  { 345, 6, 12, 8, 2, -12 },
  { 354, 10, 12, 12, 1, -12 },
  { 369, 8, 12, 12, 2, -12 },
  { 381, 3, 12, 5, 1, -12 },
  { 386, 4, 15, 4, -2, -12 },
  { 394, 8, 12, 10, 2, -12 },
  { 406, 6, 12, 9, 2, -12 },
  { 415, 11, 12, 14, 2, -12 },
  { 432, 8, 12, 12, 2, -12 },
  { 444, 11, 12, 13, 1, -12 },
  { 461, 7, 12, 10, 2, -12 },
  { 472, 11, 15, 13, 1, -12 },
  { 493, 8, 12, 10, 2, -12 },
  { 505, 7, 12, 9, 1, -12 },
  { 516, 9, 12, 9, 0, -12 },
  { 530, 9, 12, 12, 2, -12 },
  { 544, 10, 12, 10, 0, -12 },
  { 559, 15, 12, 15, 0, -12 },
  { 582, 9, 12, 9, 0, -12 },
  { 596, 9, 12, 9, 0, -12 },
  { 610, 8, 12, 10, 1, -12 },
  { 622, 4, 15, 5, 1, -12 },
  { 630, 5, 12, 6, 0, -12 },
  { 638, 4, 15, 5, 0, -12 },
  { 646, 8, 7, 10, 1, -12 },
  { 653, 7, 1, 7, 0, 1 },
  { 654, 3, 3, 4, 1, -13 },
  { 656, 6, 9, 9, 1, -9 },
  { 663, 8, 13, 10, 1, -13 },
  { 676, 7, 9, 8, 1, -9 },
  { 684, 8, 13, 10, 1, -13 },
  { 697, 7, 9, 9, 1, -9 },
  { 705, 6, 13, 5, 0, -13 },
  { 715, 8, 13, 10, 1, -9 },
  { 728, 6, 13, 10, 2, -13 },
  { 738, 1, 12, 4, 1, -12 },
  { 740, 3, 16, 4, -1, -12 },
  { 746, 6, 13, 8, 2, -13 },
  { 756, 1, 13, 4, 1, -13 },
  { 758, 11, 9, 15, 2, -9 },
  { 771, 6, 9, 10, 2, -9 },
  { 778, 8, 9, 10, 1, -9 },
  { 787, 7, 13, 10, 2, -9 },
  { 799, 7, 13, 10, 1, -9 },
  { 811, 4, 9, 7, 2, -9 },
  { 816, 6, 9, 8, 1, -9 },
  { 823, 5, 11, 6, 0, -11 },
  { 830, 7, 9, 10, 1, -9 },
  { 838, 8, 9, 8, 0, -9 },
  { 847, 12, 9, 12, 0, -9 },
  { 861, 8, 9, 8, 0, -9 },
  { 870, 8, 13, 8, 0, -9 },
  { 883, 6, 9, 8, 1, -9 },
  { 890, 5, 15, 6, 0, -12 },
  { 900, 1, 17, 9, 4, -13 },
  { 903, 4, 15, 6, 1, -12 },
  { 911, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_ExtraLight17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRALIGHT17PT7B_H_
