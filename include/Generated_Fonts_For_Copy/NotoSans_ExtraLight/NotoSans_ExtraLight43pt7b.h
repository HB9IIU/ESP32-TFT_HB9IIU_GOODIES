#ifndef _NOTOSANS_EXTRALIGHT43PT7B_H_
#define _NOTOSANS_EXTRALIGHT43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x00, 0x30, 0x08, 0x00,
  0x0C, 0x02, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x60, 0x10,
  0x00, 0x18, 0x04, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0xC0, 0x00, 0x40,
  0x30, 0x00, 0x10, 0x0C, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x80, 0x00,
  0x80, 0x60, 0x00, 0x20, 0x18, 0x00, 0x08, 0x06, 0x00, 0x06, 0x01, 0x00,
  0x01, 0x80, 0x40, 0x00, 0x40, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x04, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x08, 0x00, 0x08,
  0x06, 0x00, 0x02, 0x01, 0x80, 0x01, 0x80, 0x40, 0x00, 0x60, 0x10, 0x00,
  0x18, 0x04, 0x00, 0x04, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x1F, 0xFF,
  0x0C, 0x20, 0xC6, 0x08, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x20, 0x20, 0x08,
  0x08, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x18, 0x20, 0x07, 0x08, 0x00, 0xF2,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x02, 0x38, 0x00, 0x83,
  0x00, 0x20, 0x60, 0x08, 0x18, 0x02, 0x02, 0x00, 0x80, 0xC0, 0x20, 0x30,
  0x08, 0x08, 0x02, 0x06, 0x00, 0x81, 0xA0, 0x21, 0xCF, 0xCB, 0xE0, 0xFF,
  0xE0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x0F, 0x80,
  0x01, 0x80, 0x63, 0x00, 0x0C, 0x03, 0x06, 0x00, 0x20, 0x18, 0x08, 0x01,
  0x80, 0x60, 0x30, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x01, 0x80,
  0x10, 0x04, 0x06, 0x00, 0xC0, 0x10, 0x30, 0x03, 0x00, 0x40, 0x80, 0x0C,
  0x01, 0x06, 0x00, 0x10, 0x04, 0x10, 0x00, 0x40, 0x10, 0xC3, 0xC1, 0x00,
  0xC2, 0x3F, 0xC6, 0x03, 0x18, 0xC3, 0x18, 0x08, 0xC6, 0x06, 0x30, 0x63,
  0x10, 0x08, 0x63, 0x18, 0xC0, 0x30, 0xF8, 0x43, 0x00, 0xC0, 0x03, 0x0C,
  0x03, 0x00, 0x08, 0x30, 0x0C, 0x00, 0x60, 0xC0, 0x30, 0x01, 0x03, 0x00,
  0xC0, 0x0C, 0x0C, 0x03, 0x00, 0x20, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x01, 0x00, 0x80, 0x30, 0x04, 0x06, 0x01, 0x80, 0x18, 0x18, 0x04,
  0x00, 0x30, 0xC0, 0x30, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x04, 0x00, 0x18, 0x01, 0x80, 0x06,
  0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x18, 0x01, 0x80,
  0x02, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1C,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x66, 0x00, 0xC0, 0x1B, 0x00, 0x18, 0x04,
  0xC0, 0x03, 0x03, 0x30, 0x00, 0x60, 0xC8, 0x00, 0x0C, 0x62, 0x00, 0x01,
  0x90, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0xC1, 0x80,
  0x01, 0x98, 0x70, 0x01, 0xC3, 0x0F, 0x01, 0xC0, 0x60, 0xFF, 0xC0, 0x0C,
  0xFF, 0xFF, 0xFC, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x30, 0x60,
  0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x30, 0x30, 0x10,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x02, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x10, 0x10, 0x0B, 0x82, 0x0F, 0xBE, 0x4F, 0x80, 0x7F, 0x00,
  0x01, 0x80, 0x00, 0x58, 0x00, 0x19, 0x80, 0x06, 0x10, 0x01, 0x83, 0x00,
  0x30, 0x30, 0x0C, 0x07, 0x01, 0x00, 0x40, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x33, 0x36, 0x66,
  0x4C, 0xC8, 0x80, 0xFF, 0xC0, 0xFC, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xE7, 0xC0, 0x60, 0x1C, 0x18, 0x01, 0x82, 0x00, 0x18, 0xC0, 0x01, 0x10,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x16, 0x00, 0x06, 0x40, 0x00, 0xCC, 0x00, 0x10, 0x80,
  0x06, 0x18, 0x00, 0x81, 0x80, 0x30, 0x1C, 0x1C, 0x01, 0xFE, 0x00, 0x00,
  0xC0, 0x70, 0x3C, 0x3B, 0x18, 0xCC, 0x3E, 0x0D, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0xF8, 0x03, 0xE7, 0xC0, 0xE0, 0x0C, 0x30, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xF3, 0xE1, 0xC0, 0x0E, 0x60,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x68, 0x00,
  0x19, 0xF0, 0x1E, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x48, 0x00, 0x01, 0x90, 0x00,
  0x06, 0x20, 0x00, 0x18, 0x40, 0x00, 0x20, 0x80, 0x00, 0xC1, 0x00, 0x03,
  0x02, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x08, 0x00, 0x60, 0x10, 0x01, 0x80,
  0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x30, 0x01, 0x00, 0xC0, 0x02,
  0x01, 0x00, 0x04, 0x06, 0x00, 0x08, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF8, 0x1C, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC8, 0x00, 0x31, 0xE0, 0x3C, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x7C, 0x30, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x1F, 0x81, 0x8F, 0xFE, 0x37,
  0x00, 0xE5, 0x80, 0x06, 0xA0, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x03, 0x40,
  0x00, 0x6C, 0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x61, 0x80, 0x18, 0x1C,
  0x0E, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF8,
  0x03, 0xE3, 0xC0, 0xE0, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x08, 0x80, 0x01,
  0x90, 0x00, 0x32, 0x00, 0x06, 0x40, 0x00, 0xCC, 0x00, 0x10, 0x80, 0x06,
  0x1C, 0x01, 0x81, 0xC0, 0xE0, 0x0E, 0x70, 0x00, 0x78, 0x00, 0x3F, 0xC0,
  0x0C, 0x0E, 0x07, 0x00, 0x61, 0x80, 0x06, 0x20, 0x00, 0x6C, 0x00, 0x05,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0x30, 0x00, 0x67, 0x00, 0x18, 0x38, 0x1E, 0x03, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0xF1, 0xE0, 0x18, 0x03, 0x03, 0x00, 0x18, 0x60, 0x00,
  0xC6, 0x00, 0x0C, 0x40, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x07, 0x60,
  0x00, 0x73, 0x00, 0x0B, 0x38, 0x03, 0x31, 0xE0, 0xE2, 0x07, 0xF8, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x02, 0x03, 0xC0, 0x3F, 0xF0, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x33, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33,
  0x26, 0x66, 0x4C, 0xC8, 0x80, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE1, 0xFD, 0xF1, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x0C, 0x30, 0x01, 0xFC, 0x01, 0x8C, 0x01, 0xFF, 0xC0, 0x66,
  0x00, 0xC0, 0x30, 0x09, 0x80, 0x60, 0x0C, 0x02, 0x40, 0x30, 0x03, 0x00,
  0x90, 0x0C, 0x00, 0xC0, 0x3C, 0x02, 0x00, 0x30, 0x0F, 0x01, 0x80, 0x0C,
  0x03, 0xC0, 0x60, 0x03, 0x00, 0xF0, 0x18, 0x00, 0xC0, 0x2C, 0x06, 0x00,
  0x20, 0x0B, 0x01, 0x80, 0x08, 0x02, 0xC0, 0x60, 0x07, 0x01, 0x90, 0x08,
  0x01, 0xC0, 0x44, 0x03, 0x00, 0x90, 0x31, 0x80, 0x60, 0xE6, 0x18, 0x60,
  0x0F, 0xE0, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x41, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x10, 0x18, 0x00, 0x18, 0x04, 0x00, 0x0C,
  0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x40, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x80,
  0x40, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x08, 0x10, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0xC0, 0x03, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0xCC, 0x00, 0x38, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xC0,
  0x01, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF7, 0xF0, 0x38, 0x00, 0xC3, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x1F, 0x06,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x0C,
  0x00, 0x3C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFF, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0xE0, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x30, 0x70, 0x00, 0x18, 0x1F, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x40,
  0xFF, 0x7F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x06, 0x83, 0x3F, 0x83, 0x00, 0xC0, 0x00, 0x36, 0x00,
  0x03, 0x30, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x03,
  0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x30, 0x30,
  0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x3C, 0x00, 0x1B,
  0x30, 0x00, 0xF0, 0xC0, 0x07, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x60, 0x0E, 0x03, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xC0,
  0x03, 0x06, 0x00, 0x1C, 0x30, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x5D, 0x00,
  0x00, 0x0D, 0xD8, 0x00, 0x00, 0xDD, 0x80, 0x00, 0x09, 0xC8, 0x00, 0x01,
  0x9C, 0xC0, 0x00, 0x11, 0xC4, 0x00, 0x03, 0x1C, 0x60, 0x00, 0x31, 0xC6,
  0x00, 0x02, 0x1C, 0x20, 0x00, 0x61, 0xC3, 0x00, 0x04, 0x1C, 0x10, 0x00,
  0xC1, 0xC1, 0x80, 0x0C, 0x1C, 0x18, 0x01, 0x81, 0xC0, 0x80, 0x18, 0x1C,
  0x0C, 0x01, 0x01, 0xC0, 0x40, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x60, 0x1C, 0x03, 0x06, 0x01, 0xC0, 0x30, 0x40, 0x1C, 0x01, 0x0C, 0x01,
  0xC0, 0x18, 0xC0, 0x1C, 0x01, 0x98, 0x01, 0xC0, 0x0D, 0x80, 0x1C, 0x00,
  0xD0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x10, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xD8, 0x00, 0x07, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x71, 0x80, 0x01, 0xC7,
  0x00, 0x07, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xC0,
  0x07, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x18, 0x07,
  0x00, 0x70, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0x81, 0xC0, 0x03, 0x07, 0x00,
  0x0C, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xC7, 0x00, 0x01,
  0x9C, 0x00, 0x03, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x1C, 0x00,
  0x70, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0E, 0x00,
  0x03, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0x00, 0x3C, 0x60, 0x00, 0xCC, 0x00, 0x0D,
  0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0x30, 0x00, 0x66,
  0x00, 0x38, 0xC0, 0xFE, 0x1F, 0xFE, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x1C, 0x00, 0x70,
  0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x03,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0x4C, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x04,
  0xC0, 0x00, 0x4C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x03,
  0x0C, 0x00, 0xE0, 0xFF, 0xF8, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x01,
  0x80, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x30, 0x03, 0xFF, 0x01, 0xF3, 0xF8, 0x60, 0x01,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x68,
  0x00, 0x19, 0xF0, 0x1E, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x40, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x61, 0x80, 0x01, 0xC1, 0xC0, 0x07, 0x01, 0xE0, 0x3C, 0x00,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x42, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0x20, 0x00, 0x18, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x02, 0x00, 0x40, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x04, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x10, 0x00, 0x08, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x34, 0x00, 0x06, 0x00,
  0x02, 0x60, 0x00, 0xE0, 0x00, 0x66, 0x00, 0x0F, 0x00, 0x06, 0x60, 0x00,
  0xB0, 0x00, 0x62, 0x00, 0x09, 0x00, 0x04, 0x30, 0x01, 0x90, 0x00, 0xC3,
  0x00, 0x19, 0x80, 0x0C, 0x30, 0x01, 0x18, 0x00, 0xC1, 0x00, 0x30, 0x80,
  0x18, 0x18, 0x03, 0x0C, 0x01, 0x81, 0x80, 0x30, 0xC0, 0x18, 0x08, 0x02,
  0x04, 0x01, 0x00, 0xC0, 0x60, 0x40, 0x30, 0x0C, 0x06, 0x06, 0x03, 0x00,
  0xC0, 0x40, 0x60, 0x30, 0x04, 0x04, 0x02, 0x06, 0x00, 0x60, 0xC0, 0x30,
  0x60, 0x06, 0x0C, 0x03, 0x06, 0x00, 0x60, 0x80, 0x30, 0x40, 0x02, 0x18,
  0x01, 0x0C, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x03, 0x18, 0x01, 0x8C, 0x00,
  0x11, 0x00, 0x08, 0x80, 0x01, 0x30, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x40, 0xC0, 0x01, 0x80,
  0xC0, 0x06, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x03,
  0x01, 0x80, 0x03, 0x06, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30,
  0x00, 0x60, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x40,
  0x30, 0x00, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x82, 0x00, 0x01, 0x8C,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x36,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0x60, 0x00, 0x81, 0x80,
  0x06, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x20, 0x18,
  0x00, 0xC0, 0xC0, 0x01, 0x03, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x60, 0x00,
  0x33, 0x00, 0x00, 0x68, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFF,
  0xFC, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0x60, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x00,
  0x20, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x01, 0xB0, 0x00, 0x08, 0x80,
  0x00, 0xC6, 0x00, 0x0C, 0x10, 0x00, 0x60, 0xC0, 0x06, 0x02, 0x00, 0x30,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x01, 0x80, 0x08, 0x08, 0x00, 0x60,
  0xC0, 0x01, 0x04, 0x00, 0x0C, 0x60, 0x00, 0x22, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0xFF, 0xFF, 0x80, 0xC0, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x80, 0x07,
  0xF8, 0x1F, 0x8F, 0x04, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x3F, 0xE1, 0xFC,
  0x33, 0x80, 0x1B, 0x80, 0x0D, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF6, 0x00, 0xD9, 0xC1, 0xCC, 0x7F, 0xC2,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x0F, 0xF0, 0x47, 0x8F, 0x09, 0x80, 0x31, 0x60, 0x03, 0x28, 0x00, 0x37,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0x6E, 0x00, 0x09, 0x40, 0x03, 0x2C,
  0x00, 0xC4, 0xE0, 0x70, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xE3, 0xC3,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x1C, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x03, 0xFC, 0x30,
  0x70, 0xF3, 0x1C, 0x01, 0xB1, 0x80, 0x0B, 0x30, 0x00, 0xF2, 0x00, 0x07,
  0x60, 0x00, 0x76, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x76, 0x00, 0x07, 0x30, 0x00, 0x73, 0x00, 0x0B, 0x18,
  0x01, 0xB0, 0xE0, 0x73, 0x07, 0xFC, 0x30, 0x01, 0xFC, 0x00, 0xF1, 0xE0,
  0x30, 0x0E, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x40, 0x01, 0x98, 0x00, 0x13,
  0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D, 0xFF, 0xFF, 0xFF, 0xFF, 0xF4,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x04, 0x1E, 0x03, 0x80,
  0xFF, 0xE0, 0x00, 0xF8, 0x0F, 0xF0, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0F, 0xFE, 0x3F, 0xF8, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x03, 0xFC, 0x30, 0x78, 0xF3, 0x1C, 0x01, 0xB1, 0x80, 0x0B, 0x30, 0x00,
  0x72, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00,
  0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x07, 0x30, 0x00, 0x73,
  0x00, 0x0B, 0x18, 0x01, 0xB0, 0xE0, 0x73, 0x03, 0xFC, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x20, 0x01, 0x83, 0xE0, 0x70, 0x0F, 0xFE, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0xFE, 0x19, 0xC3,
  0xC9, 0x80, 0x35, 0x80, 0x0E, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x7D, 0x80,
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x03, 0x07,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02,
  0x06, 0x8C, 0xF8, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x38, 0x80, 0x30, 0x80, 0x60, 0x80,
  0xC0, 0x81, 0x80, 0x83, 0x00, 0x86, 0x00, 0x8E, 0x00, 0x9B, 0x00, 0xB3,
  0x00, 0xA1, 0x80, 0xC0, 0xC0, 0x80, 0x60, 0x80, 0x60, 0x80, 0x30, 0x80,
  0x18, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x87, 0xF0, 0x1F, 0xC2, 0x38, 0xF1,
  0xE3, 0xC9, 0x00, 0xCC, 0x03, 0xA8, 0x01, 0xA0, 0x06, 0xE0, 0x07, 0x80,
  0x0B, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xC0, 0x83, 0xF8, 0x47,
  0x0F, 0x26, 0x00, 0xD6, 0x00, 0x3A, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x01, 0xFE,
  0x00, 0x78, 0xF0, 0x0C, 0x01, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0x62, 0x00,
  0x02, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x01, 0x40,
  0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x32, 0x00, 0x02, 0x30, 0x00, 0x61, 0x80, 0x0C,
  0x1C, 0x01, 0xC0, 0xF0, 0x78, 0x03, 0xFE, 0x00, 0x83, 0xFC, 0x11, 0xE3,
  0xC2, 0x60, 0x0C, 0x58, 0x00, 0xCA, 0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00,
  0x16, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xD8, 0x00, 0x1A, 0x80, 0x03, 0x58, 0x00, 0xC9, 0x80, 0x31, 0x9C, 0x1C,
  0x31, 0xFF, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x21, 0xE1, 0xE4, 0x70, 0x06, 0x8C, 0x00,
  0x53, 0x00, 0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00,
  0x28, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x50, 0x00, 0x0A, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0x80, 0x03,
  0x98, 0x00, 0x51, 0x80, 0x1A, 0x1C, 0x0C, 0x41, 0xFF, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x87, 0xF8,
  0xE3, 0x98, 0x0B, 0x00, 0xA0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0xF8, 0x3C,
  0x3E, 0x60, 0x02, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x80, 0x06, 0xE0, 0x1C, 0x7F, 0xF0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xE1, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0xC2, 0x07, 0xF0, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x1D,
  0x80, 0x05, 0x30, 0x06, 0x47, 0x07, 0x10, 0xFF, 0x84, 0xC0, 0x00, 0x68,
  0x00, 0x0D, 0x80, 0x01, 0x30, 0x00, 0x62, 0x00, 0x0C, 0x60, 0x03, 0x0C,
  0x00, 0x60, 0xC0, 0x08, 0x18, 0x03, 0x01, 0x00, 0x60, 0x30, 0x08, 0x06,
  0x03, 0x00, 0x40, 0x40, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x18, 0x40, 0x03,
  0x18, 0x00, 0x23, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x0A, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xB0,
  0x01, 0xC0, 0x0C, 0x80, 0x0A, 0x00, 0x66, 0x00, 0xD8, 0x03, 0x30, 0x06,
  0xC0, 0x11, 0x80, 0x22, 0x01, 0x84, 0x03, 0x18, 0x0C, 0x30, 0x18, 0xC0,
  0x61, 0x80, 0x82, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x81,
  0x82, 0x02, 0x08, 0x0C, 0x30, 0x18, 0xC0, 0x21, 0x80, 0xC6, 0x01, 0x88,
  0x06, 0x30, 0x0C, 0xC0, 0x11, 0x00, 0x26, 0x00, 0xD8, 0x01, 0x20, 0x06,
  0xC0, 0x0F, 0x00, 0x16, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xCC, 0x00, 0x30, 0xC0, 0x06, 0x0C,
  0x01, 0x81, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x18, 0xC0, 0x03,
  0x10, 0x00, 0x36, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x60, 0x00, 0xC6, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0x80, 0xC0, 0x60,
  0x0C, 0x08, 0x01, 0x83, 0x00, 0x18, 0xC0, 0x01, 0xB0, 0x00, 0x10, 0xC0,
  0x00, 0x78, 0x00, 0x0D, 0x80, 0x01, 0x30, 0x00, 0x62, 0x00, 0x0C, 0x60,
  0x03, 0x0C, 0x00, 0x60, 0xC0, 0x08, 0x18, 0x03, 0x01, 0x00, 0x60, 0x30,
  0x18, 0x06, 0x03, 0x00, 0x40, 0x40, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x18,
  0x40, 0x03, 0x18, 0x00, 0x23, 0x00, 0x06, 0x40, 0x00, 0xD8, 0x00, 0x0A,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x30, 0x1F, 0x03, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x01, 0xC0, 0xF0, 0x0F, 0x00, 0x1C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x38, 0x01, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x07, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x3E, 0x00, 0xF0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x1C, 0x0F, 0xC0, 0x70, 0x00, 0x3F, 0x80, 0x17,
  0x0E, 0x03, 0xC0, 0x3F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraLight43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 2, 31, 10, 4, -31 },
  { 9, 8, 11, 15, 3, -31 },
  { 20, 26, 31, 28, 1, -31 },
  { 121, 18, 36, 25, 3, -33 },
  { 202, 30, 31, 34, 2, -31 },
  { 319, 26, 31, 30, 3, -31 },
  { 420, 2, 11, 8, 3, -31 },
  { 423, 8, 38, 11, 2, -31 },
  { 461, 9, 38, 11, 1, -31 },
  { 504, 19, 18, 24, 2, -33 },
  { 547, 20, 20, 25, 2, -25 },
  { 597, 4, 11, 9, 2, -5 },
  { 603, 10, 1, 14, 2, -12 },
  { 605, 2, 3, 10, 4, -3 },
  { 606, 13, 31, 14, 1, -31 },
  { 657, 19, 31, 25, 3, -31 },
  { 731, 10, 31, 25, 4, -31 },
  { 770, 19, 31, 25, 2, -31 },
  { 844, 19, 31, 25, 2, -31 },
  { 918, 23, 31, 25, 1, -31 },
  { 1008, 19, 31, 25, 3, -31 },
  { 1082, 19, 31, 25, 3, -31 },
  { 1156, 20, 31, 25, 2, -31 },
  { 1234, 19, 31, 25, 3, -31 },
  { 1308, 20, 32, 25, 2, -31 },
  { 1388, 2, 23, 10, 4, -23 },
  { 1394, 4, 29, 10, 2, -23 },
  { 1409, 20, 19, 25, 2, -25 },
  { 1457, 20, 10, 25, 2, -20 },
  { 1482, 20, 19, 25, 2, -25 },
  { 1530, 15, 31, 18, 1, -31 },
  { 1589, 34, 34, 38, 2, -30 },
  { 1734, 25, 31, 25, 0, -31 },
  { 1831, 20, 31, 27, 4, -31 },
  { 1909, 22, 31, 27, 3, -31 },
  { 1995, 23, 31, 30, 4, -31 },
  { 2085, 17, 31, 24, 4, -31 },
  { 2151, 17, 31, 21, 4, -31 },
  { 2217, 25, 31, 31, 3, -31 },
  { 2314, 22, 31, 31, 4, -31 },
  { 2400, 8, 31, 13, 2, -31 },
  { 2431, 10, 39, 10, -4, -31 },
  { 2480, 21, 31, 25, 4, -31 },
  { 2562, 17, 31, 22, 4, -31 },
  { 2628, 28, 31, 37, 4, -31 },
  { 2737, 22, 31, 31, 4, -31 },
  { 2823, 27, 31, 33, 3, -31 },
  { 2928, 19, 31, 25, 4, -31 },
  { 3002, 27, 38, 33, 3, -31 },
  { 3131, 20, 31, 25, 4, -31 },
  { 3209, 19, 31, 23, 2, -31 },
  { 3283, 22, 31, 22, 0, -31 },
  { 3369, 23, 31, 31, 4, -31 },
  { 3459, 25, 31, 25, 0, -31 },
  { 3556, 36, 31, 38, 1, -31 },
  { 3696, 23, 31, 23, 0, -31 },
  { 3786, 22, 31, 22, 0, -31 },
  { 3872, 21, 31, 25, 2, -31 },
  { 3954, 9, 38, 14, 4, -31 },
  { 3997, 13, 31, 14, 1, -31 },
  { 4048, 9, 38, 14, 1, -31 },
  { 4091, 21, 19, 25, 2, -31 },
  { 4141, 17, 1, 17, 0, 4 },
  { 4144, 7, 7, 11, 2, -33 },
  { 4151, 17, 23, 22, 2, -23 },
  { 4200, 19, 33, 25, 4, -33 },
  { 4279, 17, 23, 20, 2, -23 },
  { 4328, 20, 33, 25, 2, -33 },
  { 4411, 19, 23, 23, 2, -23 },
  { 4466, 14, 33, 12, 1, -33 },
  { 4524, 20, 33, 25, 2, -23 },
  { 4607, 17, 33, 25, 4, -33 },
  { 4678, 3, 31, 9, 3, -31 },
  { 4690, 8, 41, 9, -2, -31 },
  { 4731, 16, 33, 20, 4, -33 },
  { 4797, 2, 33, 9, 4, -33 },
  { 4806, 30, 23, 37, 4, -23 },
  { 4893, 17, 23, 25, 4, -23 },
  { 4942, 20, 23, 25, 2, -23 },
  { 5000, 19, 33, 25, 4, -23 },
  { 5079, 19, 33, 25, 2, -23 },
  { 5158, 12, 23, 16, 4, -23 },
  { 5193, 16, 23, 20, 2, -23 },
  { 5239, 13, 28, 14, 0, -28 },
  { 5285, 18, 23, 25, 3, -23 },
  { 5337, 19, 23, 19, 0, -23 },
  { 5392, 29, 23, 30, 1, -23 },
  { 5476, 19, 23, 21, 1, -23 },
  { 5531, 19, 33, 19, 0, -23 },
  { 5610, 16, 23, 20, 2, -23 },
  { 5656, 12, 38, 15, 1, -31 },
  { 5713, 1, 44, 23, 11, -33 },
  { 5719, 13, 38, 15, 1, -31 },
  { 5781, 20, 4, 25, 2, -17 },
};

const GFXfont NotoSans_ExtraLight43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRALIGHT43PT7B_H_
