#ifndef _NOTOSANS_EXTRALIGHT7PT7B_H_
#define _NOTOSANS_EXTRALIGHT7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xF0, 0x5F, 0x5E, 0x60, 0xF9, 0x3E, 0xF5, 0x3E, 0x75, 0x80,
  0x63, 0x1B, 0x2F, 0x80, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xCD, 0x80, 0x4F,
  0x40, 0xC0, 0xC0, 0x00, 0x56, 0x80, 0x69, 0x99, 0x60, 0xF8, 0xE4, 0xAE,
  0xE5, 0x9E, 0x26, 0x6F, 0x20, 0xE8, 0x71, 0xF0, 0x68, 0xF9, 0x70, 0xF2,
  0x22, 0x40, 0xF9, 0x69, 0xF0, 0xE9, 0xF1, 0x60, 0x80, 0x98, 0x3C, 0x30,
  0xF0, 0xC3, 0xC0, 0xE5, 0x20, 0x7A, 0xDC, 0xF5, 0xA9, 0xC0, 0x46, 0x5B,
  0x90, 0xF7, 0x5E, 0x78, 0x88, 0x70, 0xF6, 0xDE, 0xEE, 0xC0, 0xEE, 0x80,
  0x74, 0x25, 0x17, 0x80, 0xB7, 0xDA, 0xD5, 0xC0, 0x55, 0x70, 0xBA, 0x6A,
  0xAA, 0xC0, 0x99, 0xBF, 0xD0, 0xB7, 0xDA, 0x74, 0x63, 0x17, 0x00, 0xF7,
  0x48, 0x74, 0x63, 0x17, 0x08, 0xF7, 0x6A, 0xF1, 0x9E, 0xF4, 0x44, 0x40,
  0xB6, 0xDE, 0x99, 0x66, 0x40, 0xA6, 0x57, 0x52, 0x48, 0x96, 0x46, 0x90,
  0x9A, 0x44, 0x40, 0xF2, 0x44, 0xF0, 0xFC, 0xA5, 0x40, 0xD5, 0x70, 0x46,
  0x90, 0xE0, 0xC0, 0x67, 0xF0, 0x9A, 0xDE, 0x72, 0x70, 0x17, 0x99, 0xF0,
  0x77, 0x70, 0xFA, 0x80, 0x79, 0x9F, 0x16, 0x9A, 0xDA, 0x78, 0x7E, 0xBA,
  0xC0, 0xF8, 0xF5, 0x6B, 0x50, 0xD6, 0xD0, 0x69, 0x9F, 0xD6, 0xF9, 0x00,
  0x79, 0x9F, 0x11, 0xEA, 0x71, 0xF0, 0xBA, 0xC0, 0xFF, 0xB6, 0xA0, 0xAD,
  0x74, 0xA0, 0xA9, 0x50, 0xB6, 0xA5, 0x00, 0xE5, 0x70, 0x57, 0x50, 0xFE,
  0xD5, 0x70, 0xF0,
};

const GFXglyph NotoSans_ExtraLight7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 4, 5, 5, 0, -5 },
  { 6, 3, 5, 4, 0, -5 },
  { 8, 5, 5, 6, 0, -5 },
  { 12, 5, 5, 5, 0, -5 },
  { 16, 1, 2, 1, 0, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 3, 3, 4, 0, -5 },
  { 23, 4, 3, 4, 0, -4 },
  { 25, 1, 2, 1, 0, -1 },
  { 26, 2, 1, 2, 0, -2 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 2, 5, 2, 0, -5 },
  { 30, 4, 5, 4, 0, -5 },
  { 33, 1, 5, 4, 1, -5 },
  { 34, 3, 5, 4, 0, -5 },
  { 36, 3, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 4, 5, 4, 0, -5 },
  { 44, 4, 5, 4, 0, -5 },
  { 47, 4, 5, 4, 0, -5 },
  { 50, 4, 5, 4, 0, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 1, 4, 2, 0, -4 },
  { 57, 1, 5, 2, 0, -4 },
  { 58, 4, 3, 4, 0, -4 },
  { 60, 4, 1, 4, 0, -3 },
  { 61, 4, 3, 4, 0, -4 },
  { 63, 3, 5, 3, 0, -5 },
  { 65, 6, 6, 6, 0, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 3, 5, 4, 1, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 3, 5, 5, 1, -5 },
  { 80, 2, 5, 4, 1, -5 },
  { 82, 2, 5, 3, 1, -5 },
  { 84, 5, 5, 5, 0, -5 },
  { 88, 3, 5, 5, 1, -5 },
  { 90, 2, 5, 2, 0, -5 },
  { 92, 2, 6, 2, -1, -5 },
  { 94, 3, 5, 4, 1, -5 },
  { 96, 2, 5, 4, 1, -5 },
  { 98, 4, 5, 6, 1, -5 },
  { 101, 3, 5, 5, 1, -5 },
  { 103, 5, 5, 5, 0, -5 },
  { 107, 3, 5, 4, 1, -5 },
  { 109, 5, 6, 5, 0, -5 },
  { 113, 3, 5, 4, 1, -5 },
  { 115, 3, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 3, 5, 5, 1, -5 },
  { 122, 4, 5, 4, 0, -5 },
  { 125, 6, 5, 6, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 1, 6, 2, 1, -5 },
  { 139, 2, 5, 2, 0, -5 },
  { 141, 2, 6, 2, 0, -5 },
  { 143, 4, 3, 4, 0, -5 },
  { 145, 3, 1, 3, 0, 0 },
  { 146, 2, 1, 2, 0, -5 },
  { 147, 3, 4, 4, 0, -4 },
  { 149, 3, 5, 4, 1, -5 },
  { 151, 3, 4, 3, 0, -4 },
  { 153, 4, 5, 4, 0, -5 },
  { 156, 3, 4, 4, 0, -4 },
  { 158, 2, 5, 2, 0, -5 },
  { 160, 4, 6, 4, 0, -4 },
  { 163, 3, 5, 4, 1, -5 },
  { 165, 1, 5, 2, 0, -5 },
  { 166, 1, 7, 2, 0, -5 },
  { 167, 2, 5, 3, 1, -5 },
  { 169, 1, 5, 2, 0, -5 },
  { 170, 5, 4, 6, 1, -4 },
  { 173, 3, 4, 4, 1, -4 },
  { 175, 4, 4, 4, 0, -4 },
  { 177, 3, 6, 4, 1, -4 },
  { 180, 4, 6, 4, 0, -4 },
  { 183, 2, 4, 3, 1, -4 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 2, 5, 2, 0, -5 },
  { 188, 2, 4, 4, 1, -4 },
  { 189, 3, 4, 3, 0, -4 },
  { 191, 5, 4, 5, 0, -4 },
  { 194, 3, 4, 3, 0, -4 },
  { 196, 3, 6, 3, 0, -4 },
  { 199, 3, 4, 3, 0, -4 },
  { 201, 2, 6, 2, 0, -5 },
  { 203, 1, 7, 4, 1, -5 },
  { 204, 2, 6, 2, 0, -5 },
  { 206, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_ExtraLight7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRALIGHT7PT7B_H_
