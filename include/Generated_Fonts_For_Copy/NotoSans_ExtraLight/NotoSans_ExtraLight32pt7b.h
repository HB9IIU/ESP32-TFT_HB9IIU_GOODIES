#ifndef _NOTOSANS_EXTRALIGHT32PT7B_H_
#define _NOTOSANS_EXTRALIGHT32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight32pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x3C, 0xC7, 0x8F, 0x16, 0x2C, 0x50,
  0xA1, 0x42, 0x01, 0x83, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00,
  0x10, 0x20, 0x04, 0x0C, 0x00, 0x81, 0x03, 0xFF, 0xFF, 0x02, 0x04, 0x00,
  0x40, 0x80, 0x18, 0x30, 0x02, 0x04, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01,
  0x02, 0x07, 0xFF, 0xFE, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04,
  0x08, 0x01, 0x81, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x02, 0x00, 0x10,
  0x07, 0xFC, 0xC4, 0x24, 0x20, 0x61, 0x02, 0x08, 0x10, 0x40, 0xC2, 0x02,
  0x10, 0x1C, 0x80, 0x3C, 0x00, 0x70, 0x01, 0x70, 0x08, 0xC0, 0x43, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x21, 0xC1, 0x1B, 0xFF, 0x80, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x3E, 0x00, 0xC1, 0x8C, 0x02, 0x04, 0x10, 0x10,
  0x20, 0x40, 0x40, 0x81, 0x82, 0x02, 0x06, 0x08, 0x08, 0x08, 0x40, 0x20,
  0x23, 0x00, 0x81, 0x88, 0x02, 0x06, 0x67, 0x88, 0x11, 0x31, 0x10, 0x4C,
  0x82, 0x62, 0x26, 0x08, 0xF1, 0x10, 0x30, 0x04, 0x40, 0x40, 0x21, 0x01,
  0x01, 0x84, 0x04, 0x04, 0x10, 0x10, 0x30, 0x40, 0xC0, 0x81, 0x02, 0x06,
  0x02, 0x08, 0x10, 0x08, 0x60, 0x80, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0x83,
  0x00, 0x10, 0x10, 0x03, 0x01, 0x80, 0x30, 0x08, 0x03, 0x01, 0x80, 0x10,
  0x10, 0x01, 0x83, 0x00, 0x08, 0x60, 0x00, 0x5C, 0x00, 0x07, 0x00, 0x00,
  0xD0, 0x00, 0x30, 0x80, 0x26, 0x04, 0x06, 0xC0, 0x20, 0x48, 0x01, 0x04,
  0x80, 0x08, 0x88, 0x00, 0x58, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x40, 0x0C,
  0x83, 0x01, 0x84, 0x1F, 0xE0, 0x30, 0xFF, 0xEA, 0x04, 0x21, 0x84, 0x30,
  0x82, 0x10, 0x41, 0x04, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x04, 0x10, 0x41,
  0x82, 0x0C, 0x10, 0x60, 0x81, 0xC1, 0x82, 0x0C, 0x10, 0x60, 0x82, 0x0C,
  0x30, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xC3, 0x08, 0x21, 0x84, 0x30,
  0x86, 0x30, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x82, 0x0B, 0xC9,
  0xF0, 0xF8, 0x00, 0xC0, 0x05, 0x80, 0x22, 0x01, 0x84, 0x0C, 0x18, 0x10,
  0x20, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x24, 0xB4, 0x94, 0xFF, 0xF0, 0x00,
  0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x0C, 0x00, 0x0F, 0xC0, 0x60, 0xC2, 0x01, 0x18, 0x02, 0x40,
  0x09, 0x00, 0x3C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x05, 0x00, 0x34,
  0x00, 0x98, 0x02, 0x20, 0x10, 0x40, 0xC0, 0xFC, 0x00, 0x02, 0x0C, 0x69,
  0x94, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x1F, 0xC1, 0xC1, 0x8C, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xE0, 0x60, 0x31, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x03, 0x80, 0x7F, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xD8, 0x03, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0A, 0x00, 0x09, 0x00, 0x0C, 0x80, 0x0C, 0x40, 0x04, 0x20, 0x04, 0x10,
  0x06, 0x08, 0x02, 0x04, 0x02, 0x02, 0x02, 0x01, 0x03, 0x00, 0x81, 0x00,
  0x41, 0x00, 0x21, 0x80, 0x10, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x3F, 0xF8, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x3E, 0x07, 0xDE, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x1B, 0x00, 0xC7, 0xFC,
  0x00, 0x03, 0xF8, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x1F, 0x89, 0x83, 0x28, 0x02, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x05, 0x00, 0x14, 0x00, 0x58, 0x03,
  0x20, 0x08, 0x60, 0x40, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x00, 0x0F,
  0xE0, 0xC0, 0xC6, 0x01, 0x90, 0x02, 0x40, 0x09, 0x00, 0x24, 0x00, 0x98,
  0x06, 0x30, 0x30, 0x61, 0x80, 0x78, 0x03, 0xF0, 0x30, 0x31, 0x80, 0x64,
  0x00, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x03, 0x40, 0x08,
  0xC0, 0xC1, 0xFE, 0x00, 0x1F, 0xC0, 0xC1, 0x86, 0x01, 0x30, 0x06, 0x80,
  0x0A, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x3C, 0x00, 0xD0,
  0x05, 0x20, 0x24, 0x7F, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x22, 0x64, 0x44,
  0x80, 0x00, 0x04, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x40, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x18, 0x18, 0x01,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF9, 0xF0, 0x01, 0xC0,
  0x0C, 0x01, 0x80, 0x01, 0x81, 0x00, 0x00, 0x41, 0x80, 0x00, 0x11, 0x80,
  0x00, 0x0C, 0x80, 0x7F, 0x02, 0x40, 0xC0, 0x81, 0x40, 0x40, 0x40, 0xA0,
  0x40, 0x20, 0x50, 0x20, 0x10, 0x38, 0x30, 0x08, 0x1C, 0x10, 0x04, 0x0A,
  0x08, 0x02, 0x05, 0x06, 0x03, 0x02, 0x81, 0x01, 0x83, 0x40, 0xC1, 0x41,
  0x30, 0x3F, 0x1B, 0x08, 0x02, 0x02, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00,
  0x11, 0x00, 0x02, 0x20, 0x00, 0xC6, 0x00, 0x10, 0x40, 0x02, 0x08, 0x00,
  0xC1, 0x80, 0x10, 0x10, 0x02, 0x02, 0x00, 0x80, 0x20, 0x1F, 0xFC, 0x07,
  0xFF, 0xC0, 0x80, 0x08, 0x10, 0x01, 0x04, 0x00, 0x30, 0x80, 0x02, 0x30,
  0x00, 0x64, 0x00, 0x04, 0x80, 0x00, 0xB0, 0x00, 0x18, 0xFF, 0xC1, 0x80,
  0xF3, 0x00, 0x36, 0x00, 0x2C, 0x00, 0x58, 0x00, 0xB0, 0x01, 0x60, 0x02,
  0xC0, 0x0D, 0x80, 0x33, 0xFF, 0x87, 0xFF, 0x8C, 0x00, 0xD8, 0x00, 0xB0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x2C, 0x00,
  0xD8, 0x07, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0x80, 0xC2, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x08, 0x0F, 0xFC, 0xFF, 0xC0, 0x60, 0x7C, 0x30, 0x03,
  0x18, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0xD8, 0x00,
  0xCC, 0x00, 0xC6, 0x03, 0x83, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F,
  0xFD, 0xFF, 0xEC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0xFF, 0xEF, 0xFF, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0xE0, 0x18, 0x30, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x40, 0x00, 0x68, 0x00, 0x0C, 0x80, 0x01, 0x98, 0x00, 0x31, 0x80,
  0x06, 0x1C, 0x01, 0xC0, 0xFF, 0xE0, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0xFC, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8F,
  0xC0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x02, 0x02, 0x06, 0xFC, 0x70, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x66,
  0x01, 0x8C, 0x06, 0x18, 0x18, 0x30, 0x60, 0x61, 0x80, 0xC6, 0x01, 0x98,
  0x03, 0x70, 0x07, 0xB0, 0x0E, 0x30, 0x18, 0x20, 0x30, 0x60, 0x60, 0x60,
  0xC0, 0x61, 0x80, 0x43, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0x98, 0x00, 0xB0,
  0x01, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0xFF, 0xE0, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xE8, 0x00, 0x0B,
  0x60, 0x00, 0x59, 0x00, 0x06, 0xC8, 0x00, 0x26, 0x60, 0x03, 0x31, 0x00,
  0x11, 0x8C, 0x00, 0x8C, 0x20, 0x0C, 0x61, 0x00, 0x43, 0x0C, 0x06, 0x18,
  0x20, 0x20, 0xC1, 0x81, 0x06, 0x04, 0x18, 0x30, 0x20, 0x81, 0x81, 0x8C,
  0x0C, 0x04, 0x40, 0x60, 0x32, 0x03, 0x00, 0xB0, 0x18, 0x05, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0x80, 0x20, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xB0,
  0x01, 0x90, 0x01, 0x98, 0x01, 0x8C, 0x01, 0x84, 0x01, 0x82, 0x01, 0x83,
  0x01, 0x81, 0x01, 0x80, 0x81, 0x80, 0xC1, 0x80, 0x41, 0x80, 0x21, 0x80,
  0x31, 0x80, 0x11, 0x80, 0x09, 0x80, 0x0D, 0x80, 0x05, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0x03, 0xFC, 0x00, 0xE0, 0x30, 0x18, 0x01, 0x83, 0x00,
  0x04, 0x20, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x02,
  0x20, 0x00, 0x63, 0x00, 0x04, 0x18, 0x00, 0x80, 0xE0, 0x30, 0x03, 0xFC,
  0x00, 0xFF, 0x83, 0x03, 0x8C, 0x01, 0xB0, 0x02, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x2C, 0x01, 0xB0, 0x0C, 0xFF, 0xC3,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xE0, 0x30, 0x18,
  0x01, 0x83, 0x00, 0x04, 0x20, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00,
  0x34, 0x00, 0x02, 0x20, 0x00, 0x63, 0x00, 0x04, 0x18, 0x00, 0x80, 0xE0,
  0x30, 0x03, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0xFF, 0x81, 0x83, 0xE3, 0x00, 0x66, 0x00, 0x4C,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x09, 0x80, 0x13, 0x00,
  0x46, 0x07, 0x0F, 0xF8, 0x18, 0x10, 0x30, 0x30, 0x60, 0x20, 0xC0, 0x21,
  0x80, 0x63, 0x00, 0x46, 0x00, 0xCC, 0x00, 0x98, 0x00, 0xB0, 0x01, 0x80,
  0x0F, 0xF0, 0xC0, 0x66, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x1A, 0x00, 0xCF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x62, 0x00, 0x20,
  0xC0, 0x60, 0x3F, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x34, 0x00, 0x09, 0x80,
  0x02, 0x20, 0x01, 0x88, 0x00, 0x43, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x02,
  0x06, 0x01, 0x80, 0x80, 0x40, 0x30, 0x10, 0x04, 0x0C, 0x01, 0x02, 0x00,
  0x60, 0x80, 0x08, 0x60, 0x02, 0x10, 0x00, 0xCC, 0x00, 0x12, 0x00, 0x06,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x00, 0x14, 0x00, 0xC0, 0x0D, 0x00, 0x78, 0x02, 0x40, 0x12, 0x00,
  0x98, 0x04, 0x80, 0x22, 0x01, 0x20, 0x18, 0x80, 0xC4, 0x04, 0x20, 0x21,
  0x01, 0x0C, 0x08, 0x40, 0xC1, 0x02, 0x18, 0x30, 0x41, 0x02, 0x08, 0x18,
  0x40, 0x82, 0x02, 0x10, 0x21, 0x80, 0x8C, 0x0C, 0x40, 0x22, 0x01, 0x10,
  0x0C, 0x80, 0x44, 0x01, 0x20, 0x1B, 0x00, 0x58, 0x02, 0x80, 0x14, 0x00,
  0xA0, 0x07, 0x00, 0x28, 0x00, 0xC0, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x40,
  0x01, 0x10, 0x01, 0x0C, 0x01, 0x82, 0x00, 0x81, 0x80, 0x80, 0x40, 0xC0,
  0x10, 0x40, 0x0C, 0x60, 0x02, 0x20, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x14, 0x00, 0x1B, 0x00, 0x18, 0x80, 0x08, 0x20, 0x0C, 0x18, 0x04,
  0x04, 0x04, 0x01, 0x06, 0x00, 0xC2, 0x00, 0x22, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x01, 0xA0, 0x01, 0x98, 0x00, 0x84, 0x00, 0xC3, 0x00, 0x40, 0x80,
  0x60, 0x60, 0x20, 0x10, 0x30, 0x04, 0x10, 0x02, 0x10, 0x00, 0x88, 0x00,
  0x68, 0x00, 0x14, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x7F, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFE,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30,
  0x04, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x10,
  0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x02,
  0xC0, 0x03, 0xFF, 0xF8, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x1F, 0xC6, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x1F, 0x3E, 0x16, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x5C, 0x0D, 0x7F, 0x10, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x23,
  0xF8, 0xB0, 0x32, 0x80, 0x6C, 0x00, 0xB0, 0x02, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xF0, 0x02, 0xC0, 0x0B,
  0x80, 0x4B, 0x03, 0x27, 0xF0, 0x0F, 0xF1, 0x81, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x01, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x43, 0xF1, 0x30, 0x35, 0x80,
  0x54, 0x00, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x03, 0x40, 0x0D, 0x80, 0x53, 0x03, 0x47,
  0xF1, 0x0F, 0xC0, 0xC0, 0xC2, 0x01, 0x10, 0x06, 0x40, 0x0B, 0x00, 0x28,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x02, 0x0F, 0xF0, 0x07, 0xE1, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x07, 0xFC, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x0F, 0xE4, 0xC0, 0xD6, 0x01, 0x50, 0x03, 0xC0,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x0D, 0x00, 0x36, 0x01, 0x4C, 0x0D, 0x1F, 0xC4, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x24, 0x01, 0x9F, 0x78, 0x07, 0x80,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x11,
  0xF8, 0xB0, 0x35, 0x00, 0xB0, 0x07, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0xD0, 0x05, 0x55, 0x55, 0x55, 0x54, 0x0C, 0x10, 0x00,
  0x00, 0x00, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0E, 0x66, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x03, 0x80, 0x48, 0x08,
  0x81, 0x08, 0x20, 0x86, 0x08, 0xC0, 0x98, 0x0B, 0xC0, 0xE6, 0x0C, 0x20,
  0x83, 0x08, 0x18, 0x80, 0xC8, 0x04, 0x80, 0x68, 0x03, 0xFF, 0xFF, 0xFF,
  0x9F, 0x83, 0xF2, 0xC1, 0xB0, 0x6C, 0x02, 0x80, 0xF0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x8F,
  0xC5, 0x81, 0xA8, 0x05, 0x80, 0x3C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x0F, 0xE0, 0x60, 0x61, 0x80, 0x22, 0x00, 0x6C, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x2C, 0x00, 0x48, 0x01, 0x98, 0x02, 0x18, 0x18, 0x0F, 0xE0, 0x8F,
  0xE2, 0x40, 0xCA, 0x01, 0xB0, 0x02, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x0B, 0x00, 0x2A,
  0x01, 0xAC, 0x0C, 0x8F, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x0F, 0xC4, 0xC0, 0xD6, 0x01, 0x50, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x01, 0x4C, 0x09, 0x1F, 0xC4, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x9F,
  0xD8, 0x38, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x1F, 0xE2, 0x01, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x1C, 0x06, 0x7F, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x40, 0xFF, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x20, 0x0F, 0xC0,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00,
  0xAC, 0x09, 0x3F, 0x88, 0x80, 0x05, 0x00, 0x34, 0x00, 0x98, 0x02, 0x20,
  0x18, 0x80, 0x43, 0x03, 0x04, 0x08, 0x18, 0x20, 0x21, 0x80, 0x84, 0x03,
  0x10, 0x04, 0x80, 0x12, 0x00, 0x28, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x10,
  0x05, 0x00, 0xE0, 0x34, 0x02, 0x80, 0x98, 0x0A, 0x02, 0x20, 0x6C, 0x08,
  0x81, 0x10, 0x63, 0x04, 0x41, 0x04, 0x31, 0x04, 0x10, 0x82, 0x10, 0x42,
  0x08, 0xC1, 0x98, 0x22, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x34, 0x05,
  0x80, 0x60, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xC0, 0x09, 0x80,
  0x42, 0x03, 0x04, 0x18, 0x18, 0x40, 0x23, 0x00, 0x58, 0x01, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0xC8, 0x02, 0x30, 0x10, 0x60, 0xC0, 0x82, 0x01, 0x10,
  0x06, 0xC0, 0x0C, 0x80, 0x05, 0x00, 0x34, 0x00, 0x98, 0x02, 0x20, 0x18,
  0x80, 0x43, 0x03, 0x04, 0x08, 0x18, 0x20, 0x21, 0x80, 0x84, 0x03, 0x10,
  0x04, 0x80, 0x12, 0x00, 0x28, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x2E, 0x00, 0xE0, 0x00, 0x7F,
  0xF0, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0xFF,
  0xF0, 0x01, 0x83, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x07, 0x03, 0x80, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x18, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x1C, 0x0E, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x1C, 0x00, 0x3C, 0x07, 0x1C,
  0x18, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraLight32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 23, 7, 3, -23 },
  { 7, 7, 8, 11, 2, -23 },
  { 14, 19, 23, 21, 1, -23 },
  { 69, 13, 26, 18, 2, -24 },
  { 112, 22, 23, 26, 2, -23 },
  { 176, 20, 23, 23, 2, -23 },
  { 234, 2, 8, 6, 2, -23 },
  { 236, 6, 28, 8, 1, -23 },
  { 257, 6, 28, 8, 1, -23 },
  { 278, 14, 13, 18, 2, -24 },
  { 301, 15, 15, 18, 2, -19 },
  { 330, 3, 8, 6, 1, -4 },
  { 333, 8, 1, 10, 1, -9 },
  { 334, 2, 2, 7, 3, -2 },
  { 335, 10, 23, 11, 0, -23 },
  { 364, 14, 23, 18, 2, -23 },
  { 405, 7, 23, 18, 3, -23 },
  { 426, 14, 23, 18, 2, -23 },
  { 467, 15, 23, 18, 1, -23 },
  { 511, 17, 23, 18, 1, -23 },
  { 560, 14, 23, 18, 2, -23 },
  { 601, 14, 23, 18, 2, -23 },
  { 642, 14, 23, 18, 2, -23 },
  { 683, 14, 23, 18, 2, -23 },
  { 724, 14, 23, 18, 2, -23 },
  { 765, 2, 17, 7, 3, -17 },
  { 770, 4, 21, 7, 1, -17 },
  { 781, 14, 15, 18, 2, -19 },
  { 808, 14, 7, 18, 2, -15 },
  { 821, 14, 15, 18, 2, -19 },
  { 848, 11, 23, 13, 1, -23 },
  { 880, 25, 26, 28, 2, -23 },
  { 962, 19, 23, 19, 0, -23 },
  { 1017, 15, 23, 20, 3, -23 },
  { 1061, 17, 23, 20, 2, -23 },
  { 1110, 17, 23, 22, 3, -23 },
  { 1159, 13, 23, 18, 3, -23 },
  { 1197, 13, 23, 16, 3, -23 },
  { 1235, 19, 23, 23, 2, -23 },
  { 1290, 17, 23, 23, 3, -23 },
  { 1339, 6, 23, 9, 2, -23 },
  { 1357, 8, 29, 8, -3, -23 },
  { 1386, 15, 23, 18, 3, -23 },
  { 1430, 13, 23, 16, 3, -23 },
  { 1468, 21, 23, 27, 3, -23 },
  { 1529, 16, 23, 23, 3, -23 },
  { 1575, 20, 23, 24, 2, -23 },
  { 1633, 14, 23, 19, 3, -23 },
  { 1674, 20, 28, 24, 2, -23 },
  { 1744, 15, 23, 19, 3, -23 },
  { 1788, 14, 23, 17, 2, -23 },
  { 1829, 16, 23, 16, 0, -23 },
  { 1875, 17, 23, 23, 3, -23 },
  { 1924, 18, 23, 18, 0, -23 },
  { 1976, 26, 23, 28, 1, -23 },
  { 2051, 17, 23, 17, 0, -23 },
  { 2100, 17, 23, 17, 0, -23 },
  { 2149, 16, 23, 18, 1, -23 },
  { 2195, 6, 28, 10, 3, -23 },
  { 2216, 10, 23, 11, 0, -23 },
  { 2245, 6, 28, 10, 1, -23 },
  { 2266, 16, 14, 18, 1, -23 },
  { 2294, 13, 1, 13, 0, 3 },
  { 2296, 6, 6, 8, 1, -25 },
  { 2301, 12, 17, 17, 2, -17 },
  { 2327, 14, 24, 19, 3, -24 },
  { 2369, 12, 17, 15, 2, -17 },
  { 2395, 14, 24, 19, 2, -24 },
  { 2437, 14, 17, 17, 2, -17 },
  { 2467, 11, 24, 9, 0, -24 },
  { 2500, 14, 25, 19, 2, -17 },
  { 2544, 13, 24, 19, 3, -24 },
  { 2583, 2, 23, 7, 2, -23 },
  { 2589, 6, 31, 7, -2, -23 },
  { 2613, 12, 24, 15, 3, -24 },
  { 2649, 1, 24, 7, 3, -24 },
  { 2652, 22, 17, 28, 3, -17 },
  { 2699, 13, 17, 19, 3, -17 },
  { 2727, 15, 17, 19, 2, -17 },
  { 2759, 14, 24, 19, 3, -17 },
  { 2801, 14, 24, 19, 2, -17 },
  { 2843, 9, 17, 12, 3, -17 },
  { 2863, 12, 17, 15, 1, -17 },
  { 2889, 10, 21, 11, 0, -21 },
  { 2916, 13, 17, 19, 3, -17 },
  { 2944, 14, 17, 14, 0, -17 },
  { 2974, 22, 17, 23, 0, -17 },
  { 3021, 14, 17, 16, 1, -17 },
  { 3051, 14, 25, 14, 0, -17 },
  { 3095, 12, 17, 15, 1, -17 },
  { 3121, 9, 28, 11, 1, -23 },
  { 3153, 1, 32, 17, 8, -24 },
  { 3157, 9, 28, 11, 1, -23 },
  { 3189, 14, 3, 18, 2, -13 },
};

const GFXfont NotoSans_ExtraLight32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRALIGHT32PT7B_H_
