#ifndef _NOTOSANS_EXTRALIGHT16PT7B_H_
#define _NOTOSANS_EXTRALIGHT16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x09, 0x02, 0x41, 0x11, 0xFF, 0x11, 0x04,
  0x81, 0x23, 0xBE, 0x22, 0x08, 0x82, 0x40, 0x10, 0xFA, 0x44, 0x89, 0x0E,
  0x06, 0x0A, 0x12, 0x24, 0x57, 0xC1, 0x00, 0x60, 0x12, 0x12, 0x44, 0x45,
  0x08, 0xA1, 0x2B, 0xA5, 0x4B, 0x51, 0x0A, 0x22, 0x44, 0x48, 0x90, 0xE0,
  0x18, 0x19, 0x04, 0x21, 0x10, 0x24, 0x06, 0x06, 0x86, 0x12, 0x82, 0xA0,
  0x48, 0x31, 0xF3, 0xF0, 0x6A, 0x49, 0x24, 0x92, 0x24, 0x40, 0x89, 0x22,
  0x49, 0x29, 0x29, 0x00, 0x10, 0x23, 0x59, 0xC2, 0x89, 0x80, 0x10, 0x20,
  0x47, 0xF1, 0x02, 0x04, 0x00, 0xF0, 0xF0, 0x80, 0x08, 0x44, 0x22, 0x10,
  0x88, 0x42, 0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05,
  0x09, 0xE0, 0x74, 0x92, 0x49, 0x24, 0x80, 0x19, 0x88, 0x10, 0x10, 0x40,
  0x82, 0x04, 0x10, 0x41, 0x07, 0xF0, 0x39, 0x88, 0x08, 0x10, 0x41, 0x1F,
  0x01, 0x02, 0x04, 0x0F, 0xE0, 0x02, 0x03, 0x02, 0x82, 0x42, 0x21, 0x11,
  0x09, 0xFF, 0x02, 0x01, 0x00, 0x80, 0x7C, 0x81, 0x04, 0x0F, 0xC0, 0x40,
  0x81, 0x02, 0x07, 0xF0, 0x1C, 0x41, 0x04, 0x08, 0x17, 0xB0, 0xC1, 0x83,
  0x05, 0x09, 0xE0, 0xFE, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40,
  0x80, 0x38, 0x8A, 0x0C, 0x14, 0x47, 0x1B, 0x41, 0x83, 0x06, 0x0B, 0xE0,
  0x38, 0x8A, 0x0C, 0x18, 0x30, 0x71, 0x9D, 0x02, 0x04, 0x17, 0xC0, 0xC0,
  0x80, 0xC1, 0xE0, 0x06, 0x31, 0x86, 0x03, 0x01, 0x80, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0xC0, 0x60, 0x30, 0x31, 0x8C, 0x20, 0x00, 0x74, 0x42, 0x10,
  0x88, 0x88, 0x40, 0x00, 0x80, 0x1F, 0xC2, 0x02, 0x40, 0x18, 0xF9, 0x90,
  0x99, 0x09, 0x90, 0x99, 0x09, 0x8B, 0xA8, 0x44, 0x40, 0x03, 0x08, 0x0F,
  0x00, 0x08, 0x06, 0x05, 0x02, 0x42, 0x21, 0x10, 0xFC, 0x82, 0x40, 0xC0,
  0x60, 0x20, 0xFD, 0x06, 0x0C, 0x18, 0x5F, 0xA0, 0xC1, 0x83, 0x07, 0xF0,
  0x0E, 0x31, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3F,
  0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0xFE,
  0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83,
  0xF8, 0x20, 0x82, 0x08, 0x00, 0x0F, 0x18, 0x50, 0x10, 0x08, 0x04, 0x02,
  0x1F, 0x01, 0x80, 0xA0, 0x50, 0x27, 0xF0, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92, 0x4B, 0x80, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x1E, 0x87, 0x12, 0x45, 0x0C, 0x14, 0x24,
  0x44, 0x89, 0x0A, 0x08, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F,
  0xC0, 0x80, 0x60, 0x3C, 0x0F, 0x05, 0xA1, 0x68, 0x99, 0x26, 0x49, 0x94,
  0x63, 0x18, 0x84, 0x81, 0xC1, 0xC1, 0xA1, 0x91, 0x91, 0x89, 0x85, 0x85,
  0x83, 0x81, 0x1E, 0x08, 0x44, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x14, 0x08, 0xFC, 0xFE, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82,
  0x08, 0x00, 0x1E, 0x08, 0x44, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x14, 0x08, 0xFC, 0x02, 0x00, 0x40, 0x08, 0xFD, 0x0A, 0x0C,
  0x28, 0x5F, 0x24, 0x44, 0x85, 0x0A, 0x08, 0x3C, 0x86, 0x04, 0x08, 0x0C,
  0x06, 0x02, 0x02, 0x04, 0x0F, 0xE0, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x40, 0xA0, 0x8F, 0x80, 0x80, 0xA0, 0x50, 0x48, 0x22, 0x21,
  0x10, 0x88, 0x28, 0x14, 0x04, 0x02, 0x00, 0xC3, 0x05, 0x0C, 0x24, 0x30,
  0x91, 0x22, 0x24, 0x90, 0x92, 0x42, 0x49, 0x0A, 0x14, 0x18, 0x60, 0x60,
  0x81, 0x02, 0x00, 0xC1, 0x42, 0x24, 0x14, 0x18, 0x08, 0x14, 0x24, 0x42,
  0x41, 0x81, 0x81, 0x42, 0x42, 0x24, 0x14, 0x18, 0x08, 0x08, 0x08, 0x08,
  0x08, 0xFE, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x40, 0x80, 0xFF,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x82, 0x10, 0x82, 0x10, 0x42,
  0x10, 0x42, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x20, 0xA1,
  0x24, 0x48, 0x60, 0xC1, 0xFC, 0x90, 0x7A, 0x10, 0x41, 0x7E, 0x18, 0x61,
  0xFC, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x82, 0x81, 0x81, 0x81, 0x82, 0xC2,
  0xBC, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7C, 0x02, 0x04, 0x09, 0xD4,
  0x70, 0x60, 0xC1, 0x83, 0x06, 0x0B, 0xF0, 0x38, 0x8A, 0x0C, 0x1F, 0xF0,
  0x20, 0x40, 0x7C, 0x3C, 0x82, 0x3C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x38, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x7E, 0x04, 0x0C, 0x17, 0xC0,
  0x81, 0x02, 0x05, 0xEC, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0xCF,
  0xF0, 0x24, 0x02, 0x49, 0x24, 0x92, 0x4E, 0x81, 0x02, 0x04, 0x28, 0x91,
  0x24, 0x50, 0xD1, 0x12, 0x14, 0x30, 0xFF, 0xF0, 0x39, 0xCC, 0x62, 0x82,
  0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x10, 0x3D, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x7C, 0x1C, 0xE2, 0x82, 0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC, 0x80,
  0x80, 0x80, 0x80, 0x38, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x7E, 0x04,
  0x08, 0x10, 0x20, 0x3E, 0x21, 0x08, 0x42, 0x10, 0x80, 0x7A, 0x08, 0x20,
  0x70, 0x20, 0x41, 0xF8, 0x42, 0x3E, 0x84, 0x21, 0x08, 0x42, 0x0E, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xBF, 0x82, 0x85, 0x12, 0x22, 0x85, 0x0A,
  0x08, 0x84, 0x28, 0xC5, 0x29, 0x25, 0x24, 0x94, 0x62, 0x8C, 0x61, 0x04,
  0x42, 0x48, 0x60, 0x81, 0x84, 0x91, 0x61, 0x82, 0x85, 0x12, 0x22, 0x85,
  0x04, 0x08, 0x10, 0x40, 0x86, 0x00, 0xFC, 0x21, 0x08, 0x21, 0x08, 0x3F,
  0x19, 0x08, 0x42, 0x13, 0x04, 0x21, 0x08, 0x43, 0x04, 0xFF, 0xFF, 0xC4,
  0x44, 0x42, 0x12, 0x44, 0x44, 0x48, 0xFE,
};

const GFXglyph NotoSans_ExtraLight16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 11, 4, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 10, 11, 10, 0, -11 },
  { 19, 7, 13, 9, 1, -12 },
  { 31, 11, 12, 13, 1, -12 },
  { 48, 10, 12, 11, 1, -12 },
  { 63, 1, 4, 3, 1, -11 },
  { 64, 3, 14, 4, 1, -11 },
  { 70, 3, 14, 4, 1, -11 },
  { 76, 7, 6, 9, 1, -12 },
  { 82, 7, 7, 9, 1, -9 },
  { 89, 1, 4, 3, 1, -2 },
  { 90, 4, 1, 5, 1, -5 },
  { 91, 1, 1, 4, 1, -1 },
  { 92, 5, 11, 5, 0, -11 },
  { 99, 7, 12, 9, 1, -12 },
  { 110, 3, 11, 9, 2, -11 },
  { 115, 7, 12, 9, 1, -12 },
  { 126, 7, 12, 9, 1, -12 },
  { 137, 9, 11, 9, 0, -11 },
  { 150, 7, 11, 9, 1, -11 },
  { 160, 7, 12, 9, 1, -12 },
  { 171, 7, 11, 9, 1, -11 },
  { 181, 7, 12, 9, 1, -12 },
  { 192, 7, 12, 9, 1, -12 },
  { 203, 1, 9, 4, 1, -9 },
  { 205, 1, 11, 4, 1, -9 },
  { 207, 7, 7, 9, 1, -9 },
  { 214, 7, 4, 9, 1, -8 },
  { 218, 7, 7, 9, 1, -9 },
  { 225, 5, 12, 7, 1, -12 },
  { 233, 12, 13, 14, 1, -11 },
  { 253, 9, 11, 9, 0, -11 },
  { 266, 7, 11, 10, 2, -11 },
  { 276, 8, 12, 10, 1, -12 },
  { 288, 8, 11, 11, 2, -11 },
  { 299, 6, 11, 9, 2, -11 },
  { 308, 6, 11, 8, 2, -11 },
  { 317, 9, 12, 12, 1, -12 },
  { 331, 8, 11, 11, 2, -11 },
  { 342, 3, 11, 5, 1, -11 },
  { 347, 4, 14, 4, -2, -11 },
  { 354, 7, 11, 9, 2, -11 },
  { 364, 6, 11, 8, 2, -11 },
  { 373, 10, 11, 14, 2, -11 },
  { 387, 8, 11, 11, 2, -11 },
  { 398, 10, 12, 12, 1, -12 },
  { 413, 6, 11, 9, 2, -11 },
  { 422, 10, 15, 12, 1, -12 },
  { 441, 7, 11, 9, 2, -11 },
  { 451, 7, 12, 9, 1, -12 },
  { 462, 8, 11, 8, 0, -11 },
  { 473, 9, 11, 11, 1, -11 },
  { 486, 9, 11, 9, 0, -11 },
  { 499, 14, 11, 14, 0, -11 },
  { 519, 8, 11, 8, 0, -11 },
  { 530, 8, 11, 8, 0, -11 },
  { 541, 8, 11, 9, 1, -11 },
  { 552, 4, 14, 5, 1, -11 },
  { 559, 5, 11, 5, 0, -11 },
  { 566, 4, 14, 5, 0, -11 },
  { 573, 7, 8, 9, 1, -12 },
  { 580, 6, 1, 6, 0, 1 },
  { 581, 2, 2, 4, 1, -12 },
  { 582, 6, 9, 8, 1, -9 },
  { 589, 8, 12, 9, 1, -12 },
  { 601, 6, 9, 8, 1, -9 },
  { 608, 7, 12, 9, 1, -12 },
  { 619, 7, 9, 9, 1, -9 },
  { 627, 6, 12, 5, 0, -12 },
  { 636, 7, 13, 9, 1, -9 },
  { 648, 7, 12, 9, 1, -12 },
  { 659, 1, 12, 3, 1, -12 },
  { 661, 3, 16, 3, -1, -12 },
  { 667, 7, 12, 8, 1, -12 },
  { 678, 1, 12, 3, 1, -12 },
  { 680, 12, 9, 14, 1, -9 },
  { 694, 7, 9, 9, 1, -9 },
  { 702, 7, 9, 9, 1, -9 },
  { 710, 8, 13, 9, 1, -9 },
  { 723, 7, 13, 9, 1, -9 },
  { 735, 5, 9, 6, 1, -9 },
  { 741, 6, 9, 7, 1, -9 },
  { 748, 5, 11, 5, 0, -11 },
  { 755, 7, 8, 9, 1, -8 },
  { 762, 7, 8, 7, 0, -8 },
  { 769, 11, 8, 11, 0, -8 },
  { 780, 7, 8, 8, 0, -8 },
  { 787, 7, 12, 7, 0, -8 },
  { 798, 6, 8, 7, 1, -8 },
  { 804, 5, 14, 6, 0, -11 },
  { 813, 1, 16, 9, 4, -12 },
  { 815, 4, 14, 6, 1, -11 },
  { 822, 7, 1, 9, 1, -6 },
};

const GFXfont NotoSans_ExtraLight16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRALIGHT16PT7B_H_
