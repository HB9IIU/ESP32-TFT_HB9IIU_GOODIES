#ifndef _NOTOSANS_EXTRALIGHT42PT7B_H_
#define _NOTOSANS_EXTRALIGHT42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight42pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x00, 0x3E,
  0xC0, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x81,
  0x00, 0x20, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x02,
  0x00, 0x06, 0x01, 0x00, 0x02, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80,
  0x40, 0x00, 0xC0, 0x20, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x10,
  0x0C, 0x00, 0x08, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x20, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x10, 0x0C, 0x00, 0x08, 0x04, 0x00,
  0x04, 0x02, 0x00, 0x06, 0x01, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00, 0xC0,
  0x00, 0x80, 0x60, 0x00, 0x40, 0x20, 0x00, 0x60, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x01, 0xFF, 0x83, 0xC9, 0xF3, 0x04, 0x0B, 0x02,
  0x01, 0x81, 0x00, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x18, 0x10, 0x0C,
  0x08, 0x03, 0x04, 0x00, 0xE2, 0x00, 0x3D, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x27, 0x00, 0x10, 0xC0, 0x08, 0x30, 0x04, 0x0C, 0x02, 0x06, 0x01,
  0x03, 0x00, 0x81, 0x80, 0x40, 0xC0, 0x20, 0x60, 0x10, 0x68, 0x08, 0x77,
  0xC5, 0xE1, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x1F,
  0x80, 0x03, 0x01, 0x86, 0x00, 0x10, 0x08, 0x18, 0x01, 0x80, 0xC0, 0x40,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x20, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x40,
  0x18, 0x06, 0x06, 0x00, 0xC0, 0x10, 0x20, 0x06, 0x00, 0x83, 0x00, 0x30,
  0x0C, 0x10, 0x01, 0x80, 0x61, 0x80, 0x04, 0x03, 0x18, 0xFC, 0x20, 0x18,
  0x8E, 0x31, 0x80, 0x8C, 0x60, 0xC4, 0x0C, 0x46, 0x02, 0x30, 0xC6, 0x30,
  0x18, 0xFC, 0x21, 0x00, 0xC0, 0x03, 0x08, 0x02, 0x00, 0x10, 0x40, 0x10,
  0x01, 0x82, 0x00, 0x80, 0x18, 0x10, 0x04, 0x00, 0xC0, 0x80, 0x20, 0x0C,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x0C,
  0x04, 0x03, 0x00, 0x20, 0x60, 0x10, 0x01, 0x86, 0x01, 0x80, 0x07, 0xE0,
  0x03, 0xFC, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C,
  0x00, 0x10, 0x01, 0x00, 0x04, 0x00, 0x40, 0x01, 0x00, 0x10, 0x00, 0x60,
  0x04, 0x00, 0x18, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x30, 0x30, 0x01, 0x98, 0x06, 0x00, 0xCC, 0x00,
  0xC0, 0x33, 0x00, 0x18, 0x08, 0x80, 0x03, 0x06, 0x20, 0x00, 0x61, 0x88,
  0x00, 0x0C, 0xC2, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x1E,
  0x06, 0x00, 0x0E, 0xC1, 0xC0, 0x06, 0x18, 0x3C, 0x0F, 0x03, 0x03, 0xFF,
  0x00, 0x70, 0xFF, 0xFF, 0xF8, 0x07, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x20, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x06, 0x03, 0xE0, 0x20, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x18, 0x10, 0x37,
  0xE2, 0x3F, 0x0F, 0x7E, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0xD8, 0x00,
  0x31, 0x80, 0x04, 0x10, 0x01, 0x83, 0x00, 0x60, 0x30, 0x1C, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x33, 0x26, 0x66, 0x4C, 0xC8, 0xFF, 0xC0, 0x7D, 0x80, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x00,
  0x03, 0xFC, 0x01, 0xC0, 0xE0, 0x30, 0x0E, 0x0C, 0x00, 0xC3, 0x00, 0x0C,
  0x60, 0x01, 0x88, 0x00, 0x13, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D,
  0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x16,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x19, 0x00, 0x02, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0x60, 0x06, 0x06, 0x01, 0x80, 0x60, 0x60, 0x07, 0xF8, 0x00,
  0x00, 0xC0, 0xF0, 0x6C, 0x33, 0x38, 0xD8, 0x3C, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x07, 0xF8, 0x03, 0x81, 0xC1, 0xC0, 0x0C, 0x10, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0x81, 0xE3, 0x80, 0x0E, 0x20, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x78, 0x01,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x07, 0x40, 0x01, 0xCF, 0x00, 0xF0, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x68, 0x00, 0x01,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60, 0x03,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x18, 0x01,
  0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x6F, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x1A, 0x00, 0x1C, 0xF0, 0x1E, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x70, 0x10, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x0C, 0x7F, 0xC1, 0x18, 0x0E, 0x24, 0x00, 0x65, 0x00, 0x04, 0xE0,
  0x00, 0xD8, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x12, 0x00, 0x02, 0x60, 0x00, 0xC4, 0x00, 0x18, 0xC0,
  0x06, 0x0C, 0x01, 0x80, 0xE0, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xF8, 0x07, 0x03, 0x83, 0x00, 0x31, 0x80, 0x06, 0x60, 0x01, 0x90,
  0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x98, 0x00, 0x63, 0x00,
  0x30, 0x60, 0x18, 0x0E, 0x1C, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x38, 0x70,
  0x38, 0x06, 0x1C, 0x00, 0xC6, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x36, 0x00,
  0x19, 0xC0, 0x0C, 0x3C, 0x0E, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xC1,
  0xC0, 0xE0, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x08, 0xC0, 0x01, 0x90, 0x00,
  0x16, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x34, 0x00, 0x06, 0xC0, 0x01, 0xD8, 0x00, 0x29, 0x80, 0x1B, 0x1C, 0x06,
  0x61, 0xFF, 0x8C, 0x02, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x02, 0x03, 0x80, 0x7F, 0xC0, 0x00, 0x80, 0x00, 0x5F, 0xA0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xD8, 0x27, 0x72, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x33, 0x66, 0x66, 0x4C, 0xC8, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE1,
  0xE0, 0x71, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x18, 0x01, 0xFF, 0x01,
  0x88, 0x03, 0x81, 0x80, 0x4C, 0x03, 0x00, 0x40, 0x24, 0x03, 0x00, 0x20,
  0x1A, 0x01, 0x00, 0x10, 0x0F, 0x01, 0x80, 0x08, 0x07, 0x80, 0xC0, 0x04,
  0x03, 0xC0, 0x40, 0x06, 0x01, 0xE0, 0x20, 0x03, 0x00, 0xF0, 0x10, 0x01,
  0x80, 0x78, 0x08, 0x00, 0xC0, 0x2C, 0x06, 0x00, 0x60, 0x16, 0x03, 0x00,
  0x70, 0x19, 0x00, 0xC0, 0x28, 0x18, 0x80, 0x70, 0x66, 0x18, 0x60, 0x0F,
  0xE1, 0xF8, 0x10, 0x00, 0x80, 0x10, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0x10, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x82, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x20, 0x20, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x02, 0x00,
  0x0C, 0x01, 0x80, 0x04, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0xFF, 0xFC, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x20, 0x00, 0x08, 0x30, 0x00, 0x06, 0x10, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x0C, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xC0, 0x03, 0x8C, 0x00, 0x0C,
  0xC0, 0x00, 0x4C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x03, 0x8C, 0x07,
  0xE0, 0xFF, 0xFC, 0x0C, 0x00, 0x78, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x18,
  0xC0, 0x7F, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0xF0, 0x70,
  0x00, 0x83, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x38, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x0F,
  0x06, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x04, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x1C,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0xFB, 0xFF, 0xFD, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x1F, 0x07, 0x00, 0x02,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x1C, 0x00, 0x03,
  0x07, 0x00, 0x03, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x1A, 0x0C, 0xFE,
  0x00, 0xC0, 0x00, 0x7C, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0,
  0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x0C,
  0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0xF0, 0x00,
  0xD9, 0x80, 0x0F, 0x18, 0x00, 0xE0, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x70,
  0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00,
  0x60, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0,
  0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x5D, 0x80, 0x00,
  0x1B, 0xB0, 0x00, 0x02, 0x72, 0x00, 0x00, 0xCE, 0x60, 0x00, 0x19, 0xC4,
  0x00, 0x02, 0x38, 0xC0, 0x00, 0xC7, 0x18, 0x00, 0x10, 0xE1, 0x00, 0x06,
  0x1C, 0x30, 0x00, 0xC3, 0x82, 0x00, 0x10, 0x70, 0x60, 0x06, 0x0E, 0x0C,
  0x00, 0x81, 0xC0, 0x80, 0x30, 0x38, 0x18, 0x06, 0x07, 0x01, 0x01, 0x80,
  0xE0, 0x30, 0x30, 0x1C, 0x06, 0x04, 0x03, 0x80, 0x41, 0x80, 0x70, 0x0C,
  0x30, 0x0E, 0x00, 0x8C, 0x01, 0xC0, 0x19, 0x80, 0x38, 0x03, 0x20, 0x07,
  0x00, 0x2C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x40, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xD8, 0x00, 0x0F, 0x70, 0x00, 0x3C, 0xC0, 0x00, 0xF1, 0x80, 0x03,
  0xC3, 0x00, 0x0F, 0x0C, 0x00, 0x3C, 0x18, 0x00, 0xF0, 0x30, 0x03, 0xC0,
  0xC0, 0x0F, 0x01, 0x80, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x18,
  0x0F, 0x00, 0x30, 0x3C, 0x00, 0xC0, 0xF0, 0x01, 0x83, 0xC0, 0x03, 0x0F,
  0x00, 0x0C, 0x3C, 0x00, 0x18, 0xF0, 0x00, 0x33, 0xC0, 0x00, 0xCF, 0x00,
  0x01, 0xBC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x70,
  0x00, 0x38, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x03, 0x0E, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x03, 0xC0, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x8C, 0x00, 0x73, 0x00, 0x0E,
  0xC0, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00,
  0x73, 0x00, 0x78, 0xFF, 0xF8, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x38,
  0x18, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x03, 0xC0, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0xC0, 0x01,
  0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x08, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0,
  0x0E, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0C,
  0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0x6C, 0x00, 0x07, 0x07, 0xFF, 0x03, 0xC0, 0x78, 0xE0, 0x01, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x07, 0x40, 0x01, 0xCF, 0x00, 0xF0,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x63, 0x00, 0x03, 0x06, 0x00, 0x18, 0x0F, 0x03, 0xC0, 0x0F, 0xFC,
  0x00, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81,
  0x80, 0x00, 0x81, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x64, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x68,
  0x00, 0x1C, 0x00, 0x0D, 0x80, 0x03, 0x80, 0x03, 0x30, 0x00, 0x50, 0x00,
  0x66, 0x00, 0x1B, 0x00, 0x0C, 0x40, 0x03, 0x60, 0x01, 0x0C, 0x00, 0x4C,
  0x00, 0x61, 0x80, 0x08, 0x80, 0x0C, 0x10, 0x03, 0x18, 0x01, 0x82, 0x00,
  0x63, 0x00, 0x20, 0x60, 0x08, 0x20, 0x0C, 0x0C, 0x03, 0x04, 0x01, 0x80,
  0x80, 0x60, 0xC0, 0x20, 0x18, 0x08, 0x18, 0x0C, 0x03, 0x01, 0x01, 0x01,
  0x80, 0x60, 0x60, 0x30, 0x30, 0x04, 0x0C, 0x06, 0x04, 0x00, 0xC1, 0x00,
  0x41, 0x80, 0x18, 0x60, 0x08, 0x30, 0x01, 0x0C, 0x01, 0x86, 0x00, 0x21,
  0x80, 0x31, 0x80, 0x06, 0x20, 0x02, 0x30, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x09, 0x80, 0x0C, 0x80, 0x01, 0x20, 0x00, 0xB0, 0x00, 0x34, 0x00, 0x16,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x43, 0x00, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x40, 0x30, 0x03, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x06, 0x18, 0x00, 0x08,
  0x60, 0x00, 0x33, 0x00, 0x00, 0x68, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x48, 0x00, 0x03, 0x30, 0x00, 0x18, 0x60, 0x00,
  0x60, 0x80, 0x03, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x03, 0x08, 0x00, 0x04,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x66,
  0x00, 0x01, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x60, 0x01, 0x80, 0x80,
  0x0C, 0x03, 0x00, 0x30, 0x04, 0x01, 0x80, 0x18, 0x06, 0x00, 0x20, 0x30,
  0x00, 0xC0, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x10, 0x00, 0x0C, 0xC0, 0x00,
  0x32, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0xFF, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x04, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0xD0, 0x00, 0x09, 0x80, 0x01, 0x88, 0x00, 0x10, 0xC0, 0x03,
  0x04, 0x00, 0x20, 0x60, 0x06, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x01,
  0x80, 0x18, 0x18, 0x00, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x46, 0x00, 0x06,
  0x40, 0x00, 0x2C, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0xC0, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x00, 0xC0, 0x0F, 0xFC, 0x38, 0x0E, 0x20, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x3F, 0x07, 0xFF, 0x1C, 0x01, 0x70, 0x01, 0x60, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x05, 0x60, 0x0D, 0x70, 0x39, 0x1F,
  0xE1, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x38, 0x08,
  0x7F, 0xC2, 0x70, 0x18, 0xB0, 0x03, 0x28, 0x00, 0x6E, 0x00, 0x1B, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0B, 0x00, 0x06, 0xA0, 0x03, 0x2C, 0x01, 0xC9, 0xC0, 0xE2, 0x1F,
  0xE0, 0x00, 0x38, 0x01, 0xFF, 0xC3, 0xC0, 0x43, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x18,
  0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x1E, 0x0C, 0x1F, 0xF1, 0x87, 0x03, 0xB1, 0x80, 0x1A, 0x60, 0x01, 0x48,
  0x00, 0x3B, 0x00, 0x03, 0x60, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x03, 0x40,
  0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0x90, 0x00, 0x73, 0x00, 0x0A, 0x30,
  0x02, 0x43, 0x81, 0x88, 0x3F, 0xE1, 0x00, 0x70, 0x01, 0xFF, 0x80, 0xE0,
  0x70, 0x60, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03,
  0x40, 0x00, 0x50, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x43, 0xC0, 0x70, 0x3F, 0xF0, 0x00, 0xFE,
  0x07, 0x88, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x03, 0xFF, 0x80, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xC4, 0x38, 0x0C, 0x8C, 0x00, 0xF3, 0x00, 0x0E, 0x60, 0x01,
  0xD8, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x0C, 0x80, 0x03, 0x98, 0x00, 0x71, 0x80, 0x16,
  0x1C, 0x0C, 0xC1, 0xFF, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x88, 0x00, 0xE1,
  0xF8, 0xF8, 0x07, 0xFC, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0xF0, 0x21, 0xFF, 0x13, 0x81, 0xCB, 0x00, 0x35, 0x00, 0x1B, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xFD, 0x00, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x80, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x06, 0x9C, 0xF8, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x0E, 0x80, 0x18, 0x80, 0x18, 0x80, 0x30, 0x80, 0x60, 0x80,
  0xC0, 0x81, 0x80, 0x83, 0x00, 0x86, 0x00, 0x8C, 0x00, 0x9E, 0x00, 0xB3,
  0x00, 0xA1, 0x80, 0xC0, 0x80, 0x80, 0xC0, 0x80, 0x60, 0x80, 0x30, 0x80,
  0x10, 0x80, 0x18, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x06, 0x04, 0x7F, 0xC1, 0xFE, 0x26, 0x07, 0x38, 0x19,
  0x60, 0x19, 0x00, 0x6E, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x40, 0x03, 0x80, 0x02, 0x00, 0x1C, 0x00, 0x10,
  0x00, 0xE0, 0x00, 0x80, 0x07, 0x00, 0x04, 0x00, 0x38, 0x00, 0x20, 0x01,
  0xC0, 0x01, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x70, 0x00, 0x40, 0x03, 0x80,
  0x02, 0x00, 0x1C, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x80, 0x07, 0x00, 0x04,
  0x00, 0x38, 0x00, 0x20, 0x01, 0xC0, 0x01, 0x00, 0x0E, 0x00, 0x08, 0x00,
  0x60, 0x01, 0xE0, 0x43, 0xFE, 0x27, 0x03, 0x96, 0x00, 0x6A, 0x00, 0x36,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0E, 0x03, 0x81, 0x80, 0x1C,
  0x30, 0x00, 0xC2, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00,
  0x34, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00, 0x06, 0x30,
  0x00, 0x63, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x70, 0x03, 0xFE, 0x00,
  0x01, 0xE0, 0x21, 0xFF, 0x09, 0xC0, 0x62, 0x40, 0x0C, 0xA0, 0x01, 0xB8,
  0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x2E, 0x00, 0x1A, 0x80, 0x0E, 0xB0, 0x07, 0x27,
  0x03, 0x88, 0x7F, 0x82, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x84, 0x30, 0x1D, 0x8C, 0x00,
  0xF3, 0x00, 0x0E, 0x40, 0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03,
  0x98, 0x00, 0xF1, 0x80, 0x36, 0x1C, 0x0C, 0xC1, 0xFF, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x01, 0xD1,
  0xFE, 0x60, 0x58, 0x0A, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x3F, 0xFC, 0xC0, 0x1B,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x38, 0x00, 0xFC, 0x03, 0x9F,
  0xFC, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x03,
  0xFF, 0xE1, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x82, 0x07, 0xF0,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x40, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x3C, 0xC0, 0x1B, 0x3C, 0x1C, 0xC3,
  0xFC, 0x30, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x43,
  0x00, 0x18, 0x60, 0x03, 0x04, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x02, 0x01,
  0x00, 0xC0, 0x30, 0x18, 0x02, 0x02, 0x00, 0x60, 0xC0, 0x0C, 0x10, 0x00,
  0x86, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00, 0x26, 0x00, 0x06, 0xC0, 0x00,
  0x50, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x0F, 0x00, 0x24, 0x00, 0xD0, 0x06, 0x60, 0x09, 0x00,
  0x66, 0x01, 0x98, 0x04, 0x20, 0x19, 0x80, 0x43, 0x01, 0x08, 0x0C, 0x30,
  0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x08, 0x10, 0x20, 0x41, 0x81, 0x86, 0x06,
  0x18, 0x18, 0x60, 0x61, 0x80, 0x84, 0x02, 0x10, 0x08, 0xC0, 0x33, 0x00,
  0xCC, 0x03, 0x30, 0x0C, 0x80, 0x13, 0x00, 0x48, 0x01, 0x20, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xE0, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x30, 0x60, 0x18, 0x0C, 0x06, 0x01,
  0x03, 0x00, 0x61, 0x80, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x07, 0x80, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x61, 0x80, 0x10, 0x30,
  0x0C, 0x04, 0x06, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x60, 0x01, 0xB0,
  0x00, 0x30, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x43,
  0x00, 0x18, 0x60, 0x03, 0x04, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x02, 0x01,
  0x00, 0xC0, 0x30, 0x18, 0x02, 0x02, 0x00, 0x60, 0xC0, 0x0C, 0x10, 0x00,
  0x86, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00, 0x26, 0x00, 0x06, 0xC0, 0x00,
  0x50, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x27, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x70, 0x1F, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x07, 0x80, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x1F, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0F,
  0x00, 0x70, 0x1C, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x0C, 0x0F, 0x80, 0xE0, 0x00, 0x1F, 0x00, 0x17, 0xFC, 0x03, 0xC0, 0x78,
  0x68, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraLight42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 30, 10, 3, -30 },
  { 13, 8, 11, 14, 3, -30 },
  { 24, 25, 30, 27, 1, -30 },
  { 118, 17, 34, 24, 3, -32 },
  { 191, 29, 30, 34, 2, -30 },
  { 300, 26, 30, 30, 3, -30 },
  { 398, 2, 11, 8, 3, -30 },
  { 401, 8, 37, 11, 2, -30 },
  { 438, 8, 37, 11, 1, -30 },
  { 475, 19, 17, 23, 2, -32 },
  { 516, 20, 20, 24, 2, -25 },
  { 566, 4, 10, 8, 2, -5 },
  { 571, 10, 1, 14, 2, -12 },
  { 573, 3, 3, 10, 3, -3 },
  { 575, 13, 30, 14, 0, -30 },
  { 624, 19, 30, 24, 2, -30 },
  { 696, 10, 30, 24, 4, -30 },
  { 734, 19, 30, 24, 2, -30 },
  { 806, 19, 30, 24, 2, -30 },
  { 878, 22, 30, 24, 1, -30 },
  { 961, 18, 30, 24, 3, -30 },
  { 1029, 19, 30, 24, 3, -30 },
  { 1101, 20, 30, 24, 2, -30 },
  { 1176, 18, 30, 24, 3, -30 },
  { 1244, 19, 31, 24, 2, -30 },
  { 1318, 3, 23, 10, 3, -23 },
  { 1327, 4, 28, 10, 2, -23 },
  { 1341, 20, 19, 24, 2, -25 },
  { 1389, 20, 10, 24, 2, -20 },
  { 1414, 20, 19, 24, 2, -25 },
  { 1462, 15, 30, 18, 1, -30 },
  { 1519, 33, 34, 37, 2, -30 },
  { 1660, 25, 30, 25, 0, -30 },
  { 1754, 20, 30, 26, 4, -30 },
  { 1829, 22, 30, 26, 3, -30 },
  { 1912, 23, 30, 29, 4, -30 },
  { 1999, 17, 30, 23, 4, -30 },
  { 2063, 17, 30, 21, 4, -30 },
  { 2127, 24, 30, 30, 3, -30 },
  { 2217, 22, 30, 30, 4, -30 },
  { 2300, 8, 30, 12, 2, -30 },
  { 2330, 10, 37, 10, -4, -30 },
  { 2377, 20, 30, 24, 4, -30 },
  { 2452, 17, 30, 21, 4, -30 },
  { 2516, 27, 30, 36, 4, -30 },
  { 2618, 22, 30, 30, 4, -30 },
  { 2701, 26, 30, 32, 3, -30 },
  { 2799, 18, 30, 24, 4, -30 },
  { 2867, 26, 37, 32, 3, -30 },
  { 2988, 20, 30, 25, 4, -30 },
  { 3063, 19, 30, 23, 2, -30 },
  { 3135, 22, 30, 22, 0, -30 },
  { 3218, 22, 30, 30, 4, -30 },
  { 3301, 24, 30, 24, 0, -30 },
  { 3391, 35, 30, 37, 1, -30 },
  { 3523, 22, 30, 22, 0, -30 },
  { 3606, 22, 30, 22, 0, -30 },
  { 3689, 21, 30, 24, 2, -30 },
  { 3768, 8, 37, 13, 4, -30 },
  { 3805, 13, 30, 14, 0, -30 },
  { 3854, 9, 37, 13, 1, -30 },
  { 3896, 20, 18, 24, 2, -30 },
  { 3941, 17, 1, 17, 0, 4 },
  { 3944, 7, 7, 11, 2, -32 },
  { 3951, 16, 23, 22, 2, -23 },
  { 3997, 18, 32, 25, 4, -32 },
  { 4069, 17, 23, 20, 2, -23 },
  { 4118, 19, 32, 25, 2, -32 },
  { 4194, 18, 23, 23, 2, -23 },
  { 4246, 15, 32, 12, 0, -32 },
  { 4306, 19, 33, 25, 2, -23 },
  { 4385, 17, 32, 24, 4, -32 },
  { 4453, 3, 30, 9, 3, -30 },
  { 4465, 8, 40, 9, -2, -30 },
  { 4505, 16, 32, 20, 4, -32 },
  { 4569, 1, 32, 9, 4, -32 },
  { 4573, 29, 23, 37, 4, -23 },
  { 4657, 17, 23, 24, 4, -23 },
  { 4706, 20, 23, 24, 2, -23 },
  { 4764, 18, 33, 25, 4, -23 },
  { 4839, 19, 33, 25, 2, -23 },
  { 4918, 11, 23, 16, 4, -23 },
  { 4950, 15, 23, 19, 2, -23 },
  { 4994, 13, 28, 14, 0, -28 },
  { 5040, 18, 22, 24, 3, -22 },
  { 5090, 19, 22, 19, 0, -22 },
  { 5143, 28, 22, 30, 1, -22 },
  { 5220, 18, 22, 21, 1, -22 },
  { 5270, 19, 32, 19, 0, -22 },
  { 5346, 16, 22, 19, 2, -22 },
  { 5390, 12, 37, 15, 1, -30 },
  { 5446, 2, 42, 23, 10, -32 },
  { 5457, 12, 37, 15, 1, -30 },
  { 5513, 20, 4, 24, 2, -17 },
};

const GFXfont NotoSans_ExtraLight42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRALIGHT42PT7B_H_
