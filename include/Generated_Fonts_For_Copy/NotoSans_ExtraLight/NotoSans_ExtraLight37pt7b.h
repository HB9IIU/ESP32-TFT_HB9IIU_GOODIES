#ifndef _NOTOSANS_EXTRALIGHT37PT7B_H_
#define _NOTOSANS_EXTRALIGHT37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight37pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00, 0x02, 0xF8, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xC1, 0x82, 0x00, 0xC0, 0x40, 0x03, 0x01,
  0x00, 0x08, 0x0C, 0x00, 0x20, 0x20, 0x00, 0x80, 0x80, 0x02, 0x02, 0x00,
  0x18, 0x08, 0x00, 0x40, 0x60, 0x7F, 0xFF, 0xFC, 0x04, 0x04, 0x00, 0x10,
  0x10, 0x00, 0xC0, 0x40, 0x03, 0x03, 0x00, 0x08, 0x0C, 0x00, 0x20, 0x20,
  0x00, 0x80, 0x80, 0x06, 0x02, 0x03, 0xFF, 0xFF, 0xC0, 0x40, 0x60, 0x01,
  0x01, 0x00, 0x04, 0x04, 0x00, 0x10, 0x10, 0x00, 0xC0, 0x40, 0x02, 0x03,
  0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x00, 0x01, 0x80, 0x01, 0x80, 0x07,
  0xE0, 0x1F, 0xFE, 0x31, 0x84, 0x61, 0x80, 0x41, 0x80, 0xC1, 0x80, 0xC1,
  0x80, 0xC1, 0x80, 0x41, 0x80, 0x61, 0x80, 0x39, 0x80, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x01, 0x9C, 0x01, 0x86, 0x01, 0x82, 0x01, 0x83, 0x01,
  0x83, 0x01, 0x83, 0x01, 0x83, 0x01, 0x82, 0x01, 0x86, 0xE1, 0x9C, 0x7F,
  0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x08, 0x0E, 0xC0,
  0x04, 0x06, 0x08, 0x03, 0x01, 0x03, 0x00, 0x80, 0x40, 0x40, 0x60, 0x30,
  0x10, 0x10, 0x0C, 0x04, 0x0C, 0x02, 0x01, 0x02, 0x00, 0x80, 0x41, 0x00,
  0x20, 0x10, 0xC0, 0x0C, 0x04, 0x20, 0x03, 0x01, 0x18, 0xF8, 0x40, 0x44,
  0x63, 0x10, 0x33, 0x30, 0x66, 0x08, 0x88, 0x08, 0xFC, 0x62, 0x02, 0x0E,
  0x11, 0x80, 0x80, 0x08, 0x60, 0x20, 0x02, 0x18, 0x0C, 0x01, 0x06, 0x03,
  0x00, 0xC1, 0x80, 0x80, 0x20, 0x60, 0x20, 0x18, 0x18, 0x08, 0x04, 0x02,
  0x02, 0x03, 0x00, 0xC1, 0x80, 0x80, 0x10, 0xC0, 0x60, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x30, 0x01, 0x80,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x0C, 0x03, 0x00, 0x08, 0x04,
  0x00, 0x18, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xD8, 0x00, 0x07, 0x18, 0x00, 0x18, 0x18, 0x02, 0x60, 0x18, 0x0C,
  0x80, 0x18, 0x13, 0x00, 0x18, 0x66, 0x00, 0x18, 0x8C, 0x00, 0x1B, 0x18,
  0x00, 0x1C, 0x10, 0x00, 0x18, 0x30, 0x00, 0xD8, 0x30, 0x03, 0x18, 0x70,
  0x1C, 0x18, 0x3F, 0xE0, 0x18, 0xFF, 0x80, 0x0E, 0x30, 0x41, 0x82, 0x0C,
  0x18, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x18, 0x30, 0x20, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x03, 0x03, 0xE0,
  0x40, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0xC1,
  0x06, 0x18, 0x60, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x80, 0xC0, 0x83, 0xF8, 0x9F, 0x0F, 0xF0, 0x01, 0x80, 0x03, 0x40, 0x02,
  0x60, 0x04, 0x20, 0x0C, 0x30, 0x18, 0x18, 0x18, 0x08, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x33, 0x32, 0x26, 0x44, 0xC0, 0xFF, 0xFF, 0xC0, 0x5F, 0x00, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0x03, 0xE0, 0x07, 0xBC, 0x06, 0x03, 0x06, 0x00, 0xC2, 0x00, 0x23,
  0x00, 0x19, 0x00, 0x04, 0x80, 0x02, 0x40, 0x01, 0x60, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x24, 0x00, 0x13, 0x00, 0x18,
  0x80, 0x0C, 0x60, 0x04, 0x10, 0x04, 0x06, 0x0E, 0x01, 0xFC, 0x00, 0x03,
  0x0D, 0x19, 0x31, 0xC1, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0xC0, 0x1F, 0xF0, 0x70, 0x0C, 0x40, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x07, 0xC0, 0x3F, 0xF8, 0x60,
  0x0C, 0xC0, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0xF0, 0x0F, 0xE0, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x80, 0x06, 0xE0, 0x1C, 0x7F,
  0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0A, 0x00, 0x01, 0xA0, 0x00,
  0x32, 0x00, 0x02, 0x20, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x00, 0x86, 0x00,
  0x10, 0x60, 0x03, 0x06, 0x00, 0x60, 0x60, 0x04, 0x06, 0x00, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x00, 0x60, 0x20, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x06,
  0x0F, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xFC, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x5F, 0xC0, 0xFD, 0xF0, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x80, 0x0C, 0xC0, 0x38, 0x7F,
  0xE0, 0x00, 0x7E, 0x01, 0xF7, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0xFF, 0x04, 0xC0, 0xE6, 0x80, 0x1B, 0x80, 0x05, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x1B, 0x00, 0x0C,
  0x80, 0x04, 0x60, 0x06, 0x18, 0x02, 0x06, 0x06, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xBC, 0x06,
  0x01, 0x84, 0x00, 0x46, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x02, 0x18, 0x03, 0x06, 0x03, 0x01, 0xC7, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x30, 0x60, 0x60, 0x0C, 0x60, 0x03, 0x20, 0x00, 0xB0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x00, 0x04, 0xC0, 0x06, 0x20, 0x06,
  0x0C, 0x06, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x0F, 0xFC, 0x0C, 0x03, 0x0C,
  0x00, 0x84, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x34, 0x00, 0x3B, 0x00, 0x3C, 0xC0,
  0x36, 0x3C, 0xF2, 0x07, 0xC1, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x0F, 0xF0, 0x00, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0B, 0xE0, 0x31,
  0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0x8C, 0x46,
  0x31, 0x08, 0xC0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x87,
  0xFF, 0x10, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x84, 0x00, 0xFC, 0x06, 0x60,
  0x1C, 0x70, 0x12, 0x01, 0x80, 0x80, 0x90, 0x18, 0x04, 0x05, 0x81, 0x80,
  0x20, 0x3C, 0x08, 0x01, 0x01, 0xC0, 0x40, 0x08, 0x0E, 0x02, 0x00, 0x40,
  0x70, 0x10, 0x02, 0x02, 0x80, 0x80, 0x30, 0x14, 0x04, 0x01, 0x80, 0xB0,
  0x20, 0x0C, 0x0D, 0x81, 0x80, 0xA0, 0x44, 0x07, 0x18, 0x8C, 0x20, 0x0F,
  0x83, 0xC1, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x12, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x10, 0x00,
  0x08, 0x40, 0x00, 0x61, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x30, 0x00, 0x80, 0x40, 0x06, 0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x08,
  0x03, 0xFF, 0xF0, 0x08, 0x00, 0x40, 0x60, 0x01, 0x81, 0x00, 0x06, 0x04,
  0x00, 0x08, 0x30, 0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x18, 0x00,
  0x06, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x30, 0xFF, 0xF8, 0x40, 0x0E, 0x20,
  0x01, 0x90, 0x00, 0x68, 0x00, 0x34, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x03, 0x40, 0x01, 0x20, 0x03, 0x1F, 0xFF, 0x0F, 0xFF, 0x84, 0x00,
  0x72, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x0C, 0x80, 0x7C,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x07, 0x00, 0x20, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x06, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x08, 0x01, 0xE0, 0x80, 0x07, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8,
  0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00,
  0x04, 0x80, 0x00, 0xC8, 0x00, 0x18, 0x80, 0x03, 0x08, 0x00, 0xE0, 0x80,
  0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x3F,
  0xFE, 0xFF, 0xFA, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0xFF, 0xE8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xEF, 0xE0, 0x30, 0x01, 0x83, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00,
  0x00, 0x34, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x31, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0xF0,
  0x0F, 0xFF, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x11, 0xFC, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x06, 0xFC,
  0x20, 0x80, 0x03, 0xC0, 0x03, 0x20, 0x03, 0x10, 0x03, 0x08, 0x03, 0x04,
  0x03, 0x02, 0x03, 0x01, 0x03, 0x00, 0x83, 0x00, 0x43, 0x00, 0x23, 0x00,
  0x13, 0xC0, 0x0B, 0x60, 0x07, 0x18, 0x03, 0x06, 0x01, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x30, 0x20, 0x0C, 0x10, 0x02, 0x08, 0x01, 0x84, 0x00, 0x62,
  0x00, 0x19, 0x00, 0x0C, 0x80, 0x03, 0x40, 0x00, 0xC0, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xA0, 0x00, 0x0F, 0xB0, 0x00, 0x0B, 0xB0, 0x00, 0x0B, 0x90, 0x00,
  0x1B, 0x98, 0x00, 0x13, 0x88, 0x00, 0x33, 0x8C, 0x00, 0x23, 0x8C, 0x00,
  0x63, 0x84, 0x00, 0x63, 0x86, 0x00, 0x43, 0x82, 0x00, 0xC3, 0x83, 0x00,
  0x83, 0x81, 0x01, 0x83, 0x81, 0x01, 0x83, 0x81, 0x81, 0x03, 0x80, 0x83,
  0x03, 0x80, 0xC2, 0x03, 0x80, 0x46, 0x03, 0x80, 0x46, 0x03, 0x80, 0x64,
  0x03, 0x80, 0x2C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xD8, 0x00, 0x39, 0x00,
  0x07, 0x30, 0x00, 0xE3, 0x00, 0x1C, 0x20, 0x03, 0x86, 0x00, 0x70, 0x60,
  0x0E, 0x06, 0x01, 0xC0, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xC0, 0xE0, 0x18,
  0x1C, 0x01, 0x83, 0x80, 0x18, 0x70, 0x03, 0x0E, 0x00, 0x31, 0xC0, 0x03,
  0x38, 0x00, 0x67, 0x00, 0x06, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xF1, 0x00, 0x72, 0x00, 0x34, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x68, 0x01,
  0x90, 0x3E, 0x3F, 0xF0, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0xFF, 0xF0, 0x40, 0x1C, 0x20, 0x03, 0x10, 0x00,
  0xC8, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x40,
  0x03, 0x20, 0x01, 0x10, 0x01, 0x88, 0x03, 0x87, 0xFF, 0x02, 0x03, 0x01,
  0x00, 0x80, 0x80, 0x60, 0x40, 0x18, 0x20, 0x04, 0x10, 0x03, 0x08, 0x00,
  0xC4, 0x00, 0x62, 0x00, 0x19, 0x00, 0x04, 0x80, 0x03, 0x40, 0x00, 0xC0,
  0x03, 0xF0, 0x1F, 0xFF, 0x30, 0x02, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0xE0, 0x1C, 0x7F, 0xF0, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00,
  0x26, 0x00, 0x02, 0x30, 0x00, 0x61, 0x80, 0x0C, 0x0E, 0x03, 0x80, 0x7F,
  0xE0, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x62,
  0x00, 0x02, 0x18, 0x00, 0x30, 0x40, 0x01, 0x82, 0x00, 0x08, 0x18, 0x00,
  0xC0, 0x40, 0x04, 0x03, 0x00, 0x20, 0x18, 0x03, 0x00, 0x40, 0x10, 0x03,
  0x01, 0x80, 0x08, 0x0C, 0x00, 0x40, 0x40, 0x03, 0x06, 0x00, 0x08, 0x20,
  0x00, 0x61, 0x00, 0x03, 0x18, 0x00, 0x08, 0x80, 0x00, 0x6C, 0x00, 0x01,
  0x60, 0x00, 0x0A, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x80, 0x07, 0x00, 0x09, 0x00, 0x0E, 0x00, 0x33, 0x00, 0x34,
  0x00, 0x66, 0x00, 0x48, 0x00, 0x84, 0x00, 0x98, 0x03, 0x08, 0x01, 0x30,
  0x06, 0x18, 0x06, 0x20, 0x08, 0x30, 0x08, 0x40, 0x10, 0x20, 0x10, 0xC0,
  0x60, 0x60, 0x60, 0x80, 0xC0, 0xC0, 0xC1, 0x01, 0x00, 0x81, 0x03, 0x02,
  0x01, 0x02, 0x06, 0x0C, 0x03, 0x0C, 0x04, 0x18, 0x06, 0x10, 0x08, 0x20,
  0x04, 0x20, 0x18, 0xC0, 0x08, 0x40, 0x11, 0x80, 0x19, 0x80, 0x22, 0x00,
  0x32, 0x00, 0x64, 0x00, 0x24, 0x00, 0xD8, 0x00, 0x58, 0x00, 0xB0, 0x00,
  0xF0, 0x01, 0x40, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x66, 0x00, 0x18, 0x40, 0x06, 0x0C, 0x00,
  0x80, 0xC0, 0x30, 0x08, 0x0C, 0x01, 0x81, 0x00, 0x10, 0x60, 0x03, 0x08,
  0x00, 0x32, 0x00, 0x02, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x6C, 0x00, 0x08, 0xC0, 0x03, 0x08, 0x00, 0xC1, 0x80, 0x10, 0x18,
  0x06, 0x01, 0x01, 0x80, 0x30, 0x20, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x06,
  0x60, 0x00, 0x78, 0x00, 0x0C, 0x40, 0x00, 0x6C, 0x00, 0x18, 0x80, 0x03,
  0x18, 0x00, 0xC1, 0x00, 0x10, 0x30, 0x06, 0x02, 0x00, 0x80, 0x60, 0x30,
  0x04, 0x04, 0x00, 0xC1, 0x80, 0x0C, 0x20, 0x01, 0x8C, 0x00, 0x19, 0x00,
  0x01, 0x60, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0xFF, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0xFF, 0x00, 0x80, 0x00, 0x60, 0x00, 0x50, 0x00, 0x2C,
  0x00, 0x22, 0x00, 0x11, 0x80, 0x10, 0x40, 0x18, 0x30, 0x08, 0x08, 0x0C,
  0x06, 0x04, 0x01, 0x06, 0x00, 0xC2, 0x00, 0x23, 0x00, 0x19, 0x00, 0x05,
  0x80, 0x03, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x40, 0x40,
  0x40, 0x40, 0x40, 0x07, 0xE0, 0xF9, 0xC2, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x1F, 0xF3, 0xC0, 0x58, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x56, 0x06,
  0x4F, 0xF1, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC3, 0xF0, 0x67, 0x1E, 0x36,
  0x01, 0x9E, 0x00, 0xCE, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x05, 0x80, 0x02,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x16, 0x00,
  0x0B, 0x00, 0x05, 0x80, 0x06, 0xE0, 0x02, 0x78, 0x03, 0x36, 0x07, 0x11,
  0xFE, 0x00, 0x03, 0xF8, 0x3C, 0x71, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0xC0, 0x41,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x03, 0xE1, 0x87, 0x1C, 0xC6, 0x01,
  0x66, 0x00, 0xF6, 0x00, 0x3A, 0x00, 0x1D, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D,
  0x00, 0x06, 0x80, 0x07, 0x60, 0x03, 0x98, 0x02, 0xC6, 0x03, 0x61, 0xFE,
  0x30, 0x03, 0xE0, 0x0F, 0x38, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x02, 0x40,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x1C, 0x06, 0x07, 0xFC, 0x03, 0xF8, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1F, 0xC7, 0xFE, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x03, 0xF1, 0x87, 0x1C, 0xC6, 0x01, 0x66, 0x00, 0x76,
  0x00, 0x3A, 0x00, 0x0D, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x00, 0x06, 0xC0,
  0x07, 0x60, 0x03, 0x98, 0x02, 0xC6, 0x07, 0x61, 0xFE, 0x30, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x10, 0x01,
  0x8F, 0xEF, 0x80, 0xFE, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC3, 0xF1, 0x9C, 0x73,
  0x40, 0x37, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x10, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0A, 0x77,
  0x80, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x0F, 0x00, 0x6C, 0x03, 0x30, 0x18, 0xC0, 0xC3,
  0x06, 0x0C, 0x30, 0x30, 0x80, 0xC4, 0x03, 0x38, 0x0D, 0x20, 0x3C, 0xC0,
  0xE1, 0x83, 0x03, 0x0C, 0x04, 0x30, 0x18, 0xC0, 0x33, 0x00, 0x6C, 0x00,
  0xB0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x7E,
  0x37, 0x1C, 0x79, 0xCD, 0x01, 0xB0, 0x1B, 0x80, 0x28, 0x03, 0xC0, 0x0E,
  0x00, 0xF0, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x01, 0xC0,
  0x0C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x01,
  0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x30,
  0x01, 0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00,
  0x30, 0x01, 0x83, 0xF1, 0x1C, 0x73, 0x40, 0x37, 0x00, 0x3E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x10, 0x03, 0xF0, 0x07, 0x1E, 0x06, 0x01, 0x86, 0x00,
  0x66, 0x00, 0x12, 0x00, 0x0D, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0D, 0x00, 0x06,
  0xC0, 0x02, 0x20, 0x03, 0x18, 0x03, 0x07, 0x03, 0x00, 0xFF, 0x00, 0xC3,
  0xF0, 0x67, 0x1E, 0x36, 0x01, 0x9E, 0x00, 0x4E, 0x00, 0x36, 0x00, 0x0B,
  0x00, 0x05, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0B, 0x00, 0x05, 0xC0, 0x06, 0xE0, 0x02, 0x78,
  0x03, 0x36, 0x07, 0x18, 0xFE, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xE1, 0x0E, 0x39, 0x38, 0x0D, 0x20, 0x07, 0x60, 0x03, 0x40,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x30,
  0x05, 0x18, 0x19, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0xC7,
  0xF9, 0xCB, 0x40, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x00, 0x0F, 0xE1, 0xC3, 0xD8, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xF0, 0x0C, 0xFF, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x03, 0xFF, 0xFF, 0xC6, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x3F, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x0E, 0xC0, 0x14, 0xC0, 0xC8, 0xFF, 0x10, 0xC0,
  0x01, 0xE0, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x61, 0x00, 0x30,
  0xC0, 0x10, 0x20, 0x18, 0x18, 0x08, 0x04, 0x04, 0x02, 0x06, 0x01, 0x82,
  0x00, 0x43, 0x00, 0x21, 0x00, 0x18, 0x80, 0x04, 0xC0, 0x03, 0x40, 0x00,
  0xA0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x80, 0x08, 0x01, 0xC0, 0x0C, 0x00,
  0xB0, 0x07, 0x00, 0x58, 0x02, 0x80, 0x64, 0x03, 0x40, 0x23, 0x01, 0x30,
  0x11, 0x80, 0x88, 0x18, 0x40, 0xC4, 0x0C, 0x20, 0x43, 0x04, 0x18, 0x21,
  0x82, 0x0C, 0x30, 0x43, 0x02, 0x10, 0x31, 0x81, 0x08, 0x18, 0x80, 0xCC,
  0x04, 0x40, 0x24, 0x02, 0x60, 0x12, 0x01, 0xB0, 0x0F, 0x00, 0x50, 0x07,
  0x00, 0x28, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x03, 0x60,
  0x06, 0x20, 0x0C, 0x30, 0x08, 0x18, 0x18, 0x0C, 0x30, 0x04, 0x20, 0x06,
  0x60, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x60, 0x04,
  0x20, 0x08, 0x30, 0x18, 0x18, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x61,
  0x00, 0x30, 0xC0, 0x10, 0x20, 0x18, 0x18, 0x08, 0x04, 0x04, 0x02, 0x06,
  0x01, 0x82, 0x00, 0x43, 0x00, 0x31, 0x00, 0x18, 0x80, 0x04, 0xC0, 0x03,
  0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x13, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0xFF, 0xF0,
  0x03, 0xC1, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x83, 0x80, 0x70, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0x80, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x03, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x07,
  0x01, 0xC0, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x1E, 0x07, 0x00, 0x1E, 0x00,
  0xB3, 0xC0, 0x60, 0x3F, 0xC0, 0x03, 0x80,
};

const GFXglyph NotoSans_ExtraLight37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 26, 9, 3, -26 },
  { 11, 7, 9, 13, 3, -26 },
  { 19, 22, 26, 24, 1, -26 },
  { 91, 16, 30, 21, 2, -28 },
  { 151, 26, 27, 30, 2, -27 },
  { 239, 23, 27, 26, 2, -27 },
  { 317, 1, 9, 7, 3, -26 },
  { 319, 7, 32, 10, 2, -26 },
  { 347, 7, 32, 10, 1, -26 },
  { 375, 16, 15, 20, 2, -28 },
  { 405, 17, 18, 21, 2, -22 },
  { 444, 4, 9, 7, 1, -4 },
  { 449, 9, 2, 12, 1, -11 },
  { 452, 3, 3, 9, 3, -3 },
  { 454, 12, 26, 12, 0, -26 },
  { 493, 17, 27, 21, 2, -27 },
  { 551, 8, 26, 21, 4, -26 },
  { 577, 16, 27, 21, 2, -27 },
  { 631, 16, 27, 21, 2, -27 },
  { 685, 20, 27, 21, 1, -27 },
  { 753, 16, 26, 21, 3, -26 },
  { 805, 17, 27, 21, 2, -27 },
  { 863, 17, 26, 21, 2, -26 },
  { 919, 17, 27, 21, 2, -27 },
  { 977, 17, 27, 21, 2, -27 },
  { 1035, 3, 20, 9, 3, -20 },
  { 1043, 5, 25, 9, 1, -20 },
  { 1059, 17, 17, 21, 2, -22 },
  { 1096, 17, 8, 21, 2, -17 },
  { 1113, 17, 17, 21, 2, -22 },
  { 1150, 13, 27, 15, 1, -27 },
  { 1194, 29, 30, 33, 2, -26 },
  { 1303, 22, 26, 22, 0, -26 },
  { 1375, 17, 26, 23, 4, -26 },
  { 1431, 20, 27, 23, 2, -27 },
  { 1499, 20, 26, 26, 4, -26 },
  { 1564, 14, 26, 20, 4, -26 },
  { 1610, 14, 26, 18, 4, -26 },
  { 1656, 22, 27, 27, 2, -27 },
  { 1731, 19, 26, 26, 4, -26 },
  { 1793, 7, 26, 11, 2, -26 },
  { 1816, 8, 33, 9, -3, -26 },
  { 1849, 17, 26, 21, 4, -26 },
  { 1905, 14, 26, 19, 4, -26 },
  { 1951, 24, 26, 31, 4, -26 },
  { 2029, 19, 26, 26, 4, -26 },
  { 2091, 24, 27, 28, 2, -27 },
  { 2172, 15, 26, 21, 4, -26 },
  { 2221, 24, 33, 28, 2, -27 },
  { 2320, 17, 26, 22, 4, -26 },
  { 2376, 16, 27, 20, 2, -27 },
  { 2430, 19, 26, 19, 0, -26 },
  { 2492, 20, 26, 26, 3, -26 },
  { 2557, 21, 26, 21, 0, -26 },
  { 2626, 31, 26, 33, 1, -26 },
  { 2727, 19, 26, 19, 0, -26 },
  { 2789, 19, 26, 19, 0, -26 },
  { 2851, 19, 26, 21, 1, -26 },
  { 2913, 8, 32, 12, 3, -26 },
  { 2945, 12, 26, 12, 0, -26 },
  { 2984, 8, 32, 12, 1, -26 },
  { 3016, 17, 17, 21, 2, -27 },
  { 3053, 15, 2, 15, 0, 3 },
  { 3057, 7, 6, 9, 1, -28 },
  { 3063, 14, 20, 19, 2, -20 },
  { 3098, 17, 28, 22, 3, -28 },
  { 3158, 14, 20, 18, 2, -20 },
  { 3193, 17, 28, 22, 2, -28 },
  { 3253, 16, 20, 20, 2, -20 },
  { 3293, 13, 28, 11, 0, -28 },
  { 3339, 17, 29, 22, 2, -20 },
  { 3401, 15, 28, 22, 3, -28 },
  { 3454, 2, 27, 8, 3, -27 },
  { 3461, 7, 36, 8, -2, -27 },
  { 3493, 14, 28, 17, 3, -28 },
  { 3542, 2, 28, 8, 3, -28 },
  { 3549, 26, 20, 32, 3, -20 },
  { 3614, 15, 20, 22, 3, -20 },
  { 3652, 17, 20, 22, 2, -20 },
  { 3695, 17, 29, 22, 3, -20 },
  { 3757, 16, 29, 22, 2, -20 },
  { 3815, 11, 20, 14, 3, -20 },
  { 3843, 13, 20, 17, 2, -20 },
  { 3876, 11, 24, 12, 0, -24 },
  { 3909, 15, 20, 22, 3, -20 },
  { 3947, 17, 20, 17, 0, -20 },
  { 3990, 25, 20, 26, 1, -20 },
  { 4053, 16, 20, 18, 1, -20 },
  { 4093, 17, 29, 16, 0, -20 },
  { 4155, 13, 20, 17, 2, -20 },
  { 4188, 10, 32, 13, 1, -26 },
  { 4228, 2, 37, 20, 9, -28 },
  { 4238, 11, 32, 13, 1, -26 },
  { 4282, 17, 4, 21, 2, -15 },
};

const GFXfont NotoSans_ExtraLight37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRALIGHT37PT7B_H_
