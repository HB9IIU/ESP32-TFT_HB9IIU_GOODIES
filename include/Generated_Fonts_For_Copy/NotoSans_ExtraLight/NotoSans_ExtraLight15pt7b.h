#ifndef _NOTOSANS_EXTRALIGHT15PT7B_H_
#define _NOTOSANS_EXTRALIGHT15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x09, 0x08, 0x84, 0x4F, 0xF1, 0x20, 0x90,
  0x89, 0xFF, 0x24, 0x12, 0x09, 0x00, 0x3B, 0x59, 0x24, 0xD0, 0xC1, 0xC5,
  0x14, 0x5F, 0x84, 0x61, 0x24, 0x49, 0x22, 0x48, 0x95, 0xA5, 0x96, 0xA4,
  0x49, 0x12, 0x48, 0x92, 0x1C, 0x38, 0x22, 0x11, 0x08, 0x82, 0x83, 0x82,
  0x23, 0x09, 0x83, 0x41, 0x9F, 0x20, 0xF0, 0x5A, 0xAA, 0xAA, 0x40, 0xA5,
  0x55, 0x55, 0x80, 0x10, 0x4D, 0xCC, 0x49, 0x20, 0x10, 0x20, 0x47, 0xF1,
  0x02, 0x04, 0x00, 0xF0, 0xE0, 0x80, 0x08, 0x44, 0x22, 0x10, 0x88, 0x42,
  0x20, 0x38, 0x8A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0xE0, 0x13,
  0xD1, 0x11, 0x11, 0x11, 0x10, 0x7A, 0x10, 0x41, 0x04, 0x21, 0x04, 0x21,
  0x0F, 0xC0, 0x7A, 0x10, 0x41, 0x05, 0xE0, 0x41, 0x04, 0x1F, 0x80, 0x02,
  0x04, 0x0A, 0x12, 0x12, 0x22, 0x42, 0xFF, 0x02, 0x02, 0x02, 0x7C, 0x82,
  0x04, 0x0B, 0x09, 0x80, 0x81, 0x02, 0x0B, 0xE0, 0x3C, 0x82, 0x04, 0x0B,
  0x98, 0xA0, 0xC1, 0x83, 0x09, 0xF0, 0xFE, 0x04, 0x10, 0x20, 0x81, 0x04,
  0x08, 0x20, 0x40, 0x80, 0x79, 0x0A, 0x14, 0x24, 0x87, 0x31, 0x41, 0x83,
  0x05, 0xF0, 0x79, 0x0A, 0x14, 0x18, 0x30, 0xDE, 0x82, 0x04, 0x0B, 0xE0,
  0x81, 0x83, 0xC0, 0x02, 0x39, 0x84, 0x06, 0x03, 0x01, 0x80, 0xFE, 0x03,
  0xF8, 0x80, 0xC0, 0x60, 0x30, 0xCE, 0x20, 0x00, 0xF8, 0x10, 0x41, 0x08,
  0x42, 0x08, 0x00, 0x02, 0x00, 0x0F, 0x06, 0x19, 0x00, 0xC3, 0x19, 0x93,
  0x22, 0x64, 0x4C, 0x89, 0x93, 0x31, 0x99, 0x00, 0x1F, 0xC0, 0x08, 0x04,
  0x05, 0x02, 0x82, 0x21, 0x10, 0xF8, 0x82, 0x41, 0x40, 0xA0, 0x20, 0xFA,
  0x18, 0x61, 0x87, 0xE8, 0x61, 0x86, 0x1F, 0x80, 0x1F, 0x60, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x3F, 0xF8, 0x84, 0x82, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x84, 0xF8, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84,
  0x3E, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x20, 0x1F, 0x90, 0x10, 0x10,
  0x08, 0x04, 0x3A, 0x03, 0x01, 0x80, 0xA0, 0x4F, 0xE0, 0x83, 0x06, 0x0C,
  0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08, 0xE9, 0x24, 0x92, 0x4B, 0x80,
  0x24, 0x92, 0x49, 0x24, 0x93, 0x80, 0x85, 0x12, 0x45, 0x0C, 0x14, 0x28,
  0x48, 0x89, 0x0A, 0x18, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3E, 0x80,
  0xC0, 0x60, 0x78, 0x3C, 0x2D, 0x16, 0x8B, 0x29, 0x94, 0xCC, 0x62, 0x20,
  0x83, 0x07, 0x0E, 0x1A, 0x32, 0x64, 0xC5, 0x87, 0x0E, 0x08, 0x3E, 0x20,
  0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x8F, 0x80, 0xF2,
  0x28, 0x61, 0x86, 0x2F, 0x20, 0x82, 0x08, 0x00, 0x3E, 0x20, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x8E, 0x80, 0x80, 0x20, 0x08,
  0xF2, 0x38, 0x61, 0x86, 0x2F, 0x24, 0x8A, 0x18, 0x40, 0x7E, 0x08, 0x20,
  0xC0, 0xC0, 0xC1, 0x04, 0x1F, 0x80, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x3E, 0x80, 0xC0, 0x90, 0x48, 0x24, 0x21, 0x10, 0x90,
  0x48, 0x14, 0x0C, 0x02, 0x00, 0x82, 0x0A, 0x10, 0x51, 0x44, 0x8A, 0x24,
  0x51, 0x12, 0x48, 0xA2, 0x85, 0x14, 0x28, 0xA0, 0x82, 0x04, 0x10, 0x81,
  0x42, 0x24, 0x24, 0x18, 0x10, 0x18, 0x24, 0x44, 0x42, 0x81, 0x81, 0x82,
  0x42, 0x24, 0x24, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x08, 0x10,
  0x41, 0x02, 0x08, 0x20, 0x41, 0x03, 0xF8, 0xF2, 0x49, 0x24, 0x92, 0x4E,
  0x84, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0xE4, 0x92, 0x49, 0x24, 0x9E,
  0x10, 0x60, 0xA2, 0x44, 0x50, 0xA0, 0x80, 0xFC, 0x90, 0xF8, 0x10, 0x4F,
  0xC6, 0x18, 0xFD, 0x81, 0x02, 0x05, 0xEC, 0x30, 0x60, 0xC1, 0x83, 0x07,
  0xF0, 0x7E, 0x08, 0x20, 0x82, 0x08, 0x1F, 0x02, 0x04, 0x0B, 0xD8, 0x70,
  0x60, 0xC1, 0x83, 0x0D, 0xE8, 0x7A, 0x18, 0x7F, 0x82, 0x08, 0x1F, 0x3A,
  0x11, 0xE4, 0x21, 0x08, 0x42, 0x10, 0x7B, 0x0E, 0x0C, 0x18, 0x30, 0x61,
  0xBD, 0x02, 0x06, 0x13, 0xC0, 0x82, 0x08, 0x2F, 0xC6, 0x18, 0x61, 0x86,
  0x18, 0x40, 0x9F, 0xE0, 0x20, 0x12, 0x49, 0x24, 0x92, 0x70, 0x82, 0x08,
  0x21, 0x8A, 0x4A, 0x34, 0x92, 0x28, 0x40, 0xFF, 0xE0, 0xFB, 0xD0, 0x86,
  0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0xBF, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x61, 0x3C, 0xBD, 0x86, 0x0C,
  0x18, 0x30, 0x70, 0xDE, 0x81, 0x02, 0x04, 0x00, 0x7E, 0x18, 0x61, 0x86,
  0x18, 0x5F, 0x04, 0x10, 0x41, 0xBE, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x20,
  0xC1, 0x84, 0x3F, 0x42, 0x3C, 0x84, 0x21, 0x08, 0x41, 0xC0, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x5F, 0x83, 0x09, 0x12, 0x22, 0x85, 0x0C, 0x08, 0x84,
  0x63, 0x14, 0xA5, 0x29, 0x52, 0x8C, 0x63, 0x18, 0x84, 0xC2, 0x88, 0xA0,
  0x81, 0x05, 0x11, 0x61, 0x83, 0x09, 0x12, 0x22, 0x85, 0x0C, 0x08, 0x10,
  0x40, 0x86, 0x00, 0xF8, 0x44, 0x42, 0x22, 0x1F, 0x19, 0x08, 0x42, 0x13,
  0x04, 0x21, 0x08, 0x43, 0x80, 0xFF, 0xFE, 0x84, 0x44, 0x44, 0x32, 0x44,
  0x44, 0xC0, 0xFE,
};

const GFXglyph NotoSans_ExtraLight15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 9, 11, 10, 0, -11 },
  { 18, 6, 12, 9, 1, -11 },
  { 27, 10, 11, 12, 1, -11 },
  { 41, 9, 11, 11, 1, -11 },
  { 54, 1, 4, 3, 1, -11 },
  { 55, 2, 13, 4, 1, -11 },
  { 59, 2, 13, 4, 1, -11 },
  { 63, 6, 6, 8, 1, -11 },
  { 68, 7, 7, 9, 1, -9 },
  { 75, 1, 4, 3, 1, -2 },
  { 76, 3, 1, 5, 1, -5 },
  { 77, 1, 1, 3, 1, -1 },
  { 78, 5, 11, 5, 0, -11 },
  { 85, 7, 11, 9, 1, -11 },
  { 95, 4, 11, 9, 1, -11 },
  { 101, 6, 11, 9, 1, -11 },
  { 110, 6, 11, 9, 1, -11 },
  { 119, 8, 11, 9, 0, -11 },
  { 130, 7, 11, 9, 1, -11 },
  { 140, 7, 11, 9, 1, -11 },
  { 150, 7, 11, 9, 1, -11 },
  { 160, 7, 11, 9, 1, -11 },
  { 170, 7, 11, 9, 1, -11 },
  { 180, 1, 8, 3, 1, -8 },
  { 181, 1, 10, 3, 1, -8 },
  { 183, 7, 7, 9, 1, -9 },
  { 190, 7, 3, 9, 1, -7 },
  { 193, 7, 7, 9, 1, -9 },
  { 200, 6, 11, 6, 0, -11 },
  { 209, 11, 12, 13, 1, -11 },
  { 226, 9, 11, 9, 0, -11 },
  { 239, 6, 11, 9, 2, -11 },
  { 248, 8, 11, 9, 1, -11 },
  { 259, 8, 11, 11, 2, -11 },
  { 270, 5, 11, 8, 2, -11 },
  { 277, 5, 11, 7, 2, -11 },
  { 284, 9, 11, 11, 1, -11 },
  { 297, 7, 11, 11, 2, -11 },
  { 307, 3, 11, 4, 1, -11 },
  { 312, 3, 14, 4, -1, -11 },
  { 318, 7, 11, 9, 2, -11 },
  { 328, 5, 11, 8, 2, -11 },
  { 335, 9, 11, 13, 2, -11 },
  { 348, 7, 11, 11, 2, -11 },
  { 358, 9, 11, 11, 1, -11 },
  { 371, 6, 11, 9, 2, -11 },
  { 380, 9, 14, 11, 1, -11 },
  { 396, 6, 11, 9, 2, -11 },
  { 405, 6, 11, 8, 1, -11 },
  { 414, 8, 11, 8, 0, -11 },
  { 425, 8, 11, 11, 1, -11 },
  { 436, 9, 11, 9, 0, -11 },
  { 449, 13, 11, 13, 0, -11 },
  { 467, 8, 11, 8, 0, -11 },
  { 478, 8, 11, 8, 0, -11 },
  { 489, 7, 11, 9, 1, -11 },
  { 499, 3, 13, 5, 1, -11 },
  { 504, 5, 11, 5, 0, -11 },
  { 511, 3, 13, 5, 0, -11 },
  { 516, 7, 7, 9, 1, -11 },
  { 523, 6, 1, 6, 0, 1 },
  { 524, 2, 2, 4, 1, -11 },
  { 525, 6, 8, 8, 1, -8 },
  { 531, 7, 11, 9, 1, -11 },
  { 541, 6, 8, 7, 1, -8 },
  { 547, 7, 11, 9, 1, -11 },
  { 557, 6, 8, 8, 1, -8 },
  { 563, 5, 11, 4, 0, -11 },
  { 570, 7, 12, 9, 1, -8 },
  { 581, 6, 11, 9, 1, -11 },
  { 590, 1, 11, 3, 1, -11 },
  { 592, 3, 15, 3, -1, -11 },
  { 598, 6, 11, 7, 1, -11 },
  { 607, 1, 11, 3, 1, -11 },
  { 609, 11, 8, 13, 1, -8 },
  { 620, 6, 8, 9, 1, -8 },
  { 626, 7, 8, 9, 1, -8 },
  { 633, 7, 12, 9, 1, -8 },
  { 644, 6, 12, 9, 1, -8 },
  { 653, 5, 8, 6, 1, -8 },
  { 658, 5, 8, 7, 1, -8 },
  { 663, 5, 10, 5, 0, -10 },
  { 670, 6, 8, 9, 1, -8 },
  { 676, 7, 8, 7, 0, -8 },
  { 683, 10, 8, 11, 0, -8 },
  { 693, 7, 8, 7, 0, -8 },
  { 700, 7, 12, 7, 0, -8 },
  { 711, 5, 8, 7, 1, -8 },
  { 716, 5, 13, 5, 0, -11 },
  { 725, 1, 15, 8, 4, -11 },
  { 727, 4, 13, 5, 1, -11 },
  { 734, 7, 1, 9, 1, -6 },
};

const GFXfont NotoSans_ExtraLight15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRALIGHT15PT7B_H_
