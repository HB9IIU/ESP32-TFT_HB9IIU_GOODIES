#ifndef _NOTOSANS_EXTRALIGHT29PT7B_H_
#define _NOTOSANS_EXTRALIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight29pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x01, 0xC0, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x01, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x41, 0x00, 0x20, 0x80,
  0x10, 0x40, 0x10, 0x20, 0xFF, 0xFF, 0x04, 0x10, 0x02, 0x08, 0x01, 0x04,
  0x01, 0x02, 0x00, 0x81, 0x00, 0x41, 0x83, 0xFF, 0xFC, 0x10, 0x40, 0x08,
  0x20, 0x08, 0x10, 0x04, 0x08, 0x02, 0x08, 0x01, 0x04, 0x00, 0x04, 0x00,
  0x40, 0x3F, 0xC6, 0x42, 0xC4, 0x08, 0x40, 0x84, 0x08, 0x40, 0xC4, 0x06,
  0x40, 0x3C, 0x00, 0xE0, 0x05, 0x80, 0x46, 0x04, 0x30, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x38, 0x46, 0xFF, 0xC0, 0x40, 0x04, 0x00, 0x40, 0x3C, 0x01,
  0x04, 0x60, 0x20, 0x82, 0x02, 0x08, 0x20, 0x40, 0x81, 0x0C, 0x08, 0x10,
  0x80, 0x81, 0x10, 0x08, 0x11, 0x00, 0x81, 0x21, 0x08, 0x22, 0x6C, 0x82,
  0x48, 0x24, 0x64, 0x82, 0x3C, 0x88, 0x20, 0x18, 0x83, 0x01, 0x18, 0x30,
  0x31, 0x83, 0x02, 0x08, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x80, 0xC6,
  0x18, 0x07, 0xC0, 0x0F, 0x80, 0x06, 0x18, 0x03, 0x02, 0x00, 0x80, 0x80,
  0x20, 0x20, 0x08, 0x08, 0x03, 0x02, 0x00, 0x41, 0x00, 0x09, 0x80, 0x01,
  0x80, 0x01, 0xA0, 0x00, 0x84, 0x02, 0x40, 0x80, 0xA0, 0x10, 0x48, 0x02,
  0x12, 0x00, 0x48, 0x80, 0x0E, 0x20, 0x01, 0x0C, 0x01, 0xA1, 0x80, 0xC4,
  0x3F, 0xC0, 0xC0, 0xFF, 0x0C, 0x61, 0x0C, 0x21, 0x84, 0x10, 0x43, 0x08,
  0x20, 0x82, 0x0C, 0x20, 0xC1, 0x04, 0x10, 0x60, 0x83, 0x04, 0x08, 0x30,
  0x82, 0x08, 0x41, 0x08, 0x61, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x84, 0x44, 0x00, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0xC4,
  0x37, 0xDE, 0x06, 0x00, 0x60, 0x09, 0x01, 0x08, 0x30, 0xC2, 0x04, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x2D, 0x25, 0x20,
  0xFE, 0x70, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x0C, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10, 0x10, 0x08,
  0x0C, 0x00, 0x0F, 0x81, 0x82, 0x18, 0x08, 0x80, 0x64, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x02, 0xC0, 0x12, 0x00, 0x98, 0x08, 0x60, 0xC1, 0xF8,
  0x00, 0x04, 0x31, 0x59, 0xC4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0x06, 0x0C, 0x80, 0x60, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xFF,
  0xF0, 0x0F, 0xC1, 0x83, 0x10, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x06, 0x03, 0xF0, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x07, 0x80, 0x67, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x12, 0x00, 0x64, 0x00,
  0x88, 0x02, 0x10, 0x08, 0x20, 0x30, 0x40, 0x40, 0x81, 0x01, 0x06, 0x02,
  0x08, 0x04, 0x20, 0x08, 0x7F, 0xFF, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x3F, 0xE3, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFE, 0x00, 0x18, 0x00, 0x20,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0D, 0x00,
  0xC7, 0xF8, 0x00, 0x03, 0xF0, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x87, 0x84, 0xC3, 0x28, 0x0D, 0x80, 0x28, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x98, 0x04, 0x60, 0x40,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x1F, 0x81, 0x83, 0x10, 0x08, 0x80, 0x2C, 0x01, 0x60, 0x09, 0x00,
  0xCC, 0x04, 0x30, 0xC0, 0x78, 0x03, 0xE0, 0x61, 0x84, 0x03, 0x60, 0x0A,
  0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0xB0, 0x04, 0xC0, 0xC1, 0xFC, 0x00,
  0x1F, 0x01, 0x06, 0x10, 0x19, 0x00, 0x48, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x0E, 0xC1, 0xB1, 0xF9, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x03, 0x07, 0xF0, 0x00, 0x74,
  0x00, 0x00, 0x07, 0x2C, 0x80, 0x00, 0x00, 0x00, 0x5A, 0x4A, 0x40, 0x00,
  0x08, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x80, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x7E, 0x30, 0x60, 0x0C, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x0F, 0xBE, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x08, 0x30, 0x00, 0x11,
  0x80, 0x00, 0x24, 0x03, 0xC0, 0xB0, 0x30, 0x81, 0x81, 0x02, 0x06, 0x08,
  0x08, 0x18, 0x20, 0x20, 0x60, 0x80, 0x81, 0x86, 0x02, 0x06, 0x08, 0x08,
  0x18, 0x20, 0x20, 0xA0, 0x81, 0x82, 0x81, 0x09, 0x12, 0x03, 0xC3, 0x84,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x32, 0x00, 0x11, 0x00, 0x08, 0xC0, 0x08, 0x20, 0x04, 0x10, 0x02,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0xFF, 0xC0, 0x80, 0x20, 0x40, 0x18,
  0x40, 0x04, 0x20, 0x02, 0x30, 0x00, 0x90, 0x00, 0x48, 0x00, 0x38, 0x00,
  0x08, 0xFF, 0x04, 0x0F, 0x20, 0x0D, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x02, 0x80, 0x34, 0x0E, 0x3F, 0xF1, 0x00, 0x68, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0xCF, 0xF8, 0x00,
  0x03, 0xF8, 0x1C, 0x0C, 0x60, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xE0, 0x10, 0x7F, 0xC0, 0xFF, 0x01, 0x03, 0xC2, 0x00, 0xC4, 0x00, 0x48,
  0x00, 0x50, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x05,
  0x00, 0x1A, 0x00, 0x64, 0x07, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0xC0,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0F,
  0xFE, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x7F, 0xF8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x01, 0xFC, 0x07, 0x01, 0x86, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x0F, 0xF8, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x80, 0x03, 0x40, 0x01, 0x90, 0x00, 0xCC, 0x00, 0x61, 0x80,
  0x30, 0x7F, 0xE0, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0xF9, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x4F, 0x80, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x05, 0xF0, 0x80, 0x0A, 0x00, 0x48,
  0x02, 0x20, 0x10, 0x80, 0x82, 0x04, 0x08, 0x20, 0x21, 0x00, 0x88, 0x02,
  0x60, 0x0A, 0xC0, 0x31, 0x80, 0x82, 0x02, 0x04, 0x08, 0x18, 0x20, 0x30,
  0x80, 0x42, 0x00, 0x88, 0x03, 0x20, 0x04, 0x80, 0x0C, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0F, 0xFE, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x02, 0xD0, 0x00, 0x5A,
  0x00, 0x13, 0x20, 0x02, 0x64, 0x00, 0xCC, 0xC0, 0x11, 0x88, 0x02, 0x31,
  0x00, 0x86, 0x10, 0x10, 0xC2, 0x06, 0x18, 0x60, 0x83, 0x04, 0x10, 0x60,
  0x84, 0x0C, 0x08, 0x81, 0x81, 0x30, 0x30, 0x34, 0x06, 0x02, 0x80, 0xC0,
  0x60, 0x18, 0x04, 0x02, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0D, 0x00, 0x1B,
  0x00, 0x33, 0x00, 0x62, 0x00, 0xC6, 0x01, 0x86, 0x03, 0x04, 0x06, 0x04,
  0x0C, 0x0C, 0x18, 0x08, 0x30, 0x08, 0x60, 0x18, 0xC0, 0x11, 0x80, 0x13,
  0x00, 0x36, 0x00, 0x2C, 0x00, 0x38, 0x00, 0x60, 0x03, 0xF8, 0x03, 0x03,
  0x01, 0x00, 0x30, 0x80, 0x04, 0x40, 0x00, 0x90, 0x00, 0x2C, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x05, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00,
  0x43, 0x00, 0x30, 0x60, 0x18, 0x07, 0xF8, 0x00, 0xFE, 0x08, 0x3C, 0x80,
  0x28, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80,
  0x6F, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x03, 0x03, 0x01, 0x00, 0x30, 0x80,
  0x04, 0x40, 0x00, 0x90, 0x00, 0x2C, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x05, 0x00, 0x02, 0x40, 0x00, 0x88, 0x00, 0x43, 0x00, 0x30, 0x60,
  0x18, 0x07, 0xF8, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0xFF, 0x04, 0x1E, 0x20, 0x09, 0x00, 0x68, 0x01, 0x40,
  0x0A, 0x00, 0x50, 0x02, 0x80, 0x34, 0x01, 0x20, 0x31, 0xFE, 0x08, 0x10,
  0x40, 0xC2, 0x02, 0x10, 0x08, 0x80, 0x64, 0x01, 0x20, 0x0D, 0x00, 0x28,
  0x00, 0x80, 0x1F, 0xC3, 0x03, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x38, 0x06, 0xFF, 0x80, 0xFF, 0xFE,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x09,
  0x80, 0x31, 0x80, 0xC1, 0xFE, 0x00, 0x80, 0x01, 0xE0, 0x00, 0x90, 0x00,
  0x48, 0x00, 0x42, 0x00, 0x21, 0x00, 0x30, 0xC0, 0x10, 0x20, 0x08, 0x10,
  0x0C, 0x0C, 0x04, 0x02, 0x02, 0x01, 0x02, 0x00, 0x41, 0x00, 0x21, 0x80,
  0x18, 0x80, 0x04, 0x40, 0x02, 0x60, 0x01, 0xA0, 0x00, 0x50, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x80, 0x10, 0x01, 0x80, 0x18, 0x02, 0xC0, 0x18, 0x02,
  0x40, 0x28, 0x02, 0x40, 0x28, 0x06, 0x40, 0x24, 0x04, 0x20, 0x64, 0x04,
  0x20, 0x44, 0x04, 0x20, 0x46, 0x0C, 0x20, 0x42, 0x08, 0x10, 0x82, 0x08,
  0x10, 0x82, 0x18, 0x10, 0x81, 0x10, 0x19, 0x81, 0x10, 0x09, 0x01, 0x10,
  0x09, 0x01, 0xB0, 0x09, 0x00, 0xA0, 0x07, 0x00, 0xA0, 0x06, 0x00, 0xA0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x40, 0x06, 0xC0, 0x08, 0x80, 0x20,
  0x80, 0xC1, 0x81, 0x01, 0x04, 0x01, 0x08, 0x02, 0x20, 0x02, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x14, 0x00, 0x64, 0x00, 0x88, 0x02, 0x08, 0x04, 0x18,
  0x10, 0x10, 0x60, 0x10, 0x80, 0x32, 0x00, 0x2C, 0x00, 0x20, 0x80, 0x02,
  0x80, 0x09, 0x00, 0x11, 0x00, 0x43, 0x01, 0x82, 0x02, 0x06, 0x0C, 0x04,
  0x10, 0x0C, 0x60, 0x08, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x7F, 0xFC, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xF0, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x18,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40,
  0x10, 0x08, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07, 0xF0, 0x01, 0x00,
  0x0C, 0x00, 0x28, 0x01, 0x20, 0x04, 0x40, 0x21, 0x00, 0x82, 0x04, 0x08,
  0x10, 0x10, 0x80, 0x62, 0x00, 0x90, 0x03, 0xC0, 0x04, 0xFF, 0xF0, 0xC3,
  0x0C, 0x30, 0x03, 0x03, 0xDC, 0x20, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x3F, 0x1C, 0x16, 0x01, 0x40, 0x1C, 0x03, 0xC0, 0x34, 0x05, 0x60,
  0xD3, 0xF1, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x87,
  0x0B, 0x9C, 0xE0, 0x6C, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x02, 0xA0, 0x49, 0xF8, 0x07,
  0x83, 0x9C, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x0C, 0x08, 0xFF, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x18, 0x67, 0xBB, 0x60, 0x3A,
  0x01, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x06, 0x80, 0x56, 0x04, 0x8F, 0xC4, 0x07, 0x01, 0xDC,
  0x20, 0x64, 0x02, 0xC0, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x11, 0xFE, 0x07, 0xC2, 0x00,
  0x80, 0x60, 0x10, 0x04, 0x01, 0x03, 0xFC, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x00, 0x07, 0x01, 0xC6, 0xD8, 0x0E, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xA0, 0x1C,
  0x81, 0x63, 0xF3, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x30,
  0x30, 0xFE, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x21,
  0xC5, 0xCE, 0xE0, 0x78, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0xF0, 0x05,
  0x55, 0x55, 0x55, 0x40, 0x18, 0xC0, 0x00, 0x00, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0xC5, 0xC0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x14, 0x04, 0x81, 0x10, 0x62,
  0x18, 0x46, 0x09, 0x81, 0x20, 0x2A, 0x06, 0x60, 0x86, 0x10, 0x42, 0x04,
  0x40, 0xC8, 0x0D, 0x00, 0xC0, 0xFF, 0xFF, 0xFC, 0x06, 0x03, 0x0B, 0x39,
  0xCC, 0xC0, 0xF0, 0x28, 0x06, 0x03, 0x80, 0x60, 0x18, 0x04, 0x01, 0x80,
  0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18,
  0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01,
  0x06, 0x17, 0x3B, 0x81, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x07, 0x00,
  0xE6, 0x18, 0x08, 0x80, 0x2C, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x01, 0x20, 0x18, 0x81, 0x83, 0xF8,
  0x07, 0x09, 0x9C, 0xA0, 0x6C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x02, 0xA0, 0x49, 0xF8,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x06,
  0x03, 0xDD, 0x60, 0x34, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x60, 0x51, 0xF9, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x06, 0xBB,
  0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x07, 0x07, 0x3D, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x13, 0xFC,
  0x10, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x03, 0xE0, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x14, 0x01, 0x40, 0x36, 0x05, 0x3F, 0x90, 0xC0, 0x1A, 0x00,
  0x90, 0x04, 0xC0, 0x42, 0x02, 0x10, 0x10, 0x41, 0x02, 0x08, 0x18, 0xC0,
  0x44, 0x02, 0x20, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x08, 0x00, 0xC0, 0x20,
  0x14, 0x07, 0x03, 0x40, 0x50, 0x22, 0x05, 0x02, 0x20, 0x98, 0x22, 0x08,
  0x84, 0x30, 0x88, 0x41, 0x10, 0x84, 0x11, 0x04, 0x41, 0x10, 0x48, 0x0A,
  0x04, 0x80, 0xA0, 0x28, 0x0A, 0x03, 0x80, 0xC0, 0x30, 0x04, 0x01, 0x00,
  0xC0, 0x36, 0x06, 0x20, 0x41, 0x08, 0x19, 0x80, 0x90, 0x06, 0x00, 0x60,
  0x0F, 0x00, 0x90, 0x10, 0x82, 0x04, 0x60, 0x64, 0x02, 0x80, 0x10, 0xC0,
  0x1A, 0x00, 0x90, 0x04, 0xC0, 0x42, 0x02, 0x10, 0x10, 0x41, 0x02, 0x08,
  0x18, 0xC0, 0x44, 0x02, 0x20, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x78, 0x00, 0x7F,
  0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03,
  0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x3F, 0xF8, 0x01, 0x0E, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30, 0xE0, 0xE0, 0x30, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0F, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x70, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x0C, 0x07, 0x07, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x18, 0xF0, 0x80, 0x30, 0x06, 0x70, 0x60, 0x7C,
};

const GFXglyph NotoSans_ExtraLight29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 21, 7, 2, -21 },
  { 7, 6, 8, 10, 2, -21 },
  { 13, 17, 21, 19, 1, -21 },
  { 58, 12, 24, 17, 2, -22 },
  { 94, 20, 21, 23, 2, -21 },
  { 147, 18, 21, 21, 2, -21 },
  { 195, 1, 8, 5, 2, -21 },
  { 196, 6, 26, 8, 1, -21 },
  { 216, 5, 26, 8, 1, -21 },
  { 233, 12, 12, 16, 2, -22 },
  { 251, 13, 13, 17, 2, -17 },
  { 273, 3, 7, 6, 1, -3 },
  { 276, 7, 1, 9, 1, -8 },
  { 277, 2, 2, 7, 2, -2 },
  { 278, 9, 21, 10, 0, -21 },
  { 302, 13, 21, 17, 2, -21 },
  { 337, 6, 21, 17, 3, -21 },
  { 353, 12, 21, 17, 2, -21 },
  { 385, 13, 21, 17, 1, -21 },
  { 420, 15, 21, 17, 1, -21 },
  { 460, 13, 21, 17, 2, -21 },
  { 495, 13, 21, 17, 2, -21 },
  { 530, 13, 21, 17, 2, -21 },
  { 565, 13, 21, 17, 2, -21 },
  { 600, 13, 21, 17, 2, -21 },
  { 635, 2, 16, 7, 2, -16 },
  { 639, 3, 20, 7, 1, -16 },
  { 647, 13, 13, 17, 2, -17 },
  { 669, 13, 7, 17, 2, -14 },
  { 681, 13, 13, 17, 2, -17 },
  { 703, 10, 21, 12, 1, -21 },
  { 730, 22, 24, 26, 2, -21 },
  { 796, 17, 21, 17, 0, -21 },
  { 841, 13, 21, 18, 3, -21 },
  { 876, 15, 21, 18, 2, -21 },
  { 916, 15, 21, 20, 3, -21 },
  { 956, 11, 21, 16, 3, -21 },
  { 985, 11, 21, 14, 3, -21 },
  { 1014, 17, 21, 21, 2, -21 },
  { 1059, 15, 21, 21, 3, -21 },
  { 1099, 5, 21, 9, 2, -21 },
  { 1113, 7, 26, 7, -3, -21 },
  { 1136, 14, 21, 17, 3, -21 },
  { 1173, 11, 21, 15, 3, -21 },
  { 1202, 19, 21, 25, 3, -21 },
  { 1252, 15, 21, 21, 3, -21 },
  { 1292, 18, 21, 22, 2, -21 },
  { 1340, 12, 21, 17, 3, -21 },
  { 1372, 18, 26, 22, 2, -21 },
  { 1431, 13, 21, 17, 3, -21 },
  { 1466, 12, 21, 16, 2, -21 },
  { 1498, 15, 21, 15, 0, -21 },
  { 1538, 15, 21, 21, 3, -21 },
  { 1578, 17, 21, 17, 0, -21 },
  { 1623, 24, 21, 26, 1, -21 },
  { 1686, 15, 21, 15, 0, -21 },
  { 1726, 15, 21, 15, 0, -21 },
  { 1766, 15, 21, 17, 1, -21 },
  { 1806, 6, 26, 9, 2, -21 },
  { 1826, 9, 21, 10, 0, -21 },
  { 1850, 6, 26, 9, 1, -21 },
  { 1870, 14, 13, 17, 1, -21 },
  { 1893, 12, 1, 12, 0, 3 },
  { 1895, 5, 4, 7, 1, -22 },
  { 1898, 12, 16, 15, 1, -16 },
  { 1922, 12, 22, 17, 3, -22 },
  { 1955, 11, 16, 14, 2, -16 },
  { 1977, 13, 22, 17, 2, -22 },
  { 2013, 12, 16, 16, 2, -16 },
  { 2037, 10, 22, 8, 0, -22 },
  { 2065, 13, 23, 17, 2, -16 },
  { 2103, 11, 22, 17, 3, -22 },
  { 2134, 2, 21, 6, 2, -21 },
  { 2140, 5, 28, 6, -1, -21 },
  { 2158, 11, 22, 14, 3, -22 },
  { 2189, 1, 22, 6, 3, -22 },
  { 2192, 20, 16, 25, 3, -16 },
  { 2232, 11, 16, 17, 3, -16 },
  { 2254, 13, 16, 17, 2, -16 },
  { 2280, 12, 23, 17, 3, -16 },
  { 2315, 12, 23, 17, 2, -16 },
  { 2350, 8, 16, 11, 3, -16 },
  { 2366, 11, 16, 13, 1, -16 },
  { 2388, 9, 19, 10, 0, -19 },
  { 2410, 12, 15, 17, 2, -15 },
  { 2433, 13, 15, 13, 0, -15 },
  { 2458, 20, 15, 20, 0, -15 },
  { 2496, 12, 15, 14, 1, -15 },
  { 2519, 13, 22, 13, 0, -15 },
  { 2555, 11, 15, 13, 1, -15 },
  { 2576, 8, 26, 10, 1, -21 },
  { 2602, 1, 29, 16, 7, -22 },
  { 2606, 8, 26, 10, 1, -21 },
  { 2632, 13, 3, 17, 2, -12 },
};

const GFXfont NotoSans_ExtraLight29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRALIGHT29PT7B_H_
