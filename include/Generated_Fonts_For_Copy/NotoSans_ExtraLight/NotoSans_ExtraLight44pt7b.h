#ifndef _NOTOSANS_EXTRALIGHT44PT7B_H_
#define _NOTOSANS_EXTRALIGHT44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight44pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x00, 0x0D,
  0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0x60,
  0xB0, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x02, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x80, 0x20, 0x00, 0x20, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01,
  0x00, 0x01, 0x80, 0x40, 0x00, 0x40, 0x10, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x20, 0x08, 0x00,
  0x08, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x10,
  0x00, 0x10, 0x04, 0x00, 0x04, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xC0,
  0x30, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x00, 0x80, 0x00,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x04, 0x00, 0x06, 0x01, 0x00,
  0x01, 0x00, 0x40, 0x00, 0x40, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1E, 0x00, 0x3F, 0xFC, 0x38, 0xC3, 0x98, 0x30, 0x0C, 0x0C, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0,
  0x18, 0x30, 0x03, 0x8C, 0x00, 0x7B, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x0F, 0xC0, 0x03, 0x1C, 0x00, 0xC3, 0x80, 0x30, 0x60, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1,
  0xA0, 0x30, 0xCF, 0xCF, 0xE0, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0C, 0x06,
  0x0C, 0x00, 0x60, 0x10, 0x18, 0x01, 0x80, 0xC0, 0x60, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x20, 0x0C, 0x04, 0x00, 0x80, 0x30,
  0x30, 0x02, 0x00, 0xC0, 0x80, 0x08, 0x03, 0x06, 0x00, 0x20, 0x0C, 0x30,
  0x00, 0x80, 0x30, 0xC0, 0x02, 0x00, 0x86, 0x1F, 0x8C, 0x02, 0x10, 0xC7,
  0x30, 0x18, 0xC6, 0x0C, 0x40, 0x62, 0x30, 0x19, 0x83, 0x18, 0xC0, 0x63,
  0xF8, 0x42, 0x00, 0x83, 0xC3, 0x08, 0x03, 0x00, 0x18, 0x20, 0x0C, 0x00,
  0x61, 0x80, 0x30, 0x03, 0x06, 0x00, 0xC0, 0x08, 0x18, 0x03, 0x00, 0x60,
  0x20, 0x0C, 0x01, 0x00, 0x80, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x0C,
  0x06, 0x01, 0x80, 0x30, 0x18, 0x0C, 0x00, 0x60, 0x40, 0x30, 0x01, 0xC7,
  0x01, 0x80, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0x00,
  0x06, 0x00, 0x20, 0x00, 0xC0, 0x04, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00,
  0x30, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0x07, 0x00, 0x18, 0xC0, 0x70, 0x03, 0x30, 0x07, 0x00, 0x4C,
  0x00, 0x70, 0x19, 0x80, 0x07, 0x02, 0x30, 0x00, 0x70, 0xC4, 0x00, 0x07,
  0x18, 0x80, 0x00, 0x76, 0x18, 0x00, 0x07, 0x83, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x1F, 0x06, 0x00, 0x06, 0x60, 0x60, 0x03, 0x86, 0x07, 0x81, 0xE0,
  0x60, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0x06, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x30, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60,
  0x20, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0xC0, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x02, 0x02, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x60, 0x60, 0xC0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x0C, 0x0F, 0xE3, 0x1F, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0x04, 0x80, 0x03, 0x30, 0x01, 0x86, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x18,
  0x06, 0x02, 0x01, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x33, 0x36, 0x66, 0x64, 0xCC, 0x80, 0xFF, 0xFF, 0xF0, 0xDF, 0x00, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x70, 0x1C, 0x0C, 0x00, 0xC3,
  0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x32, 0x00, 0x02, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x40,
  0x00, 0x6C, 0x00, 0x09, 0x80, 0x03, 0x18, 0x00, 0x43, 0x00, 0x18, 0x30,
  0x06, 0x03, 0x83, 0x80, 0x3F, 0xE0, 0x00, 0xC0, 0xF0, 0x74, 0x31, 0x38,
  0x7C, 0x14, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0xF0, 0x03,
  0xFF, 0x81, 0xE0, 0x18, 0x70, 0x01, 0x84, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x38, 0x03, 0x8E, 0x00, 0x1C, 0x40,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC8, 0x00, 0x18, 0xF8, 0x0F, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x20, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0x86,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x7F, 0x00, 0xFF, 0xFC, 0x08, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC8, 0x00, 0x39, 0xF0, 0x3C, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x3F, 0xE0, 0xCE, 0x07,
  0x0D, 0x80, 0x1C, 0xF0, 0x00, 0xCE, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40,
  0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xC1,
  0xC0, 0x18, 0x0E, 0x07, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x60, 0x0C,
  0x18, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x32, 0x00, 0x02,
  0x40, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0xC1, 0x80, 0x30,
  0x1C, 0x1C, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0x3C, 0x03, 0x80, 0xE0,
  0xC0, 0x06, 0x30, 0x00, 0x6C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x36,
  0x00, 0x0C, 0x60, 0x03, 0x07, 0x01, 0xC0, 0x3F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x1C, 0x03, 0x03, 0x80, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x04,
  0x60, 0x00, 0x64, 0x00, 0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00,
  0x07, 0x30, 0x00, 0xB1, 0x80, 0x3B, 0x0F, 0xFE, 0x30, 0x3F, 0x83, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x20, 0x3C, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x5B, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xBE, 0x11, 0x8E, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x19, 0x8C, 0x62, 0x31, 0x88, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x60, 0x1C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x7F,
  0xE0, 0x32, 0x00, 0x70, 0x30, 0x0D, 0x80, 0x30, 0x04, 0x03, 0x60, 0x18,
  0x01, 0x00, 0x50, 0x0C, 0x00, 0x40, 0x14, 0x03, 0x00, 0x10, 0x07, 0x00,
  0x80, 0x04, 0x01, 0xC0, 0x60, 0x01, 0x00, 0x70, 0x18, 0x00, 0x40, 0x1C,
  0x06, 0x00, 0x30, 0x07, 0x01, 0x80, 0x0C, 0x03, 0xC0, 0x20, 0x03, 0x00,
  0xF0, 0x08, 0x00, 0xC0, 0x34, 0x03, 0x00, 0x50, 0x19, 0x00, 0x60, 0x36,
  0x04, 0x60, 0x1C, 0x38, 0xC7, 0x18, 0x01, 0xF8, 0x1F, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x01, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x04, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x06, 0x00,
  0x3C, 0x30, 0x00, 0x39, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00,
  0x19, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x07, 0x83, 0xFF, 0xF0, 0x18,
  0x01, 0xF0, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00, 0x1C,
  0x7F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF8,
  0x0F, 0x00, 0x38, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0x00,
  0x7F, 0xFC, 0xFF, 0xFE, 0x00, 0xC0, 0x0F, 0x80, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0xE0, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFB, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xB0,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x70, 0x01, 0xE0, 0xE0, 0x00, 0x10, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x23, 0x00, 0x00, 0x10, 0xE0,
  0x00, 0x08, 0x38, 0x00, 0x0C, 0x07, 0xC0, 0x3E, 0x00, 0xFF, 0xFC, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x3F, 0x80, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0xBF, 0xC7, 0xC0, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60,
  0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00,
  0x30, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x36,
  0x00, 0x1B, 0x18, 0x00, 0xF0, 0xE0, 0x07, 0x03, 0x00, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00,
  0xE0, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x01, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF4, 0x00, 0x00, 0x1F, 0xB0, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x0D,
  0xE6, 0x00, 0x00, 0x6F, 0x30, 0x00, 0x02, 0x78, 0x80, 0x00, 0x33, 0xC6,
  0x00, 0x01, 0x1E, 0x30, 0x00, 0x18, 0xF0, 0xC0, 0x00, 0xC7, 0x86, 0x00,
  0x04, 0x3C, 0x10, 0x00, 0x61, 0xE0, 0xC0, 0x02, 0x0F, 0x06, 0x00, 0x30,
  0x78, 0x18, 0x01, 0x83, 0xC0, 0xC0, 0x18, 0x1E, 0x02, 0x00, 0xC0, 0xF0,
  0x18, 0x04, 0x07, 0x80, 0xC0, 0x60, 0x3C, 0x03, 0x03, 0x01, 0xE0, 0x18,
  0x30, 0x0F, 0x00, 0x41, 0x80, 0x78, 0x03, 0x08, 0x03, 0xC0, 0x18, 0xC0,
  0x1E, 0x00, 0x66, 0x00, 0xF0, 0x03, 0x60, 0x07, 0x80, 0x0B, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x60, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0xC0, 0x00, 0x3D, 0x80,
  0x00, 0x79, 0x80, 0x00, 0xF1, 0x80, 0x01, 0xE3, 0x00, 0x03, 0xC3, 0x00,
  0x07, 0x83, 0x00, 0x0F, 0x06, 0x00, 0x1E, 0x06, 0x00, 0x3C, 0x06, 0x00,
  0x78, 0x0C, 0x00, 0xF0, 0x0C, 0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x1C, 0x07,
  0x80, 0x18, 0x0F, 0x00, 0x18, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x30, 0x78,
  0x00, 0x30, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0x63, 0xC0, 0x00, 0x67, 0x80,
  0x00, 0xEF, 0x00, 0x00, 0xDE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x30, 0x00, 0x01, 0x82, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x18,
  0x03, 0xE3, 0x00, 0x0E, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x38, 0xFF,
  0xFC, 0x1F, 0xFC, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00,
  0x60, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x0C, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xE0, 0x78, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFC, 0x06, 0x00, 0xF8, 0x30, 0x00, 0x61,
  0x80, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x8C,
  0x00, 0x0C, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x0F, 0xC0, 0xFF, 0xF8,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60,
  0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x30, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00,
  0x00, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x1C, 0x00, 0xE3, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC8, 0x00, 0x1C, 0xF8, 0x0F, 0x03, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xA0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x31, 0xC0, 0x00,
  0xC1, 0xC0, 0x03, 0x01, 0xF0, 0x3C, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0x40, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x04, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x11, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x1B, 0x00, 0x03, 0x80, 0x01, 0x98, 0x00, 0x1C, 0x00,
  0x0C, 0xC0, 0x01, 0xA0, 0x00, 0x62, 0x00, 0x0D, 0x80, 0x06, 0x18, 0x00,
  0x4C, 0x00, 0x30, 0xC0, 0x02, 0x60, 0x01, 0x86, 0x00, 0x31, 0x00, 0x08,
  0x10, 0x01, 0x8C, 0x00, 0xC0, 0xC0, 0x08, 0x60, 0x06, 0x06, 0x00, 0xC1,
  0x00, 0x30, 0x10, 0x06, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x60, 0x18, 0x06,
  0x01, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x08, 0x06, 0x00, 0x80, 0xC0, 0x60,
  0x60, 0x06, 0x04, 0x03, 0x03, 0x00, 0x30, 0x60, 0x08, 0x18, 0x01, 0x83,
  0x00, 0x60, 0x80, 0x04, 0x18, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x18, 0x60,
  0x01, 0x8C, 0x00, 0x43, 0x00, 0x0C, 0x60, 0x03, 0x30, 0x00, 0x22, 0x00,
  0x19, 0x80, 0x01, 0x90, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x02, 0x40, 0x00,
  0x2C, 0x00, 0x1E, 0x00, 0x01, 0x40, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x30, 0x60, 0x00, 0x40, 0xC0, 0x01, 0x80, 0xC0,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x06, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xC8, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x60, 0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x00, 0xC2, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x61, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x18, 0x06, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x26, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x0F, 0xFF, 0xFC, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0xFF,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x10,
  0x00, 0x60, 0xC0, 0x03, 0x02, 0x00, 0x30, 0x18, 0x01, 0x80, 0x40, 0x18,
  0x03, 0x00, 0x80, 0x08, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x06, 0x00, 0x0C,
  0x20, 0x00, 0x23, 0x00, 0x01, 0x90, 0x00, 0x05, 0x80, 0x00, 0x30, 0xFF,
  0xFF, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0xE0, 0x07,
  0xFF, 0x0F, 0x01, 0xC4, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x7F, 0xF0, 0xF8,
  0x09, 0xC0, 0x05, 0x80, 0x02, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x2B, 0x00, 0x24, 0xE0, 0xE2, 0x3F, 0xE1,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x3E, 0x03,
  0x1F, 0xF8, 0x66, 0x03, 0x8D, 0x80, 0x19, 0xE0, 0x01, 0xA8, 0x00, 0x37,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x6E, 0x00, 0x0D, 0x60, 0x03, 0x26,
  0x00, 0xE4, 0x70, 0x70, 0x87, 0xFC, 0x00, 0x00, 0x7C, 0x07, 0xFF, 0x0E,
  0x01, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x03, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x3E, 0x0C, 0x3F, 0xF1, 0x8E, 0x03, 0xB3,
  0x80, 0x16, 0xE0, 0x01, 0xD8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x76, 0x00, 0x0E, 0xC0, 0x03, 0x4E, 0x00, 0xC8, 0xF0, 0x71, 0x07,
  0xFC, 0x20, 0x00, 0xF0, 0x01, 0xFF, 0x01, 0xC0, 0x70, 0xE0, 0x0C, 0x30,
  0x01, 0x98, 0x00, 0x24, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x18, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x10, 0xE0, 0x38, 0x1F, 0xFC, 0x00, 0x78, 0x0F, 0xF0,
  0x70, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x3F, 0xF8, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0xC4, 0x70, 0x1D, 0x98, 0x00, 0xF7, 0x00, 0x0E, 0xC0, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xB0, 0x00, 0x77, 0x00, 0x1E, 0x70, 0x06,
  0xC7, 0x83, 0x98, 0x3F, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x32, 0x00, 0x0C,
  0x78, 0x07, 0x07, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x3C, 0x0C, 0x7F, 0xE3, 0x70, 0x1C, 0xD0,
  0x01, 0xB8, 0x00, 0x6E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x7D,
  0x80, 0x00, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x03,
  0x07, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x02, 0x06, 0x0E, 0xFC, 0x30, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0xB0, 0x01, 0x98, 0x01, 0x8C, 0x01, 0x86, 0x01, 0x83,
  0x01, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x18, 0xC0,
  0x0C, 0xE0, 0x06, 0xD8, 0x03, 0xC6, 0x01, 0xC1, 0x80, 0xC0, 0xC0, 0x60,
  0x30, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0x63, 0x00, 0x19,
  0x80, 0x06, 0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xE0, 0x07, 0x81, 0x1F, 0xF0, 0x3F, 0xE2, 0x70, 0x31,
  0xC0, 0xE5, 0x80, 0x36, 0x00, 0x6E, 0x00, 0x28, 0x00, 0xDC, 0x00, 0x70,
  0x00, 0xB0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x00,
  0x07, 0x80, 0x06, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x3C, 0x00, 0x30, 0x00, 0x78, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xC0, 0x01,
  0xE0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x00, 0x07, 0x80, 0x06, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x1E, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x78,
  0x00, 0x60, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0x80, 0x03, 0x01,
  0xF0, 0x21, 0xFF, 0x88, 0xC0, 0x72, 0x40, 0x06, 0xE0, 0x01, 0xB8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x1C, 0x03,
  0x03, 0x80, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00,
  0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x06, 0x40, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x18,
  0x0E, 0x07, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x10, 0xFF, 0xC2, 0x30, 0x1C,
  0x4C, 0x00, 0xCF, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0x70, 0x00, 0x6F, 0x00, 0x19, 0xB0, 0x07, 0x33, 0x83, 0xC6,
  0x3F, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE3, 0x0E, 0x03, 0x31, 0x80, 0x0B,
  0x30, 0x00, 0xF3, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x03, 0x60, 0x00,
  0x34, 0x00, 0x03, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60,
  0x00, 0x73, 0x00, 0x07, 0x30, 0x00, 0xF1, 0x80, 0x1B, 0x0E, 0x07, 0x30,
  0x7F, 0xC3, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x01, 0xE8, 0x7F, 0xDC, 0x0D, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x03, 0xE0, 0x1F, 0xFF, 0x38, 0x06, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x80, 0x06, 0xF0,
  0x1C, 0x7F, 0xF8, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x03, 0xFF, 0xE1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x10, 0x3F, 0x80, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0B,
  0x60, 0x06, 0xCE, 0x07, 0x31, 0xFF, 0x0C, 0xC0, 0x00, 0x74, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x08, 0x10, 0x01,
  0x81, 0x80, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x40,
  0x60, 0x06, 0x06, 0x00, 0x60, 0x40, 0x02, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x18, 0x00, 0x19, 0x80, 0x01, 0x90, 0x00, 0x0B, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x06, 0xC0, 0x0B, 0x00, 0x26, 0x00, 0xC8, 0x03, 0x30,
  0x06, 0x40, 0x18, 0x80, 0x23, 0x00, 0xC6, 0x03, 0x18, 0x04, 0x30, 0x18,
  0x40, 0x61, 0x80, 0x83, 0x03, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x40,
  0x81, 0x82, 0x03, 0x0C, 0x04, 0x30, 0x18, 0x60, 0x31, 0x80, 0x42, 0x01,
  0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x19, 0x80, 0x26, 0x00, 0x4C, 0x01, 0xB0,
  0x03, 0x40, 0x0D, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xE6, 0x00, 0x38, 0xC0, 0x06,
  0x0C, 0x01, 0x80, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x18, 0xC0,
  0x01, 0x98, 0x00, 0x16, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0B, 0x00,
  0x03, 0x30, 0x00, 0xC6, 0x00, 0x30, 0x60, 0x06, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x18,
  0xC0, 0x00, 0x74, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x08, 0x10, 0x01, 0x81, 0x80, 0x18, 0x18, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x00, 0x40, 0x60, 0x06, 0x06, 0x00, 0x60, 0x40, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x01, 0x18, 0x00, 0x19, 0x80, 0x01, 0x90, 0x00,
  0x0B, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x3C, 0x01, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1F, 0x80,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x03, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x1F, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0xF8, 0x0E, 0x00, 0x0F, 0x00,
  0x01, 0xFE, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00,
};

const GFXglyph NotoSans_ExtraLight44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 31, 10, 4, -31 },
  { 13, 9, 11, 15, 3, -31 },
  { 26, 26, 31, 28, 1, -31 },
  { 127, 18, 36, 25, 3, -33 },
  { 208, 30, 32, 35, 3, -32 },
  { 328, 27, 32, 31, 3, -32 },
  { 436, 2, 11, 8, 3, -31 },
  { 439, 8, 38, 12, 2, -31 },
  { 477, 8, 38, 12, 2, -31 },
  { 515, 18, 18, 24, 3, -33 },
  { 556, 21, 21, 25, 2, -26 },
  { 612, 4, 11, 9, 2, -5 },
  { 618, 10, 2, 14, 2, -13 },
  { 621, 3, 3, 10, 4, -3 },
  { 623, 13, 31, 15, 1, -31 },
  { 674, 19, 32, 25, 3, -32 },
  { 750, 10, 31, 25, 4, -31 },
  { 789, 19, 32, 25, 3, -32 },
  { 865, 20, 32, 25, 2, -32 },
  { 945, 24, 32, 25, 1, -32 },
  { 1041, 19, 31, 25, 3, -31 },
  { 1115, 20, 32, 25, 3, -32 },
  { 1195, 21, 31, 25, 2, -31 },
  { 1277, 19, 32, 25, 3, -32 },
  { 1353, 20, 33, 25, 2, -32 },
  { 1436, 3, 24, 10, 4, -24 },
  { 1445, 5, 30, 10, 2, -24 },
  { 1464, 21, 20, 25, 2, -26 },
  { 1517, 21, 11, 25, 2, -21 },
  { 1546, 21, 20, 25, 2, -26 },
  { 1599, 16, 32, 18, 1, -32 },
  { 1663, 34, 35, 39, 2, -31 },
  { 1812, 26, 32, 26, 0, -32 },
  { 1916, 21, 31, 27, 4, -31 },
  { 1998, 23, 32, 27, 3, -32 },
  { 2090, 24, 31, 31, 4, -31 },
  { 2183, 18, 31, 24, 4, -31 },
  { 2253, 18, 31, 22, 4, -31 },
  { 2323, 25, 32, 32, 3, -32 },
  { 2423, 23, 31, 31, 4, -31 },
  { 2513, 7, 31, 13, 3, -31 },
  { 2541, 10, 39, 11, -4, -31 },
  { 2590, 21, 31, 25, 4, -31 },
  { 2672, 18, 31, 22, 4, -31 },
  { 2742, 29, 31, 37, 4, -31 },
  { 2855, 23, 31, 31, 4, -31 },
  { 2945, 28, 32, 33, 3, -32 },
  { 3057, 19, 31, 26, 4, -31 },
  { 3131, 28, 39, 33, 3, -32 },
  { 3268, 21, 31, 26, 4, -31 },
  { 3350, 20, 32, 24, 2, -32 },
  { 3430, 23, 31, 23, 0, -31 },
  { 3520, 23, 31, 32, 4, -31 },
  { 3610, 25, 31, 25, 0, -31 },
  { 3707, 37, 31, 39, 1, -31 },
  { 3851, 23, 31, 23, 0, -31 },
  { 3941, 23, 31, 23, 0, -31 },
  { 4031, 22, 31, 25, 2, -31 },
  { 4117, 9, 38, 14, 4, -31 },
  { 4160, 13, 31, 15, 1, -31 },
  { 4211, 9, 38, 14, 1, -31 },
  { 4254, 21, 20, 25, 2, -32 },
  { 4307, 18, 1, 18, 0, 4 },
  { 4310, 8, 7, 11, 2, -34 },
  { 4317, 17, 24, 23, 2, -24 },
  { 4368, 19, 33, 26, 4, -33 },
  { 4447, 16, 24, 21, 3, -24 },
  { 4495, 19, 33, 26, 3, -33 },
  { 4574, 18, 24, 24, 3, -24 },
  { 4628, 14, 34, 13, 1, -34 },
  { 4688, 19, 35, 26, 3, -24 },
  { 4772, 18, 33, 26, 4, -33 },
  { 4847, 3, 32, 10, 3, -32 },
  { 4859, 8, 43, 10, -2, -32 },
  { 4902, 17, 33, 21, 4, -33 },
  { 4973, 2, 33, 10, 4, -33 },
  { 4982, 31, 24, 38, 4, -24 },
  { 5075, 18, 24, 26, 4, -24 },
  { 5129, 20, 24, 26, 3, -24 },
  { 5189, 19, 34, 26, 4, -24 },
  { 5270, 20, 34, 26, 2, -24 },
  { 5355, 12, 24, 17, 4, -24 },
  { 5391, 16, 24, 20, 2, -24 },
  { 5439, 13, 29, 14, 0, -29 },
  { 5487, 18, 23, 26, 4, -23 },
  { 5539, 20, 23, 20, 0, -23 },
  { 5597, 29, 23, 31, 1, -23 },
  { 5681, 19, 23, 22, 1, -23 },
  { 5736, 20, 34, 20, 0, -23 },
  { 5821, 16, 23, 20, 2, -23 },
  { 5867, 13, 38, 15, 1, -31 },
  { 5929, 2, 45, 24, 11, -34 },
  { 5941, 12, 38, 15, 2, -31 },
  { 5998, 21, 5, 25, 2, -18 },
};

const GFXfont NotoSans_ExtraLight44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRALIGHT44PT7B_H_
