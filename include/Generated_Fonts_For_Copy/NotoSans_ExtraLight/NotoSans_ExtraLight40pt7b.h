#ifndef _NOTOSANS_EXTRALIGHT40PT7B_H_
#define _NOTOSANS_EXTRALIGHT40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight40pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDA, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x01, 0x7E,
  0xC3, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x82, 0x82, 0x82, 0x82, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00,
  0x40, 0x20, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x40, 0x00,
  0x80, 0x40, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x01,
  0x80, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x03, 0x01, 0x00, 0x02, 0x01, 0x00, 0xFF, 0xFF, 0xFC, 0x02,
  0x01, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x04, 0x02, 0x00, 0x04,
  0x02, 0x00, 0x04, 0x02, 0x00, 0x04, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x04, 0x00, 0x01, 0x00, 0x01, 0x00, 0x07, 0xF0, 0x3F, 0xFE, 0x71, 0x06,
  0xC1, 0x00, 0xC1, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00,
  0xC1, 0x00, 0x61, 0x00, 0x39, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x01, 0x1C, 0x01, 0x06, 0x01, 0x03, 0x01, 0x03, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x01, 0x03, 0x01, 0x02, 0x81, 0x06, 0xF1, 0x3C, 0x7F, 0xF0,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x06, 0x03, 0xB8, 0x00,
  0x40, 0x20, 0xC0, 0x0C, 0x06, 0x06, 0x01, 0x80, 0x40, 0x60, 0x10, 0x04,
  0x02, 0x03, 0x00, 0xC0, 0x20, 0x20, 0x0C, 0x02, 0x06, 0x00, 0xC0, 0x20,
  0x40, 0x0C, 0x02, 0x0C, 0x00, 0xC0, 0x20, 0x80, 0x0C, 0x02, 0x18, 0x20,
  0x40, 0x21, 0x1F, 0x84, 0x06, 0x23, 0x0C, 0x60, 0x66, 0x20, 0x62, 0x0C,
  0x46, 0x02, 0x3B, 0x8C, 0x40, 0x20, 0xF0, 0x84, 0x03, 0x00, 0x18, 0x40,
  0x30, 0x01, 0x04, 0x03, 0x00, 0x30, 0x40, 0x30, 0x02, 0x04, 0x03, 0x00,
  0x40, 0x40, 0x30, 0x0C, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20, 0x18, 0x06,
  0x06, 0x01, 0x00, 0x20, 0x60, 0x30, 0x03, 0x0C, 0x06, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x03, 0x80, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0x80, 0x10, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x04, 0x00, 0x10, 0x02,
  0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x00, 0x01, 0x83, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x38, 0x18, 0x03, 0x10, 0x06, 0x01, 0x98, 0x01, 0x80, 0x88,
  0x00, 0x60, 0xC4, 0x00, 0x18, 0x66, 0x00, 0x06, 0x63, 0x00, 0x01, 0xA0,
  0x80, 0x00, 0x70, 0x60, 0x00, 0x38, 0x30, 0x00, 0x36, 0x0C, 0x00, 0x71,
  0x83, 0x80, 0xE0, 0x60, 0x7F, 0xC0, 0x18, 0xFA, 0xAA, 0xA8, 0x06, 0x08,
  0x30, 0xC1, 0x06, 0x08, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x60, 0xC0, 0x81, 0x03, 0x02, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C,
  0x04, 0x04, 0x06, 0x06, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08,
  0x18, 0x30, 0x30, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x10, 0x30, 0x2F, 0x88, 0x7C, 0x7E, 0xF8, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x12, 0x00, 0x0C, 0xC0, 0x06, 0x18, 0x03, 0x02, 0x00,
  0xC0, 0xC0, 0x60, 0x18, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x32,
  0x66, 0x64, 0x4C, 0x88, 0xFF, 0xFF, 0xC0, 0x5F, 0x80, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x01,
  0xEF, 0x00, 0xC0, 0x60, 0x60, 0x0C, 0x30, 0x01, 0x88, 0x00, 0x66, 0x00,
  0x09, 0x80, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x14, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0xD8, 0x00, 0x36, 0x00,
  0x08, 0x80, 0x02, 0x30, 0x01, 0x84, 0x00, 0x41, 0x80, 0x30, 0x38, 0x38,
  0x03, 0xF8, 0x00, 0x00, 0x81, 0xC1, 0xA1, 0x93, 0x8B, 0x07, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x03, 0xF0, 0x07, 0xDF, 0x03, 0x00, 0x61, 0x80, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x07, 0xDF, 0x07, 0x00,
  0x63, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x68, 0x00, 0x33, 0xC0, 0x38, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x1A, 0x00, 0x01,
  0x90, 0x00, 0x08, 0x80, 0x00, 0xC4, 0x00, 0x0C, 0x20, 0x00, 0x41, 0x00,
  0x06, 0x08, 0x00, 0x60, 0x40, 0x06, 0x02, 0x00, 0x20, 0x10, 0x03, 0x00,
  0x80, 0x30, 0x04, 0x03, 0x00, 0x20, 0x10, 0x01, 0x01, 0x80, 0x08, 0x18,
  0x00, 0x40, 0x80, 0x02, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x88, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x05, 0xFF, 0x03, 0xC3, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0xA0, 0x01, 0x9C, 0x03, 0x87, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xF0, 0xC0,
  0xE0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x07, 0x80, 0x87, 0xFC,
  0x26, 0x01, 0x8B, 0x00, 0x33, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x28,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x09, 0x00,
  0x02, 0x60, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0x70, 0x38, 0x07, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF8,
  0x03, 0xEF, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x20, 0x01, 0x98, 0x00, 0x26,
  0x00, 0x09, 0x80, 0x02, 0x20, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x30, 0x30,
  0x18, 0x07, 0x1C, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x38, 0x38, 0x18, 0x03,
  0x0C, 0x00, 0x66, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x05, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x23, 0x00, 0x18, 0x70,
  0x1C, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xDF, 0x01, 0x80, 0x60, 0xC0,
  0x0C, 0x60, 0x01, 0x10, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x76,
  0x00, 0x34, 0xC0, 0x19, 0x1E, 0x1C, 0xC1, 0xFC, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0xC1, 0x00, 0xE0, 0x3F, 0xE0, 0x00, 0xFD, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x7E, 0x39, 0xC4, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x11, 0x8C, 0x63, 0x11, 0x8C, 0x46, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xFF, 0xC4, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x03, 0x01, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x02, 0x18, 0x00, 0x00, 0x06, 0x20, 0x07, 0xFC, 0x04, 0xC0, 0x38, 0x08,
  0x0D, 0x00, 0xC0, 0x10, 0x1A, 0x01, 0x00, 0x20, 0x1C, 0x06, 0x00, 0x40,
  0x38, 0x08, 0x01, 0x80, 0x70, 0x30, 0x03, 0x00, 0xE0, 0x60, 0x06, 0x01,
  0xC0, 0xC0, 0x0C, 0x03, 0x81, 0x80, 0x18, 0x0F, 0x03, 0x00, 0x30, 0x1E,
  0x02, 0x00, 0xE0, 0x2C, 0x06, 0x01, 0x40, 0xC8, 0x06, 0x04, 0xC3, 0x10,
  0x07, 0xF0, 0xFC, 0x30, 0x03, 0x80, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x66, 0x00, 0x00, 0x46, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x81, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x01, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x06,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x08,
  0x00, 0x30, 0x18, 0x00, 0x10, 0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30,
  0x00, 0x08, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0xFF, 0x40, 0x1F, 0xFF, 0x83, 0x00, 0x1C,
  0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x00, 0x8C, 0x00, 0x71,
  0xFF, 0xF8, 0x3F, 0xFF, 0x06, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x1B,
  0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x16,
  0x00, 0x02, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x3F, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x07, 0x00, 0x10, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x07,
  0x01, 0xFF, 0xE0, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x30, 0x03, 0xC1, 0x80,
  0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30,
  0x01, 0xC1, 0x81, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xF3, 0xF8, 0x1C, 0x00,
  0x30, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x90, 0x00,
  0x03, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x3E, 0x01,
  0xF0, 0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFE, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x02, 0x01, 0x80, 0x6C, 0xF3, 0xF0, 0xC0, 0x00, 0xF8, 0x00, 0x33,
  0x00, 0x0E, 0x60, 0x03, 0x8C, 0x00, 0xE1, 0x80, 0x18, 0x30, 0x06, 0x06,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x18, 0x03, 0x06, 0x00, 0x61, 0x80, 0x0C,
  0x60, 0x01, 0x9C, 0x00, 0x36, 0xC0, 0x07, 0x8C, 0x00, 0xE0, 0xC0, 0x18,
  0x18, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x06, 0x60,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7A, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF6, 0x00, 0x00, 0xBD, 0x80, 0x00,
  0x6F, 0x20, 0x00, 0x13, 0xCC, 0x00, 0x0C, 0xF3, 0x00, 0x03, 0x3C, 0x60,
  0x00, 0x8F, 0x18, 0x00, 0x63, 0xC2, 0x00, 0x10, 0xF0, 0xC0, 0x0C, 0x3C,
  0x10, 0x02, 0x0F, 0x06, 0x01, 0x83, 0xC1, 0x80, 0x60, 0xF0, 0x20, 0x10,
  0x3C, 0x0C, 0x0C, 0x0F, 0x01, 0x02, 0x03, 0xC0, 0x61, 0x80, 0xF0, 0x18,
  0x60, 0x3C, 0x02, 0x10, 0x0F, 0x00, 0xCC, 0x03, 0xC0, 0x12, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00,
  0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0xF0,
  0x00, 0x1D, 0x80, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xC6, 0x00, 0x1C,
  0x30, 0x01, 0xC3, 0x00, 0x1C, 0x18, 0x01, 0xC0, 0xC0, 0x1C, 0x0C, 0x01,
  0xC0, 0x60, 0x1C, 0x03, 0x01, 0xC0, 0x30, 0x1C, 0x01, 0x81, 0xC0, 0x0C,
  0x1C, 0x00, 0xC1, 0xC0, 0x06, 0x1C, 0x00, 0x31, 0xC0, 0x03, 0x1C, 0x00,
  0x19, 0xC0, 0x00, 0xDC, 0x00, 0x05, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x10, 0x00, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x03, 0x80, 0x1C, 0x03,
  0x80, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x32, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x08, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x0C, 0x00, 0xF0, 0x1C, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xFC, 0x30, 0x07, 0x98, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x36, 0x00, 0x1B, 0x00, 0x39, 0x81, 0xF0, 0xFF, 0xE0, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x03, 0x03,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x31, 0x80, 0x00, 0x18, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x32, 0x00, 0x00, 0x19, 0x80, 0x00, 0x08, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x00,
  0xF0, 0x1C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x0C, 0x00, 0xE3, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x04, 0xC0, 0x03, 0x30, 0x01, 0x8C,
  0x01, 0xC3, 0xFF, 0xC0, 0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00,
  0x60, 0xC0, 0x08, 0x30, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x03,
  0x30, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x03, 0xFC,
  0x03, 0xEF, 0xE3, 0x80, 0x18, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x33, 0x80,
  0x78, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x58, 0x00, 0x06, 0x60, 0x00, 0x33, 0x80,
  0x03, 0x0E, 0x00, 0x30, 0x3C, 0x07, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x09, 0x00, 0x00, 0x33, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x08, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x40, 0x20, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x04, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x01, 0x00, 0x40, 0x03, 0x01, 0x80, 0x06,
  0x02, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x20, 0x00, 0x18,
  0xC0, 0x00, 0x31, 0x80, 0x00, 0x22, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xD0, 0x00, 0x70, 0x00, 0x6C, 0x00,
  0x28, 0x00, 0x26, 0x00, 0x14, 0x00, 0x31, 0x00, 0x1B, 0x00, 0x18, 0x80,
  0x0C, 0x80, 0x0C, 0x60, 0x04, 0x40, 0x04, 0x30, 0x02, 0x30, 0x06, 0x08,
  0x03, 0x18, 0x03, 0x04, 0x01, 0x04, 0x01, 0x03, 0x00, 0x82, 0x01, 0x81,
  0x80, 0xC1, 0x80, 0xC0, 0x40, 0x60, 0xC0, 0x60, 0x30, 0x20, 0x20, 0x20,
  0x18, 0x10, 0x18, 0x30, 0x04, 0x18, 0x0C, 0x18, 0x02, 0x0C, 0x02, 0x0C,
  0x01, 0x84, 0x01, 0x04, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0x23, 0x00, 0x63,
  0x00, 0x11, 0x00, 0x11, 0x00, 0x0C, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x06,
  0xC0, 0x01, 0x60, 0x01, 0x60, 0x00, 0xA0, 0x00, 0xA0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x11, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x06,
  0x00, 0xC0, 0x10, 0x04, 0x00, 0xC0, 0x60, 0x03, 0x06, 0x00, 0x08, 0x30,
  0x00, 0x63, 0x00, 0x01, 0x90, 0x00, 0x0D, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0A, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0x60, 0x00, 0x41, 0x00,
  0x06, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x30, 0x06, 0x03, 0x00,
  0x18, 0x18, 0x00, 0xC1, 0x80, 0x03, 0x08, 0x00, 0x08, 0xC0, 0x00, 0x6C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x1A, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x40,
  0x00, 0xC3, 0x00, 0x06, 0x08, 0x00, 0x60, 0x60, 0x02, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x00, 0x30, 0x18, 0x01, 0x80, 0x80, 0x06, 0x0C, 0x00, 0x10,
  0xC0, 0x00, 0xC6, 0x00, 0x02, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F,
  0xE0, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF,
  0x00, 0x40, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0xD8, 0x00, 0x11, 0x00,
  0x06, 0x30, 0x00, 0x82, 0x00, 0x30, 0x60, 0x04, 0x04, 0x01, 0x80, 0xC0,
  0x20, 0x08, 0x0C, 0x01, 0x81, 0x00, 0x10, 0x60, 0x03, 0x08, 0x00, 0x23,
  0x00, 0x06, 0x40, 0x00, 0x58, 0x00, 0x0C, 0xFF, 0xFF, 0xC1, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x80, 0x00, 0x80, 0x1F, 0xF8, 0x38, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x03, 0xFF, 0x1F, 0x03, 0x30, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x40, 0x1B, 0x70, 0x33, 0x3F, 0xE3,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0xC0, 0x47, 0xFC, 0x26, 0x03, 0x16,
  0x00, 0xCE, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0x60, 0x01, 0xB8, 0x00, 0xD6, 0x00, 0xC9,
  0x81, 0xC4, 0x7F, 0x80, 0x00, 0x30, 0x03, 0xFF, 0x0E, 0x01, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x03, 0x07, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0xE0, 0x41, 0xFF, 0x10, 0xC0,
  0x64, 0x60, 0x0D, 0x30, 0x01, 0x58, 0x00, 0x76, 0x00, 0x0D, 0x00, 0x03,
  0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x73, 0x00,
  0x14, 0xE0, 0x0D, 0x1C, 0x0E, 0x41, 0xFE, 0x10, 0x00, 0x40, 0x03, 0xFE,
  0x03, 0x01, 0x83, 0x00, 0x63, 0x00, 0x11, 0x00, 0x0D, 0x80, 0x06, 0x80,
  0x01, 0x40, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x38, 0x3F, 0xF8, 0x00, 0x30, 0x07, 0xF0, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x0F, 0xFE, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x11, 0xC0, 0x64, 0x60, 0x0D, 0x30,
  0x01, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D,
  0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x73, 0x00, 0x14, 0xE0, 0x0F, 0x1C,
  0x0E, 0xC1, 0xFE, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x0C, 0x01, 0xC3, 0xFF, 0xC0,
  0x03, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x81, 0x80, 0x8F, 0xF8, 0x98, 0x0C,
  0xA0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xDF, 0x00, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x06, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x06, 0x0C, 0xFC, 0x60, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x1A, 0x00,
  0x64, 0x01, 0x88, 0x06, 0x10, 0x18, 0x20, 0x60, 0x41, 0x80, 0x86, 0x01,
  0x18, 0x02, 0x70, 0x04, 0xB0, 0x0A, 0x30, 0x18, 0x30, 0x20, 0x60, 0x40,
  0x60, 0x80, 0x61, 0x00, 0x62, 0x00, 0xC4, 0x00, 0xC8, 0x00, 0xD0, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x0C, 0x11, 0xFE, 0x0F, 0xF2,
  0xE0, 0xE7, 0x03, 0x50, 0x04, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x00, 0x80, 0x8F, 0xF8,
  0x98, 0x0C, 0xB0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x30, 0x1C, 0x0C,
  0x00, 0xC3, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x32, 0x00, 0x02, 0x40,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xD0, 0x00, 0x1A, 0x00, 0x02, 0x60, 0x00, 0xC4, 0x00, 0x18, 0xC0,
  0x06, 0x0C, 0x01, 0x80, 0xE0, 0x60, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x47,
  0xFC, 0x26, 0x03, 0x16, 0x00, 0xCA, 0x00, 0x36, 0x00, 0x0B, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xB8,
  0x00, 0xD6, 0x00, 0xC9, 0xC1, 0xC4, 0x7F, 0xC2, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x11, 0xC0, 0x64, 0x60, 0x0D,
  0x30, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0D, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x0B,
  0x1C, 0x0C, 0xC1, 0xFE, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x01, 0x11, 0xFE, 0x60, 0x50, 0x0E, 0x01, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xF9,
  0xC0, 0x32, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x6E, 0x03, 0x8F,
  0xFE, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x0F, 0xFF, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x40, 0x03, 0xB0, 0x03, 0xD8, 0x01, 0x67, 0x03, 0x31,
  0xFF, 0x18, 0xC0, 0x00, 0xD0, 0x00, 0x26, 0x00, 0x19, 0x80, 0x04, 0x20,
  0x03, 0x0C, 0x00, 0xC1, 0x00, 0x20, 0x60, 0x18, 0x18, 0x06, 0x02, 0x01,
  0x00, 0xC0, 0xC0, 0x30, 0x20, 0x04, 0x18, 0x01, 0x86, 0x00, 0x21, 0x00,
  0x0C, 0xC0, 0x03, 0x20, 0x00, 0x48, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x80, 0x0C, 0x00, 0x78, 0x01, 0xC0, 0x0B, 0x00, 0x28, 0x03,
  0x20, 0x0D, 0x00, 0x66, 0x01, 0xB0, 0x08, 0xC0, 0x26, 0x01, 0x08, 0x0C,
  0x40, 0x61, 0x01, 0x8C, 0x0C, 0x30, 0x21, 0x81, 0x06, 0x0C, 0x10, 0x60,
  0x41, 0x83, 0x0C, 0x0C, 0x20, 0x61, 0x81, 0x8C, 0x04, 0x20, 0x11, 0x80,
  0x8C, 0x02, 0x20, 0x19, 0x80, 0x6C, 0x01, 0x20, 0x0D, 0x80, 0x24, 0x00,
  0xA0, 0x07, 0x80, 0x14, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0xE0, 0x01, 0x90, 0x01, 0x8C, 0x01, 0x83, 0x00, 0x80, 0x80, 0xC0,
  0x60, 0xC0, 0x18, 0xC0, 0x06, 0x60, 0x01, 0x60, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x2C, 0x00, 0x32, 0x00, 0x31, 0x80, 0x10, 0x60, 0x18, 0x18, 0x18,
  0x0C, 0x18, 0x03, 0x0C, 0x00, 0xCC, 0x00, 0x2C, 0x00, 0x18, 0xC0, 0x00,
  0xD0, 0x00, 0x26, 0x00, 0x19, 0x80, 0x04, 0x20, 0x03, 0x0C, 0x00, 0xC1,
  0x00, 0x20, 0x60, 0x18, 0x18, 0x06, 0x02, 0x01, 0x00, 0xC0, 0xC0, 0x10,
  0x20, 0x06, 0x18, 0x01, 0x86, 0x00, 0x21, 0x00, 0x0C, 0xC0, 0x03, 0x20,
  0x00, 0x48, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x20, 0x3C, 0x0C, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x18, 0x1E,
  0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x70, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0F, 0x00, 0xF0, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x01, 0xC0, 0xF0, 0x00, 0x3F,
  0x00, 0x2C, 0x78, 0x0E, 0x01, 0xFF, 0x40, 0x07, 0x80,
};

const GFXglyph NotoSans_ExtraLight40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 29, 9, 3, -29 },
  { 12, 8, 11, 14, 3, -29 },
  { 23, 24, 29, 26, 1, -29 },
  { 110, 16, 32, 23, 3, -30 },
  { 174, 28, 29, 32, 2, -29 },
  { 276, 25, 29, 28, 2, -29 },
  { 367, 2, 11, 7, 3, -29 },
  { 370, 7, 35, 11, 2, -29 },
  { 401, 8, 35, 11, 1, -29 },
  { 436, 18, 16, 22, 2, -30 },
  { 472, 19, 18, 23, 2, -23 },
  { 515, 4, 10, 8, 2, -5 },
  { 520, 9, 2, 13, 2, -12 },
  { 523, 3, 3, 9, 3, -3 },
  { 525, 13, 29, 13, 0, -29 },
  { 573, 18, 29, 23, 2, -29 },
  { 639, 9, 29, 23, 4, -29 },
  { 672, 18, 29, 23, 2, -29 },
  { 738, 18, 29, 23, 2, -29 },
  { 804, 21, 29, 23, 1, -29 },
  { 881, 17, 29, 23, 3, -29 },
  { 943, 18, 29, 23, 3, -29 },
  { 1009, 19, 29, 23, 2, -29 },
  { 1078, 18, 29, 23, 2, -29 },
  { 1144, 18, 29, 23, 2, -29 },
  { 1210, 3, 21, 9, 3, -21 },
  { 1218, 5, 26, 9, 1, -21 },
  { 1235, 19, 19, 23, 2, -24 },
  { 1281, 19, 10, 23, 2, -19 },
  { 1305, 19, 19, 23, 2, -24 },
  { 1351, 14, 29, 17, 1, -29 },
  { 1402, 31, 32, 35, 2, -28 },
  { 1526, 24, 29, 24, 0, -29 },
  { 1613, 19, 29, 25, 4, -29 },
  { 1682, 20, 29, 25, 3, -29 },
  { 1755, 21, 29, 28, 4, -29 },
  { 1832, 16, 29, 22, 4, -29 },
  { 1890, 16, 29, 20, 4, -29 },
  { 1948, 23, 29, 29, 3, -29 },
  { 2032, 20, 29, 29, 4, -29 },
  { 2105, 8, 29, 12, 2, -29 },
  { 2134, 10, 36, 10, -4, -29 },
  { 2179, 19, 29, 23, 4, -29 },
  { 2248, 16, 29, 20, 4, -29 },
  { 2306, 26, 29, 34, 4, -29 },
  { 2401, 20, 29, 28, 4, -29 },
  { 2474, 25, 29, 30, 3, -29 },
  { 2565, 17, 29, 23, 4, -29 },
  { 2627, 25, 36, 30, 3, -29 },
  { 2740, 18, 29, 23, 4, -29 },
  { 2806, 18, 29, 22, 2, -29 },
  { 2872, 20, 29, 21, 0, -29 },
  { 2945, 21, 29, 29, 4, -29 },
  { 3022, 23, 29, 23, 0, -29 },
  { 3106, 33, 29, 35, 1, -29 },
  { 3226, 21, 29, 21, 0, -29 },
  { 3303, 21, 29, 21, 0, -29 },
  { 3380, 20, 29, 23, 1, -29 },
  { 3453, 9, 35, 13, 3, -29 },
  { 3493, 13, 29, 13, 0, -29 },
  { 3541, 8, 35, 13, 1, -29 },
  { 3576, 19, 18, 23, 2, -29 },
  { 3619, 16, 1, 16, 0, 4 },
  { 3621, 7, 7, 10, 2, -31 },
  { 3628, 16, 22, 21, 2, -22 },
  { 3672, 17, 30, 24, 4, -30 },
  { 3736, 16, 22, 19, 2, -22 },
  { 3780, 18, 30, 24, 2, -30 },
  { 3848, 17, 22, 22, 2, -22 },
  { 3895, 14, 31, 12, 0, -31 },
  { 3950, 18, 32, 24, 2, -22 },
  { 4022, 16, 30, 23, 4, -30 },
  { 4082, 3, 29, 9, 3, -29 },
  { 4093, 8, 39, 9, -2, -29 },
  { 4132, 15, 30, 19, 4, -30 },
  { 4189, 1, 30, 9, 4, -30 },
  { 4193, 27, 22, 35, 4, -22 },
  { 4268, 16, 22, 23, 4, -22 },
  { 4312, 19, 22, 23, 2, -22 },
  { 4365, 17, 31, 24, 4, -22 },
  { 4431, 18, 31, 24, 2, -22 },
  { 4501, 11, 22, 15, 4, -22 },
  { 4532, 15, 22, 18, 2, -22 },
  { 4574, 12, 26, 13, 0, -26 },
  { 4613, 17, 21, 23, 3, -21 },
  { 4658, 18, 21, 18, 0, -21 },
  { 4706, 27, 21, 28, 1, -21 },
  { 4777, 17, 21, 20, 1, -21 },
  { 4822, 18, 31, 18, 0, -21 },
  { 4892, 15, 21, 18, 2, -21 },
  { 4932, 11, 35, 14, 1, -29 },
  { 4981, 1, 40, 22, 10, -30 },
  { 4986, 12, 35, 14, 1, -29 },
  { 5039, 19, 4, 23, 2, -16 },
};

const GFXfont NotoSans_ExtraLight40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRALIGHT40PT7B_H_
