#ifndef _NOTOSANS_EXTRALIGHT58PT7B_H_
#define _NOTOSANS_EXTRALIGHT58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight58pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x0E, 0xFF, 0xE4, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x34, 0x06, 0x80, 0xD0, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x1C, 0x18, 0x3C, 0x38,
  0x18, 0x04, 0x70, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x18, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x70, 0x18, 0x00, 0x3C,
  0x18, 0x00, 0x1F, 0x18, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x19, 0xF0, 0x00, 0x18, 0x78, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x18, 0x07, 0x00,
  0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00,
  0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x1C, 0xC0,
  0x18, 0x38, 0xFC, 0x19, 0xF0, 0x7F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x00, 0x38, 0x0E, 0x00, 0x06, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x00,
  0x70, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x03, 0x00, 0x00,
  0x60, 0x03, 0x06, 0x07, 0xF0, 0x60, 0x03, 0x06, 0x1F, 0xF8, 0x60, 0x03,
  0x0C, 0x38, 0x1C, 0x70, 0x06, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x18, 0x70,
  0x06, 0x38, 0x0C, 0x38, 0x60, 0x06, 0x1C, 0x1C, 0x30, 0x60, 0x07, 0x0F,
  0xF8, 0x70, 0xE0, 0x03, 0x03, 0xE0, 0x60, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x03,
  0x00, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x07,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00,
  0x30, 0x0E, 0x00, 0x60, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x38, 0x01, 0xC0, 0x01, 0xCE,
  0x00, 0x1C, 0x00, 0x31, 0x80, 0x01, 0xC0, 0x06, 0x70, 0x00, 0x1C, 0x01,
  0xCC, 0x00, 0x01, 0xC0, 0x31, 0x80, 0x00, 0x1C, 0x0E, 0x30, 0x00, 0x01,
  0xC1, 0x86, 0x00, 0x00, 0x1C, 0x60, 0xC0, 0x00, 0x01, 0xDC, 0x18, 0x00,
  0x00, 0x1F, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x3C, 0x06,
  0x00, 0x00, 0x1D, 0xC0, 0xE0, 0x00, 0x07, 0x1C, 0x0E, 0x00, 0x01, 0xC1,
  0xC0, 0xF0, 0x01, 0xF0, 0x1C, 0x0F, 0xFF, 0xF8, 0x01, 0xC0, 0x7F, 0xFC,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0x6D, 0xB6, 0xDB, 0x64,
  0x90, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0xE0, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x01, 0xBC,
  0x06, 0x07, 0xFF, 0xC3, 0x1F, 0xE0, 0xFD, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x04, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8C,
  0x30, 0xC7, 0x18, 0x63, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0xFE, 0x40,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xE0,
  0x00, 0xE0, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x38, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x01, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x38, 0x07, 0xC0, 0x76, 0x07, 0x30, 0xF1, 0x8E, 0x0C, 0xE0, 0x7E, 0x03,
  0xC0, 0x1A, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x08, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x00, 0x70,
  0xF0, 0x00, 0x0E, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC8, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0xF0, 0xFF, 0xCF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x03,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x01, 0xC0, 0x00, 0xC0,
  0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE4, 0x00, 0x00,
  0xE3, 0xC0, 0x01, 0xE0, 0xFF, 0xBF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x20,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x3F, 0xF8,
  0x0C, 0x3F, 0x9F, 0x83, 0x1C, 0x00, 0x70, 0xCC, 0x00, 0x0E, 0x36, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x60, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x18,
  0x00, 0x03, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0xF0,
  0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03,
  0xE0, 0x3E, 0x03, 0x80, 0x03, 0x83, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x31,
  0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x30, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x70, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x38,
  0x00, 0x03, 0x98, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x0F, 0xE3,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x0F, 0x30, 0x00, 0x06, 0xCE, 0x00, 0x03, 0xB1, 0xC0, 0x01, 0xCC, 0x3C,
  0x01, 0xE3, 0x07, 0xFF, 0xE0, 0xC0, 0x3F, 0xE0, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x3F, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xE4, 0x1C, 0x3C, 0x78, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x18,
  0x30, 0xE1, 0x83, 0x06, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0xF0, 0xF8, 0x0F, 0x8C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x00, 0x00, 0xC1, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0x18,
  0x00, 0x3F, 0x1F, 0x80, 0x18, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0xCE, 0x00,
  0x38, 0x00, 0x60, 0x07, 0x60, 0x03, 0x80, 0x03, 0x00, 0x1B, 0x00, 0x18,
  0x00, 0x18, 0x00, 0xD8, 0x01, 0x80, 0x00, 0xC0, 0x07, 0xC0, 0x0C, 0x00,
  0x06, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x30, 0x01, 0xE0, 0x06, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x30, 0x00, 0x18, 0x00, 0x78, 0x01, 0x80, 0x00, 0xC0,
  0x03, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x60, 0x00, 0x30, 0x00,
  0xF0, 0x03, 0x00, 0x01, 0x80, 0x0D, 0x80, 0x18, 0x00, 0x0C, 0x00, 0x6C,
  0x00, 0xE0, 0x00, 0xE0, 0x03, 0x70, 0x03, 0x00, 0x05, 0x80, 0x31, 0x80,
  0x1C, 0x00, 0x6C, 0x01, 0x8C, 0x00, 0x70, 0x06, 0x70, 0x18, 0x60, 0x01,
  0xE0, 0xE1, 0xC3, 0x83, 0x80, 0x07, 0xFE, 0x07, 0xF8, 0x0C, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x18, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x70, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0xF8, 0x60, 0x00, 0x07, 0x8C,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x83, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0C, 0x00, 0x1F, 0xC1, 0x80, 0x00, 0x1C,
  0x30, 0x00, 0x01, 0xE6, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x1E, 0x30, 0x00, 0x1F, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x3C, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x06, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x01, 0xF8, 0x06, 0x00,
  0x00, 0x78, 0x0C, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x07, 0x86, 0x00, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x78, 0x18, 0x00,
  0x07, 0xC0, 0x30, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x1F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x10, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x00, 0x18, 0x3C, 0x00, 0x00,
  0x0C, 0x0F, 0x80, 0x00, 0x06, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x18, 0xFF, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x81, 0xE7, 0xFE, 0x3F, 0xC0, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x06, 0x00,
  0x07, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x30, 0x1C,
  0x00, 0x06, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x78, 0x00, 0x03,
  0x1F, 0x80, 0x00, 0x67, 0x70, 0x00, 0x0D, 0xC7, 0x00, 0x01, 0xF0, 0x70,
  0x00, 0x3C, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x1C,
  0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x38, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xB0, 0x00, 0x00, 0x01, 0xFD, 0x80, 0x00, 0x00, 0x0D, 0xEE, 0x00,
  0x00, 0x00, 0x6F, 0x30, 0x00, 0x00, 0x07, 0x79, 0xC0, 0x00, 0x00, 0x33,
  0xC6, 0x00, 0x00, 0x03, 0x9E, 0x30, 0x00, 0x00, 0x18, 0xF1, 0xC0, 0x00,
  0x00, 0xC7, 0x86, 0x00, 0x00, 0x0C, 0x3C, 0x38, 0x00, 0x00, 0x61, 0xE0,
  0xC0, 0x00, 0x07, 0x0F, 0x06, 0x00, 0x00, 0x30, 0x78, 0x38, 0x00, 0x01,
  0x83, 0xC0, 0xC0, 0x00, 0x18, 0x1E, 0x07, 0x00, 0x00, 0xC0, 0xF0, 0x18,
  0x00, 0x0E, 0x07, 0x80, 0xC0, 0x00, 0x60, 0x3C, 0x07, 0x00, 0x03, 0x01,
  0xE0, 0x18, 0x00, 0x30, 0x0F, 0x00, 0xE0, 0x01, 0x80, 0x78, 0x03, 0x00,
  0x1C, 0x03, 0xC0, 0x18, 0x00, 0xC0, 0x1E, 0x00, 0xE0, 0x06, 0x00, 0xF0,
  0x03, 0x00, 0x60, 0x07, 0x80, 0x1C, 0x03, 0x00, 0x3C, 0x00, 0x60, 0x38,
  0x01, 0xE0, 0x03, 0x01, 0x80, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x00,
  0x60, 0xC0, 0x03, 0xC0, 0x03, 0x86, 0x00, 0x1E, 0x00, 0x0C, 0x70, 0x00,
  0xF0, 0x00, 0x63, 0x00, 0x07, 0x80, 0x01, 0xB8, 0x00, 0x3C, 0x00, 0x0D,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3D,
  0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x78, 0xC0,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0x60, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x80, 0x0C, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x06, 0x00, 0x78, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1C, 0x07, 0x80,
  0x00, 0x70, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x30,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xC0, 0x00,
  0xF8, 0xC0, 0x00, 0x3C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0xF0, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0x00, 0x03, 0xE0, 0x60,
  0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x3C, 0x0C, 0x00, 0x3E, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60, 0x0C,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xF0, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC8,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x00, 0x0B, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x38, 0x30, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x38, 0x18,
  0x00, 0x18, 0x70, 0x00, 0x38, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x0E,
  0x00, 0x30, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x07,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x01, 0xC0, 0x03,
  0x00, 0xC0, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x03,
  0x81, 0xC0, 0x07, 0x03, 0x80, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x01, 0xC1, 0x80, 0x03, 0x07, 0x00, 0x00,
  0xC3, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x00,
  0xC3, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x07, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07,
  0x01, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x70, 0x06, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x30, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xE0, 0x0F,
  0x06, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0x03,
  0x1F, 0x00, 0x0C, 0xF0, 0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFE, 0x00, 0x06, 0xDC, 0x00, 0x3B, 0x78, 0x01, 0xCC,
  0xFE, 0x7E, 0x10, 0xFF, 0xE0, 0x40, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x3F, 0xF0, 0x0C, 0x1F, 0xFF, 0x03, 0x1E, 0x00, 0xE0,
  0xCE, 0x00, 0x1C, 0x37, 0x00, 0x03, 0x8D, 0x80, 0x00, 0x73, 0xC0, 0x00,
  0x0C, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x06, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xCF,
  0x00, 0x00, 0x73, 0x60, 0x00, 0x38, 0xCC, 0x00, 0x1C, 0x33, 0xC0, 0x0E,
  0x0C, 0x3F, 0x7F, 0x03, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x0F, 0x80, 0x30, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x40, 0x7F,
  0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x05, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x1F, 0xF0, 0x30, 0x1F, 0xFF, 0x0C, 0x1E, 0x00, 0xE3, 0x0E,
  0x00, 0x0C, 0xC7, 0x00, 0x01, 0xB1, 0x80, 0x00, 0x2C, 0xE0, 0x00, 0x0F,
  0x30, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x07, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x3C, 0x70, 0x00, 0x1B, 0x0E, 0x00, 0x0C, 0xC3, 0xC0, 0x06, 0x30,
  0x3F, 0xBF, 0x0C, 0x07, 0xFF, 0x83, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x20, 0x78, 0x00, 0x70, 0x1F, 0xEF, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7F, 0xFC, 0x3F,
  0xFF, 0x80, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0xC0, 0x7F, 0xFC, 0x30, 0x78, 0x03, 0x8C, 0x38, 0x00, 0x33,
  0x1C, 0x00, 0x06, 0xC6, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xB1,
  0xC0, 0x00, 0x6C, 0x38, 0x00, 0x33, 0x07, 0x00, 0x38, 0xC0, 0xFE, 0xFC,
  0x30, 0x1F, 0xFE, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x83, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x7F, 0xC0, 0xC3, 0xFF, 0xF0, 0xC7,
  0x80, 0x78, 0xCE, 0x00, 0x1C, 0xD8, 0x00, 0x0E, 0xD8, 0x00, 0x06, 0xF0,
  0x00, 0x06, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1D, 0x07, 0x3F, 0xC7, 0xE0, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0xEC, 0x00, 0x07, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x00, 0x06,
  0x0C, 0x00, 0x38, 0x30, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0x70, 0x0C,
  0x03, 0x80, 0x30, 0x1C, 0x00, 0xC0, 0xE0, 0x03, 0x07, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0xF0, 0x00, 0xC6, 0xE0, 0x03, 0x31, 0xC0, 0x0D, 0x83, 0x00,
  0x3C, 0x0E, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x38, 0x0C, 0x00, 0x60, 0x30,
  0x01, 0xC0, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x38, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x00, 0x1F, 0xF0, 0x61, 0xFF, 0xE0, 0x3F, 0xFC, 0x31, 0xC0, 0x78,
  0x78, 0x07, 0x19, 0x80, 0x0E, 0x70, 0x01, 0xCD, 0x80, 0x03, 0x30, 0x00,
  0x76, 0x80, 0x01, 0xF0, 0x00, 0x1B, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0xC0, 0xFF, 0xC0, 0xC3, 0xFF, 0xF0, 0xC7, 0x80, 0x78, 0xCE,
  0x00, 0x1C, 0xDC, 0x00, 0x0E, 0xD8, 0x00, 0x06, 0xF0, 0x00, 0x06, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x07,
  0x00, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x80, 0x78, 0x01,
  0xE0, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0xC0,
  0x7F, 0xC0, 0x30, 0x7F, 0xFC, 0x0C, 0x78, 0x03, 0xC3, 0x38, 0x00, 0x78,
  0xCC, 0x00, 0x0E, 0x36, 0x00, 0x01, 0xCD, 0x00, 0x00, 0x33, 0xC0, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x1B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0x36, 0x00, 0x01, 0xCD,
  0x80, 0x00, 0xE3, 0x30, 0x00, 0x70, 0xC7, 0x00, 0x3C, 0x30, 0xFD, 0xFC,
  0x0C, 0x0F, 0xFE, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0xC0, 0xFF, 0xFC, 0x30, 0x78, 0x03, 0x8C,
  0x38, 0x00, 0x33, 0x1C, 0x00, 0x06, 0xC6, 0x00, 0x01, 0xB3, 0x80, 0x00,
  0x3C, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x03, 0xCE,
  0x00, 0x01, 0xB1, 0x80, 0x00, 0x6C, 0x70, 0x00, 0x33, 0x0F, 0x00, 0x38,
  0xC1, 0xFC, 0xFC, 0x30, 0x1F, 0xFC, 0x0C, 0x00, 0xF8, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xFF, 0xC3, 0xFF, 0xC7, 0x00, 0xCC,
  0x00, 0xD8, 0x00, 0xD8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE1, 0xE0, 0x03, 0x8E, 0x00, 0x02, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xA0, 0x00, 0x0E,
  0xF0, 0x00, 0x73, 0xFE, 0x3F, 0x81, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x18, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x70,
  0x00, 0x37, 0x70, 0x00, 0x77, 0x3C, 0x00, 0xE3, 0x1F, 0xDF, 0xC3, 0x07,
  0xFF, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x70,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x70, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00,
  0x3B, 0x00, 0x01, 0xE0, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0xCE, 0x00,
  0x0D, 0xC0, 0x03, 0x8C, 0x00, 0x19, 0x80, 0x06, 0x18, 0x00, 0x73, 0x00,
  0x0C, 0x38, 0x00, 0xC7, 0x00, 0x18, 0x30, 0x01, 0x86, 0x00, 0x70, 0x60,
  0x07, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x1C, 0x01, 0x81, 0xC0, 0x18, 0x18,
  0x03, 0x01, 0x80, 0x70, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x07,
  0x01, 0x80, 0x60, 0x30, 0x06, 0x07, 0x00, 0xC0, 0xE0, 0x0C, 0x0C, 0x01,
  0x81, 0x80, 0x18, 0x18, 0x03, 0x83, 0x00, 0x38, 0x70, 0x03, 0x06, 0x00,
  0x30, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x0E, 0x30, 0x00, 0xC7, 0x00,
  0x0C, 0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x3B, 0x80,
  0x03, 0x30, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x80,
  0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01, 0x80,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0x87, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x00, 0xC0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x60, 0x00,
  0x18, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x38,
  0x00, 0x70, 0x06, 0x00, 0x18, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x03, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x07, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x08, 0x38, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x1E, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x2F, 0xFF, 0x80, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x03, 0xFF, 0xE8, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_ExtraLight58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 42, 13, 5, -41 },
  { 22, 11, 15, 20, 4, -41 },
  { 43, 34, 41, 37, 2, -41 },
  { 218, 24, 47, 33, 4, -44 },
  { 359, 40, 43, 46, 3, -42 },
  { 574, 35, 43, 41, 4, -42 },
  { 763, 3, 15, 11, 4, -41 },
  { 769, 11, 50, 15, 2, -41 },
  { 838, 11, 50, 15, 2, -41 },
  { 907, 25, 24, 32, 3, -44 },
  { 982, 27, 27, 33, 3, -34 },
  { 1074, 6, 14, 12, 2, -7 },
  { 1085, 14, 2, 19, 2, -17 },
  { 1089, 4, 5, 13, 5, -4 },
  { 1092, 18, 41, 19, 1, -41 },
  { 1185, 27, 43, 33, 3, -42 },
  { 1331, 13, 41, 33, 6, -41 },
  { 1398, 26, 42, 33, 3, -42 },
  { 1535, 26, 43, 33, 3, -42 },
  { 1675, 31, 42, 33, 1, -42 },
  { 1838, 25, 42, 33, 4, -41 },
  { 1970, 26, 43, 33, 4, -42 },
  { 2110, 27, 41, 33, 3, -41 },
  { 2249, 25, 43, 33, 4, -42 },
  { 2384, 26, 43, 33, 3, -42 },
  { 2524, 4, 32, 13, 5, -31 },
  { 2540, 7, 38, 13, 2, -31 },
  { 2574, 27, 26, 33, 3, -34 },
  { 2662, 27, 13, 33, 3, -27 },
  { 2706, 27, 26, 33, 3, -34 },
  { 2794, 20, 43, 24, 2, -42 },
  { 2902, 45, 47, 51, 3, -41 },
  { 3167, 34, 42, 34, 0, -42 },
  { 3346, 27, 41, 36, 6, -41 },
  { 3485, 30, 43, 36, 4, -42 },
  { 3647, 31, 41, 41, 6, -41 },
  { 3806, 22, 41, 32, 6, -41 },
  { 3919, 22, 41, 29, 6, -41 },
  { 4032, 33, 43, 42, 4, -42 },
  { 4210, 29, 41, 41, 6, -41 },
  { 4359, 11, 41, 17, 3, -41 },
  { 4416, 13, 51, 14, -5, -41 },
  { 4499, 27, 41, 33, 6, -41 },
  { 4638, 22, 41, 30, 6, -41 },
  { 4751, 37, 41, 49, 6, -41 },
  { 4941, 29, 41, 41, 6, -41 },
  { 5090, 36, 43, 44, 4, -42 },
  { 5284, 24, 41, 34, 6, -41 },
  { 5407, 36, 52, 44, 4, -42 },
  { 5641, 27, 41, 34, 6, -41 },
  { 5780, 26, 43, 32, 3, -42 },
  { 5920, 30, 41, 30, 0, -41 },
  { 6074, 31, 42, 42, 5, -41 },
  { 6237, 33, 41, 33, 0, -41 },
  { 6407, 48, 41, 51, 2, -41 },
  { 6653, 31, 41, 30, 0, -41 },
  { 6812, 30, 41, 30, 0, -41 },
  { 6966, 29, 41, 33, 2, -41 },
  { 7115, 12, 50, 18, 5, -41 },
  { 7190, 18, 41, 19, 1, -41 },
  { 7283, 12, 50, 18, 1, -41 },
  { 7358, 28, 26, 33, 3, -42 },
  { 7449, 23, 2, 23, 0, 5 },
  { 7455, 11, 9, 15, 2, -44 },
  { 7468, 22, 32, 30, 3, -31 },
  { 7556, 26, 45, 34, 5, -44 },
  { 7703, 23, 32, 27, 3, -31 },
  { 7795, 26, 45, 34, 3, -44 },
  { 7942, 25, 32, 32, 3, -31 },
  { 8042, 19, 44, 17, 1, -44 },
  { 8147, 26, 45, 34, 3, -31 },
  { 8294, 24, 44, 34, 5, -44 },
  { 8426, 3, 42, 13, 5, -42 },
  { 8442, 11, 56, 13, -3, -42 },
  { 8519, 22, 44, 27, 5, -44 },
  { 8640, 2, 44, 13, 5, -44 },
  { 8651, 41, 31, 50, 5, -31 },
  { 8810, 24, 31, 34, 5, -31 },
  { 8903, 27, 32, 34, 3, -31 },
  { 9011, 26, 45, 34, 5, -31 },
  { 9158, 26, 45, 34, 3, -31 },
  { 9305, 16, 31, 22, 5, -31 },
  { 9367, 22, 32, 27, 2, -31 },
  { 9455, 16, 39, 19, 1, -38 },
  { 9533, 24, 32, 34, 5, -31 },
  { 9629, 26, 31, 26, 0, -31 },
  { 9730, 39, 31, 41, 1, -31 },
  { 9882, 26, 31, 28, 1, -31 },
  { 9983, 26, 45, 26, 0, -31 },
  { 10130, 22, 31, 27, 2, -31 },
  { 10216, 16, 50, 20, 2, -41 },
  { 10316, 3, 58, 31, 14, -44 },
  { 10338, 17, 50, 20, 2, -41 },
  { 10445, 27, 5, 33, 3, -23 },
};

const GFXfont NotoSans_ExtraLight58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRALIGHT58PT7B_H_
