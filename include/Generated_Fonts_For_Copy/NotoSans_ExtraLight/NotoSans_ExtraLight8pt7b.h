#ifndef _NOTOSANS_EXTRALIGHT8PT7B_H_
#define _NOTOSANS_EXTRALIGHT8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0x32, 0x9E, 0xAF, 0xA8, 0x72, 0x27, 0x80, 0x4A, 0xAB,
  0x95, 0x35, 0x30, 0x62, 0x98, 0xD9, 0xBC, 0xC0, 0x6A, 0xA4, 0x95, 0x58,
  0x2F, 0x60, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x29, 0x29, 0x00, 0x69, 0x99,
  0x97, 0x75, 0x50, 0x61, 0x12, 0x4F, 0xE1, 0x17, 0x1F, 0x12, 0x59, 0xF1,
  0xF3, 0x13, 0xC0, 0x73, 0x5B, 0xC0, 0xF1, 0x12, 0x24, 0x69, 0x75, 0x9F,
  0x69, 0x97, 0x16, 0x10, 0x18, 0x16, 0xC3, 0xFF, 0xC2, 0x3C, 0xE4, 0xA4,
  0x80, 0x3C, 0x86, 0xED, 0x5A, 0xAA, 0x8E, 0x00, 0x23, 0x14, 0xE9, 0x44,
  0xE9, 0xAD, 0x9E, 0x3A, 0x21, 0x08, 0x3C, 0xE9, 0x99, 0x9E, 0xF3, 0xC9,
  0xC0, 0xF2, 0x79, 0x00, 0x3A, 0x21, 0x38, 0xBC, 0x99, 0x9F, 0x99, 0xD5,
  0x70, 0x55, 0x5C, 0x9A, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0x8C, 0x67, 0xBE,
  0xD4, 0x99, 0xDB, 0xB9, 0x39, 0x18, 0x61, 0x85, 0xE0, 0xD6, 0xE9, 0x00,
  0x39, 0x18, 0x61, 0x85, 0xA1, 0x80, 0xCA, 0xAC, 0xA9, 0x78, 0xC3, 0x1F,
  0xF2, 0x22, 0x22, 0x99, 0x99, 0x9F, 0x8C, 0xA4, 0xA6, 0x10, 0x93, 0x26,
  0xAB, 0x64, 0x49, 0x00, 0x95, 0x22, 0x59, 0x99, 0x62, 0x22, 0xF1, 0x22,
  0x4F, 0xFE, 0x91, 0x24, 0x40, 0xD5, 0x5C, 0x26, 0x59, 0xE0, 0xC0, 0x77,
  0x9F, 0x9A, 0xDB, 0xC0, 0x78, 0x87, 0x13, 0xD9, 0x97, 0xFF, 0x87, 0x79,
  0x24, 0x80, 0xF9, 0x97, 0x1F, 0x9A, 0xDB, 0x40, 0xBC, 0xBF, 0x97, 0x4D,
  0x40, 0xFC, 0xFD, 0x6B, 0x50, 0xF6, 0xD0, 0xF9, 0x97, 0xF6, 0xF9, 0x00,
  0xF9, 0x97, 0x11, 0xEA, 0xE8, 0xF0, 0xEA, 0xC0, 0xB6, 0xF0, 0x9A, 0x64,
  0xA6, 0xE4, 0x92, 0xB4, 0x69, 0x9A, 0x64, 0x4C, 0x65, 0x70, 0x57, 0x54,
  0xFF, 0x89, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_ExtraLight8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 6, 5, 1, -6 },
  { 10, 6, 6, 6, 0, -6 },
  { 15, 5, 6, 6, 0, -6 },
  { 19, 1, 2, 1, 0, -6 },
  { 20, 2, 7, 2, 0, -6 },
  { 22, 2, 7, 2, 0, -6 },
  { 24, 4, 3, 4, 0, -6 },
  { 26, 4, 4, 5, 0, -5 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 2, 1, 3, 0, -3 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 4, 6, 5, 0, -6 },
  { 37, 2, 6, 5, 1, -6 },
  { 39, 4, 6, 5, 0, -6 },
  { 42, 4, 6, 5, 0, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 3, 6, 5, 1, -6 },
  { 51, 3, 6, 5, 1, -6 },
  { 54, 4, 6, 5, 0, -6 },
  { 57, 4, 6, 5, 0, -6 },
  { 60, 4, 6, 5, 0, -6 },
  { 63, 1, 4, 2, 0, -4 },
  { 64, 1, 5, 2, 0, -4 },
  { 65, 4, 4, 5, 0, -5 },
  { 67, 4, 2, 5, 0, -4 },
  { 68, 4, 4, 5, 0, -5 },
  { 70, 3, 6, 3, 0, -6 },
  { 73, 7, 7, 7, 0, -6 },
  { 80, 5, 6, 5, 0, -6 },
  { 84, 4, 6, 5, 1, -6 },
  { 87, 5, 6, 5, 0, -6 },
  { 91, 4, 6, 6, 1, -6 },
  { 94, 3, 6, 4, 1, -6 },
  { 97, 3, 6, 4, 1, -6 },
  { 100, 5, 6, 6, 0, -6 },
  { 104, 4, 6, 6, 1, -6 },
  { 107, 2, 6, 2, 0, -6 },
  { 109, 2, 7, 2, -1, -6 },
  { 111, 4, 6, 5, 1, -6 },
  { 114, 3, 6, 4, 1, -6 },
  { 117, 5, 6, 7, 1, -6 },
  { 121, 4, 6, 6, 1, -6 },
  { 124, 6, 6, 6, 0, -6 },
  { 129, 3, 6, 5, 1, -6 },
  { 132, 6, 7, 6, 0, -6 },
  { 138, 4, 6, 5, 1, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 4, 6, 6, 1, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 7, 6, 7, 0, -6 },
  { 160, 4, 6, 4, 0, -6 },
  { 163, 4, 6, 4, 0, -6 },
  { 166, 4, 6, 5, 0, -6 },
  { 169, 1, 7, 3, 1, -6 },
  { 170, 3, 6, 3, 0, -6 },
  { 173, 2, 7, 3, 0, -6 },
  { 175, 4, 4, 5, 0, -6 },
  { 177, 3, 1, 3, 0, 0 },
  { 178, 2, 1, 2, 0, -6 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 3, 6, 5, 1, -6 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 4, 6, 5, 0, -6 },
  { 189, 4, 4, 4, 0, -4 },
  { 191, 3, 6, 2, 0, -6 },
  { 194, 4, 6, 5, 0, -4 },
  { 197, 3, 6, 5, 1, -6 },
  { 200, 1, 6, 2, 0, -6 },
  { 201, 1, 8, 2, 0, -6 },
  { 202, 3, 6, 4, 1, -6 },
  { 205, 1, 6, 2, 0, -6 },
  { 206, 5, 4, 7, 1, -4 },
  { 209, 3, 4, 5, 1, -4 },
  { 211, 4, 4, 5, 0, -4 },
  { 213, 3, 6, 5, 1, -4 },
  { 216, 4, 6, 5, 0, -4 },
  { 219, 2, 4, 3, 1, -4 },
  { 220, 3, 4, 4, 0, -4 },
  { 222, 2, 5, 3, 0, -5 },
  { 224, 3, 4, 5, 1, -4 },
  { 226, 4, 4, 4, 0, -4 },
  { 228, 6, 4, 6, 0, -4 },
  { 231, 4, 4, 4, 0, -4 },
  { 233, 4, 6, 4, 0, -4 },
  { 236, 3, 4, 4, 0, -4 },
  { 238, 2, 7, 3, 0, -6 },
  { 240, 1, 8, 4, 2, -6 },
  { 241, 3, 7, 3, 0, -6 },
  { 244, 4, 1, 5, 0, -3 },
};

const GFXfont NotoSans_ExtraLight8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRALIGHT8PT7B_H_
