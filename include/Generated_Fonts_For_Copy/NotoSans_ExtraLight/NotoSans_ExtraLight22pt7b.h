#ifndef _NOTOSANS_EXTRALIGHT22PT7B_H_
#define _NOTOSANS_EXTRALIGHT22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0x99, 0x99, 0x99, 0x04, 0x40, 0x42, 0x02, 0x10, 0x10,
  0x80, 0x84, 0x7F, 0xFC, 0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x3F, 0xFC,
  0x22, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x08, 0x02, 0x03, 0xF9,
  0x20, 0x88, 0x22, 0x04, 0x81, 0x20, 0x38, 0x01, 0x80, 0x98, 0x22, 0x08,
  0x42, 0x10, 0x8B, 0x2C, 0x3C, 0x02, 0x00, 0x38, 0x08, 0x88, 0x22, 0x10,
  0x84, 0x21, 0x08, 0x44, 0x10, 0x88, 0x21, 0x26, 0x42, 0x53, 0x45, 0x22,
  0x72, 0x84, 0x09, 0x08, 0x22, 0x10, 0x44, 0x21, 0x08, 0x42, 0x08, 0x88,
  0x1E, 0x0F, 0x00, 0x42, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x44, 0x01,
  0xA0, 0x03, 0x00, 0x36, 0x01, 0x0C, 0x24, 0x18, 0xA0, 0x34, 0x80, 0x71,
  0x00, 0x84, 0x05, 0x0F, 0xE3, 0xFC, 0x12, 0x24, 0x48, 0x88, 0x88, 0x88,
  0x88, 0x84, 0x42, 0x30, 0x84, 0x42, 0x22, 0x11, 0x11, 0x11, 0x11, 0x22,
  0x24, 0x80, 0x08, 0x02, 0x00, 0x82, 0x21, 0x7B, 0x83, 0x00, 0xC0, 0x48,
  0x21, 0x00, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x56, 0xA0, 0xF8, 0xC0, 0x02, 0x04, 0x10, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x1E, 0x08, 0x64,
  0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01,
  0x40, 0x50, 0x22, 0x08, 0x7C, 0x08, 0xDB, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x3E, 0x10, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFF, 0x3E,
  0x30, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0xF8, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x40, 0x18, 0x0B, 0xFC, 0x01, 0x00, 0x20, 0x0A, 0x02,
  0x40, 0x88, 0x11, 0x04, 0x21, 0x04, 0x40, 0x88, 0x12, 0x02, 0x7F, 0xF0,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x7F, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x61, 0xCC, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x06, 0x05, 0xFC, 0x0F,
  0x84, 0x02, 0x01, 0x00, 0x40, 0x10, 0x04, 0xF2, 0xC2, 0xC0, 0x70, 0x18,
  0x05, 0x01, 0x40, 0x50, 0x12, 0x08, 0x7C, 0xFF, 0xC0, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x40, 0x50, 0x23, 0x10,
  0x38, 0x33, 0x10, 0x24, 0x06, 0x01, 0x80, 0x50, 0x14, 0x08, 0xFC, 0x1E,
  0x18, 0x44, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x41, 0xCF, 0x90,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x11, 0xF8, 0xC0, 0x30, 0x50, 0x00, 0x15,
  0xA8, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x30, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x10, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x00, 0x79, 0x0C,
  0x08, 0x10, 0x20, 0x41, 0x86, 0x10, 0x40, 0x81, 0x00, 0x00, 0x08, 0x10,
  0x01, 0xE0, 0x03, 0x0E, 0x06, 0x00, 0x84, 0x00, 0x24, 0x00, 0x0A, 0x0F,
  0x85, 0x08, 0x43, 0x08, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x61, 0x04, 0x30,
  0x82, 0x18, 0x62, 0x92, 0x0E, 0x31, 0x00, 0x00, 0x40, 0x00, 0x10, 0x08,
  0x07, 0xF8, 0x00, 0x02, 0x00, 0x10, 0x01, 0x40, 0x0A, 0x00, 0x88, 0x04,
  0x40, 0x22, 0x02, 0x08, 0x10, 0x40, 0xFE, 0x08, 0x08, 0x40, 0x44, 0x01,
  0x20, 0x09, 0x00, 0x50, 0x01, 0xFE, 0x20, 0x68, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0B, 0xFC, 0x81, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0B,
  0xFC, 0x07, 0xE1, 0x81, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0xFF, 0xFE, 0x08, 0x18, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x8F,
  0xF0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFE, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x07, 0xF0, 0xC0, 0x4C, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x81, 0xFC, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0x90, 0x04,
  0x40, 0x21, 0xFF, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0F, 0xFF, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x2F, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x47, 0xC0, 0x80, 0x50,
  0x12, 0x04, 0x41, 0x08, 0x41, 0x10, 0x24, 0x05, 0x80, 0xC8, 0x10, 0x82,
  0x18, 0x41, 0x08, 0x11, 0x01, 0x20, 0x24, 0x03, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE8, 0x03, 0xA0, 0x16, 0x40,
  0x59, 0x01, 0x62, 0x09, 0x88, 0x26, 0x21, 0x18, 0x44, 0x61, 0x11, 0x82,
  0x86, 0x0A, 0x18, 0x30, 0x60, 0x41, 0x80, 0x38, 0x07, 0x80, 0xD0, 0x19,
  0x03, 0x10, 0x62, 0x0C, 0x21, 0x82, 0x30, 0x46, 0x04, 0xC0, 0x58, 0x0B,
  0x00, 0xE0, 0x0C, 0x01, 0x07, 0xC0, 0x60, 0xC2, 0x00, 0x90, 0x02, 0x40,
  0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50,
  0x01, 0x40, 0x08, 0x80, 0x21, 0x01, 0x03, 0xF8, 0xFC, 0x20, 0xC8, 0x0A,
  0x02, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x8F, 0x3C, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x07, 0xC0, 0x60, 0xC2, 0x00, 0x90, 0x02, 0x40,
  0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x50,
  0x01, 0x40, 0x08, 0x80, 0x21, 0x01, 0x03, 0xF8, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0xFE, 0x20, 0x48, 0x0A, 0x02, 0x80, 0x60, 0x28, 0x0A,
  0x04, 0xFE, 0x21, 0x08, 0x22, 0x04, 0x81, 0x20, 0x28, 0x0A, 0x01, 0x1F,
  0x18, 0x24, 0x02, 0x00, 0x80, 0x10, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x0B, 0xFC, 0xFF, 0xE0, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x24, 0x02, 0x60, 0x41, 0xF8, 0x80, 0x0C, 0x00, 0x90, 0x04, 0x80, 0x42,
  0x02, 0x10, 0x10, 0x81, 0x02, 0x08, 0x10, 0x40, 0x84, 0x02, 0x20, 0x12,
  0x00, 0x50, 0x02, 0x80, 0x18, 0x00, 0x40, 0x80, 0x80, 0x60, 0x20, 0x18,
  0x14, 0x0A, 0x05, 0x02, 0x41, 0x40, 0x90, 0x48, 0x44, 0x22, 0x10, 0x88,
  0x84, 0x22, 0x21, 0x08, 0x84, 0x82, 0x41, 0x20, 0x50, 0x48, 0x14, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0xC0, 0x24, 0x04, 0x20, 0x42,
  0x08, 0x10, 0x80, 0x90, 0x0A, 0x00, 0x60, 0x06, 0x00, 0xA0, 0x11, 0x01,
  0x08, 0x20, 0x82, 0x04, 0x40, 0x28, 0x03, 0x80, 0x28, 0x05, 0x01, 0x10,
  0x22, 0x08, 0x21, 0x04, 0x40, 0x48, 0x0A, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x07, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0xF0, 0x80, 0x81, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x40, 0x80, 0x81, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0xF0, 0x04, 0x01, 0x80, 0x28, 0x09, 0x01, 0x10, 0x42, 0x08, 0x22, 0x04,
  0x40, 0x50, 0x0C, 0xFF, 0x80, 0x84, 0x21, 0x3E, 0x20, 0x80, 0x40, 0x10,
  0x08, 0x7D, 0xC3, 0x01, 0x80, 0xC0, 0xE0, 0xAF, 0x90, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x27, 0x8A, 0x13, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x28, 0x0B, 0x04, 0xBE, 0x00, 0x0F, 0x18, 0x50, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x03, 0xF0, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x47, 0x92, 0x1D, 0x03, 0x40, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x14, 0x05, 0x03, 0x3F, 0x40, 0x1E, 0x08, 0x44, 0x09, 0x01,
  0x80, 0x7F, 0xF8, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7E, 0x0F, 0x10,
  0x10, 0x20, 0x20, 0xFC, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x1E, 0x48, 0x74, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x50, 0x16, 0x0C, 0xFD, 0x00, 0x40, 0x10, 0x04, 0x02, 0x7F,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xF2, 0x85, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xCF, 0xFF, 0x11,
  0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xE0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x81, 0x82, 0x84, 0x88, 0x90, 0xB0, 0xD0, 0x88, 0x84,
  0x86, 0x82, 0x81, 0xFF, 0xFF, 0x80, 0xBC, 0x3D, 0x85, 0x86, 0x06, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x10, 0x9E, 0x50, 0xB0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x1F, 0x08, 0x24, 0x05, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x50, 0x12, 0x08, 0x7C, 0x9E, 0x28,
  0x4C, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x2C, 0x1A,
  0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x48, 0x54, 0x0D,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14, 0x0C, 0xFD, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x9F, 0x8C, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x3E, 0x41, 0x80, 0x80, 0x40, 0x30, 0x0E, 0x01, 0x01,
  0x01, 0x01, 0xFE, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x07, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x6F, 0xD0, 0x80, 0x60, 0x24, 0x09, 0x02,
  0x21, 0x08, 0x42, 0x10, 0x48, 0x12, 0x05, 0x00, 0xC0, 0x30, 0x81, 0x02,
  0x83, 0x05, 0x06, 0x0A, 0x14, 0x24, 0x24, 0x44, 0x48, 0x89, 0x11, 0x12,
  0x14, 0x14, 0x28, 0x30, 0x50, 0x60, 0x40, 0x40, 0x80, 0x80, 0xA0, 0x90,
  0x84, 0x41, 0x40, 0xC0, 0x60, 0x28, 0x22, 0x21, 0x10, 0x50, 0x10, 0x80,
  0x60, 0x24, 0x09, 0x02, 0x21, 0x08, 0x42, 0x10, 0x48, 0x12, 0x05, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0xE0, 0x00, 0xFF, 0x01, 0x02,
  0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0xFF, 0x0C, 0x42, 0x08,
  0x20, 0x82, 0x08, 0x23, 0x04, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0xC0,
  0xFF, 0xFF, 0xFC, 0xC0, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x31, 0x84,
  0x10, 0x41, 0x04, 0x10, 0x8E, 0x00, 0x78, 0x61, 0xF0,
};

const GFXglyph NotoSans_ExtraLight22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 4, 6, 7, 2, -16 },
  { 6, 13, 16, 14, 1, -16 },
  { 32, 10, 18, 13, 1, -17 },
  { 55, 15, 16, 18, 1, -16 },
  { 85, 14, 16, 16, 1, -16 },
  { 113, 1, 6, 4, 2, -16 },
  { 114, 4, 19, 6, 1, -16 },
  { 124, 4, 19, 6, 1, -16 },
  { 134, 10, 9, 12, 1, -17 },
  { 146, 10, 10, 13, 1, -13 },
  { 159, 2, 6, 4, 1, -3 },
  { 161, 5, 1, 7, 1, -6 },
  { 162, 1, 2, 5, 2, -2 },
  { 163, 7, 16, 7, 0, -16 },
  { 177, 10, 16, 13, 1, -16 },
  { 197, 5, 16, 13, 2, -16 },
  { 207, 10, 16, 13, 1, -16 },
  { 227, 10, 16, 13, 1, -16 },
  { 247, 11, 16, 13, 1, -16 },
  { 269, 9, 16, 13, 2, -16 },
  { 287, 10, 16, 13, 1, -16 },
  { 307, 10, 16, 13, 1, -16 },
  { 327, 10, 16, 13, 1, -16 },
  { 347, 10, 16, 13, 1, -16 },
  { 367, 1, 12, 5, 2, -12 },
  { 369, 2, 15, 5, 1, -12 },
  { 373, 10, 10, 13, 1, -13 },
  { 386, 10, 5, 13, 1, -10 },
  { 393, 10, 10, 13, 1, -13 },
  { 406, 7, 16, 9, 1, -16 },
  { 420, 17, 18, 19, 1, -16 },
  { 459, 13, 16, 13, 0, -16 },
  { 485, 10, 16, 14, 2, -16 },
  { 505, 12, 16, 14, 1, -16 },
  { 529, 12, 16, 15, 2, -16 },
  { 553, 9, 16, 12, 2, -16 },
  { 571, 9, 16, 11, 2, -16 },
  { 589, 13, 16, 16, 1, -16 },
  { 615, 11, 16, 16, 2, -16 },
  { 637, 4, 16, 6, 1, -16 },
  { 645, 5, 20, 5, -2, -16 },
  { 658, 11, 16, 13, 2, -16 },
  { 680, 9, 16, 11, 2, -16 },
  { 698, 14, 16, 19, 2, -16 },
  { 726, 11, 16, 16, 2, -16 },
  { 748, 14, 16, 17, 1, -16 },
  { 776, 10, 16, 13, 2, -16 },
  { 796, 14, 20, 17, 1, -16 },
  { 831, 10, 16, 13, 2, -16 },
  { 851, 10, 16, 12, 1, -16 },
  { 871, 11, 16, 11, 0, -16 },
  { 893, 12, 16, 16, 2, -16 },
  { 917, 13, 16, 13, 0, -16 },
  { 943, 18, 16, 19, 1, -16 },
  { 979, 12, 16, 12, 0, -16 },
  { 1003, 11, 16, 11, 0, -16 },
  { 1025, 11, 16, 13, 1, -16 },
  { 1047, 4, 19, 7, 2, -16 },
  { 1057, 7, 16, 7, 0, -16 },
  { 1071, 4, 19, 7, 1, -16 },
  { 1081, 11, 10, 13, 1, -16 },
  { 1095, 9, 1, 9, 0, 2 },
  { 1097, 4, 4, 6, 1, -17 },
  { 1099, 9, 12, 11, 1, -12 },
  { 1113, 10, 17, 13, 2, -17 },
  { 1135, 9, 12, 10, 1, -12 },
  { 1149, 10, 17, 13, 1, -17 },
  { 1171, 10, 12, 12, 1, -12 },
  { 1186, 8, 17, 6, 0, -17 },
  { 1203, 10, 17, 13, 1, -12 },
  { 1225, 9, 17, 13, 2, -17 },
  { 1245, 1, 16, 5, 2, -16 },
  { 1247, 4, 21, 5, -1, -16 },
  { 1258, 8, 17, 10, 2, -17 },
  { 1275, 1, 17, 5, 2, -17 },
  { 1278, 15, 12, 19, 2, -12 },
  { 1301, 9, 12, 13, 2, -12 },
  { 1315, 10, 12, 13, 1, -12 },
  { 1330, 10, 17, 13, 2, -12 },
  { 1352, 10, 17, 13, 1, -12 },
  { 1374, 6, 12, 8, 2, -12 },
  { 1383, 8, 12, 10, 1, -12 },
  { 1395, 7, 15, 7, 0, -15 },
  { 1409, 9, 12, 13, 2, -12 },
  { 1423, 10, 12, 10, 0, -12 },
  { 1438, 15, 12, 16, 0, -12 },
  { 1461, 9, 12, 11, 1, -12 },
  { 1475, 10, 17, 10, 0, -12 },
  { 1497, 8, 12, 10, 1, -12 },
  { 1509, 6, 19, 8, 1, -16 },
  { 1524, 1, 22, 12, 5, -17 },
  { 1527, 6, 19, 8, 1, -16 },
  { 1542, 10, 2, 13, 1, -9 },
};

const GFXfont NotoSans_ExtraLight22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRALIGHT22PT7B_H_
