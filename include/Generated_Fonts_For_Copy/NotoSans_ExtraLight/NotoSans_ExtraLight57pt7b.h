#ifndef _NOTOSANS_EXTRALIGHT57PT7B_H_
#define _NOTOSANS_EXTRALIGHT57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight57pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x0E, 0xEF, 0xE4, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x03,
  0xF6, 0x3F, 0x8F, 0x0C, 0x06, 0x38, 0x18, 0x00, 0x60, 0x30, 0x01, 0xC0,
  0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x60,
  0x00, 0xE0, 0xC0, 0x00, 0xF1, 0x80, 0x00, 0xFB, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x33, 0xE0, 0x00, 0x61, 0xE0,
  0x00, 0xC0, 0xE0, 0x01, 0x80, 0xE0, 0x03, 0x00, 0xE0, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x70, 0x03, 0x00, 0xC0, 0x06, 0x03, 0xA0, 0x0C,
  0x1E, 0x7E, 0x18, 0xF8, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0x00, 0x1F, 0xF0, 0x00, 0x0E, 0x00, 0x60, 0x70, 0x00, 0x18,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x03, 0x80, 0x06, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x00, 0x60,
  0x01, 0x81, 0x80, 0x00, 0xE0, 0x03, 0x06, 0x07, 0xC0, 0xC0, 0x06, 0x0C,
  0x3F, 0xE1, 0x80, 0x18, 0x30, 0xE0, 0xE3, 0x00, 0x30, 0xE3, 0x80, 0xE7,
  0x00, 0x61, 0x86, 0x00, 0xC6, 0x01, 0x86, 0x1C, 0x01, 0x86, 0x07, 0x0C,
  0x30, 0x01, 0x8F, 0xFC, 0x30, 0x60, 0x03, 0x07, 0xE0, 0x60, 0xC0, 0x06,
  0x00, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x00, 0x60, 0x38, 0x00,
  0xC0, 0x01, 0x80, 0x30, 0x01, 0x80, 0x03, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x0E,
  0x00, 0x0C, 0x03, 0x80, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x70, 0x00, 0x1E,
  0x38, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC1, 0xC0, 0x0E, 0x00, 0x0C, 0x38,
  0x00, 0x70, 0x01, 0xC3, 0x00, 0x03, 0x80, 0x18, 0x70, 0x00, 0x1C, 0x01,
  0x86, 0x00, 0x00, 0xE0, 0x38, 0x60, 0x00, 0x0F, 0x03, 0x06, 0x00, 0x00,
  0x78, 0x70, 0xE0, 0x00, 0x03, 0xC6, 0x0E, 0x00, 0x00, 0x1E, 0xC0, 0x60,
  0x00, 0x00, 0xFC, 0x06, 0x00, 0x00, 0x07, 0x80, 0x60, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x01, 0xCE, 0x01, 0xC0, 0x00,
  0x78, 0x70, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x7F, 0xFF, 0xC0, 0x1C, 0x01,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0xE0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x70, 0x08, 0x03, 0xFE, 0x04,
  0x0F, 0xC7, 0xE2, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x60, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x71, 0xC6, 0x18, 0xE3,
  0x8C, 0x30, 0xC6, 0x18, 0x63, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xEE, 0xFE,
  0x40, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x38, 0x07, 0x80, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07,
  0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x67, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x70,
  0x00, 0x18, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x07, 0xCF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x3E, 0x07, 0xB0, 0x73, 0x87, 0x1C, 0xF0, 0xEE, 0x07, 0xE0,
  0x3E, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07,
  0xC0, 0x3C, 0x0F, 0x80, 0x07, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0x80, 0x1E, 0x0F,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE4, 0x00, 0x00,
  0xF3, 0xC0, 0x01, 0xE1, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01, 0x87,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x06, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC4, 0x00, 0x01, 0xE3, 0xC0, 0x03, 0xC0, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x7F, 0xC0, 0x60, 0xFF,
  0xF8, 0x31, 0xE0, 0x0E, 0x19, 0xC0, 0x03, 0x8D, 0x80, 0x00, 0x67, 0x80,
  0x00, 0x3B, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01,
  0xB8, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x60, 0x70, 0x00, 0x60, 0x1C, 0x00, 0xF0, 0x07, 0xE7, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x78, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x0E,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x38, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x00, 0x78, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x78, 0x00,
  0x38, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x06, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x1F, 0x87, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x38, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x1B, 0x38, 0x00, 0x0F, 0xC7, 0x00, 0x07, 0x70,
  0xE0, 0x07, 0x9C, 0x1F, 0xFF, 0x86, 0x01, 0xFF, 0x81, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x4E, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xEF, 0xE4, 0x08, 0x38, 0x78,
  0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0C,
  0x18, 0x30, 0xE1, 0x83, 0x06, 0x18, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0,
  0xF0, 0x07, 0x88, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xFF, 0x80, 0x06, 0x30, 0x00,
  0x3F, 0xFE, 0x00, 0x63, 0x00, 0x0F, 0x00, 0x60, 0x06, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x36, 0x00, 0x38, 0x00, 0x60, 0x03, 0x60, 0x03, 0x00, 0x06,
  0x00, 0x36, 0x00, 0x60, 0x00, 0x60, 0x03, 0xE0, 0x06, 0x00, 0x06, 0x00,
  0x3C, 0x00, 0xC0, 0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x3C,
  0x00, 0xC0, 0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x3C, 0x00,
  0xC0, 0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xC0,
  0x00, 0xE0, 0x03, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x6C, 0x00, 0xC0, 0x00,
  0xE0, 0x06, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x66, 0x00, 0x60, 0x01, 0x60,
  0x0C, 0x60, 0x07, 0x00, 0x73, 0x01, 0xC6, 0x00, 0x3C, 0x0E, 0x38, 0x38,
  0x60, 0x01, 0xFF, 0xC1, 0xFF, 0x03, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x38, 0x01, 0x80, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0xFF, 0x83, 0x00, 0x00,
  0xF8, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x0F, 0x0C, 0x00,
  0x3F, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x0F, 0x0C,
  0x00, 0x00, 0xF3, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x07,
  0x30, 0x00, 0x07, 0x8C, 0x00, 0x07, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x10, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0x40, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xFF, 0x80, 0x30, 0x00,
  0x0F, 0x80, 0xC0, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x0F, 0x03, 0x00, 0x00, 0xF8, 0x0C, 0x00, 0x1F,
  0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xB0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x60,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87,
  0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x81, 0xE7, 0xFE,
  0x3F, 0xC0, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x07,
  0x03, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x0C, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x0C,
  0x07, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0xE0, 0x00,
  0x0C, 0x7C, 0x00, 0x03, 0x3B, 0x80, 0x00, 0xDC, 0x70, 0x00, 0x36, 0x1C,
  0x00, 0x0F, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0x80,
  0x30, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x30, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0E, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x00, 0x0D, 0xEC, 0x00, 0x00, 0x00,
  0xDF, 0x70, 0x00, 0x00, 0x06, 0xF9, 0x80, 0x00, 0x00, 0x77, 0xCE, 0x00,
  0x00, 0x03, 0x3E, 0x30, 0x00, 0x00, 0x19, 0xF1, 0x80, 0x00, 0x01, 0x8F,
  0x8E, 0x00, 0x00, 0x0C, 0x7C, 0x30, 0x00, 0x00, 0xE3, 0xE1, 0xC0, 0x00,
  0x06, 0x1F, 0x06, 0x00, 0x00, 0x30, 0xF8, 0x30, 0x00, 0x03, 0x07, 0xC1,
  0xC0, 0x00, 0x18, 0x3E, 0x06, 0x00, 0x01, 0xC1, 0xF0, 0x38, 0x00, 0x0C,
  0x0F, 0x80, 0xC0, 0x00, 0x60, 0x7C, 0x06, 0x00, 0x06, 0x03, 0xE0, 0x38,
  0x00, 0x30, 0x1F, 0x00, 0xC0, 0x03, 0x80, 0xF8, 0x07, 0x00, 0x18, 0x07,
  0xC0, 0x18, 0x00, 0xC0, 0x3E, 0x00, 0xC0, 0x0C, 0x01, 0xF0, 0x07, 0x00,
  0x60, 0x0F, 0x80, 0x18, 0x07, 0x00, 0x7C, 0x00, 0xE0, 0x30, 0x03, 0xE0,
  0x03, 0x01, 0x80, 0x1F, 0x00, 0x18, 0x18, 0x00, 0xF8, 0x00, 0xE0, 0xC0,
  0x07, 0xC0, 0x03, 0x0E, 0x00, 0x3E, 0x00, 0x1C, 0x60, 0x01, 0xF0, 0x00,
  0x67, 0x00, 0x0F, 0x80, 0x03, 0x30, 0x00, 0x7C, 0x00, 0x1D, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x0E,
  0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xEC, 0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x07,
  0xC6, 0x00, 0x00, 0x3E, 0x38, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x0F, 0x83,
  0x00, 0x00, 0x7C, 0x1C, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x1F, 0x01, 0x80,
  0x00, 0xF8, 0x0E, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x3E, 0x00, 0xE0, 0x01,
  0xF0, 0x07, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x7C, 0x00, 0x70, 0x03, 0xE0,
  0x03, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0x38, 0x07, 0xC0, 0x01,
  0xC0, 0x3E, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0xE0,
  0x7C, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x30, 0x78,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x18, 0xF0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0D, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x05, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0xC0, 0x0F, 0xF0, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x3C,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70,
  0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0xFF, 0x03,
  0x00, 0x01, 0xE0, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x01, 0xE0, 0xC0, 0x01, 0xE0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x30,
  0x00, 0xE0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x38, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x03, 0xE0,
  0x07, 0xC3, 0x80, 0x00, 0x43, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF3, 0x80, 0x01, 0xE1, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x7C, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x33, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x78, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xB8, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x60, 0x00, 0x1C,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x60,
  0xE0, 0x00, 0x61, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x81,
  0x80, 0x03, 0x87, 0x00, 0x06, 0x03, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x18, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x70, 0x18, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0xE0, 0x0C, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x18, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0xE0, 0x01, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x06,
  0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x61, 0xC0, 0x00, 0x31, 0xC0,
  0x00, 0xE3, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE6, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x38, 0x00, 0x01, 0xB8, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x18, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0xE0, 0x06, 0x00, 0x03, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0x30, 0x03, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x30,
  0x00, 0x60, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x1C,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x01, 0xF8, 0x3E, 0x07,
  0x00, 0x1C, 0x10, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F,
  0x80, 0x0C, 0xF0, 0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFE, 0x00, 0x06, 0xD8, 0x00, 0x33, 0x78, 0x01, 0x8C, 0xFC,
  0x7C, 0x30, 0xFF, 0xE0, 0xC0, 0x38, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x03, 0xF0, 0x06,
  0x0F, 0xFF, 0x03, 0x0F, 0x87, 0xC1, 0x8C, 0x00, 0x78, 0xCC, 0x00, 0x1C,
  0x6C, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6F,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x33, 0x60, 0x00, 0x39, 0xB8, 0x00, 0x38,
  0xCE, 0x00, 0x78, 0x63, 0xF3, 0xF8, 0x30, 0x7F, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0x87, 0xC1, 0xE0, 0x01,
  0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x04, 0x0F, 0xF7, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x3F, 0x01, 0xC0,
  0x7F, 0xF8, 0x70, 0x3E, 0x0F, 0x1C, 0x1C, 0x00, 0x67, 0x0E, 0x00, 0x0D,
  0xC7, 0x00, 0x01, 0xB3, 0x80, 0x00, 0x6C, 0xC0, 0x00, 0x0F, 0x70, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x0F, 0x30, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xB1, 0x80, 0x00, 0x6C,
  0x70, 0x00, 0x33, 0x0F, 0x00, 0x38, 0xC1, 0xFC, 0xFC, 0x30, 0x1F, 0xFC,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xF8,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x38, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x1F,
  0xCF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0xFC, 0x03, 0xE7, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x30,
  0x3E, 0x0F, 0x8C, 0x1C, 0x00, 0x77, 0x0E, 0x00, 0x0D, 0xC7, 0x00, 0x01,
  0xF3, 0x80, 0x00, 0x3C, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x60, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x30,
  0x00, 0x03, 0xCE, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x37,
  0x0F, 0x00, 0x39, 0xC0, 0xFC, 0xFC, 0x70, 0x1F, 0xFC, 0x1C, 0x00, 0x20,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x20, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0xFC, 0x1F,
  0x80, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x03, 0xE0, 0x18, 0x3F, 0xFC,
  0x30, 0xF0, 0x7C, 0x67, 0x00, 0x1C, 0xCC, 0x00, 0x1D, 0xB0, 0x00, 0x1B,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x18,
  0x7F, 0x76, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0xE0, 0x3C,
  0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC8, 0x79, 0xFE, 0x0F,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x0B, 0x00, 0x01, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x83,
  0x00, 0x0E, 0x0C, 0x00, 0x70, 0x30, 0x03, 0x80, 0xC0, 0x1C, 0x03, 0x00,
  0xE0, 0x0C, 0x07, 0x00, 0x30, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00,
  0x0C, 0x3C, 0x00, 0x31, 0xB0, 0x00, 0xCC, 0xE0, 0x03, 0x61, 0xC0, 0x0F,
  0x03, 0x80, 0x3C, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x38, 0x0C, 0x00,
  0x70, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x83, 0x00, 0x07, 0x0C, 0x00, 0x0E,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0xC7, 0x83, 0xC1,
  0xF0, 0x78, 0xCE, 0x00, 0xE3, 0x80, 0x1C, 0xD8, 0x00, 0x77, 0x00, 0x0E,
  0xD0, 0x00, 0x36, 0x00, 0x06, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x3F,
  0x01, 0x83, 0xFF, 0xC3, 0x0F, 0x07, 0xC6, 0x70, 0x01, 0xCC, 0xC0, 0x01,
  0xDB, 0x00, 0x01, 0xBC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0x83, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x0E, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0x00, 0x60, 0xFF, 0xF0, 0x30, 0xF8,
  0x3E, 0x18, 0xE0, 0x07, 0x8C, 0xC0, 0x00, 0xC6, 0xC0, 0x00, 0x73, 0x60,
  0x00, 0x1D, 0xE0, 0x00, 0x06, 0xF0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x06, 0xF0, 0x00, 0x07, 0x68, 0x00,
  0x03, 0x36, 0x00, 0x03, 0x99, 0x80, 0x03, 0x8C, 0x70, 0x07, 0x86, 0x1F,
  0xBF, 0x83, 0x07, 0xFF, 0x01, 0x80, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xF0, 0x40, 0xF8, 0x3C, 0x61, 0xE0, 0x03, 0x30, 0xC0,
  0x00, 0xD8, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x60, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0x30, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xC6, 0x00, 0x03, 0x63, 0x80,
  0x03, 0xB0, 0xF0, 0x03, 0x98, 0x3F, 0x1F, 0x8C, 0x07, 0xFF, 0x06, 0x00,
  0x3C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x3C, 0xC1, 0xFF, 0xC7, 0xC7, 0xCE, 0x00,
  0xDC, 0x00, 0xD8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xC0,
  0xF8, 0x3F, 0x87, 0x00, 0x04, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xA0, 0x00, 0x0E, 0xE0,
  0x00, 0xF3, 0xFC, 0x7F, 0x81, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0xE7,
  0x01, 0xFF, 0x00, 0x10, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1E, 0xC0, 0x00, 0x6D, 0xC0, 0x01, 0x99, 0xE0, 0x0E,
  0x31, 0xF9, 0xF8, 0x60, 0xFF, 0xE0, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x1C,
  0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x00,
  0x60, 0x03, 0x80, 0x38, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x80, 0x60, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x80, 0x01, 0xD8, 0x00,
  0x1B, 0x00, 0x06, 0x70, 0x00, 0x6C, 0x00, 0x19, 0xC0, 0x01, 0xB0, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0x31, 0x80, 0x0C, 0x38, 0x00,
  0xC6, 0x00, 0x30, 0x60, 0x06, 0x1C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x07,
  0x06, 0x00, 0x60, 0xC0, 0x18, 0x1C, 0x03, 0x03, 0x80, 0x60, 0x30, 0x0C,
  0x06, 0x03, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x81, 0x80, 0x70, 0x30,
  0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x07, 0x00, 0x60, 0xE0,
  0x0E, 0x18, 0x01, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x70, 0x01, 0x8E, 0x00, 0x39, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00,
  0x0C, 0xC0, 0x01, 0xB8, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x70, 0x00, 0x03, 0x9C, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x81, 0x80, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x38,
  0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0x60, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x18, 0x60, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x0E,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x80, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x00, 0xC0,
  0x70, 0x00, 0x70, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x07,
  0x0C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x43, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x0F, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x17, 0x03,
  0xE0, 0x0F, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x00,
};

const GFXglyph NotoSans_ExtraLight57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 42, 13, 5, -41 },
  { 22, 11, 15, 19, 4, -41 },
  { 43, 33, 41, 37, 2, -41 },
  { 213, 23, 46, 32, 4, -43 },
  { 346, 39, 42, 46, 3, -41 },
  { 551, 36, 42, 40, 3, -41 },
  { 740, 2, 15, 10, 4, -41 },
  { 744, 11, 50, 15, 2, -41 },
  { 813, 11, 50, 15, 2, -41 },
  { 882, 25, 23, 31, 3, -43 },
  { 954, 26, 26, 32, 3, -33 },
  { 1039, 6, 14, 11, 2, -7 },
  { 1050, 14, 2, 18, 2, -16 },
  { 1054, 4, 5, 13, 5, -4 },
  { 1057, 17, 41, 19, 1, -41 },
  { 1145, 26, 42, 32, 3, -41 },
  { 1282, 13, 41, 32, 6, -41 },
  { 1349, 25, 41, 32, 3, -41 },
  { 1478, 25, 42, 32, 3, -41 },
  { 1610, 31, 41, 32, 1, -41 },
  { 1769, 25, 42, 32, 4, -41 },
  { 1901, 25, 42, 32, 4, -41 },
  { 2033, 26, 41, 32, 3, -41 },
  { 2167, 26, 42, 32, 3, -41 },
  { 2304, 26, 42, 32, 3, -41 },
  { 2441, 4, 32, 13, 5, -31 },
  { 2457, 7, 38, 13, 2, -31 },
  { 2491, 26, 26, 32, 3, -34 },
  { 2576, 26, 14, 32, 3, -27 },
  { 2622, 26, 26, 32, 3, -34 },
  { 2707, 20, 42, 24, 2, -41 },
  { 2812, 44, 46, 50, 3, -40 },
  { 3065, 34, 41, 34, 0, -41 },
  { 3240, 26, 41, 35, 6, -41 },
  { 3374, 29, 42, 35, 4, -41 },
  { 3527, 30, 41, 40, 6, -41 },
  { 3681, 22, 41, 31, 6, -41 },
  { 3794, 22, 41, 28, 6, -41 },
  { 3907, 33, 42, 41, 4, -41 },
  { 4081, 29, 41, 41, 6, -41 },
  { 4230, 11, 41, 17, 3, -41 },
  { 4287, 13, 51, 14, -5, -41 },
  { 4370, 26, 41, 32, 6, -41 },
  { 4504, 22, 41, 29, 6, -41 },
  { 4617, 37, 41, 49, 6, -41 },
  { 4807, 29, 41, 41, 6, -41 },
  { 4956, 36, 42, 43, 4, -41 },
  { 5145, 24, 41, 33, 6, -41 },
  { 5268, 36, 51, 43, 4, -41 },
  { 5498, 26, 41, 33, 6, -41 },
  { 5632, 25, 42, 31, 3, -41 },
  { 5764, 29, 41, 29, 0, -41 },
  { 5913, 30, 42, 41, 5, -41 },
  { 6071, 33, 41, 33, 0, -41 },
  { 6241, 47, 41, 50, 2, -41 },
  { 6482, 30, 41, 30, 0, -41 },
  { 6636, 29, 41, 29, 0, -41 },
  { 6785, 29, 41, 33, 2, -41 },
  { 6934, 12, 50, 18, 5, -41 },
  { 7009, 17, 41, 19, 1, -41 },
  { 7097, 12, 50, 18, 1, -41 },
  { 7172, 27, 25, 32, 3, -41 },
  { 7257, 23, 2, 23, 0, 5 },
  { 7263, 10, 9, 15, 2, -44 },
  { 7275, 22, 32, 30, 3, -31 },
  { 7363, 25, 44, 34, 5, -43 },
  { 7501, 22, 32, 27, 3, -31 },
  { 7589, 26, 44, 34, 3, -43 },
  { 7732, 25, 32, 31, 3, -31 },
  { 7832, 19, 44, 16, 1, -44 },
  { 7937, 26, 45, 34, 3, -31 },
  { 8084, 23, 43, 33, 5, -43 },
  { 8208, 4, 41, 12, 4, -41 },
  { 8229, 11, 55, 12, -3, -41 },
  { 8305, 22, 43, 27, 5, -43 },
  { 8424, 2, 43, 12, 5, -43 },
  { 8435, 40, 31, 50, 5, -31 },
  { 8590, 23, 31, 33, 5, -31 },
  { 8680, 27, 32, 33, 3, -31 },
  { 8788, 25, 44, 34, 5, -31 },
  { 8926, 25, 44, 34, 3, -31 },
  { 9064, 16, 31, 22, 5, -31 },
  { 9126, 22, 32, 26, 2, -31 },
  { 9214, 16, 39, 19, 1, -38 },
  { 9292, 23, 31, 33, 5, -30 },
  { 9382, 25, 30, 25, 0, -30 },
  { 9476, 38, 30, 40, 1, -30 },
  { 9619, 25, 30, 28, 1, -30 },
  { 9713, 25, 44, 25, 0, -30 },
  { 9851, 22, 30, 26, 2, -30 },
  { 9934, 17, 50, 20, 1, -41 },
  { 10041, 2, 57, 31, 14, -43 },
  { 10056, 16, 50, 20, 2, -41 },
  { 10156, 26, 6, 32, 3, -23 },
};

const GFXfont NotoSans_ExtraLight57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRALIGHT57PT7B_H_
