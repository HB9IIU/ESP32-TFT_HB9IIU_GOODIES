#ifndef _NOTOSANS_EXTRALIGHT12PT7B_H_
#define _NOTOSANS_EXTRALIGHT12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFF, 0x12, 0x28, 0x93, 0xF2, 0x44, 0xBE, 0x94, 0x48,
  0x75, 0x29, 0x44, 0x18, 0xA5, 0xF1, 0x00, 0x42, 0xA4, 0xA4, 0xAA, 0xB5,
  0x59, 0x29, 0x29, 0x47, 0x71, 0x12, 0x22, 0x86, 0x12, 0x62, 0xC2, 0xFA,
  0xF0, 0x29, 0x49, 0x24, 0x48, 0x80, 0x89, 0x12, 0x49, 0x4A, 0x00, 0x21,
  0x7C, 0xC9, 0x00, 0x21, 0x3E, 0x42, 0x10, 0x68, 0xE0, 0x80, 0x11, 0x22,
  0x24, 0x48, 0x80, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x2E, 0x92, 0x49,
  0x20, 0x74, 0x42, 0x11, 0x11, 0x08, 0xF8, 0x74, 0x42, 0x17, 0x04, 0x21,
  0xF0, 0x08, 0x10, 0x61, 0x44, 0x89, 0x3F, 0x84, 0x08, 0xFC, 0x21, 0x0F,
  0x04, 0x21, 0xF0, 0x3A, 0x21, 0x4D, 0xC6, 0x31, 0x70, 0xF8, 0x42, 0x21,
  0x10, 0x88, 0x40, 0x74, 0x63, 0x17, 0x46, 0x31, 0xF0, 0x74, 0x63, 0x18,
  0xBC, 0x21, 0xF0, 0x84, 0x40, 0x1A, 0x1B, 0x20, 0xC1, 0x80, 0xF8, 0x3E,
  0x83, 0x82, 0x6C, 0x00, 0xF0, 0x42, 0x11, 0x11, 0x00, 0x40, 0x1C, 0x31,
  0xA0, 0x33, 0x9A, 0x4D, 0x26, 0x93, 0x36, 0x80, 0x3F, 0x00, 0x10, 0x20,
  0xA1, 0x42, 0x4F, 0x91, 0x41, 0x82, 0xF2, 0x38, 0x61, 0xFA, 0x18, 0x61,
  0xF8, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7C, 0xF1, 0x1A, 0x14, 0x18,
  0x30, 0x60, 0xC2, 0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0xF8, 0xFC, 0x21,
  0x0F, 0xC2, 0x10, 0x80, 0x3E, 0x82, 0x04, 0x09, 0xD0, 0x60, 0xC1, 0x7E,
  0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xEA, 0xAA, 0xC0, 0x24, 0x92,
  0x49, 0x27, 0x00, 0x86, 0x29, 0x28, 0xE2, 0x89, 0x22, 0x84, 0x84, 0x21,
  0x08, 0x42, 0x10, 0xF8, 0x81, 0x81, 0xC3, 0xC3, 0xA5, 0xA5, 0x95, 0x99,
  0x89, 0x86, 0x1C, 0x69, 0x96, 0x58, 0xE1, 0x84, 0x38, 0x8E, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x7C, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x80, 0x38, 0x8E,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x74, 0x10, 0x10, 0xF2, 0x28, 0x62, 0x8B,
  0xC9, 0x22, 0x84, 0x7C, 0x21, 0x06, 0x0C, 0x21, 0xF0, 0xFC, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0x83,
  0x05, 0x12, 0x24, 0x45, 0x0A, 0x18, 0x10, 0x84, 0x61, 0x14, 0xC5, 0x29,
  0x4A, 0x94, 0xA3, 0x28, 0xC4, 0x21, 0x00, 0x85, 0x14, 0x8C, 0x10, 0xC4,
  0x91, 0x84, 0x86, 0x14, 0x92, 0x30, 0x41, 0x04, 0x10, 0x7C, 0x10, 0x82,
  0x10, 0x82, 0x10, 0xFC, 0xEA, 0xAA, 0xAC, 0x88, 0x44, 0x42, 0x21, 0x10,
  0xE4, 0x92, 0x49, 0x27, 0x80, 0x23, 0x15, 0x28, 0xC4, 0xF8, 0xC4, 0xF1,
  0x79, 0x9F, 0x84, 0x2D, 0x98, 0xC6, 0x31, 0xF8, 0xF8, 0x88, 0x87, 0x08,
  0x5F, 0x18, 0xC6, 0x31, 0xF8, 0xFC, 0x7F, 0x08, 0x3C, 0x74, 0xE4, 0x44,
  0x44, 0x40, 0xFC, 0x63, 0x18, 0xFC, 0x21, 0xF0, 0x84, 0x2D, 0x98, 0xC6,
  0x31, 0x88, 0x9F, 0x80, 0x20, 0x12, 0x49, 0x24, 0xE0, 0x84, 0x21, 0x2A,
  0x62, 0x92, 0x88, 0xFF, 0x80, 0xFF, 0x89, 0x89, 0x89, 0x89, 0x89, 0xFC,
  0x63, 0x18, 0xC4, 0xFC, 0x63, 0x18, 0xB8, 0xFC, 0x63, 0x18, 0xFE, 0x10,
  0x80, 0xFC, 0x63, 0x18, 0xFC, 0x21, 0x08, 0xF2, 0x49, 0x00, 0x7C, 0x1C,
  0x10, 0xFC, 0x4F, 0x44, 0x44, 0x47, 0x8C, 0x63, 0x18, 0xFC, 0x8C, 0x52,
  0xA2, 0x10, 0x89, 0x99, 0x55, 0x55, 0x66, 0x22, 0xC9, 0x42, 0x0C, 0x4A,
  0x30, 0x8C, 0x52, 0xA2, 0x10, 0x84, 0xC0, 0x78, 0x88, 0x44, 0x7C, 0x12,
  0x44, 0x4C, 0x44, 0x44, 0x30, 0xFF, 0xF0, 0xC2, 0x22, 0x21, 0x22, 0x22,
  0xC0, 0xF8,
};

const GFXglyph NotoSans_ExtraLight12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 4, 4, 1, -9 },
  { 4, 7, 9, 8, 0, -9 },
  { 12, 5, 10, 7, 1, -9 },
  { 19, 8, 9, 10, 1, -9 },
  { 28, 7, 9, 9, 1, -9 },
  { 36, 1, 4, 2, 1, -9 },
  { 37, 3, 11, 3, 0, -9 },
  { 42, 3, 11, 3, 0, -9 },
  { 47, 5, 5, 7, 1, -9 },
  { 51, 5, 6, 7, 1, -7 },
  { 55, 2, 3, 2, 0, -1 },
  { 56, 3, 1, 4, 0, -4 },
  { 57, 1, 1, 3, 1, -1 },
  { 58, 4, 9, 4, 0, -9 },
  { 63, 5, 9, 7, 1, -9 },
  { 69, 3, 9, 7, 1, -9 },
  { 73, 5, 9, 7, 1, -9 },
  { 79, 5, 9, 7, 1, -9 },
  { 85, 7, 9, 7, 0, -9 },
  { 93, 5, 9, 7, 1, -9 },
  { 99, 5, 9, 7, 1, -9 },
  { 105, 5, 9, 7, 1, -9 },
  { 111, 5, 9, 7, 1, -9 },
  { 117, 5, 9, 7, 1, -9 },
  { 123, 1, 6, 3, 1, -6 },
  { 124, 2, 8, 3, 0, -6 },
  { 126, 5, 5, 7, 1, -7 },
  { 130, 5, 3, 7, 1, -6 },
  { 132, 5, 5, 7, 1, -7 },
  { 136, 5, 9, 5, 0, -9 },
  { 142, 9, 10, 11, 1, -9 },
  { 154, 7, 9, 7, 0, -9 },
  { 162, 6, 9, 7, 1, -9 },
  { 169, 6, 9, 7, 1, -9 },
  { 176, 7, 9, 8, 1, -9 },
  { 184, 5, 9, 7, 1, -9 },
  { 190, 5, 9, 6, 1, -9 },
  { 196, 7, 9, 9, 1, -9 },
  { 204, 6, 9, 9, 1, -9 },
  { 211, 2, 9, 4, 1, -9 },
  { 214, 3, 11, 3, -1, -9 },
  { 219, 6, 9, 7, 1, -9 },
  { 226, 5, 9, 6, 1, -9 },
  { 232, 8, 9, 10, 1, -9 },
  { 241, 6, 9, 9, 1, -9 },
  { 248, 7, 9, 9, 1, -9 },
  { 256, 5, 9, 7, 1, -9 },
  { 262, 7, 11, 9, 1, -9 },
  { 272, 6, 9, 7, 1, -9 },
  { 279, 5, 9, 7, 1, -9 },
  { 285, 6, 9, 6, 0, -9 },
  { 292, 6, 9, 9, 1, -9 },
  { 299, 7, 9, 7, 0, -9 },
  { 307, 10, 9, 11, 0, -9 },
  { 319, 6, 9, 6, 0, -9 },
  { 326, 6, 9, 6, 0, -9 },
  { 333, 6, 9, 7, 0, -9 },
  { 340, 2, 11, 4, 1, -9 },
  { 343, 4, 9, 4, 0, -9 },
  { 348, 3, 11, 4, 0, -9 },
  { 353, 5, 6, 7, 1, -9 },
  { 357, 5, 1, 5, 0, 1 },
  { 358, 3, 2, 3, 0, -9 },
  { 359, 4, 6, 6, 1, -6 },
  { 362, 5, 9, 7, 1, -9 },
  { 368, 4, 6, 6, 1, -6 },
  { 371, 5, 9, 7, 1, -9 },
  { 377, 5, 6, 7, 1, -6 },
  { 381, 4, 9, 3, 0, -9 },
  { 386, 5, 9, 7, 1, -6 },
  { 392, 5, 9, 7, 1, -9 },
  { 398, 1, 9, 3, 1, -9 },
  { 400, 3, 12, 3, -1, -9 },
  { 405, 5, 9, 6, 1, -9 },
  { 411, 1, 9, 3, 1, -9 },
  { 413, 8, 6, 10, 1, -6 },
  { 419, 5, 6, 7, 1, -6 },
  { 423, 5, 6, 7, 1, -6 },
  { 427, 5, 9, 7, 1, -6 },
  { 433, 5, 9, 7, 1, -6 },
  { 439, 3, 6, 5, 1, -6 },
  { 442, 5, 6, 6, 0, -6 },
  { 446, 4, 8, 4, 0, -8 },
  { 450, 5, 6, 7, 1, -6 },
  { 454, 5, 6, 5, 0, -6 },
  { 458, 8, 6, 8, 0, -6 },
  { 464, 6, 6, 6, 0, -6 },
  { 469, 5, 9, 5, 0, -6 },
  { 475, 5, 6, 6, 0, -6 },
  { 479, 4, 11, 4, 0, -9 },
  { 485, 1, 12, 6, 3, -9 },
  { 487, 4, 11, 4, 0, -9 },
  { 493, 5, 1, 7, 1, -5 },
};

const GFXfont NotoSans_ExtraLight12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRALIGHT12PT7B_H_
