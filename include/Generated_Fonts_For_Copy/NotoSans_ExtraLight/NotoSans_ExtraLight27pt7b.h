#ifndef _NOTOSANS_EXTRALIGHT27PT7B_H_
#define _NOTOSANS_EXTRALIGHT27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight27pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x50, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x02,
  0x08, 0x02, 0x08, 0x02, 0x08, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x7F,
  0xFF, 0x04, 0x10, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0xFF,
  0xFE, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20,
  0x80, 0x04, 0x00, 0x80, 0x7C, 0x32, 0x6C, 0x41, 0x08, 0x21, 0x04, 0x20,
  0x84, 0x08, 0x80, 0xF0, 0x07, 0x00, 0x58, 0x08, 0x81, 0x08, 0x21, 0x04,
  0x20, 0x8C, 0x11, 0x7B, 0xC0, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x1B,
  0x01, 0x08, 0x40, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x84, 0x08, 0x22,
  0x02, 0x08, 0x80, 0x82, 0x47, 0x20, 0x92, 0x28, 0x49, 0x09, 0xB2, 0x41,
  0x11, 0x10, 0x40, 0x44, 0x10, 0x21, 0x04, 0x18, 0x41, 0x04, 0x10, 0x42,
  0x04, 0x10, 0x81, 0x88, 0x40, 0x3C, 0x06, 0x00, 0x19, 0x80, 0x20, 0x40,
  0x20, 0x40, 0x20, 0x60, 0x20, 0x40, 0x20, 0x40, 0x10, 0x80, 0x0B, 0x00,
  0x0C, 0x00, 0x32, 0x00, 0x61, 0x01, 0xC0, 0x82, 0x80, 0x42, 0x80, 0x24,
  0x80, 0x14, 0x80, 0x08, 0x80, 0x14, 0x60, 0x62, 0x3F, 0x83, 0xFE, 0x18,
  0x88, 0x44, 0x21, 0x18, 0x84, 0x21, 0x08, 0x42, 0x18, 0x42, 0x10, 0x42,
  0x08, 0x60, 0xC2, 0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x10, 0x84, 0x42, 0x23, 0x00, 0x04, 0x00, 0x80, 0x10, 0x42, 0x1F, 0x5C,
  0x1C, 0x02, 0x80, 0x90, 0x11, 0x0C, 0x10, 0x82, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x69, 0x25, 0x00, 0xFE, 0xF0,
  0x01, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x30, 0x00, 0x04, 0x03,
  0xB8, 0x60, 0x44, 0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x40, 0x24,
  0x04, 0x20, 0xC1, 0xF8, 0x0C, 0x56, 0x61, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x04, 0x0F, 0x73, 0x03, 0x00,
  0x20, 0x04, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x7F, 0xF0, 0x06,
  0x03, 0x9C, 0xC0, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x40, 0x38, 0x1F, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x80, 0x67, 0xFC, 0x00, 0x60, 0x02, 0x80, 0x1A, 0x00, 0x48,
  0x02, 0x20, 0x10, 0x80, 0xC2, 0x02, 0x08, 0x10, 0x20, 0x80, 0x82, 0x02,
  0x10, 0x08, 0x80, 0x23, 0xFF, 0xF0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x7F, 0xE4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x60, 0x73, 0x80, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x68, 0x0C, 0x7F, 0x00, 0x01, 0xC0, 0xE2, 0x10,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x8F, 0x8B, 0x04, 0xC0,
  0x28, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x34, 0x02, 0x20,
  0x41, 0xF8, 0xFF, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x06, 0x03, 0x98,
  0x40, 0x4C, 0x02, 0x80, 0x28, 0x02, 0x40, 0x24, 0x04, 0x31, 0x80, 0xE0,
  0x1B, 0x86, 0x0C, 0xC0, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x38, 0x02,
  0x40, 0x43, 0xF8, 0x02, 0x00, 0xEE, 0x08, 0x18, 0x80, 0x44, 0x01, 0x20,
  0x0B, 0x00, 0x58, 0x03, 0x40, 0x1A, 0x00, 0xD8, 0x0A, 0x71, 0xA0, 0x71,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x7E, 0x00,
  0xD0, 0x00, 0x00, 0xF0, 0x64, 0x00, 0x00, 0x00, 0x34, 0x92, 0x80, 0x00,
  0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0x80, 0x00, 0x08, 0x7B, 0x80, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x01, 0x03, 0x03, 0x01, 0x00, 0x80, 0x40, 0x00, 0x00, 0x00, 0x04,
  0x02, 0x00, 0x00, 0xFF, 0x00, 0x38, 0x06, 0x03, 0x00, 0x18, 0x20, 0x00,
  0x62, 0x00, 0x01, 0x10, 0x1E, 0x05, 0x03, 0x08, 0x28, 0x20, 0x41, 0x41,
  0x02, 0x0A, 0x10, 0x10, 0x60, 0x80, 0x83, 0x04, 0x04, 0x18, 0x20, 0x20,
  0xA1, 0x03, 0x05, 0x04, 0x3C, 0x48, 0x1E, 0x3C, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x30, 0x08, 0x10, 0x08, 0x10, 0x10, 0x08, 0x1F, 0xF8,
  0x10, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40, 0x06, 0x40, 0x02, 0x40, 0x02,
  0x80, 0x01, 0xFF, 0x88, 0x06, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x06, 0xFF, 0x88, 0x3C, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x06, 0xFF, 0x80, 0x00, 0x80, 0x3C, 0xF1, 0x80,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x03, 0xFE, 0xFF, 0x82, 0x01, 0x88, 0x01, 0x20,
  0x02, 0x80, 0x0A, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xA0, 0x06, 0x80, 0x32,
  0x03, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0F, 0xFC, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x3F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x00, 0x00, 0x60, 0x0E, 0x3C, 0x60, 0x09, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03,
  0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x40, 0x04, 0x60, 0x08, 0x3F, 0xE0, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0xF0, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xA3, 0x38, 0x80,
  0x38, 0x04, 0x80, 0x88, 0x18, 0x83, 0x08, 0x60, 0x8C, 0x09, 0x80, 0xB8,
  0x0E, 0x80, 0xC4, 0x08, 0x20, 0x83, 0x08, 0x10, 0x80, 0x88, 0x04, 0x80,
  0x68, 0x02, 0x80, 0x10, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x0F, 0xFC, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xF4, 0x00,
  0x5A, 0x00, 0x2C, 0x80, 0x26, 0x40, 0x13, 0x30, 0x19, 0x88, 0x08, 0xC4,
  0x04, 0x61, 0x04, 0x30, 0x82, 0x18, 0x63, 0x0C, 0x11, 0x06, 0x08, 0x83,
  0x02, 0x81, 0x81, 0x40, 0xC0, 0xE0, 0x60, 0x20, 0x20, 0x80, 0x0E, 0x00,
  0x78, 0x03, 0x40, 0x19, 0x00, 0xCC, 0x06, 0x20, 0x30, 0x81, 0x86, 0x0C,
  0x10, 0x60, 0x43, 0x03, 0x18, 0x08, 0xC0, 0x26, 0x01, 0xB0, 0x05, 0x80,
  0x1C, 0x00, 0xE0, 0x02, 0x00, 0x80, 0x07, 0x1C, 0x04, 0x03, 0x04, 0x00,
  0x44, 0x00, 0x32, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x04,
  0x80, 0x02, 0x40, 0x02, 0x10, 0x03, 0x06, 0x03, 0x01, 0xFE, 0x00, 0xFF,
  0x90, 0x1A, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x50,
  0x33, 0xF8, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x07, 0x1C, 0x04, 0x03, 0x04, 0x00, 0x44, 0x00,
  0x32, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x02,
  0x40, 0x02, 0x10, 0x03, 0x06, 0x03, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0xFF, 0x88, 0x0C, 0x80,
  0x68, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0xC8, 0x78, 0xFE,
  0x08, 0x30, 0x81, 0x08, 0x08, 0x80, 0x88, 0x04, 0x80, 0x68, 0x02, 0x80,
  0x10, 0x02, 0x01, 0xCF, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x30, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x03, 0x80, 0x67, 0xF8, 0xFF, 0xFC, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x02, 0x40, 0x19, 0x80,
  0xC1, 0xFC, 0x00, 0x80, 0x02, 0x80, 0x05, 0x00, 0x13, 0x00, 0x22, 0x00,
  0xC4, 0x01, 0x04, 0x02, 0x08, 0x0C, 0x10, 0x10, 0x10, 0x20, 0x20, 0x80,
  0x61, 0x00, 0x42, 0x00, 0x88, 0x00, 0x90, 0x01, 0x60, 0x02, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x34, 0x03, 0x00, 0x90,
  0x14, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x42, 0x08, 0x81, 0x08, 0x21,
  0x04, 0x20, 0x84, 0x10, 0xC2, 0x10, 0x81, 0x10, 0x42, 0x04, 0x40, 0x88,
  0x11, 0x02, 0x60, 0x2C, 0x09, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x08, 0x00, 0x40, 0x0C, 0x80, 0x63,
  0x01, 0x04, 0x08, 0x08, 0x20, 0x21, 0x00, 0x48, 0x01, 0xA0, 0x03, 0x00,
  0x0C, 0x00, 0x68, 0x01, 0x20, 0x08, 0x40, 0x21, 0x81, 0x02, 0x08, 0x04,
  0x20, 0x19, 0x00, 0x28, 0x00, 0x40, 0xC0, 0x0D, 0x00, 0x26, 0x01, 0x08,
  0x04, 0x10, 0x20, 0x40, 0x80, 0x84, 0x02, 0x10, 0x04, 0x80, 0x12, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x7F, 0xF8, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x0F,
  0xFF, 0xC0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC0, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x30,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x60, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x03, 0x00, 0x28,
  0x01, 0x20, 0x11, 0x00, 0x84, 0x08, 0x20, 0x40, 0x84, 0x04, 0x20, 0x12,
  0x00, 0x90, 0x03, 0x00, 0x10, 0xFF, 0xE0, 0x82, 0x08, 0x20, 0x80, 0x06,
  0x07, 0x38, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x7F, 0x30, 0x28,
  0x07, 0x00, 0xC0, 0x3C, 0x06, 0x81, 0x4F, 0xC8, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x86, 0x09, 0x9C, 0xA0, 0x2C, 0x03, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x2A, 0x06, 0x9F, 0x80, 0x02, 0x07, 0x36, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x18, 0x01, 0xFC, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x04, 0x33, 0x99, 0x60,
  0x5C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x56, 0x05, 0x3F, 0x90, 0x04, 0x07, 0x31, 0x81, 0x20,
  0x28, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x47, 0xF0, 0x03, 0x86, 0x46, 0x02, 0x01, 0x00, 0x80, 0x41,
  0xFC, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x06, 0x03, 0x99, 0x60, 0x7C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x76,
  0x07, 0x3F, 0xB0, 0x03, 0x00, 0x20, 0x02, 0x00, 0x28, 0x04, 0xFF, 0x80,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x21, 0x84, 0xCE, 0xA0,
  0x78, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0xB0, 0x0A, 0xAA, 0xAA, 0xAA, 0x10, 0xC0,
  0x00, 0x00, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x17, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x06, 0x81, 0x90, 0x62, 0x18, 0x42, 0x08, 0x81, 0x30, 0x29, 0x06,
  0x30, 0x82, 0x10, 0x22, 0x02, 0x40, 0x68, 0x06, 0xFF, 0xFF, 0xF8, 0x02,
  0x02, 0x13, 0x73, 0x9A, 0x83, 0xC1, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80,
  0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x03,
  0x13, 0xBA, 0x81, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x06, 0x03, 0x9C, 0x60,
  0x64, 0x02, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x40, 0x26, 0x04, 0x1F, 0x80, 0x06, 0x09, 0x9C, 0xA0, 0x2C,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xA0, 0x2B, 0x06, 0x9F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x00, 0x04, 0x07, 0x75, 0x01, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x06, 0xC1, 0xCF, 0xC8,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x06, 0x9F, 0xA0, 0xC0,
  0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x04,
  0x0C, 0x74, 0x01, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x70, 0x03, 0x80, 0x30,
  0x04, 0x01, 0x00, 0x60, 0x3F, 0xF0, 0x10, 0x10, 0x10, 0x30, 0xFF, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x0F,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xA0, 0x36, 0x0A, 0x7E, 0x40, 0x80, 0x14, 0x02, 0x40,
  0x26, 0x06, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x10, 0x80, 0x90, 0x09,
  0x00, 0x70, 0x06, 0x00, 0x60, 0xC0, 0x40, 0x68, 0x0C, 0x09, 0x02, 0x81,
  0x30, 0x50, 0x22, 0x09, 0x08, 0x42, 0x21, 0x08, 0x44, 0x20, 0x88, 0x4C,
  0x12, 0x09, 0x02, 0x41, 0x20, 0x68, 0x14, 0x06, 0x03, 0x80, 0xC0, 0x60,
  0x18, 0x04, 0x00, 0xC0, 0x68, 0x08, 0x82, 0x08, 0x81, 0x90, 0x14, 0x01,
  0x00, 0x50, 0x0B, 0x02, 0x20, 0x82, 0x30, 0x64, 0x05, 0x00, 0x40, 0x80,
  0x14, 0x02, 0x40, 0x26, 0x06, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x18,
  0x80, 0x90, 0x09, 0x00, 0x70, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x0B, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x30, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80, 0x40, 0x3F,
  0xF0, 0x0E, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x86, 0x02,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x0C, 0x03, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10,
  0xE0, 0x3C, 0x0E, 0x18, 0xE0, 0x38,
};

const GFXglyph NotoSans_ExtraLight27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 5, 7, 9, 2, -19 },
  { 11, 16, 19, 17, 1, -19 },
  { 49, 11, 23, 15, 2, -21 },
  { 81, 18, 20, 22, 2, -20 },
  { 126, 16, 20, 19, 2, -20 },
  { 166, 1, 7, 5, 2, -19 },
  { 167, 5, 23, 7, 1, -19 },
  { 182, 5, 23, 7, 1, -19 },
  { 197, 11, 11, 15, 2, -20 },
  { 213, 13, 13, 15, 1, -16 },
  { 235, 3, 6, 5, 1, -3 },
  { 238, 7, 1, 9, 1, -8 },
  { 239, 2, 2, 6, 2, -2 },
  { 240, 9, 19, 9, 0, -19 },
  { 262, 12, 20, 15, 2, -20 },
  { 292, 6, 19, 15, 3, -19 },
  { 307, 11, 20, 15, 2, -20 },
  { 335, 12, 20, 15, 1, -20 },
  { 365, 14, 19, 15, 1, -19 },
  { 399, 12, 19, 15, 2, -19 },
  { 428, 12, 20, 15, 2, -20 },
  { 458, 13, 19, 15, 1, -19 },
  { 489, 12, 20, 15, 2, -20 },
  { 519, 13, 20, 15, 1, -20 },
  { 552, 2, 14, 6, 2, -14 },
  { 556, 3, 17, 6, 1, -14 },
  { 563, 13, 12, 15, 1, -16 },
  { 583, 13, 7, 15, 1, -13 },
  { 595, 13, 12, 15, 1, -16 },
  { 615, 9, 20, 11, 1, -20 },
  { 638, 21, 22, 24, 1, -19 },
  { 696, 16, 19, 16, 0, -19 },
  { 734, 12, 19, 17, 3, -19 },
  { 763, 14, 20, 17, 2, -20 },
  { 798, 14, 19, 19, 3, -19 },
  { 832, 10, 19, 15, 3, -19 },
  { 856, 10, 19, 13, 3, -19 },
  { 880, 15, 20, 20, 2, -20 },
  { 918, 14, 19, 19, 3, -19 },
  { 952, 4, 19, 8, 2, -19 },
  { 962, 7, 24, 6, -3, -19 },
  { 983, 12, 19, 15, 3, -19 },
  { 1012, 10, 19, 14, 3, -19 },
  { 1036, 17, 19, 23, 3, -19 },
  { 1077, 13, 19, 19, 3, -19 },
  { 1108, 17, 20, 21, 2, -20 },
  { 1151, 11, 19, 16, 3, -19 },
  { 1178, 17, 25, 21, 2, -20 },
  { 1232, 12, 19, 16, 3, -19 },
  { 1261, 12, 20, 15, 1, -20 },
  { 1291, 14, 19, 14, 0, -19 },
  { 1325, 14, 19, 19, 3, -19 },
  { 1359, 15, 19, 15, 0, -19 },
  { 1395, 22, 19, 24, 1, -19 },
  { 1448, 14, 19, 14, 0, -19 },
  { 1482, 14, 19, 14, 0, -19 },
  { 1516, 14, 19, 16, 1, -19 },
  { 1550, 6, 23, 9, 2, -19 },
  { 1568, 9, 19, 9, 0, -19 },
  { 1590, 5, 23, 9, 1, -19 },
  { 1605, 13, 12, 15, 1, -19 },
  { 1625, 11, 1, 11, 0, 2 },
  { 1627, 5, 5, 7, 1, -21 },
  { 1631, 11, 15, 14, 1, -15 },
  { 1652, 12, 21, 16, 2, -21 },
  { 1684, 10, 15, 13, 2, -15 },
  { 1703, 12, 21, 16, 2, -21 },
  { 1735, 11, 15, 15, 2, -15 },
  { 1756, 9, 21, 8, 0, -21 },
  { 1780, 12, 21, 16, 2, -15 },
  { 1812, 11, 21, 16, 2, -21 },
  { 1841, 2, 20, 6, 2, -20 },
  { 1846, 5, 26, 6, -1, -20 },
  { 1863, 11, 21, 13, 2, -21 },
  { 1892, 1, 21, 6, 2, -21 },
  { 1895, 19, 15, 23, 2, -15 },
  { 1931, 11, 15, 16, 2, -15 },
  { 1952, 12, 15, 16, 2, -15 },
  { 1975, 12, 21, 16, 2, -15 },
  { 2007, 11, 21, 16, 2, -15 },
  { 2036, 8, 15, 10, 2, -15 },
  { 2051, 10, 15, 12, 1, -15 },
  { 2070, 8, 18, 9, 0, -18 },
  { 2088, 11, 14, 16, 2, -14 },
  { 2108, 12, 14, 12, 0, -14 },
  { 2129, 19, 14, 19, 0, -14 },
  { 2163, 11, 14, 13, 1, -14 },
  { 2183, 12, 21, 12, 0, -14 },
  { 2215, 10, 14, 12, 1, -14 },
  { 2233, 7, 23, 9, 1, -19 },
  { 2254, 1, 28, 15, 7, -21 },
  { 2258, 8, 23, 9, 1, -19 },
  { 2281, 13, 3, 15, 1, -11 },
};

const GFXfont NotoSans_ExtraLight27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRALIGHT27PT7B_H_
