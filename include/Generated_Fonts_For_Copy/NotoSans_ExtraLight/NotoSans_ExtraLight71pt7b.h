#ifndef _NOTOSANS_EXTRALIGHT71PT7B_H_
#define _NOTOSANS_EXTRALIGHT71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight71pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x98, 0xC6,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0xDE, 0xFF, 0xFC, 0xC0, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xD8, 0x07, 0x60, 0x19, 0x80, 0x66, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x01, 0xF8, 0xC1, 0xFC, 0x1E, 0x06, 0x01, 0xC1, 0xC0, 0x30, 0x00,
  0x1C, 0x01, 0x80, 0x01, 0xE0, 0x0C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x70,
  0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x38, 0x01, 0x80, 0x01, 0xC0, 0x0C, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x07,
  0x80, 0xC0, 0x00, 0x1F, 0x06, 0x00, 0x00, 0x3E, 0x30, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1B, 0xF8, 0x00, 0x00, 0xC3, 0xE0, 0x00, 0x06, 0x07, 0xC0,
  0x00, 0x30, 0x0F, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x60, 0x07, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0,
  0x07, 0x00, 0x06, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x0E,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x18, 0x03, 0xC0, 0x00, 0xC0, 0x3C, 0xC0, 0x06, 0x03, 0xC7, 0xE0, 0x30,
  0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x01,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x38, 0x06, 0x00, 0x00, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x06,
  0x03, 0x80, 0xFC, 0x03, 0x00, 0x03, 0x03, 0x81, 0xFF, 0x81, 0x80, 0x01,
  0x81, 0xC1, 0xE1, 0xE0, 0xE0, 0x01, 0xC1, 0xC1, 0xC0, 0x38, 0x70, 0x00,
  0xE0, 0xC1, 0xC0, 0x0E, 0x18, 0x00, 0xE0, 0xE0, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0x60, 0xE0, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x70, 0x00, 0xE1, 0xE0,
  0x70, 0x30, 0x30, 0x00, 0x70, 0x7F, 0xF0, 0x38, 0x38, 0x00, 0x18, 0x0F,
  0xF0, 0x38, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0E,
  0x0F, 0x00, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78, 0x00, 0x18, 0x70, 0x00,
  0x03, 0xC0, 0x03, 0x87, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x70, 0x00, 0x00,
  0xF0, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x70, 0xE0, 0x00, 0x00, 0x3C,
  0x0E, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0xE0, 0x00, 0x00, 0x0F, 0x1C,
  0x0E, 0x00, 0x00, 0x00, 0x7B, 0x80, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x07,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x38, 0x00, 0x00, 0x07, 0xBC, 0x03, 0xC0, 0x00,
  0x00, 0xF1, 0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x78, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0x1E, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0xBF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0x6D, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x37, 0xE0, 0x18, 0x03,
  0xEF, 0xF0, 0x30, 0x3F, 0xE3, 0xFC, 0x63, 0xFE, 0x00, 0x7F, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0C,
  0x18, 0x70, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xBF,
  0xFF, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3B, 0x00,
  0xF3, 0x01, 0xE3, 0x07, 0xC3, 0x0F, 0x03, 0x1E, 0x03, 0x7C, 0x03, 0xF0,
  0x03, 0x60, 0x03, 0x40, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0xF8, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x08, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x00, 0x38, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x01, 0xF0, 0xFF, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x10, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x20, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x30,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0xFC, 0x00,
  0xE0, 0x7F, 0xFF, 0x80, 0xE1, 0xF8, 0x0F, 0xC0, 0xE3, 0xC0, 0x01, 0xE0,
  0xC7, 0x00, 0x00, 0x70, 0xCE, 0x00, 0x00, 0x38, 0xDC, 0x00, 0x00, 0x1C,
  0xD8, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0xFE, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x0E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x37,
  0x38, 0x00, 0x00, 0x77, 0x1C, 0x00, 0x00, 0xE7, 0x0F, 0x00, 0x03, 0xC7,
  0x07, 0xC0, 0x0F, 0x86, 0x03, 0xFF, 0xFE, 0x06, 0x00, 0xFF, 0xF8, 0x06,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x10, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x77, 0xBF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xBD, 0xFF, 0xF9,
  0x80, 0x0E, 0x1E, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xC0, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xC0, 0x7E, 0x0E, 0x00, 0x07, 0x84, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x0C, 0x38, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1C, 0x70, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x39, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x33,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x67, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0xEC, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x1F,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x03, 0x60, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x06, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1D,
  0x80, 0x03, 0x00, 0x00, 0x38, 0x00, 0x3B, 0x80, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x67, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xCE, 0x00, 0x0C, 0x00,
  0x06, 0xE0, 0x03, 0x8C, 0x00, 0x1C, 0x00, 0x1C, 0xC0, 0x0E, 0x18, 0x00,
  0x1C, 0x00, 0x71, 0xC0, 0x38, 0x38, 0x00, 0x1E, 0x03, 0xC3, 0xC0, 0xE0,
  0x70, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x60, 0x00, 0x1F, 0xF8, 0x01,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1C, 0x00, 0x00, 0xFE, 0x0E, 0x00, 0x00, 0x0F, 0x87, 0x00, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x1F, 0x81,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x38, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07,
  0xE0, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x08, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x00, 0xE0, 0x00,
  0x01, 0xF8, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0x01, 0xF0,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x1F,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x38, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xC0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xD8, 0x00, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xC7, 0xF0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xCC, 0x07, 0xC7, 0xFF, 0xC3, 0xFF, 0x80, 0x08, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x01, 0xC3,
  0xF0, 0x00, 0x00, 0xE3, 0x9C, 0x00, 0x00, 0x73, 0x8F, 0x00, 0x00, 0x3B,
  0x83, 0xC0, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x03, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x78,
  0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xB8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xF9, 0x80,
  0x00, 0x00, 0x00, 0x77, 0xE7, 0x00, 0x00, 0x00, 0x01, 0x9F, 0x9C, 0x00,
  0x00, 0x00, 0x0E, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x39, 0xF8, 0xE0, 0x00,
  0x00, 0x01, 0xC7, 0xE1, 0x80, 0x00, 0x00, 0x07, 0x1F, 0x87, 0x00, 0x00,
  0x00, 0x18, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0xE1, 0xF8, 0x38, 0x00, 0x00,
  0x03, 0x87, 0xE0, 0xE0, 0x00, 0x00, 0x1C, 0x1F, 0x81, 0x80, 0x00, 0x00,
  0x70, 0x7E, 0x07, 0x00, 0x00, 0x01, 0x81, 0xF8, 0x1C, 0x00, 0x00, 0x0E,
  0x07, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x1F, 0x80, 0xE0, 0x00, 0x01, 0xC0,
  0x7E, 0x01, 0x80, 0x00, 0x07, 0x01, 0xF8, 0x07, 0x00, 0x00, 0x18, 0x07,
  0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1F, 0x80, 0x38, 0x00, 0x03, 0x80, 0x7E,
  0x00, 0xE0, 0x00, 0x1C, 0x01, 0xF8, 0x01, 0x80, 0x00, 0x70, 0x07, 0xE0,
  0x07, 0x00, 0x01, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x7E, 0x00,
  0x38, 0x00, 0x38, 0x01, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x18, 0x00, 0x7E, 0x00, 0x1C,
  0x00, 0xE0, 0x01, 0xF8, 0x00, 0x38, 0x03, 0x80, 0x07, 0xE0, 0x00, 0xE0,
  0x1C, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x01,
  0x80, 0x01, 0xF8, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x1F, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xC7, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x00, 0x07,
  0xE7, 0x00, 0x00, 0x00, 0x7E, 0x38, 0x00, 0x00, 0x07, 0xE3, 0xC0, 0x00,
  0x00, 0x7E, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x00, 0x7E, 0x0F,
  0x00, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x00, 0x7E, 0x03, 0x80, 0x00, 0x07,
  0xE0, 0x3C, 0x00, 0x00, 0x7E, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x0E, 0x00,
  0x00, 0x7E, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x00, 0x7E, 0x00,
  0x38, 0x00, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x07,
  0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x78,
  0x00, 0x7E, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x7E, 0x00,
  0x01, 0xE0, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x07,
  0xE0, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x03,
  0xC0, 0x7E, 0x00, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x7E, 0x00,
  0x00, 0x0F, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x03, 0x83,
  0xE0, 0x00, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x00,
  0x0E, 0x3E, 0x00, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x00, 0x07, 0xBE, 0x00,
  0x00, 0x00, 0x3B, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x07, 0xE0, 0xE0, 0x00,
  0x03, 0xE3, 0x80, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xF8,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1C, 0x00, 0x03, 0xF8, 0x0E, 0x00, 0x00, 0x3E, 0x07, 0x00,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x00, 0x87, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x60,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0xC1, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x38, 0x03, 0x00, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x07, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x70, 0x01, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x0E, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0x80, 0xF8,
  0x00, 0x7C, 0x04, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0x0F, 0xC0,
  0x00, 0x71, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x01,
  0xF7, 0x00, 0x00, 0x1B, 0x70, 0x00, 0x03, 0x37, 0x80, 0x00, 0x73, 0x3C,
  0x00, 0x0E, 0x31, 0xF0, 0x07, 0xC3, 0x0F, 0xFF, 0xF8, 0x30, 0x3F, 0xFE,
  0x03, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0xFC,
  0x00, 0xE0, 0x7F, 0xFF, 0x00, 0xE1, 0xF8, 0x0F, 0xC0, 0xE3, 0xC0, 0x03,
  0xE0, 0xE7, 0x00, 0x00, 0xF0, 0xEE, 0x00, 0x00, 0x70, 0xEC, 0x00, 0x00,
  0x38, 0xFC, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00,
  0x38, 0xFC, 0x00, 0x00, 0x38, 0xEC, 0x00, 0x00, 0x70, 0xEE, 0x00, 0x00,
  0xF0, 0xE7, 0x80, 0x03, 0xE0, 0xE3, 0xE0, 0x0F, 0xC0, 0xE1, 0xFF, 0xFF,
  0x00, 0xC0, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0xF8, 0x00, 0x10, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x80, 0xF8, 0x00, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x1F, 0xFC, 0x07, 0x00, 0xFF, 0xFF, 0x07, 0x01, 0xF8, 0x0F,
  0x87, 0x03, 0xC0, 0x01, 0xC7, 0x07, 0x80, 0x00, 0xE7, 0x0F, 0x00, 0x00,
  0x77, 0x1E, 0x00, 0x00, 0x37, 0x1C, 0x00, 0x00, 0x3F, 0x38, 0x00, 0x00,
  0x1F, 0x38, 0x00, 0x00, 0x1F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x1F, 0x38, 0x00, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0x37, 0x1E, 0x00, 0x00,
  0x77, 0x0F, 0x00, 0x00, 0x67, 0x07, 0x80, 0x01, 0xC7, 0x03, 0xE0, 0x07,
  0x87, 0x01, 0xFF, 0xFF, 0x07, 0x00, 0x7F, 0xFC, 0x07, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x60, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x06, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x07, 0x00, 0xFF, 0xFF, 0x07, 0x01,
  0xF8, 0x0F, 0x87, 0x03, 0xC0, 0x01, 0xC7, 0x07, 0x80, 0x00, 0xE7, 0x0E,
  0x00, 0x00, 0x77, 0x1E, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x1F, 0x38,
  0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0x37, 0x1E,
  0x00, 0x00, 0x77, 0x0F, 0x00, 0x00, 0xE7, 0x07, 0x80, 0x01, 0xC7, 0x03,
  0xE0, 0x07, 0x87, 0x01, 0xFF, 0xFF, 0x07, 0x00, 0x7F, 0xFC, 0x07, 0x00,
  0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x30,
  0x00, 0x00, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x3F, 0xFE, 0x7F, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0xFC, 0x07, 0x03, 0xFF, 0xF8,
  0x38, 0x7E, 0x07, 0xE1, 0xC7, 0x80, 0x07, 0x8E, 0x70, 0x00, 0x0E, 0x77,
  0x00, 0x00, 0x7B, 0xB0, 0x00, 0x01, 0xDF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0C, 0xFF,
  0xFF, 0x60, 0x00, 0x00, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF3, 0xDF, 0x8F, 0xFC, 0x1F, 0xC0,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x00,
  0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0xE3,
  0xB8, 0x00, 0x0E, 0x3B, 0xC0, 0x00, 0xE7, 0x1C, 0x00, 0x0E, 0xE0, 0xE0,
  0x00, 0xFC, 0x07, 0x00, 0x0F, 0x80, 0x78, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x38, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x0E, 0x3F, 0x07, 0xE0, 0x7E, 0x07,
  0xC3, 0x9E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xE6, 0x00, 0x07, 0x9E, 0x00,
  0x0F, 0x3B, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0x3B, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0xE0, 0x1F, 0xFC, 0x07, 0x03, 0xFF, 0xF8, 0x38,
  0x7E, 0x07, 0xF1, 0xC7, 0x80, 0x07, 0xCE, 0x70, 0x00, 0x0E, 0x77, 0x00,
  0x00, 0x7B, 0xB0, 0x00, 0x01, 0xDF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xE0, 0x1F, 0xFC, 0x00, 0xE0, 0x7F, 0xFF, 0x00, 0xE0,
  0xF8, 0x0F, 0xC0, 0xE3, 0xC0, 0x01, 0xE0, 0xE7, 0x80, 0x00, 0xF0, 0xE6,
  0x00, 0x00, 0x78, 0xEE, 0x00, 0x00, 0x38, 0xEC, 0x00, 0x00, 0x1C, 0xF8,
  0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1C, 0xF8,
  0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x3C, 0xEC, 0x00, 0x00, 0x38, 0xEE,
  0x00, 0x00, 0x70, 0xE7, 0x00, 0x00, 0xF0, 0xE3, 0x80, 0x01, 0xE0, 0xE1,
  0xE0, 0x0F, 0xC0, 0xE0, 0xFF, 0xFF, 0x00, 0xE0, 0x3F, 0xFC, 0x00, 0xE0,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x06, 0x01,
  0xFF, 0xFE, 0x0C, 0x07, 0xE0, 0x3E, 0x18, 0x1E, 0x00, 0x1E, 0x30, 0x70,
  0x00, 0x0E, 0x61, 0xC0, 0x00, 0x0E, 0xC7, 0x00, 0x00, 0x0D, 0x8E, 0x00,
  0x00, 0x1F, 0x38, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0D, 0x9E, 0x00, 0x00, 0x1B, 0x1C,
  0x00, 0x00, 0x76, 0x1C, 0x00, 0x01, 0xCC, 0x3E, 0x00, 0x07, 0x18, 0x3F,
  0x00, 0x3C, 0x30, 0x1F, 0xFF, 0xF0, 0x60, 0x0F, 0xFF, 0x80, 0xC0, 0x03,
  0xF0, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF8,
  0xFE, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xEC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0x00, 0xFF, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xD0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0x7E, 0x00, 0x1F, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x10, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x3F,
  0x70, 0x00, 0x01, 0xB9, 0xC0, 0x00, 0x1D, 0xCF, 0x80, 0x03, 0xCE, 0x3E,
  0x00, 0x7C, 0x30, 0xFF, 0xFF, 0x81, 0x81, 0xFF, 0xF0, 0x0C, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x60, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x06, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x0C, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x06, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x30, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0x80,
  0x60, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0x80,
  0xE0, 0x03, 0x81, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC1,
  0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0x80, 0x00, 0xC1,
  0x80, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xE3,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0xE3, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x77, 0x00, 0x00, 0x77, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x83, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x9F, 0xFF, 0x80, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xE8, 0x00, 0x07, 0xFF, 0xE4,
  0x00, 0x00, 0xFF, 0xC0,
};

const GFXglyph NotoSans_ExtraLight71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 5, 52, 16, 6, -51 },
  { 34, 14, 19, 24, 5, -51 },
  { 68, 42, 51, 46, 2, -51 },
  { 336, 29, 58, 40, 5, -54 },
  { 547, 49, 52, 57, 4, -51 },
  { 866, 44, 52, 50, 4, -51 },
  { 1152, 3, 19, 13, 5, -51 },
  { 1160, 13, 62, 19, 3, -51 },
  { 1261, 14, 62, 19, 2, -51 },
  { 1370, 31, 29, 39, 4, -54 },
  { 1483, 33, 33, 40, 4, -42 },
  { 1620, 7, 17, 14, 3, -8 },
  { 1635, 17, 3, 23, 3, -21 },
  { 1642, 5, 6, 16, 6, -5 },
  { 1646, 22, 51, 24, 1, -51 },
  { 1787, 32, 52, 40, 4, -51 },
  { 1995, 16, 51, 40, 7, -51 },
  { 2097, 31, 51, 40, 4, -51 },
  { 2295, 32, 52, 40, 3, -51 },
  { 2503, 38, 51, 40, 2, -51 },
  { 2746, 31, 52, 40, 5, -51 },
  { 2948, 32, 53, 40, 5, -52 },
  { 3160, 32, 51, 40, 4, -51 },
  { 3364, 32, 52, 40, 4, -51 },
  { 3572, 32, 52, 40, 4, -51 },
  { 3780, 5, 39, 16, 6, -38 },
  { 3805, 8, 47, 16, 3, -38 },
  { 3852, 33, 32, 40, 4, -42 },
  { 3984, 33, 16, 40, 4, -33 },
  { 4050, 33, 32, 40, 4, -42 },
  { 4182, 25, 52, 30, 2, -51 },
  { 4345, 55, 57, 63, 4, -50 },
  { 4737, 42, 51, 42, 0, -51 },
  { 5005, 33, 51, 44, 7, -51 },
  { 5216, 38, 52, 44, 4, -51 },
  { 5463, 38, 51, 50, 7, -51 },
  { 5706, 28, 51, 39, 7, -51 },
  { 5885, 28, 51, 35, 7, -51 },
  { 6064, 42, 53, 51, 4, -52 },
  { 6343, 36, 51, 51, 7, -51 },
  { 6573, 13, 51, 21, 4, -51 },
  { 6656, 17, 64, 17, -7, -51 },
  { 6792, 33, 51, 40, 7, -51 },
  { 7003, 28, 51, 36, 7, -51 },
  { 7182, 46, 51, 60, 7, -51 },
  { 7476, 36, 51, 50, 7, -51 },
  { 7706, 45, 52, 54, 4, -51 },
  { 7999, 30, 51, 41, 7, -51 },
  { 8191, 45, 63, 54, 4, -51 },
  { 8546, 33, 51, 42, 7, -51 },
  { 8757, 31, 52, 39, 4, -51 },
  { 8959, 36, 51, 37, 0, -51 },
  { 9189, 37, 52, 51, 7, -51 },
  { 9430, 41, 51, 41, 0, -51 },
  { 9692, 59, 51, 63, 2, -51 },
  { 10069, 37, 51, 37, 0, -51 },
  { 10305, 37, 51, 37, 0, -51 },
  { 10541, 35, 51, 41, 3, -51 },
  { 10765, 15, 62, 22, 6, -51 },
  { 10882, 22, 51, 24, 1, -51 },
  { 11023, 14, 62, 22, 2, -51 },
  { 11132, 34, 31, 40, 3, -51 },
  { 11264, 29, 3, 29, 0, 6 },
  { 11275, 12, 11, 18, 3, -54 },
  { 11292, 28, 39, 37, 3, -38 },
  { 11429, 32, 55, 42, 6, -54 },
  { 11649, 27, 39, 34, 4, -38 },
  { 11781, 32, 55, 42, 4, -54 },
  { 12001, 31, 39, 39, 4, -38 },
  { 12153, 24, 54, 20, 1, -54 },
  { 12315, 32, 55, 42, 4, -38 },
  { 12535, 29, 54, 41, 6, -54 },
  { 12731, 4, 51, 15, 6, -51 },
  { 12757, 14, 68, 15, -4, -51 },
  { 12876, 28, 54, 33, 6, -54 },
  { 13065, 3, 54, 15, 6, -54 },
  { 13086, 50, 38, 62, 6, -38 },
  { 13324, 29, 38, 41, 6, -38 },
  { 13462, 33, 39, 41, 4, -38 },
  { 13623, 32, 55, 42, 6, -38 },
  { 13843, 31, 55, 42, 4, -38 },
  { 14057, 20, 38, 27, 6, -38 },
  { 14152, 27, 39, 33, 3, -38 },
  { 14284, 20, 48, 23, 1, -47 },
  { 14404, 29, 39, 41, 6, -38 },
  { 14546, 32, 38, 32, 0, -38 },
  { 14698, 48, 38, 50, 1, -38 },
  { 14926, 31, 38, 35, 2, -38 },
  { 15074, 32, 55, 32, 0, -38 },
  { 15294, 27, 38, 33, 3, -38 },
  { 15423, 20, 62, 25, 2, -51 },
  { 15578, 2, 72, 38, 18, -54 },
  { 15596, 21, 62, 25, 2, -51 },
  { 15759, 33, 6, 40, 4, -28 },
};

const GFXfont NotoSans_ExtraLight71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRALIGHT71PT7B_H_
