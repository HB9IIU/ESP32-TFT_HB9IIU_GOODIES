#ifndef _NOTOSANS_EXTRALIGHT23PT7B_H_
#define _NOTOSANS_EXTRALIGHT23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0x99, 0x99, 0x99, 0x04, 0x20, 0x21, 0x02, 0x10, 0x10,
  0x80, 0x84, 0x3F, 0xFC, 0x21, 0x02, 0x08, 0x10, 0x80, 0x84, 0x3F, 0xFC,
  0x21, 0x02, 0x08, 0x10, 0x80, 0x84, 0x04, 0x20, 0x04, 0x07, 0xE6, 0x49,
  0x10, 0x84, 0x21, 0x04, 0x40, 0x90, 0x1C, 0x01, 0xC0, 0x48, 0x11, 0x04,
  0x41, 0x10, 0x45, 0x96, 0x1E, 0x01, 0x00, 0x38, 0x00, 0x44, 0x08, 0x44,
  0x10, 0x82, 0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40, 0x82, 0x9E, 0x44,
  0xA2, 0x45, 0x21, 0x39, 0x21, 0x02, 0x21, 0x02, 0x21, 0x04, 0x21, 0x04,
  0x21, 0x08, 0x21, 0x10, 0x1E, 0x0E, 0x00, 0x23, 0x00, 0x82, 0x01, 0x02,
  0x02, 0x04, 0x02, 0x10, 0x04, 0x40, 0x07, 0x00, 0x1C, 0x00, 0x44, 0x09,
  0x04, 0x12, 0x04, 0x48, 0x04, 0x90, 0x06, 0x10, 0x0C, 0x30, 0x24, 0x3F,
  0x86, 0xFC, 0x12, 0x44, 0x48, 0x88, 0x88, 0x88, 0x88, 0x44, 0x42, 0x21,
  0x84, 0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x22, 0x24, 0x48, 0x04, 0x01,
  0x00, 0x43, 0x97, 0x1E, 0x03, 0x01, 0x20, 0x44, 0x21, 0x80, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x0F, 0xFE, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x56, 0xA0, 0xF8, 0xC0, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x0E, 0x06, 0x30, 0x81, 0x20, 0x24,
  0x04, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x04,
  0x80, 0x90, 0x11, 0x04, 0x1F, 0x00, 0x0C, 0xD4, 0x61, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0E, 0x1C, 0x44, 0x08, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0xFF, 0xC0, 0x1E, 0x18, 0x68, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x04, 0x1E, 0x00, 0x60, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x02,
  0x7F, 0x00, 0x00, 0x80, 0x18, 0x02, 0x80, 0x28, 0x04, 0x80, 0x88, 0x08,
  0x81, 0x08, 0x20, 0x84, 0x08, 0x40, 0x88, 0x08, 0xFF, 0xF0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x7F, 0x90, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F,
  0xE0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x80, 0x28, 0x13, 0xF8,
  0x07, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0xFC, 0xA0,
  0x48, 0x0B, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x11, 0x02, 0x1F, 0x80,
  0xFF, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x0E, 0x06,
  0x31, 0x01, 0x20, 0x24, 0x04, 0x80, 0x88, 0x20, 0xD8, 0x0E, 0x06, 0x31,
  0x01, 0x20, 0x28, 0x03, 0x00, 0x50, 0x12, 0x02, 0x3F, 0x80, 0x0E, 0x06,
  0x21, 0x02, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x0C, 0x03, 0x40, 0x64, 0x34,
  0x79, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x08, 0x7E, 0x00, 0x80, 0x30,
  0x40, 0x00, 0x15, 0xA8, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x80, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x30, 0x18, 0x0C, 0x0E, 0x02, 0x00, 0x00, 0x38, 0xC6, 0x02,
  0x01, 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x20, 0x00, 0x00,
  0x20, 0x30, 0x07, 0xFC, 0x02, 0x00, 0x81, 0x00, 0x10, 0x80, 0x02, 0x40,
  0xF0, 0x50, 0x42, 0x18, 0x20, 0x86, 0x10, 0x21, 0x84, 0x08, 0x61, 0x02,
  0x18, 0x40, 0x86, 0x10, 0x62, 0x42, 0x2D, 0x90, 0x70, 0x84, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x50,
  0x01, 0x20, 0x08, 0x80, 0x21, 0x00, 0x84, 0x04, 0x10, 0x10, 0x20, 0x7F,
  0x82, 0x02, 0x08, 0x04, 0x40, 0x11, 0x00, 0x24, 0x00, 0xA0, 0x03, 0xFF,
  0x90, 0x0A, 0x01, 0x40, 0x18, 0x05, 0x00, 0xA0, 0x27, 0xF8, 0x80, 0xD0,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x37, 0xF8, 0x03, 0xE0, 0x60,
  0xC4, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0F,
  0xF0, 0xFF, 0x84, 0x02, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x28, 0x03, 0x40, 0x12,
  0x03, 0x1F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x03, 0xE0, 0x30, 0x71, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0xF4, 0x00, 0x50, 0x01,
  0x40, 0x05, 0x00, 0x12, 0x00, 0x46, 0x01, 0x07, 0xF8, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xF2, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x2F, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x80, 0x70, 0x12, 0x04, 0x41, 0x08,
  0x41, 0x10, 0x24, 0x05, 0x40, 0xC4, 0x10, 0x82, 0x08, 0x40, 0x88, 0x19,
  0x01, 0x20, 0x14, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xC0, 0x03,
  0x40, 0x0E, 0x80, 0x1D, 0x00, 0x59, 0x00, 0xB2, 0x02, 0x62, 0x04, 0xC4,
  0x09, 0x88, 0x23, 0x08, 0x46, 0x11, 0x0C, 0x12, 0x18, 0x24, 0x30, 0x50,
  0x60, 0x60, 0xC0, 0x81, 0xC0, 0x1C, 0x01, 0xA0, 0x19, 0x01, 0x98, 0x18,
  0x81, 0x84, 0x18, 0x61, 0x82, 0x18, 0x11, 0x81, 0x98, 0x09, 0x80, 0x58,
  0x07, 0x80, 0x38, 0x01, 0x03, 0xC0, 0x18, 0x60, 0xC0, 0x21, 0x00, 0x24,
  0x00, 0x48, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x05, 0x00,
  0x0A, 0x00, 0x14, 0x00, 0x48, 0x00, 0x88, 0x02, 0x08, 0x0C, 0x0F, 0xE0,
  0xFF, 0x20, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0xFF, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x03, 0xC0, 0x18, 0x60,
  0xC0, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x50, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x48, 0x00, 0x88, 0x02,
  0x08, 0x0C, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0x90, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x08, 0xFE,
  0x10, 0x42, 0x04, 0x40, 0x88, 0x09, 0x01, 0x20, 0x14, 0x01, 0x0F, 0x0C,
  0x34, 0x01, 0x00, 0x80, 0x10, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0xFF, 0x00, 0xFF, 0xF0, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x14, 0x01, 0x20, 0x21, 0xFC, 0x80, 0x0A, 0x00, 0x90,
  0x04, 0x80, 0x22, 0x02, 0x10, 0x10, 0x40, 0x82, 0x08, 0x10, 0x40, 0x44,
  0x02, 0x20, 0x11, 0x00, 0x50, 0x02, 0x80, 0x0C, 0x00, 0x40, 0x80, 0xC0,
  0x70, 0x18, 0x0A, 0x03, 0x01, 0x20, 0x90, 0x24, 0x12, 0x08, 0x82, 0x41,
  0x10, 0x44, 0x21, 0x10, 0x88, 0x22, 0x11, 0x04, 0x42, 0x20, 0x48, 0x24,
  0x0A, 0x05, 0x01, 0x40, 0xA0, 0x28, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x20,
  0xC0, 0x32, 0x04, 0x20, 0x41, 0x08, 0x08, 0x80, 0x90, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x90, 0x08, 0x81, 0x08, 0x20, 0x42, 0x04, 0x40, 0x28, 0x01,
  0xC0, 0x34, 0x02, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x09, 0x00, 0x90,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0xFF, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x07, 0xFF, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0, 0xC0,
  0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80,
  0x81, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x04,
  0x00, 0xC0, 0x28, 0x04, 0x81, 0x10, 0x21, 0x08, 0x21, 0x02, 0x40, 0x48,
  0x06, 0x00, 0x80, 0xFF, 0x80, 0x84, 0x21, 0x7F, 0x00, 0x40, 0x20, 0x10,
  0x08, 0xFD, 0x83, 0x01, 0x80, 0xC0, 0x70, 0x6F, 0xD0, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x84, 0x2E, 0xCC, 0x0B, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x1C, 0x07, 0x02, 0xBF, 0x00, 0x1F, 0x90, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x03, 0xF0, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x42, 0x36, 0x48, 0x2A, 0x03, 0x40, 0x70, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x80, 0xD0, 0x1B, 0x05, 0x1F, 0x20, 0x1F, 0x08, 0x24,
  0x05, 0x01, 0x80, 0x7F, 0xF8, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x7F,
  0x06, 0x19, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x3F, 0xA4, 0x15, 0x01, 0xA0, 0x38,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x68, 0x0C, 0x82, 0x8F, 0x90, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x71, 0x81, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x05, 0xFB, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xC7, 0xFF, 0x80, 0x11, 0x00, 0x01, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x1A, 0x40, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x0A, 0x09, 0x08, 0x88, 0x48, 0x2C, 0x19, 0x08, 0x84, 0x22, 0x09, 0x02,
  0x81, 0x80, 0xFF, 0xFF, 0x80, 0xBE, 0x7E, 0xC1, 0x81, 0x81, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0xBF, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x1F, 0x84, 0x09, 0x01, 0x20,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x28, 0x08, 0x83, 0x0F, 0x80,
  0xBF, 0x30, 0x2C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70,
  0x1C, 0x0A, 0xFC, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x3F, 0x48,
  0x34, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x50, 0x16, 0x0C,
  0xFD, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0xBF, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x7F, 0x40, 0x20, 0x10, 0x04, 0x01, 0xC0,
  0x18, 0x02, 0x00, 0x80, 0x40, 0x5F, 0xC0, 0x20, 0x40, 0x87, 0xF2, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x07, 0x80, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x6F, 0xD0, 0x80,
  0x50, 0x14, 0x09, 0x02, 0x21, 0x08, 0x41, 0x10, 0x48, 0x12, 0x02, 0x80,
  0xC0, 0x30, 0xC0, 0x81, 0x41, 0x82, 0x41, 0x42, 0x41, 0x42, 0x22, 0x42,
  0x22, 0x24, 0x22, 0x24, 0x24, 0x24, 0x14, 0x14, 0x14, 0x18, 0x18, 0x18,
  0x08, 0x08, 0x80, 0x90, 0x42, 0x20, 0x88, 0x14, 0x02, 0x01, 0x40, 0x50,
  0x22, 0x10, 0x44, 0x1A, 0x03, 0x80, 0x50, 0x14, 0x09, 0x02, 0x21, 0x08,
  0x41, 0x10, 0x48, 0x12, 0x02, 0x80, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x30, 0x30, 0x00, 0x7F, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x20, 0x20, 0x20, 0x10, 0x1F, 0xF0, 0x1C, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x23, 0x06, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x31, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x42, 0x30, 0x7C, 0x30, 0x78,
};

const GFXglyph NotoSans_ExtraLight23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 4, 6, 8, 2, -16 },
  { 6, 13, 16, 15, 1, -16 },
  { 32, 10, 18, 13, 1, -17 },
  { 55, 16, 17, 18, 1, -17 },
  { 89, 15, 17, 16, 1, -17 },
  { 121, 1, 6, 4, 2, -16 },
  { 122, 4, 20, 6, 1, -16 },
  { 132, 4, 20, 6, 1, -16 },
  { 142, 10, 9, 13, 1, -17 },
  { 154, 11, 10, 13, 1, -13 },
  { 168, 2, 6, 5, 1, -3 },
  { 170, 5, 1, 7, 1, -7 },
  { 171, 1, 2, 5, 2, -2 },
  { 172, 7, 16, 8, 0, -16 },
  { 186, 11, 17, 13, 1, -17 },
  { 210, 6, 16, 13, 2, -16 },
  { 222, 10, 17, 13, 1, -17 },
  { 244, 10, 17, 13, 1, -17 },
  { 266, 12, 17, 13, 1, -17 },
  { 292, 10, 16, 13, 2, -16 },
  { 312, 11, 17, 13, 1, -17 },
  { 336, 11, 16, 13, 1, -16 },
  { 358, 11, 17, 13, 1, -17 },
  { 382, 11, 17, 13, 1, -17 },
  { 406, 1, 12, 5, 2, -12 },
  { 408, 2, 15, 5, 1, -12 },
  { 412, 11, 11, 13, 1, -14 },
  { 428, 11, 6, 13, 1, -11 },
  { 437, 11, 11, 13, 1, -14 },
  { 453, 8, 17, 10, 1, -17 },
  { 470, 18, 18, 20, 1, -16 },
  { 511, 14, 16, 14, 0, -16 },
  { 539, 11, 16, 14, 2, -16 },
  { 561, 13, 17, 14, 1, -17 },
  { 589, 13, 16, 16, 2, -16 },
  { 615, 9, 16, 13, 2, -16 },
  { 633, 9, 16, 11, 2, -16 },
  { 651, 14, 17, 17, 1, -17 },
  { 681, 12, 16, 16, 2, -16 },
  { 705, 4, 16, 7, 1, -16 },
  { 713, 5, 20, 6, -2, -16 },
  { 726, 11, 16, 13, 2, -16 },
  { 748, 9, 16, 12, 2, -16 },
  { 766, 15, 16, 20, 2, -16 },
  { 796, 12, 16, 16, 2, -16 },
  { 820, 15, 17, 17, 1, -17 },
  { 852, 10, 16, 13, 2, -16 },
  { 872, 15, 21, 17, 1, -17 },
  { 912, 11, 16, 13, 2, -16 },
  { 934, 10, 17, 13, 1, -17 },
  { 956, 12, 16, 12, 0, -16 },
  { 980, 12, 16, 16, 2, -16 },
  { 1004, 13, 16, 13, 0, -16 },
  { 1030, 19, 16, 20, 1, -16 },
  { 1068, 12, 16, 12, 0, -16 },
  { 1092, 12, 16, 12, 0, -16 },
  { 1116, 11, 16, 13, 1, -16 },
  { 1138, 5, 20, 7, 2, -16 },
  { 1151, 7, 16, 8, 0, -16 },
  { 1165, 4, 20, 7, 1, -16 },
  { 1175, 11, 11, 13, 1, -17 },
  { 1191, 9, 1, 9, 0, 2 },
  { 1193, 4, 4, 6, 1, -18 },
  { 1195, 9, 12, 12, 1, -12 },
  { 1209, 10, 17, 14, 2, -17 },
  { 1231, 9, 12, 11, 1, -12 },
  { 1245, 11, 17, 14, 1, -17 },
  { 1269, 10, 12, 13, 1, -12 },
  { 1284, 8, 18, 7, 0, -18 },
  { 1302, 11, 18, 14, 1, -12 },
  { 1327, 9, 17, 13, 2, -17 },
  { 1347, 1, 17, 5, 2, -17 },
  { 1350, 4, 23, 5, -1, -17 },
  { 1362, 9, 17, 11, 2, -17 },
  { 1382, 1, 17, 5, 2, -17 },
  { 1385, 16, 12, 20, 2, -12 },
  { 1409, 9, 12, 13, 2, -12 },
  { 1423, 11, 12, 13, 1, -12 },
  { 1440, 10, 17, 14, 2, -12 },
  { 1462, 10, 17, 14, 1, -12 },
  { 1484, 6, 12, 9, 2, -12 },
  { 1493, 9, 12, 11, 1, -12 },
  { 1507, 7, 15, 8, 0, -15 },
  { 1521, 9, 12, 13, 2, -12 },
  { 1535, 10, 12, 10, 0, -12 },
  { 1550, 16, 12, 16, 0, -12 },
  { 1574, 10, 12, 11, 1, -12 },
  { 1589, 10, 18, 10, 0, -12 },
  { 1612, 9, 12, 11, 1, -12 },
  { 1626, 6, 20, 8, 1, -16 },
  { 1641, 1, 24, 12, 6, -18 },
  { 1644, 6, 20, 8, 1, -16 },
  { 1659, 11, 2, 13, 1, -9 },
};

const GFXfont NotoSans_ExtraLight23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRALIGHT23PT7B_H_
