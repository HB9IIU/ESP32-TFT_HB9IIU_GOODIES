#ifndef _NOTOSANS_EXTRALIGHT35PT7B_H_
#define _NOTOSANS_EXTRALIGHT35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x54, 0x03, 0xC0, 0x42, 0x85, 0x0A, 0x14,
  0x28, 0x50, 0xA1, 0x42, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x20,
  0x20, 0x7F, 0xFF, 0xF8, 0x18, 0x10, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00,
  0x20, 0x20, 0x01, 0x03, 0x00, 0x18, 0x10, 0x00, 0x80, 0x80, 0xFF, 0xFF,
  0xE0, 0x20, 0x20, 0x01, 0x03, 0x00, 0x18, 0x10, 0x00, 0x80, 0x80, 0x04,
  0x04, 0x00, 0x20, 0x20, 0x01, 0x03, 0x00, 0x18, 0x10, 0x00, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0xFF, 0xC3, 0x10, 0xCC, 0x20, 0x30, 0x40, 0x60,
  0x80, 0xC1, 0x01, 0x82, 0x01, 0x04, 0x03, 0x08, 0x03, 0x90, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xB8, 0x01, 0x18, 0x02, 0x18, 0x04, 0x18, 0x08, 0x30,
  0x10, 0x60, 0x20, 0xC0, 0x41, 0x00, 0x86, 0xC1, 0x18, 0xFF, 0xC0, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x30, 0x61, 0x00, 0x60, 0x40,
  0x80, 0x40, 0xC0, 0x80, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0xC1, 0x80, 0x80,
  0xC1, 0x00, 0x80, 0xC2, 0x00, 0x80, 0xC2, 0x00, 0x80, 0xC4, 0x00, 0x80,
  0x8C, 0x7C, 0xC0, 0x88, 0x86, 0x40, 0x99, 0x02, 0x61, 0x11, 0x03, 0x3E,
  0x33, 0x01, 0x00, 0x23, 0x01, 0x00, 0x43, 0x01, 0x00, 0x43, 0x01, 0x00,
  0x83, 0x01, 0x01, 0x83, 0x01, 0x01, 0x03, 0x03, 0x03, 0x01, 0x03, 0x02,
  0x01, 0x02, 0x06, 0x00, 0x86, 0x0C, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x30,
  0x60, 0x01, 0x80, 0xC0, 0x04, 0x01, 0x00, 0x10, 0x04, 0x00, 0x40, 0x10,
  0x01, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x10, 0xC0, 0x00,
  0x2C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x61, 0x00, 0x22, 0x02,
  0x01, 0x90, 0x04, 0x04, 0xC0, 0x08, 0x33, 0x00, 0x10, 0x8C, 0x00, 0x26,
  0x30, 0x00, 0x50, 0xC0, 0x00, 0xC1, 0x00, 0x07, 0x06, 0x00, 0x72, 0x0E,
  0x03, 0x04, 0x0F, 0xF0, 0x1C, 0x55, 0x55, 0x40, 0x06, 0x18, 0x20, 0xC1,
  0x06, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x08, 0x30, 0x60, 0xC0, 0x81,
  0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x80,
  0xC0, 0xC0, 0x80, 0x81, 0x81, 0x02, 0x06, 0x04, 0x08, 0x10, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x30, 0x41,
  0x82, 0x0C, 0x30, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x10, 0x20, 0x7C, 0x47, 0x8F, 0xF8, 0x01, 0x00, 0x05, 0x00, 0x19,
  0x00, 0x63, 0x00, 0x82, 0x03, 0x03, 0x04, 0x04, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x33, 0x22, 0x66, 0x44, 0x80, 0xFF, 0x80,
  0xF0, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x00,
  0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x40, 0x02,
  0x40, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x18, 0x18,
  0x07, 0xE0, 0x01, 0x07, 0x0D, 0x19, 0x61, 0xC1, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x1F, 0xE0, 0x60, 0x61, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xFF, 0xFE, 0x1F, 0xF0, 0xE0, 0x33, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0xFF,
  0x01, 0xFF, 0x00, 0x03, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x60, 0x0C, 0x7F,
  0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x50, 0x00, 0x12, 0x00, 0x06,
  0x40, 0x00, 0x88, 0x00, 0x21, 0x00, 0x0C, 0x20, 0x03, 0x04, 0x00, 0x40,
  0x80, 0x10, 0x10, 0x06, 0x02, 0x01, 0x80, 0x40, 0x20, 0x08, 0x08, 0x01,
  0x03, 0x00, 0x20, 0xC0, 0x04, 0x1F, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x7F, 0xF8, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0xFF, 0x07, 0x07, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0xA0, 0x06, 0x60, 0x38, 0x7F, 0xC0,
  0x03, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC7, 0xF8, 0xD8, 0x0C,
  0xF0, 0x06, 0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x03, 0x60, 0x03, 0x20, 0x02, 0x10, 0x04, 0x1C, 0x1C,
  0x07, 0xF0, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0F, 0xF0, 0x18, 0x18, 0x20, 0x04, 0x60, 0x06,
  0x40, 0x06, 0x40, 0x02, 0x40, 0x06, 0x60, 0x06, 0x20, 0x0C, 0x18, 0x18,
  0x0E, 0x70, 0x03, 0xC0, 0x06, 0xE0, 0x18, 0x18, 0x30, 0x0C, 0x60, 0x06,
  0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x02,
  0x60, 0x06, 0x38, 0x1C, 0x0F, 0xF0, 0x0F, 0xE0, 0x38, 0x38, 0x60, 0x08,
  0x40, 0x04, 0xC0, 0x06, 0xC0, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0x40, 0x07, 0x60, 0x0F, 0x30, 0x1B, 0x1F, 0xE2,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x00,
  0x3C, 0x33, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x32, 0x26, 0x44,
  0x48, 0x00, 0x01, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x7F, 0xCC, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x10, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x33, 0x00,
  0x7E, 0x02, 0x40, 0x38, 0xE0, 0x48, 0x0C, 0x04, 0x0F, 0x03, 0x00, 0x80,
  0xC0, 0x40, 0x10, 0x18, 0x18, 0x02, 0x03, 0x02, 0x00, 0x40, 0x60, 0x40,
  0x18, 0x0C, 0x08, 0x03, 0x03, 0x81, 0x00, 0x60, 0x70, 0x30, 0x0C, 0x0A,
  0x02, 0x02, 0x83, 0x60, 0x60, 0xD8, 0xC4, 0x07, 0xE1, 0xF0, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x80, 0x00,
  0x44, 0x00, 0x06, 0x30, 0x00, 0x20, 0x80, 0x03, 0x04, 0x00, 0x10, 0x30,
  0x00, 0x80, 0x80, 0x0C, 0x06, 0x00, 0x40, 0x30, 0x02, 0x00, 0x80, 0x30,
  0x06, 0x01, 0xFF, 0xF0, 0x18, 0x00, 0x80, 0x80, 0x06, 0x04, 0x00, 0x10,
  0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x11, 0x00, 0x00, 0xC8, 0x00,
  0x02, 0xC0, 0x00, 0x18, 0xFF, 0xE0, 0x80, 0x78, 0x80, 0x0C, 0x80, 0x06,
  0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x0C,
  0x80, 0x18, 0xFF, 0xE0, 0xFF, 0xF0, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06,
  0x80, 0x0C, 0x80, 0x78, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xF0, 0x1C, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x02, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x20, 0x3E, 0x08, 0x00,
  0xC2, 0x00, 0x0C, 0x80, 0x01, 0x20, 0x00, 0x68, 0x00, 0x0A, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0A, 0x00, 0x06, 0x80, 0x03, 0x20, 0x01, 0x88, 0x00, 0xC2, 0x03, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xE8, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x0F, 0xFF, 0x7F, 0xFA, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x38, 0x07, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x60, 0x00,
  0x12, 0x00, 0x01, 0x30, 0x00, 0x11, 0x80, 0x01, 0x0C, 0x00, 0x10, 0x70,
  0x03, 0x01, 0xFF, 0xE0, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x8E, 0xF8,
  0x80, 0x07, 0x80, 0x0C, 0x80, 0x18, 0x80, 0x30, 0x80, 0x20, 0x80, 0x40,
  0x80, 0x80, 0x81, 0x00, 0x82, 0x00, 0x84, 0x00, 0x88, 0x00, 0x9C, 0x00,
  0xA6, 0x00, 0xC3, 0x00, 0x81, 0x00, 0x81, 0x80, 0x80, 0xC0, 0x80, 0x40,
  0x80, 0x60, 0x80, 0x30, 0x80, 0x18, 0x80, 0x08, 0x80, 0x0C, 0x80, 0x06,
  0x80, 0x03, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xF8, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xE8, 0x00, 0x05, 0xA0, 0x00, 0x36, 0xC0, 0x00, 0x99,
  0x00, 0x02, 0x66, 0x00, 0x11, 0x88, 0x00, 0x46, 0x30, 0x03, 0x18, 0xC0,
  0x08, 0x61, 0x00, 0x61, 0x86, 0x01, 0x06, 0x08, 0x04, 0x18, 0x30, 0x30,
  0x60, 0xC0, 0x81, 0x81, 0x06, 0x06, 0x06, 0x10, 0x18, 0x08, 0x40, 0x60,
  0x33, 0x01, 0x80, 0xC8, 0x06, 0x01, 0x60, 0x18, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x34, 0x00,
  0x1B, 0x00, 0x0C, 0xC0, 0x06, 0x20, 0x03, 0x18, 0x01, 0x86, 0x00, 0xC1,
  0x00, 0x60, 0xC0, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x06, 0x01, 0x83,
  0x00, 0x41, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x02, 0x30, 0x01, 0x98, 0x00,
  0x6C, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x80, 0x01, 0xFF,
  0x00, 0x1C, 0x07, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x80, 0x00, 0x66, 0x00, 0x00, 0x90, 0x00, 0x03, 0x40, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x88, 0x00, 0x06, 0x30, 0x00, 0x10, 0x60, 0x00, 0xC0, 0xC0,
  0x06, 0x01, 0xC0, 0x70, 0x01, 0xFF, 0x00, 0xFF, 0xC2, 0x03, 0xC8, 0x01,
  0xA0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x06, 0x80, 0x33, 0xFF, 0x8F, 0xC0, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x1C, 0x07, 0x00, 0xC0, 0x06, 0x06,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x80, 0x00, 0x66, 0x00, 0x00, 0x90, 0x00,
  0x03, 0x40, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40,
  0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0x88, 0x00, 0x06, 0x30, 0x00,
  0x10, 0x60, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0xC0, 0x70, 0x01, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xC0, 0x80, 0xF0, 0x80, 0x18, 0x80,
  0x0C, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x0C, 0x80, 0x08, 0x80, 0x18, 0x80, 0xE0, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18, 0x80,
  0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x03, 0x0F, 0xF8, 0x70, 0x1D, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x60, 0x1C, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xA0, 0x00, 0x26, 0x00, 0x04, 0x40, 0x01, 0x0C, 0x00, 0x60, 0xE0, 0x38,
  0x07, 0xFC, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00,
  0x06, 0x20, 0x00, 0x42, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x00, 0x08, 0x18,
  0x01, 0x80, 0x80, 0x10, 0x08, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x02, 0x00,
  0x40, 0x60, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00, 0x10, 0x80,
  0x01, 0x08, 0x00, 0x19, 0x80, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x00, 0x1E, 0x00, 0x30,
  0x00, 0xD0, 0x01, 0xC0, 0x04, 0x80, 0x0A, 0x00, 0x66, 0x00, 0xD0, 0x03,
  0x10, 0x04, 0xC0, 0x10, 0x80, 0x22, 0x00, 0x84, 0x01, 0x10, 0x0C, 0x30,
  0x18, 0x80, 0x60, 0x80, 0x86, 0x02, 0x04, 0x04, 0x10, 0x10, 0x30, 0x60,
  0x81, 0x81, 0x83, 0x06, 0x08, 0x04, 0x10, 0x10, 0x40, 0x20, 0x80, 0x86,
  0x01, 0x8C, 0x04, 0x30, 0x0C, 0x40, 0x31, 0x00, 0x22, 0x00, 0x88, 0x01,
  0x10, 0x04, 0xC0, 0x0D, 0x80, 0x36, 0x00, 0x28, 0x01, 0xA0, 0x01, 0x40,
  0x05, 0x00, 0x0A, 0x00, 0x38, 0x00, 0x70, 0x01, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x60, 0x00, 0xC8, 0x00, 0x63, 0x00, 0x10, 0x60, 0x0C, 0x08, 0x06,
  0x03, 0x01, 0x00, 0x40, 0xC0, 0x18, 0x60, 0x03, 0x10, 0x00, 0x4C, 0x00,
  0x1A, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x13, 0x00, 0x0C,
  0x40, 0x06, 0x18, 0x01, 0x03, 0x00, 0xC0, 0x40, 0x20, 0x18, 0x10, 0x03,
  0x0C, 0x00, 0x42, 0x00, 0x19, 0x00, 0x02, 0xC0, 0x00, 0x40, 0xC0, 0x00,
  0xD0, 0x00, 0x26, 0x00, 0x18, 0x80, 0x04, 0x30, 0x03, 0x04, 0x00, 0x80,
  0x80, 0x60, 0x30, 0x10, 0x04, 0x0C, 0x01, 0x86, 0x00, 0x21, 0x00, 0x0C,
  0xC0, 0x01, 0x20, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xFF, 0x80, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0xFE, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xFF, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x40, 0x02, 0x40, 0x06, 0x20, 0x04, 0x20, 0x08,
  0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x20, 0x04, 0x20, 0x04, 0x40,
  0x02, 0xC0, 0x02, 0x80, 0x01, 0xFF, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x07, 0xC3, 0xE7, 0x88, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x78, 0xFF, 0xDC, 0x02, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0xC0, 0x2B, 0x03, 0x4F, 0xE2, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x87, 0xE0, 0x8E, 0x38, 0xB0, 0x0C, 0xA0, 0x04, 0xC0, 0x06, 0xC0, 0x02,
  0xC0, 0x02, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xE0, 0x04, 0xA0, 0x0C, 0x98, 0x18,
  0x8F, 0xE0, 0x03, 0xF4, 0x3C, 0xE1, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x20, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x07, 0xC3, 0x1E, 0x33, 0x30, 0x0B, 0x20, 0x07,
  0x60, 0x07, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x07, 0x60, 0x07,
  0x20, 0x0F, 0x38, 0x1B, 0x0F, 0xE3, 0x07, 0xE0, 0x1C, 0xE0, 0xC0, 0x61,
  0x00, 0x66, 0x00, 0x48, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x08, 0x3F, 0xE0, 0x01, 0xF0, 0x7B, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x1F, 0xCF, 0xFC, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07,
  0xE3, 0x1E, 0x33, 0x30, 0x0B, 0x20, 0x07, 0x60, 0x07, 0x40, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x40, 0x07, 0x60, 0x07, 0x20, 0x0F, 0x18, 0x1B, 0x0F,
  0xE3, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x60, 0x1C, 0x3F, 0xF0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x87, 0xE2, 0x71, 0xEB, 0x00,
  0xA8, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x40, 0xF0, 0x0A, 0xAA, 0xAA, 0xAA, 0xAA, 0x80,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x06, 0xF8, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x1A, 0x00, 0xC8, 0x06,
  0x20, 0x30, 0x80, 0x82, 0x04, 0x08, 0x20, 0x21, 0x00, 0x8C, 0x02, 0x70,
  0x0B, 0x20, 0x38, 0xC0, 0xC1, 0x82, 0x02, 0x08, 0x04, 0x20, 0x18, 0x80,
  0x32, 0x00, 0x48, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x87, 0xC0, 0xF8,
  0x4E, 0x31, 0xE7, 0x2C, 0x0D, 0x80, 0xD4, 0x03, 0x80, 0x2C, 0x01, 0xC0,
  0x16, 0x00, 0x40, 0x0B, 0x00, 0x20, 0x07, 0x00, 0x10, 0x03, 0x80, 0x08,
  0x01, 0xC0, 0x04, 0x00, 0xE0, 0x02, 0x00, 0x70, 0x01, 0x00, 0x38, 0x00,
  0x80, 0x1C, 0x00, 0x40, 0x0E, 0x00, 0x20, 0x07, 0x00, 0x10, 0x03, 0x80,
  0x08, 0x01, 0xC0, 0x04, 0x00, 0xE0, 0x02, 0x00, 0x60, 0x87, 0xE2, 0x39,
  0xEB, 0x00, 0xA8, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0xE0, 0x1E, 0x38, 0x30,
  0x0C, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x40,
  0x02, 0x60, 0x06, 0x30, 0x04, 0x18, 0x18, 0x0F, 0xF0, 0x83, 0xE0, 0x8E,
  0x38, 0x90, 0x0C, 0xA0, 0x04, 0xE0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x06, 0xA0, 0x04, 0xB0, 0x0C, 0x98, 0x18, 0x8F, 0xF0, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x07, 0xE2, 0x38, 0x64, 0xC0, 0x2B, 0x00, 0x34, 0x00,
  0x68, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x50, 0x01, 0xB0, 0x03, 0x20, 0x0A, 0x70,
  0x34, 0x3F, 0x88, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x87, 0xE7, 0x3B, 0x02, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x0F, 0xE0, 0xF1, 0xE2, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x1B,
  0x00, 0xC7, 0xFE, 0x00, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x03, 0xFD, 0xFF,
  0x86, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x01, 0xF8,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xF0, 0x03, 0x40, 0x15, 0xC1, 0x91, 0xFC, 0x40, 0x80, 0x03,
  0xC0, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x30, 0x08,
  0x10, 0x18, 0x10, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x20,
  0x04, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x07, 0x00, 0xA0, 0x1E, 0x01, 0x40, 0x24,
  0x02, 0xC0, 0x48, 0x0D, 0x81, 0x98, 0x11, 0x03, 0x10, 0x22, 0x04, 0x20,
  0xC6, 0x08, 0x41, 0x04, 0x30, 0xC2, 0x08, 0x60, 0x8C, 0x18, 0x81, 0x10,
  0x11, 0x03, 0x20, 0x26, 0x02, 0xC0, 0x68, 0x05, 0x00, 0x50, 0x0A, 0x00,
  0xA0, 0x1C, 0x01, 0xC0, 0x10, 0x01, 0x00, 0xC0, 0x06, 0xC0, 0x18, 0x80,
  0x21, 0x80, 0xC1, 0x83, 0x01, 0x04, 0x03, 0x10, 0x03, 0x60, 0x03, 0x80,
  0x02, 0x00, 0x0A, 0x00, 0x36, 0x00, 0xC6, 0x01, 0x04, 0x06, 0x0C, 0x18,
  0x0C, 0x20, 0x08, 0x80, 0x1B, 0x00, 0x18, 0x80, 0x03, 0xC0, 0x02, 0x40,
  0x06, 0x60, 0x04, 0x20, 0x04, 0x20, 0x0C, 0x30, 0x08, 0x10, 0x18, 0x18,
  0x18, 0x08, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x60, 0x06,
  0x40, 0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0xF8,
  0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xC1, 0xC0, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x06, 0x07, 0x03, 0x80, 0x10, 0x06, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x00,
  0xF0, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x80, 0x38, 0x07, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x3C, 0x08, 0x00, 0x3E, 0x01,
  0xC3, 0x83, 0x80, 0xFE,
};

const GFXglyph NotoSans_ExtraLight35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 25, 8, 3, -25 },
  { 8, 7, 9, 12, 2, -25 },
  { 16, 21, 25, 23, 1, -25 },
  { 82, 15, 29, 20, 2, -27 },
  { 137, 24, 25, 28, 2, -25 },
  { 212, 22, 25, 25, 2, -25 },
  { 281, 2, 9, 6, 2, -25 },
  { 284, 7, 31, 9, 1, -25 },
  { 312, 7, 31, 9, 1, -25 },
  { 340, 15, 15, 19, 2, -27 },
  { 369, 16, 16, 20, 2, -20 },
  { 401, 4, 9, 7, 1, -4 },
  { 406, 9, 1, 11, 1, -10 },
  { 408, 2, 2, 8, 3, -2 },
  { 409, 11, 25, 12, 0, -25 },
  { 444, 16, 25, 20, 2, -25 },
  { 494, 8, 25, 20, 3, -25 },
  { 519, 15, 25, 20, 2, -25 },
  { 566, 15, 25, 20, 2, -25 },
  { 613, 19, 25, 20, 1, -25 },
  { 673, 15, 25, 20, 3, -25 },
  { 720, 16, 25, 20, 2, -25 },
  { 770, 16, 25, 20, 2, -25 },
  { 820, 16, 25, 20, 2, -25 },
  { 870, 16, 25, 20, 2, -25 },
  { 920, 2, 19, 8, 3, -19 },
  { 925, 4, 24, 8, 1, -19 },
  { 937, 16, 16, 20, 2, -21 },
  { 969, 16, 8, 20, 2, -16 },
  { 985, 16, 16, 20, 2, -21 },
  { 1017, 12, 25, 15, 1, -25 },
  { 1055, 27, 28, 31, 2, -25 },
  { 1150, 21, 25, 21, 0, -25 },
  { 1216, 16, 25, 22, 4, -25 },
  { 1266, 19, 25, 22, 2, -25 },
  { 1326, 18, 25, 25, 4, -25 },
  { 1383, 13, 25, 19, 4, -25 },
  { 1424, 13, 25, 17, 4, -25 },
  { 1465, 20, 25, 25, 2, -25 },
  { 1528, 17, 25, 25, 4, -25 },
  { 1582, 6, 25, 10, 2, -25 },
  { 1601, 8, 31, 8, -3, -25 },
  { 1632, 16, 25, 20, 4, -25 },
  { 1682, 13, 25, 18, 4, -25 },
  { 1723, 22, 25, 30, 4, -25 },
  { 1792, 17, 25, 25, 4, -25 },
  { 1846, 22, 25, 27, 2, -25 },
  { 1915, 14, 25, 20, 4, -25 },
  { 1959, 22, 31, 27, 2, -25 },
  { 2045, 16, 25, 21, 4, -25 },
  { 2095, 15, 25, 19, 2, -25 },
  { 2142, 18, 25, 18, 0, -25 },
  { 2199, 19, 25, 25, 3, -25 },
  { 2259, 20, 25, 20, 0, -25 },
  { 2322, 29, 25, 31, 1, -25 },
  { 2413, 18, 25, 18, 0, -25 },
  { 2470, 18, 25, 18, 0, -25 },
  { 2527, 18, 25, 20, 1, -25 },
  { 2584, 7, 31, 11, 3, -25 },
  { 2612, 11, 25, 12, 0, -25 },
  { 2647, 7, 31, 11, 1, -25 },
  { 2675, 16, 15, 20, 2, -25 },
  { 2705, 14, 1, 14, 0, 3 },
  { 2707, 7, 6, 9, 1, -27 },
  { 2713, 13, 19, 18, 2, -19 },
  { 2744, 16, 27, 21, 3, -27 },
  { 2798, 14, 19, 17, 2, -19 },
  { 2832, 16, 27, 21, 2, -27 },
  { 2886, 15, 19, 19, 2, -19 },
  { 2922, 12, 27, 10, 0, -27 },
  { 2963, 16, 27, 21, 2, -19 },
  { 3017, 14, 27, 20, 3, -27 },
  { 3065, 2, 25, 8, 3, -25 },
  { 3072, 7, 33, 8, -2, -25 },
  { 3101, 14, 27, 16, 3, -27 },
  { 3149, 1, 27, 8, 3, -27 },
  { 3153, 25, 19, 30, 3, -19 },
  { 3213, 14, 19, 20, 3, -19 },
  { 3247, 16, 19, 20, 2, -19 },
  { 3285, 16, 27, 21, 3, -19 },
  { 3339, 15, 27, 21, 2, -19 },
  { 3390, 10, 19, 13, 3, -19 },
  { 3414, 14, 19, 16, 1, -19 },
  { 3448, 11, 23, 11, 0, -23 },
  { 3480, 14, 19, 20, 3, -19 },
  { 3514, 16, 19, 16, 0, -19 },
  { 3552, 23, 19, 25, 1, -19 },
  { 3607, 15, 19, 17, 1, -19 },
  { 3643, 16, 27, 16, 0, -19 },
  { 3697, 14, 19, 16, 1, -19 },
  { 3731, 10, 31, 12, 1, -25 },
  { 3770, 1, 36, 19, 9, -27 },
  { 3775, 10, 31, 12, 1, -25 },
  { 3814, 16, 3, 20, 2, -14 },
};

const GFXfont NotoSans_ExtraLight35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRALIGHT35PT7B_H_
