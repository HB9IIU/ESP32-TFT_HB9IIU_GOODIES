#ifndef _NOTOSANS_EXTRALIGHT46PT7B_H_
#define _NOTOSANS_EXTRALIGHT46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight46pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x00,
  0x3F, 0xE0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0x40,
  0xA0, 0x50, 0x28, 0x10, 0x00, 0x18, 0x06, 0x00, 0x02, 0x00, 0xC0, 0x00,
  0x40, 0x10, 0x00, 0x18, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x08, 0x03, 0x00, 0x01, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x0C,
  0x01, 0x00, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x80,
  0x00, 0x80, 0x20, 0x00, 0x30, 0x04, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x10, 0x06, 0x00, 0x02, 0x00, 0x80, 0x00, 0xC0, 0x10, 0x00,
  0x18, 0x06, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x08, 0x02,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01,
  0x00, 0x60, 0x00, 0x20, 0x08, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x70, 0x83, 0x18, 0x10,
  0x03, 0x02, 0x00, 0xC0, 0x40, 0x18, 0x08, 0x03, 0x01, 0x00, 0x60, 0x20,
  0x0C, 0x04, 0x01, 0xC0, 0x80, 0x18, 0x10, 0x01, 0xC2, 0x00, 0x1E, 0x40,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x04, 0xF0, 0x00, 0x87,
  0x00, 0x10, 0x30, 0x02, 0x03, 0x00, 0x40, 0x60, 0x08, 0x0C, 0x01, 0x01,
  0x80, 0x20, 0x30, 0x04, 0x06, 0x00, 0x81, 0x80, 0x10, 0x36, 0x02, 0x1C,
  0xFF, 0x7F, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x1F, 0x80, 0x01, 0x80, 0x71, 0x80, 0x03, 0x01, 0x81,
  0x80, 0x0C, 0x02, 0x01, 0x00, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x03, 0x00, 0x40, 0x08, 0x04, 0x00, 0x80, 0x10,
  0x18, 0x01, 0x00, 0x20, 0x60, 0x02, 0x00, 0x40, 0xC0, 0x04, 0x00, 0x83,
  0x00, 0x08, 0x01, 0x06, 0x00, 0x18, 0x06, 0x18, 0x7E, 0x30, 0x0C, 0x21,
  0xCE, 0x60, 0x18, 0xC6, 0x06, 0x40, 0x21, 0x18, 0x0C, 0xC0, 0xC6, 0x30,
  0x08, 0xE7, 0x08, 0x60, 0x18, 0xFC, 0x30, 0x80, 0x30, 0x00, 0xC3, 0x00,
  0x60, 0x01, 0x86, 0x00, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0x0C, 0x18, 0x03,
  0x00, 0x30, 0x30, 0x06, 0x00, 0x40, 0x60, 0x0C, 0x01, 0x80, 0x40, 0x18,
  0x02, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x30, 0x03, 0x01, 0x80,
  0x60, 0x03, 0x03, 0x01, 0x80, 0x07, 0x0C, 0x07, 0x00, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x01,
  0x80, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x30, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x38, 0x0C, 0x00, 0x67, 0x00, 0x60, 0x06, 0x60, 0x03, 0x00,
  0x4C, 0x00, 0x18, 0x0C, 0xC0, 0x00, 0xC0, 0xCC, 0x00, 0x06, 0x18, 0xC0,
  0x00, 0x33, 0x0C, 0x00, 0x01, 0xB0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x1B, 0x06, 0x00, 0x03, 0x18, 0x38, 0x00, 0xE1, 0xC1,
  0xF0, 0x7C, 0x0E, 0x07, 0xFF, 0x00, 0x70, 0xFF, 0xFF, 0x55, 0x03, 0x81,
  0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x07, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x20, 0x10, 0x0F, 0x02, 0x07, 0xFC, 0x47, 0xE0, 0xFF, 0xC0, 0x01,
  0x80, 0x00, 0x50, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x00, 0x83, 0x00, 0x30,
  0x60, 0x0C, 0x06, 0x03, 0x80, 0x60, 0x20, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x33, 0x33, 0x66, 0x64, 0xCC,
  0x80, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xF8, 0xF0, 0x1C, 0x01, 0x81, 0x80,
  0x0C, 0x30, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x02, 0x40,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x62, 0x00,
  0x06, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x1C, 0x01, 0x80, 0xF0, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0xC0, 0x70, 0x7C, 0x3B, 0x18, 0xDC, 0x3E, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x07, 0xFC, 0x01, 0xE1,
  0xE0, 0x70, 0x03, 0x0E, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x7C,
  0x1E, 0x00, 0x71, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x33, 0x00, 0x07, 0x1F, 0x80, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x33, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x08, 0x0C, 0x00,
  0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x04, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x1F, 0x00, 0x7F, 0xFE, 0x03, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0xC0, 0x03, 0x8F,
  0x80, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0x02, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0xFF, 0x03, 0x1E, 0x1E, 0x19, 0x80, 0x18, 0xD8,
  0x00, 0x67, 0x80, 0x01, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x40, 0x00, 0x1B, 0x00,
  0x00, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x0C, 0x00, 0x30,
  0x30, 0x03, 0x00, 0xE0, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0xF0, 0xF0, 0x18, 0x01, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x30, 0x00, 0x43, 0x00, 0x0C, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x03, 0xDC,
  0x00, 0x0F, 0x00, 0x03, 0xBC, 0x00, 0xE0, 0x70, 0x18, 0x01, 0xC3, 0x00,
  0x0E, 0x60, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x26,
  0x00, 0x06, 0x38, 0x01, 0xC1, 0xE0, 0x78, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x7C, 0x78, 0x07, 0x00, 0x60, 0x70, 0x01, 0x83, 0x00, 0x06, 0x30,
  0x00, 0x11, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x40, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0xEC, 0x00, 0x07, 0x30, 0x00, 0x78, 0xC0, 0x0E, 0xC3, 0x81, 0xC6,
  0x0F, 0xFC, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x04, 0x03, 0xC0, 0x3F, 0xF8,
  0x00, 0x38, 0x00, 0x00, 0x5F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x11, 0xCE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x18, 0xC6, 0x63, 0x18, 0x8C, 0x62, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFC, 0xF8, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x06, 0x30, 0x01,
  0xFF, 0xC0, 0x63, 0x00, 0x38, 0x1C, 0x02, 0x20, 0x06, 0x00, 0xC0, 0x36,
  0x00, 0xC0, 0x0C, 0x03, 0x60, 0x18, 0x00, 0xC0, 0x34, 0x01, 0x00, 0x0C,
  0x03, 0x40, 0x30, 0x00, 0x80, 0x34, 0x03, 0x00, 0x08, 0x03, 0xC0, 0x30,
  0x00, 0x80, 0x3C, 0x03, 0x00, 0x08, 0x03, 0xC0, 0x30, 0x01, 0x80, 0x3C,
  0x03, 0x00, 0x18, 0x03, 0x40, 0x30, 0x01, 0x80, 0x24, 0x03, 0x00, 0x38,
  0x06, 0x60, 0x18, 0x02, 0xC0, 0x46, 0x01, 0xC0, 0x6C, 0x0C, 0x60, 0x0F,
  0xBC, 0x7F, 0x82, 0x00, 0x3F, 0x03, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x84, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x20, 0x00, 0xF1, 0x00, 0x01, 0xC8, 0x00, 0x06, 0x40, 0x00, 0x1A,
  0x00, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00,
  0x0D, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x40, 0x00, 0x62, 0x00, 0x1E, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0x04, 0x00, 0x0E, 0x20, 0x00, 0x19, 0x00, 0x00,
  0x68, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x68, 0x00, 0x03,
  0x40, 0x00, 0x32, 0x00, 0x07, 0x1F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0xFC, 0x7F, 0x03, 0xC0, 0x03, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x01, 0x01, 0xF0, 0x1E, 0x00,
  0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x80, 0x07, 0xC0, 0x80,
  0x00, 0xE0, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0xE0, 0x80, 0x03, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xA0, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE8, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x07, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x0F, 0xC0, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0xFF, 0x7E, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x67, 0xF8, 0xFE, 0x00, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xA0, 0x00, 0x39, 0x00, 0x03, 0x88, 0x00, 0x38, 0x40, 0x03, 0x82,
  0x00, 0x38, 0x10, 0x03, 0x80, 0x80, 0x38, 0x04, 0x03, 0x80, 0x20, 0x38,
  0x01, 0x03, 0x80, 0x08, 0x38, 0x00, 0x43, 0x80, 0x02, 0x1C, 0x00, 0x11,
  0xE0, 0x00, 0x99, 0x80, 0x05, 0x86, 0x00, 0x38, 0x38, 0x01, 0x80, 0xC0,
  0x08, 0x03, 0x00, 0x40, 0x0C, 0x02, 0x00, 0x70, 0x10, 0x01, 0x80, 0x80,
  0x06, 0x04, 0x00, 0x18, 0x20, 0x00, 0xC1, 0x00, 0x03, 0x08, 0x00, 0x0C,
  0x40, 0x00, 0x72, 0x00, 0x01, 0x90, 0x00, 0x06, 0x80, 0x00, 0x18, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE8, 0x00, 0x00,
  0x0F, 0x60, 0x00, 0x00, 0xDB, 0x00, 0x00, 0x06, 0xCC, 0x00, 0x00, 0x26,
  0x60, 0x00, 0x03, 0x31, 0x00, 0x00, 0x19, 0x8C, 0x00, 0x01, 0x8C, 0x60,
  0x00, 0x0C, 0x61, 0x80, 0x00, 0x43, 0x0C, 0x00, 0x06, 0x18, 0x20, 0x00,
  0x30, 0xC1, 0x80, 0x03, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x30, 0x00, 0x81,
  0x81, 0x80, 0x0C, 0x0C, 0x04, 0x00, 0x60, 0x60, 0x30, 0x06, 0x03, 0x01,
  0x80, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x00, 0x80,
  0x80, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x30, 0x60, 0x0C, 0x00, 0xC6, 0x00,
  0x60, 0x06, 0x30, 0x03, 0x00, 0x11, 0x00, 0x18, 0x00, 0xD8, 0x00, 0xC0,
  0x06, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x02,
  0x00, 0x08, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3B, 0x00, 0x00, 0x73, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC6, 0x00,
  0x03, 0x86, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x0C, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x38,
  0x00, 0x60, 0x70, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC3, 0x80,
  0x00, 0xC7, 0x00, 0x01, 0x8E, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xB8, 0x00,
  0x03, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x06, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xE0, 0x03, 0xC0,
  0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x01, 0x90, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC2, 0x00, 0x1C, 0x40, 0x00, 0xC8, 0x00,
  0x0D, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xA0, 0x00,
  0x34, 0x00, 0x0C, 0x80, 0x07, 0x10, 0x1F, 0xC3, 0xFF, 0xC0, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x20, 0x01, 0xE1, 0x00, 0x03, 0x88,
  0x00, 0x0C, 0x40, 0x00, 0x32, 0x00, 0x01, 0x90, 0x00, 0x0C, 0x80, 0x00,
  0x64, 0x00, 0x03, 0x20, 0x00, 0x19, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x40,
  0x00, 0x62, 0x00, 0x06, 0x10, 0x00, 0x70, 0x80, 0x0E, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0x00, 0x30, 0x08, 0x01, 0x80, 0x40, 0x06, 0x02, 0x00,
  0x38, 0x10, 0x00, 0xC0, 0x80, 0x03, 0x04, 0x00, 0x18, 0x20, 0x00, 0x61,
  0x00, 0x03, 0x88, 0x00, 0x0C, 0x40, 0x00, 0x32, 0x00, 0x01, 0x90, 0x00,
  0x06, 0x80, 0x00, 0x38, 0x07, 0xFF, 0x01, 0xF0, 0xFE, 0x38, 0x00, 0x47,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x80, 0x03, 0x8F, 0x80, 0xF0,
  0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01,
  0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0x38, 0x00, 0xE0, 0x0F, 0x83, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x10, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0D, 0x80, 0x00, 0xC0, 0x00, 0x36,
  0x00, 0x03, 0x80, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x02, 0x20, 0x00, 0x68,
  0x00, 0x18, 0xC0, 0x01, 0x30, 0x00, 0x63, 0x00, 0x04, 0xC0, 0x01, 0x8C,
  0x00, 0x33, 0x00, 0x0C, 0x10, 0x00, 0xC4, 0x00, 0x30, 0x60, 0x02, 0x18,
  0x00, 0xC1, 0x80, 0x18, 0x60, 0x02, 0x06, 0x00, 0x60, 0x80, 0x18, 0x0C,
  0x01, 0x83, 0x00, 0x60, 0x30, 0x04, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x40, 0x30, 0x06, 0x02, 0x01, 0x80, 0xC0, 0x18,
  0x18, 0x06, 0x03, 0x00, 0x60, 0x60, 0x18, 0x18, 0x00, 0x81, 0x80, 0x30,
  0x60, 0x03, 0x04, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x03, 0x04, 0x00, 0x30,
  0xC0, 0x04, 0x30, 0x00, 0x43, 0x00, 0x18, 0xC0, 0x01, 0x88, 0x00, 0x63,
  0x00, 0x06, 0x60, 0x01, 0x98, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x34,
  0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x50,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80,
  0x00, 0xC3, 0x00, 0x00, 0x62, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x63, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x00, 0xC3, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0F, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0xC4, 0x00, 0x02, 0x18, 0x00, 0x18, 0x20,
  0x00, 0x40, 0xC0, 0x03, 0x01, 0x00, 0x08, 0x06, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x30, 0x0C, 0x00, 0x40, 0x20, 0x01, 0x81, 0x80, 0x02, 0x04, 0x00,
  0x0C, 0x30, 0x00, 0x11, 0x80, 0x00, 0x66, 0x00, 0x00, 0xB0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xF8, 0x03, 0xFF, 0x81, 0xC0, 0x30, 0x40, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x01, 0xFF, 0x07, 0xFF, 0xC7, 0x80, 0x33, 0x00, 0x0D, 0x80, 0x03,
  0x60, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xD8,
  0x00, 0xD6, 0x00, 0x64, 0xE0, 0x71, 0x1F, 0xF0, 0x40, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0xF8,
  0x0C, 0x7F, 0xF0, 0xCE, 0x03, 0x8D, 0x80, 0x0C, 0xF0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x06,
  0xE0, 0x00, 0x6F, 0x00, 0x0C, 0xD8, 0x01, 0x8C, 0xE0, 0x70, 0xC7, 0xFE,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC3, 0xC0, 0x23, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x07, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x01, 0xF8, 0x30, 0x7F,
  0xE3, 0x1E, 0x03, 0x33, 0x80, 0x1B, 0x30, 0x00, 0xF6, 0x00, 0x07, 0x60,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00,
  0x73, 0x00, 0x0F, 0x38, 0x01, 0xB1, 0xE0, 0x71, 0x07, 0xFC, 0x10, 0x00,
  0xF8, 0x00, 0xFF, 0xC0, 0x38, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0xC0,
  0x01, 0x98, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x08, 0x78, 0x0E, 0x03, 0xFF, 0x80, 0x01,
  0xFE, 0x07, 0xDC, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x07, 0xFF, 0x80, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE3, 0x1E, 0x03,
  0xB3, 0x80, 0x0B, 0x30, 0x00, 0xF6, 0x00, 0x07, 0x60, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x73, 0x00, 0x0F,
  0x38, 0x01, 0xB0, 0xE0, 0x73, 0x07, 0xFC, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x40, 0x00, 0xC7, 0x00, 0x38, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x03,
  0xE0, 0x63, 0xFF, 0x8C, 0xE0, 0x39, 0xB0, 0x03, 0xBC, 0x00, 0x37, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x80, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x06, 0xFC, 0xF8, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x0B, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x03, 0x0C,
  0x01, 0x83, 0x00, 0xC0, 0xC0, 0x70, 0x30, 0x38, 0x0C, 0x0C, 0x03, 0x06,
  0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0xF0, 0x03, 0x66, 0x00, 0xF0, 0xC0,
  0x38, 0x38, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x07, 0x0C,
  0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0xEC, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0xC7, 0xFC, 0x0F, 0xF8, 0xCC, 0x0E, 0x38, 0x0C, 0xD0, 0x03, 0x60, 0x06,
  0xF0, 0x03, 0x40, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0xF8, 0x18, 0xFF, 0xE3, 0x38, 0x0E, 0x6C, 0x00, 0xEF, 0x00, 0x0D,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0xE0, 0x30, 0x01, 0x83, 0x00,
  0x06, 0x30, 0x00, 0x39, 0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x90,
  0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06, 0x18, 0x00, 0x70, 0x60, 0x07,
  0x01, 0xE0, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x06, 0x3F, 0xF8, 0x33,
  0x80, 0xE1, 0xB0, 0x01, 0x8D, 0x00, 0x06, 0x70, 0x00, 0x33, 0x80, 0x00,
  0xDC, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x05, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0xE0, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0xCF, 0x00,
  0x06, 0x68, 0x00, 0x63, 0x60, 0x06, 0x19, 0xE0, 0xE0, 0xC3, 0xFE, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE3, 0x1C, 0x03,
  0x33, 0x80, 0x1B, 0x30, 0x00, 0xF6, 0x00, 0x07, 0x60, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0xF3, 0x00, 0x0B,
  0x38, 0x01, 0xB1, 0xE0, 0x73, 0x07, 0xFC, 0x30, 0x04, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x01,
  0xF6, 0x3F, 0xF3, 0x01, 0xB0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xCE, 0x00, 0xCC, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x0D, 0xE0, 0x3C, 0x7F, 0xF8, 0x00, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0F, 0xFF, 0xC3, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x07,
  0x04, 0x07, 0xF0, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF6, 0x00, 0x16, 0xE0, 0x0C, 0xCF, 0x07, 0x18, 0x7F, 0xC3,
  0xC0, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x60, 0x40, 0x03, 0x03, 0x00, 0x10, 0x18, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00,
  0x66, 0x00, 0x01, 0x30, 0x00, 0x0D, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1B, 0x00,
  0x0A, 0x00, 0x33, 0x00, 0x36, 0x00, 0x66, 0x00, 0x6C, 0x00, 0x8C, 0x00,
  0x88, 0x03, 0x0C, 0x03, 0x18, 0x06, 0x18, 0x06, 0x30, 0x0C, 0x30, 0x0C,
  0x60, 0x10, 0x20, 0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC1,
  0x81, 0x81, 0x83, 0x01, 0x02, 0x01, 0x06, 0x03, 0x0C, 0x03, 0x0C, 0x06,
  0x18, 0x06, 0x30, 0x04, 0x30, 0x04, 0x60, 0x0C, 0xC0, 0x0C, 0xC0, 0x19,
  0x80, 0x19, 0x00, 0x13, 0x00, 0x36, 0x00, 0x34, 0x00, 0x2C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x00, 0x73, 0x00, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x0C, 0x03,
  0x00, 0x60, 0x70, 0x06, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x98, 0x00, 0x0D,
  0x80, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x01,
  0x98, 0x00, 0x30, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x6E, 0x00, 0x03,
  0xC0, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x08, 0xC0, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x10, 0x18, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x80, 0x01, 0x0C, 0x00, 0x0C, 0x60, 0x00,
  0x62, 0x00, 0x01, 0x30, 0x00, 0x0D, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x06, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x07, 0xC0, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x01, 0xF0, 0x0F, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xF0, 0x07, 0x80, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0xF0, 0x1E, 0x00, 0x7F, 0x80, 0x0F,
  0x07, 0x80, 0xE0, 0x0F, 0xFD, 0x00, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraLight46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 33, 11, 4, -33 },
  { 14, 9, 12, 16, 3, -33 },
  { 28, 27, 33, 30, 1, -33 },
  { 140, 19, 38, 26, 3, -35 },
  { 231, 31, 33, 37, 3, -33 },
  { 359, 28, 33, 33, 3, -33 },
  { 475, 2, 12, 8, 3, -33 },
  { 478, 9, 40, 12, 2, -33 },
  { 523, 8, 40, 12, 2, -33 },
  { 563, 19, 19, 25, 3, -35 },
  { 609, 22, 21, 26, 2, -27 },
  { 667, 4, 11, 9, 2, -5 },
  { 673, 11, 1, 15, 2, -13 },
  { 675, 3, 3, 11, 4, -3 },
  { 677, 14, 33, 15, 1, -33 },
  { 735, 20, 33, 26, 3, -33 },
  { 818, 10, 33, 26, 5, -33 },
  { 860, 20, 33, 26, 3, -33 },
  { 943, 21, 33, 26, 2, -33 },
  { 1030, 25, 33, 26, 1, -33 },
  { 1134, 20, 33, 26, 3, -33 },
  { 1217, 21, 33, 26, 3, -33 },
  { 1304, 21, 33, 26, 3, -33 },
  { 1391, 20, 33, 26, 3, -33 },
  { 1474, 21, 34, 26, 2, -33 },
  { 1564, 3, 25, 11, 4, -25 },
  { 1574, 5, 31, 11, 2, -25 },
  { 1594, 21, 21, 26, 3, -27 },
  { 1650, 21, 11, 26, 3, -22 },
  { 1679, 21, 21, 26, 3, -27 },
  { 1735, 16, 33, 19, 2, -33 },
  { 1801, 36, 38, 41, 2, -33 },
  { 1972, 27, 33, 27, 0, -33 },
  { 2084, 21, 33, 29, 5, -33 },
  { 2171, 24, 33, 28, 3, -33 },
  { 2270, 24, 33, 32, 5, -33 },
  { 2369, 18, 33, 25, 5, -33 },
  { 2444, 18, 33, 23, 5, -33 },
  { 2519, 27, 33, 33, 3, -33 },
  { 2631, 23, 33, 33, 5, -33 },
  { 2726, 8, 33, 14, 3, -33 },
  { 2759, 11, 41, 11, -4, -33 },
  { 2816, 21, 33, 26, 5, -33 },
  { 2903, 18, 33, 23, 5, -33 },
  { 2978, 29, 33, 39, 5, -33 },
  { 3098, 23, 33, 33, 5, -33 },
  { 3193, 29, 33, 35, 3, -33 },
  { 3313, 19, 33, 27, 5, -33 },
  { 3392, 29, 41, 35, 3, -33 },
  { 3541, 21, 33, 27, 5, -33 },
  { 3628, 20, 33, 25, 3, -33 },
  { 3711, 24, 33, 24, 0, -33 },
  { 3810, 25, 33, 33, 4, -33 },
  { 3914, 26, 33, 26, 0, -33 },
  { 4022, 38, 33, 41, 1, -33 },
  { 4179, 24, 33, 24, 0, -33 },
  { 4278, 24, 33, 24, 0, -33 },
  { 4377, 23, 33, 27, 2, -33 },
  { 4472, 9, 40, 15, 4, -33 },
  { 4517, 14, 33, 15, 1, -33 },
  { 4575, 10, 40, 15, 1, -33 },
  { 4625, 22, 20, 26, 2, -33 },
  { 4680, 19, 2, 18, 0, 4 },
  { 4685, 8, 7, 12, 2, -35 },
  { 4692, 18, 25, 24, 2, -25 },
  { 4749, 20, 35, 27, 4, -35 },
  { 4837, 17, 25, 22, 3, -25 },
  { 4891, 20, 35, 27, 3, -35 },
  { 4979, 19, 25, 25, 3, -25 },
  { 5039, 15, 35, 13, 1, -35 },
  { 5105, 20, 36, 27, 3, -25 },
  { 5195, 19, 35, 27, 4, -35 },
  { 5279, 2, 33, 10, 4, -33 },
  { 5288, 8, 44, 10, -2, -33 },
  { 5332, 18, 35, 22, 4, -35 },
  { 5411, 2, 35, 10, 4, -35 },
  { 5420, 32, 25, 40, 4, -25 },
  { 5520, 19, 25, 27, 4, -25 },
  { 5580, 21, 25, 27, 3, -25 },
  { 5646, 21, 36, 27, 4, -25 },
  { 5741, 20, 36, 27, 3, -25 },
  { 5831, 13, 25, 18, 4, -25 },
  { 5872, 17, 25, 21, 2, -25 },
  { 5926, 14, 30, 15, 0, -30 },
  { 5979, 19, 24, 27, 4, -24 },
  { 6036, 21, 24, 21, 0, -24 },
  { 6099, 31, 24, 32, 1, -24 },
  { 6192, 20, 24, 23, 1, -24 },
  { 6252, 21, 35, 20, 0, -24 },
  { 6344, 17, 24, 21, 2, -24 },
  { 6395, 13, 40, 16, 1, -33 },
  { 6460, 2, 46, 25, 11, -35 },
  { 6472, 13, 40, 16, 2, -33 },
  { 6537, 21, 4, 26, 3, -18 },
};

const GFXfont NotoSans_ExtraLight46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRALIGHT46PT7B_H_
