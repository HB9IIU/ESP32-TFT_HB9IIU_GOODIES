#ifndef _NOTOSANS_EXTRALIGHT53PT7B_H_
#define _NOTOSANS_EXTRALIGHT53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight53pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x6F, 0xF7, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18,
  0x01, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x02, 0x00, 0x00, 0x20,
  0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0,
  0x08, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x10, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x01, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0,
  0x78, 0xC3, 0xE3, 0x83, 0x01, 0x1C, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80,
  0xC0, 0x0E, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xC0,
  0x06, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x70, 0xC0, 0x00,
  0xF3, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0x7C, 0x00, 0x0C, 0x78, 0x00, 0x30, 0x70, 0x00, 0xC0, 0x60, 0x03, 0x01,
  0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xA0, 0x0C,
  0x1E, 0xF8, 0x31, 0xE1, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0C, 0x01, 0xCF, 0x00, 0x01, 0x80, 0x30, 0x38, 0x00, 0x30, 0x07, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x06, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x00,
  0xC0, 0x06, 0x0C, 0x00, 0x0C, 0x00, 0x41, 0x83, 0xF0, 0xC0, 0x0C, 0x18,
  0x7F, 0xC6, 0x00, 0xC3, 0x0C, 0x0C, 0x60, 0x0C, 0x31, 0x80, 0x67, 0x01,
  0x86, 0x18, 0x06, 0x30, 0x38, 0xC3, 0x00, 0x31, 0xCF, 0x0C, 0x30, 0x03,
  0x0F, 0xE1, 0x83, 0x00, 0x30, 0x00, 0x18, 0x30, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x30, 0x00, 0x30, 0x30, 0x03, 0x00, 0x06, 0x03, 0x00, 0x30, 0x00,
  0x60, 0x30, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x30, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x18, 0x06, 0x00, 0x60, 0x01, 0x80, 0x60, 0x0C,
  0x00, 0x0C, 0x0E, 0x00, 0xC0, 0x00, 0xE1, 0xC0, 0x18, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x30, 0xE0, 0x1C, 0x00, 0x38,
  0xE0, 0x07, 0x00, 0x18, 0xE0, 0x01, 0xC0, 0x0C, 0x60, 0x00, 0x70, 0x0E,
  0x30, 0x00, 0x1C, 0x06, 0x38, 0x00, 0x07, 0x07, 0x18, 0x00, 0x01, 0xC3,
  0x0C, 0x00, 0x00, 0x73, 0x06, 0x00, 0x00, 0x1F, 0x83, 0x80, 0x00, 0x07,
  0x80, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x03,
  0x9C, 0x0E, 0x00, 0x03, 0x87, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0xFC, 0x7F,
  0x00, 0x70, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x60, 0x08, 0x02, 0xF8, 0x10, 0x3E,
  0xFE, 0x23, 0xF8, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x01, 0x83, 0x00, 0x06,
  0x03, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x06, 0x00, 0x80,
  0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x18, 0xCE, 0x73, 0x18, 0xCE, 0x63, 0x19,
  0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x6F, 0xF7, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xE7, 0xE0, 0x07, 0x00, 0x70, 0x0C, 0x00, 0x38,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0E,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x03, 0xE7, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x30, 0x07,
  0x01, 0xF0, 0x3B, 0x07, 0x31, 0xC3, 0x38, 0x3F, 0x03, 0x40, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0xF0, 0x03, 0x83, 0x80, 0x03, 0x82, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x3E, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x20, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x78, 0x7F, 0x03, 0xF0, 0x1F,
  0xFF, 0xC0, 0x00, 0x68, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x18, 0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x7C, 0x00, 0x7F, 0xFF, 0x80,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x72, 0x00, 0x01, 0xC7, 0x00, 0x0F, 0x0F, 0xE1, 0xFC, 0x07, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x3C, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0xFF, 0xC0, 0x63, 0xF3, 0xF0, 0x67, 0x00, 0x38, 0x6C, 0x00,
  0x1C, 0xD8, 0x00, 0x0E, 0xD0, 0x00, 0x06, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x38, 0x03, 0xE1, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xF7,
  0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70, 0x00,
  0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x07, 0x81, 0xE0, 0x01, 0xE7, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0xF0, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00,
  0x0C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x83, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1E, 0x00,
  0xE0, 0x38, 0x00, 0x70, 0x30, 0x00, 0x38, 0x70, 0x00, 0x18, 0x60, 0x00,
  0x0C, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x70, 0x00,
  0x1B, 0x38, 0x00, 0x33, 0x1C, 0x00, 0xE3, 0x0F, 0x87, 0xC6, 0x03, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x30, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x6F, 0xF7, 0x1C, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x86, 0x38, 0xE3, 0x0C,
  0x31, 0x86, 0x18, 0x43, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x3F,
  0xFF, 0x8E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x01, 0x86, 0x00, 0x07, 0xFC, 0x00,
  0x63, 0x00, 0x0F, 0xFF, 0x80, 0x33, 0x00, 0x0E, 0x00, 0xC0, 0x19, 0x80,
  0x0C, 0x00, 0x60, 0x04, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00,
  0x18, 0x01, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0x06, 0x00,
  0x78, 0x03, 0x00, 0x03, 0x00, 0x3C, 0x01, 0x80, 0x01, 0x80, 0x1E, 0x00,
  0xC0, 0x00, 0x80, 0x0F, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x80, 0x30, 0x00,
  0x60, 0x03, 0xC0, 0x18, 0x00, 0x30, 0x03, 0x60, 0x0C, 0x00, 0x18, 0x01,
  0xB0, 0x06, 0x00, 0x1C, 0x00, 0xD8, 0x03, 0x80, 0x0F, 0x00, 0xCC, 0x00,
  0xC0, 0x0D, 0x80, 0x63, 0x00, 0x30, 0x0C, 0x60, 0x61, 0x80, 0x1F, 0x3C,
  0x3D, 0xE0, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x30, 0x00, 0x3E, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x00,
  0x70, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x18, 0x00, 0x1F, 0x0C, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x30, 0x00, 0x07, 0x18, 0x00, 0x0F,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x70, 0x1C, 0x00, 0x01, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x02, 0x00, 0x7E, 0x1F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0xFE, 0x01, 0x80,
  0x00, 0x78, 0x0C, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x0F, 0x01, 0x80, 0x03, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x8F, 0xFC, 0x01, 0xE0,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x20, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x0C, 0x0F, 0x00, 0x00, 0x18, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xFC,
  0x7F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x7F, 0xBF, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x7F, 0xE3, 0xFC, 0x00,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x98, 0x00, 0x03,
  0x8C, 0x00, 0x03, 0x86, 0x00, 0x03, 0x83, 0x00, 0x03, 0x81, 0x80, 0x03,
  0x80, 0xC0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18, 0x03,
  0x80, 0x0C, 0x03, 0x80, 0x06, 0x03, 0x80, 0x03, 0x03, 0x80, 0x01, 0x83,
  0x80, 0x00, 0xC3, 0xC0, 0x00, 0x63, 0xE0, 0x00, 0x33, 0xB8, 0x00, 0x1B,
  0x8E, 0x00, 0x0F, 0x83, 0x00, 0x07, 0x80, 0xC0, 0x03, 0x80, 0x70, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x80, 0x30, 0x00, 0xE0,
  0x18, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x30, 0x00,
  0x03, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xEC, 0x00, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x00,
  0x37, 0x98, 0x00, 0x00, 0x0C, 0xF3, 0x00, 0x00, 0x01, 0x9E, 0x70, 0x00,
  0x00, 0x33, 0xC6, 0x00, 0x00, 0x0C, 0x78, 0xC0, 0x00, 0x01, 0x8F, 0x0C,
  0x00, 0x00, 0x61, 0xE1, 0x80, 0x00, 0x0C, 0x3C, 0x38, 0x00, 0x01, 0x87,
  0x83, 0x00, 0x00, 0x60, 0xF0, 0x60, 0x00, 0x0C, 0x1E, 0x06, 0x00, 0x03,
  0x03, 0xC0, 0xC0, 0x00, 0x60, 0x78, 0x1C, 0x00, 0x0C, 0x0F, 0x01, 0x80,
  0x03, 0x01, 0xE0, 0x30, 0x00, 0x60, 0x3C, 0x03, 0x00, 0x18, 0x07, 0x80,
  0x60, 0x03, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x1E, 0x00, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0x00, 0x78, 0x01, 0x80, 0xC0, 0x0F, 0x00, 0x30, 0x18,
  0x01, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x00, 0x60, 0xC0, 0x07, 0x80, 0x0C,
  0x18, 0x00, 0xF0, 0x00, 0xC6, 0x00, 0x1E, 0x00, 0x18, 0xC0, 0x03, 0xC0,
  0x03, 0xB8, 0x00, 0x78, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1E, 0x30, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0x70, 0x00, 0x0F,
  0x06, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80, 0xC0,
  0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x18, 0x00, 0x78,
  0x03, 0x80, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x00, 0x3C, 0x00, 0x70,
  0x07, 0x80, 0x07, 0x00, 0xF0, 0x00, 0x60, 0x1E, 0x00, 0x06, 0x03, 0xC0,
  0x00, 0xE0, 0x78, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x1C,
  0x3C, 0x00, 0x01, 0x87, 0x80, 0x00, 0x18, 0xF0, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x33, 0xC0, 0x00, 0x03, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x16, 0x00, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0x00, 0x0F, 0x86, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x98,
  0x00, 0x03, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x73, 0x00, 0x01, 0xC6, 0x00, 0x0F, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x15, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x30, 0x00, 0xFC, 0x18, 0x00, 0x0F, 0x0C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x38,
  0x60, 0x00, 0x38, 0x30, 0x00, 0x38, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x98, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x78, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE6, 0x00,
  0x07, 0x8F, 0xF0, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x70, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0xE0, 0x03, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x66, 0x00, 0x01,
  0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0,
  0x00, 0x71, 0x80, 0x01, 0x98, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x01,
  0x81, 0x80, 0x0E, 0x07, 0x00, 0x30, 0x30, 0x01, 0x80, 0x60, 0x06, 0x03,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0x60, 0x18, 0x03, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x38, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00, 0x06, 0x18, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC7, 0x00,
  0x03, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x18, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x18, 0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x18, 0x30, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x03, 0x80, 0x03, 0x80,
  0x60, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F,
  0xF0, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x3F, 0x87,
  0xC1, 0x80, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x07, 0xFF, 0x07, 0xFF, 0xF1, 0xF0, 0x03, 0x38, 0x00, 0x37,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1B, 0x70, 0x03,
  0x33, 0xE1, 0xE1, 0x1F, 0xFC, 0x10, 0x08, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x0C, 0x3F, 0xF8, 0x18, 0xF0, 0x7C,
  0x33, 0x00, 0x1C, 0x6C, 0x00, 0x1C, 0xF0, 0x00, 0x19, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0x37, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x80, 0x00,
  0x67, 0x80, 0x01, 0xCD, 0x80, 0x07, 0x13, 0x80, 0x1C, 0x21, 0xE1, 0xF0,
  0x41, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0x03,
  0xF0, 0xF0, 0x70, 0x01, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x10, 0x7F, 0x1F, 0x01, 0xFF, 0xE0, 0x01, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x1C, 0x03, 0x01, 0xFF, 0x83,
  0x07, 0xC1, 0xE3, 0x0E, 0x00, 0x73, 0x1C, 0x00, 0x3B, 0x38, 0x00, 0x1B,
  0x30, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x0F, 0x30, 0x00, 0x0F, 0x38, 0x00, 0x1B, 0x18, 0x00, 0x33,
  0x0E, 0x00, 0x73, 0x07, 0xC3, 0xC3, 0x03, 0xFF, 0x83, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0x0F, 0x80, 0x70, 0x03, 0x81,
  0xC0, 0x03, 0x03, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x30, 0x3F, 0x0F, 0xE0, 0x1F, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xF0, 0x1F, 0x18, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x3F, 0xFE, 0x0F, 0xFF,
  0x80, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xFF, 0x83, 0x07, 0xC1, 0xE3, 0x0E, 0x00, 0x73,
  0x1C, 0x00, 0x1B, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x30, 0x00, 0x0B,
  0x38, 0x00, 0x1B, 0x1C, 0x00, 0x37, 0x0E, 0x00, 0x77, 0x07, 0xC3, 0xC7,
  0x03, 0xFF, 0x87, 0x00, 0x10, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x3F, 0x01, 0xF0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x60, 0x0C, 0x3F, 0xF8, 0x63, 0xC1, 0xE3, 0x30, 0x03, 0x9B, 0x00, 0x06,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x87, 0xBF, 0xC3, 0x80, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x03, 0x8C,
  0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x00, 0xC7, 0x00,
  0x0C, 0xF8, 0x00, 0xDD, 0xC0, 0x0F, 0x8E, 0x00, 0xF0, 0x60, 0x0E, 0x03,
  0x00, 0xC0, 0x38, 0x0C, 0x01, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0,
  0x07, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xEC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x00, 0x1C, 0x04, 0x1F, 0xF0, 0x0F, 0xFC, 0x23, 0xC3, 0xE1,
  0xF1, 0xF1, 0xB8, 0x03, 0x1C, 0x01, 0xCD, 0x00, 0x0C, 0xC0, 0x07, 0x78,
  0x00, 0x6C, 0x00, 0x1B, 0x80, 0x01, 0xC0, 0x00, 0xDC, 0x00, 0x0E, 0x00,
  0x07, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x18, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x01,
  0xE0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x01, 0xE0, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x78, 0x00,
  0x0C, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x3C, 0x04, 0x1F, 0xFC, 0x21, 0xE0, 0xF9, 0x98,
  0x01, 0xCD, 0x80, 0x03, 0x78, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xF0, 0x7C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x18,
  0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x1E, 0x00, 0xFC, 0x7C, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x01, 0x03, 0xFF, 0x03,
  0x1E, 0x0F, 0x86, 0x70, 0x03, 0x8D, 0x80, 0x03, 0x9E, 0x00, 0x03, 0x3C,
  0x00, 0x07, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xB8, 0x00, 0x03,
  0x78, 0x00, 0x0E, 0xF0, 0x00, 0x39, 0xB0, 0x00, 0xE3, 0x38, 0x03, 0x86,
  0x3E, 0x3E, 0x0C, 0x3F, 0xF8, 0x18, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x04, 0x1F, 0x07,
  0x88, 0x70, 0x03, 0x91, 0xC0, 0x03, 0x27, 0x00, 0x03, 0xCC, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x30, 0x00, 0x1E, 0x30, 0x00, 0x6C, 0x78, 0x01, 0x98, 0x7C, 0x1E,
  0x30, 0x3F, 0xF0, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x23, 0x0F, 0xFC, 0xF8, 0xF7, 0x00, 0xD8, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFC, 0x1F, 0x07,
  0xE3, 0x80, 0x02, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0xC0, 0x01,
  0xCF, 0xE0, 0xF8, 0x3F, 0xFF, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0F, 0x8C,
  0x07, 0xF8, 0x01, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x30, 0x00,
  0x6C, 0xF0, 0x07, 0x31, 0xF0, 0xF8, 0xC1, 0xFF, 0x83, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x06, 0x60, 0x00, 0xF0,
  0x00, 0x66, 0x00, 0x0F, 0x00, 0x06, 0x60, 0x00, 0x90, 0x00, 0xC7, 0x00,
  0x19, 0x80, 0x0C, 0x30, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x19, 0x80, 0x0C,
  0x30, 0x03, 0x0C, 0x01, 0x81, 0x80, 0x30, 0xC0, 0x18, 0x18, 0x03, 0x0C,
  0x01, 0x81, 0x80, 0x60, 0x60, 0x38, 0x18, 0x06, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x60, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x60,
  0x06, 0x0C, 0x03, 0x06, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x1E, 0x00, 0x05, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x38,
  0x60, 0x00, 0x60, 0xE0, 0x01, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x30, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x01, 0x86, 0x00, 0x03,
  0x98, 0x00, 0x03, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x37, 0x00, 0x00, 0xE6, 0x00, 0x01, 0x86, 0x00, 0x06, 0x0E,
  0x00, 0x1C, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x18, 0x18, 0x00, 0x18, 0x60, 0x00, 0x39, 0xC0, 0x00, 0x37,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E,
  0x70, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x70,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x83, 0x80,
  0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x87, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0xFC, 0x03, 0xC0, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x3F, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x0F, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0x7F, 0xF8, 0x01, 0xC0, 0x3E, 0x07, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraLight53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 38, 12, 4, -38 },
  { 20, 10, 14, 18, 4, -38 },
  { 38, 32, 38, 34, 1, -38 },
  { 190, 22, 43, 30, 3, -40 },
  { 309, 36, 39, 42, 3, -38 },
  { 485, 33, 39, 38, 3, -38 },
  { 646, 2, 14, 10, 4, -38 },
  { 650, 10, 46, 14, 2, -38 },
  { 708, 10, 46, 14, 2, -38 },
  { 766, 23, 22, 29, 3, -40 },
  { 830, 24, 25, 30, 3, -31 },
  { 905, 5, 13, 11, 2, -6 },
  { 914, 13, 2, 17, 2, -15 },
  { 918, 4, 4, 12, 4, -4 },
  { 920, 16, 38, 18, 1, -38 },
  { 996, 24, 39, 30, 3, -38 },
  { 1113, 12, 38, 30, 5, -38 },
  { 1170, 23, 38, 30, 3, -38 },
  { 1280, 24, 39, 30, 2, -38 },
  { 1397, 29, 38, 30, 1, -38 },
  { 1535, 23, 39, 30, 4, -38 },
  { 1648, 24, 39, 30, 3, -38 },
  { 1765, 24, 38, 30, 3, -38 },
  { 1879, 24, 39, 30, 3, -38 },
  { 1996, 24, 39, 30, 3, -38 },
  { 2113, 4, 28, 12, 4, -28 },
  { 2127, 6, 35, 12, 2, -28 },
  { 2154, 24, 24, 30, 3, -31 },
  { 2226, 24, 13, 30, 3, -25 },
  { 2265, 24, 24, 30, 3, -31 },
  { 2337, 18, 38, 22, 2, -38 },
  { 2423, 41, 43, 47, 3, -38 },
  { 2644, 31, 38, 31, 0, -38 },
  { 2792, 25, 38, 33, 5, -38 },
  { 2911, 28, 39, 33, 3, -38 },
  { 3048, 29, 38, 37, 5, -38 },
  { 3186, 21, 38, 29, 5, -38 },
  { 3286, 21, 38, 26, 5, -38 },
  { 3386, 31, 39, 38, 3, -38 },
  { 3538, 27, 38, 38, 5, -38 },
  { 3667, 10, 38, 16, 3, -38 },
  { 3715, 13, 47, 13, -5, -38 },
  { 3792, 25, 38, 30, 5, -38 },
  { 3911, 21, 38, 27, 5, -38 },
  { 4011, 35, 38, 45, 5, -38 },
  { 4178, 27, 38, 38, 5, -38 },
  { 4307, 34, 39, 40, 3, -38 },
  { 4473, 23, 38, 31, 5, -38 },
  { 4583, 34, 47, 40, 3, -38 },
  { 4783, 25, 38, 31, 5, -38 },
  { 4902, 23, 39, 29, 3, -38 },
  { 5015, 27, 38, 27, 0, -38 },
  { 5144, 28, 39, 38, 5, -38 },
  { 5281, 30, 38, 30, 0, -38 },
  { 5424, 43, 38, 47, 2, -38 },
  { 5629, 28, 38, 28, 0, -38 },
  { 5762, 27, 38, 27, 0, -38 },
  { 5891, 26, 38, 31, 2, -38 },
  { 6015, 10, 46, 17, 5, -38 },
  { 6073, 16, 38, 18, 1, -38 },
  { 6149, 11, 46, 17, 1, -38 },
  { 6213, 26, 23, 30, 2, -38 },
  { 6288, 21, 2, 21, 0, 5 },
  { 6294, 9, 9, 14, 2, -41 },
  { 6305, 20, 30, 28, 3, -29 },
  { 6380, 23, 41, 31, 5, -40 },
  { 6498, 20, 30, 25, 3, -29 },
  { 6573, 24, 41, 31, 3, -40 },
  { 6696, 23, 30, 29, 3, -29 },
  { 6783, 18, 41, 15, 1, -41 },
  { 6876, 24, 42, 31, 3, -29 },
  { 7002, 21, 40, 31, 5, -40 },
  { 7107, 3, 38, 12, 4, -38 },
  { 7122, 10, 51, 12, -3, -38 },
  { 7186, 20, 40, 25, 5, -40 },
  { 7286, 2, 40, 12, 5, -40 },
  { 7296, 37, 29, 46, 5, -29 },
  { 7431, 21, 29, 31, 5, -29 },
  { 7508, 25, 30, 31, 3, -29 },
  { 7602, 23, 41, 31, 5, -29 },
  { 7720, 23, 41, 31, 3, -29 },
  { 7838, 14, 29, 20, 5, -29 },
  { 7889, 20, 30, 24, 2, -29 },
  { 7964, 15, 36, 17, 1, -35 },
  { 8032, 22, 29, 31, 4, -28 },
  { 8112, 24, 28, 24, 0, -28 },
  { 8196, 36, 28, 37, 1, -28 },
  { 8322, 23, 28, 26, 1, -28 },
  { 8403, 24, 41, 24, 0, -28 },
  { 8526, 20, 28, 24, 2, -28 },
  { 8596, 15, 46, 18, 1, -38 },
  { 8683, 2, 53, 29, 13, -40 },
  { 8697, 15, 46, 18, 2, -38 },
  { 8784, 24, 5, 30, 3, -21 },
};

const GFXfont NotoSans_ExtraLight53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRALIGHT53PT7B_H_
