#ifndef _NOTOSANS_EXTRALIGHT25PT7B_H_
#define _NOTOSANS_EXTRALIGHT25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight25pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA0, 0xB0, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x04,
  0x10, 0x10, 0x40, 0x41, 0x01, 0x08, 0x04, 0x20, 0x20, 0x87, 0xFF, 0xC2,
  0x08, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04, 0x10, 0xFF, 0xFC, 0x42, 0x01,
  0x08, 0x04, 0x20, 0x20, 0x80, 0x82, 0x00, 0x08, 0x02, 0x07, 0xFA, 0x20,
  0x88, 0x22, 0x08, 0x82, 0x20, 0x48, 0x0E, 0x00, 0xE0, 0x26, 0x08, 0xC2,
  0x10, 0x84, 0x21, 0x08, 0xBA, 0xC0, 0xC0, 0x20, 0x3C, 0x04, 0x10, 0x81,
  0x04, 0x20, 0x81, 0x08, 0x20, 0x82, 0x10, 0x20, 0x84, 0x08, 0x22, 0x01,
  0x09, 0x3C, 0x42, 0x58, 0x90, 0xA4, 0x23, 0xC9, 0x08, 0x04, 0x41, 0x01,
  0x10, 0x40, 0x84, 0x10, 0x21, 0x08, 0x10, 0x42, 0x08, 0x10, 0x82, 0x03,
  0xC0, 0x1F, 0x00, 0x41, 0x00, 0x82, 0x02, 0x02, 0x04, 0x08, 0x04, 0x10,
  0x0C, 0x40, 0x0F, 0x00, 0x1C, 0x00, 0x4C, 0x01, 0x0C, 0x14, 0x0C, 0x28,
  0x0C, 0x90, 0x0D, 0x20, 0x0C, 0x40, 0x1C, 0x40, 0x4C, 0x7F, 0x0C, 0xFE,
  0x18, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x42, 0x08,
  0x41, 0x0C, 0x82, 0x10, 0x42, 0x08, 0x42, 0x10, 0x42, 0x10, 0x88, 0x42,
  0x11, 0x08, 0x44, 0x40, 0x04, 0x00, 0x80, 0x10, 0x42, 0x17, 0x4E, 0x1E,
  0x01, 0x80, 0x48, 0x11, 0x86, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x55, 0xA0, 0xFC, 0xB0, 0x01, 0x03, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0xC0, 0x0F, 0x83,
  0x04, 0x20, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x22, 0x02, 0x30, 0x41,
  0xF8, 0x04, 0x33, 0x71, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x1F, 0x0C, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x1F, 0xFC, 0x1F, 0x9C, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x04, 0x1F, 0x00, 0x38, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x4F, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x04, 0x80,
  0x64, 0x02, 0x20, 0x21, 0x02, 0x08, 0x10, 0x41, 0x02, 0x10, 0x11, 0x00,
  0x8F, 0xFF, 0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x7F,
  0xC8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x05, 0xF0, 0x41, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40, 0x10, 0x02, 0x80, 0x9F, 0xE0,
  0x0F, 0xC2, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0xF8, 0xA0,
  0xD8, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0A, 0x02, 0x60, 0xC3,
  0xE0, 0xFF, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x3F, 0x08, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00,
  0x90, 0x21, 0x98, 0x0C, 0x06, 0x61, 0x03, 0x40, 0x28, 0x03, 0x00, 0x60,
  0x0C, 0x02, 0x40, 0xC7, 0xE0, 0x1F, 0x02, 0x0C, 0x40, 0x44, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x34, 0x03, 0x40, 0x36, 0x05, 0x1F, 0xA0, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x01, 0x87, 0xE0, 0xE0, 0x00, 0x02, 0xC0,
  0x68, 0x00, 0x00, 0x01, 0x24, 0xA4, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x08, 0x00, 0x7E, 0x41, 0x80, 0x40, 0x20, 0x08, 0x08, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x00, 0x00, 0x10, 0x18, 0x00,
  0x00, 0xF8, 0x00, 0x70, 0x70, 0x08, 0x00, 0x81, 0x00, 0x04, 0x20, 0x00,
  0x24, 0x07, 0x82, 0x41, 0x84, 0x24, 0x30, 0x41, 0x82, 0x04, 0x18, 0x20,
  0x41, 0x84, 0x04, 0x18, 0x40, 0x41, 0x82, 0x0C, 0x24, 0x20, 0xC2, 0x41,
  0xF3, 0xC4, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x10, 0x04, 0x10, 0x08, 0x20, 0x20, 0x60, 0x40, 0x40, 0xFF,
  0x82, 0x00, 0x84, 0x01, 0x10, 0x02, 0x20, 0x02, 0x40, 0x05, 0x00, 0x04,
  0xFF, 0x10, 0x1A, 0x01, 0x40, 0x38, 0x03, 0x00, 0x60, 0x14, 0x04, 0xFE,
  0x10, 0x3A, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0xDF,
  0xE0, 0x07, 0xF0, 0xC0, 0x48, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F, 0x80, 0xFE, 0x04, 0x0E, 0x20, 0x19,
  0x00, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x40, 0x0A, 0x00, 0xD0, 0x0C, 0x81, 0xC7, 0xF8,
  0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xE0, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x00, 0x07, 0xF8, 0x60, 0x12, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x07,
  0xF8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x58, 0x01, 0x10,
  0x04, 0x3F, 0xE0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x0B, 0xC0, 0x80,
  0x70, 0x1A, 0x06, 0x40, 0x88, 0x21, 0x08, 0x22, 0x04, 0x80, 0xB0, 0x19,
  0x02, 0x10, 0x43, 0x08, 0x21, 0x02, 0x20, 0x64, 0x04, 0x80, 0x50, 0x04,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7F, 0xC0, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x05, 0xC0, 0x05, 0xA0, 0x09, 0xA0, 0x09, 0x90, 0x09, 0x90,
  0x11, 0x90, 0x11, 0x88, 0x21, 0x88, 0x21, 0x84, 0x21, 0x84, 0x41, 0x84,
  0x41, 0x82, 0x81, 0x82, 0x81, 0x81, 0x81, 0x81, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x1A, 0x01, 0xA0, 0x19, 0x01, 0x88, 0x18, 0x81, 0x84, 0x18, 0x21,
  0x82, 0x18, 0x11, 0x80, 0x98, 0x09, 0x80, 0x58, 0x03, 0x80, 0x38, 0x01,
  0x0F, 0xE0, 0x20, 0x30, 0x80, 0x32, 0x00, 0x28, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x50, 0x01, 0x30, 0x06, 0x30, 0x18, 0x1F, 0xC0, 0xFE, 0x20,
  0x68, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA3, 0xCF, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F, 0xE0, 0x20,
  0x30, 0x80, 0x32, 0x00, 0x28, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x50,
  0x01, 0x30, 0x06, 0x30, 0x18, 0x1F, 0xC0, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0xFC, 0x10, 0x32, 0x03, 0x40, 0x28, 0x05, 0x00, 0xA0,
  0x14, 0x04, 0x81, 0x9F, 0xC2, 0x18, 0x41, 0x08, 0x11, 0x02, 0x20, 0x24,
  0x06, 0x80, 0x50, 0x04, 0x1F, 0xC4, 0x05, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x5F, 0xF0, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x24,
  0x00, 0x90, 0x06, 0x30, 0x30, 0x7F, 0x00, 0x80, 0x07, 0x00, 0x14, 0x00,
  0x90, 0x02, 0x20, 0x08, 0x80, 0x42, 0x01, 0x04, 0x0C, 0x10, 0x20, 0x60,
  0x80, 0x84, 0x02, 0x10, 0x04, 0x40, 0x12, 0x00, 0x48, 0x00, 0xA0, 0x03,
  0x00, 0x0C, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x0A,
  0x02, 0x40, 0x90, 0x24, 0x09, 0x02, 0x40, 0x90, 0x22, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x11, 0x08, 0xC1, 0x20, 0x48, 0x12, 0x04, 0x81,
  0x20, 0x48, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x40, 0x1B, 0x00, 0x88, 0x08, 0x20, 0xC1, 0x04, 0x04, 0x40, 0x12, 0x00,
  0xA0, 0x02, 0x00, 0x38, 0x01, 0x40, 0x11, 0x00, 0x84, 0x08, 0x20, 0x80,
  0x84, 0x06, 0x40, 0x14, 0x00, 0x40, 0x80, 0x0A, 0x00, 0x90, 0x04, 0x40,
  0x42, 0x02, 0x08, 0x20, 0x62, 0x01, 0x10, 0x05, 0x00, 0x28, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x7F, 0xF0, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x0F, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x7C, 0x80, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0xF8,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0xFC, 0x02, 0x00, 0x60, 0x05, 0x00, 0x90, 0x08, 0x81, 0x08, 0x20, 0x42,
  0x04, 0x40, 0x24, 0x02, 0x80, 0x10, 0xFF, 0xC0, 0xC4, 0x21, 0x7F, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x40, 0xF3, 0xC5, 0x01, 0x80, 0x60, 0x18, 0x0D,
  0x05, 0x7E, 0x40, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x08, 0x26,
  0xE5, 0x02, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x54, 0x1A, 0x7E, 0x00, 0x03, 0x07, 0x33, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x30, 0x07, 0xF0,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x21, 0x1D, 0x92, 0x05,
  0x40, 0x34, 0x03, 0x40, 0x38, 0x01, 0x80, 0x18, 0x01, 0x40, 0x34, 0x03,
  0x40, 0x32, 0x05, 0x1F, 0x90, 0x02, 0x03, 0xB0, 0x81, 0x20, 0x14, 0x02,
  0x80, 0x60, 0x0F, 0xFE, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x02, 0x3F,
  0x80, 0x0F, 0x88, 0x04, 0x02, 0x01, 0x00, 0x83, 0xF8, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x06,
  0x01, 0x99, 0x20, 0x54, 0x03, 0x40, 0x34, 0x03, 0xC0, 0x18, 0x01, 0x80,
  0x14, 0x03, 0x40, 0x34, 0x03, 0x20, 0x51, 0xF9, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x02, 0x40, 0x43, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x21,
  0x89, 0x9A, 0x81, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0xE0, 0x2A, 0xAA, 0xAA, 0xA0, 0x18, 0x80,
  0x00, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x5C, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x1A, 0x04, 0x82,
  0x21, 0x08, 0x82, 0x40, 0xA8, 0x31, 0x08, 0x42, 0x08, 0x81, 0x20, 0x28,
  0x0C, 0xFF, 0xFF, 0xE0, 0x04, 0x04, 0x2E, 0xCE, 0xCC, 0x0A, 0x0B, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80,
  0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x10,
  0x06, 0x26, 0x6A, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x02, 0x01, 0xDC, 0x20, 0x64, 0x02,
  0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x14, 0x02,
  0x20, 0x41, 0xF8, 0x06, 0x13, 0x32, 0x81, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x2A, 0x0D, 0x3F, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x00, 0x02, 0x03, 0xB4, 0x81, 0xA0,
  0x14, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x28, 0x05, 0x00, 0xA0, 0x32,
  0x06, 0x3F, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0xBF,
  0x43, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x00, 0x0C,
  0x39, 0xD0, 0x10, 0x08, 0x02, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x40, 0x20,
  0x18, 0x0F, 0xF8, 0x20, 0x20, 0x20, 0xFE, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x1F, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x03, 0x3F, 0x40,
  0x80, 0x28, 0x09, 0x01, 0x20, 0x22, 0x08, 0x41, 0x04, 0x20, 0x88, 0x11,
  0x01, 0x40, 0x28, 0x05, 0x00, 0x40, 0xC0, 0xC0, 0xA0, 0x60, 0x50, 0x30,
  0x28, 0x24, 0x22, 0x12, 0x11, 0x09, 0x08, 0x88, 0x48, 0x24, 0x24, 0x12,
  0x12, 0x0A, 0x05, 0x05, 0x03, 0x01, 0x81, 0x80, 0x80, 0x40, 0xC0, 0x48,
  0x10, 0x84, 0x09, 0x81, 0x20, 0x18, 0x03, 0x00, 0x70, 0x12, 0x04, 0x21,
  0x82, 0x20, 0x48, 0x06, 0x80, 0x28, 0x0D, 0x01, 0x20, 0x22, 0x08, 0x41,
  0x04, 0x20, 0x88, 0x11, 0x01, 0x40, 0x28, 0x03, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x08, 0x02, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x40, 0x40, 0x40,
  0x60, 0x20, 0x20, 0x30, 0x10, 0x10, 0x10, 0x08, 0x0F, 0xF8, 0x06, 0x30,
  0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x43, 0x86, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x81, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x40,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x30, 0x71, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x83, 0x18, 0x00, 0x7C, 0x18, 0x3E,
};

const GFXglyph NotoSans_ExtraLight25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 18, 6, 2, -18 },
  { 6, 5, 7, 8, 2, -18 },
  { 11, 14, 18, 16, 1, -18 },
  { 43, 10, 20, 14, 2, -19 },
  { 68, 18, 18, 20, 1, -18 },
  { 109, 15, 18, 18, 2, -18 },
  { 143, 1, 7, 5, 2, -18 },
  { 144, 5, 22, 7, 1, -18 },
  { 158, 5, 22, 7, 1, -18 },
  { 172, 11, 10, 14, 1, -19 },
  { 186, 12, 12, 14, 1, -15 },
  { 204, 2, 6, 5, 1, -3 },
  { 206, 6, 1, 8, 1, -7 },
  { 207, 2, 2, 6, 2, -2 },
  { 208, 8, 18, 8, 0, -18 },
  { 226, 12, 18, 14, 1, -18 },
  { 253, 6, 18, 14, 2, -18 },
  { 267, 11, 18, 14, 1, -18 },
  { 292, 11, 18, 14, 1, -18 },
  { 317, 13, 18, 14, 1, -18 },
  { 347, 11, 18, 14, 2, -18 },
  { 372, 11, 18, 14, 2, -18 },
  { 397, 12, 18, 14, 1, -18 },
  { 424, 11, 18, 14, 2, -18 },
  { 449, 12, 18, 14, 1, -18 },
  { 476, 2, 13, 6, 2, -13 },
  { 480, 3, 16, 6, 1, -13 },
  { 486, 12, 12, 14, 1, -15 },
  { 504, 12, 6, 14, 1, -12 },
  { 513, 12, 12, 14, 1, -15 },
  { 531, 9, 18, 10, 1, -18 },
  { 552, 20, 20, 22, 1, -18 },
  { 602, 15, 18, 15, 0, -18 },
  { 636, 11, 18, 16, 3, -18 },
  { 661, 13, 18, 15, 2, -18 },
  { 691, 13, 18, 18, 3, -18 },
  { 721, 9, 18, 14, 3, -18 },
  { 742, 9, 18, 12, 3, -18 },
  { 763, 14, 18, 18, 2, -18 },
  { 795, 12, 18, 18, 3, -18 },
  { 822, 5, 18, 7, 1, -18 },
  { 834, 6, 22, 6, -2, -18 },
  { 851, 11, 18, 14, 3, -18 },
  { 876, 9, 18, 13, 3, -18 },
  { 897, 16, 18, 21, 3, -18 },
  { 933, 12, 18, 18, 3, -18 },
  { 960, 15, 18, 19, 2, -18 },
  { 994, 10, 18, 15, 3, -18 },
  { 1017, 15, 22, 19, 2, -18 },
  { 1059, 11, 18, 15, 3, -18 },
  { 1084, 11, 18, 14, 1, -18 },
  { 1109, 13, 18, 13, 0, -18 },
  { 1139, 14, 18, 18, 2, -18 },
  { 1171, 14, 18, 14, 0, -18 },
  { 1203, 20, 18, 22, 1, -18 },
  { 1248, 13, 18, 13, 0, -18 },
  { 1278, 13, 18, 13, 0, -18 },
  { 1308, 12, 18, 14, 1, -18 },
  { 1335, 5, 22, 8, 2, -18 },
  { 1349, 8, 18, 8, 0, -18 },
  { 1367, 5, 22, 8, 1, -18 },
  { 1381, 12, 11, 14, 1, -18 },
  { 1398, 10, 1, 10, 0, 2 },
  { 1400, 4, 4, 6, 1, -19 },
  { 1402, 10, 13, 13, 1, -13 },
  { 1419, 11, 19, 15, 2, -19 },
  { 1446, 10, 14, 12, 1, -14 },
  { 1464, 12, 19, 15, 1, -19 },
  { 1493, 11, 14, 14, 1, -14 },
  { 1513, 9, 19, 7, 0, -19 },
  { 1535, 12, 20, 15, 1, -14 },
  { 1565, 10, 19, 15, 2, -19 },
  { 1589, 2, 18, 5, 2, -18 },
  { 1594, 5, 24, 5, -1, -18 },
  { 1609, 10, 19, 12, 2, -19 },
  { 1633, 1, 19, 5, 2, -19 },
  { 1636, 18, 14, 22, 2, -14 },
  { 1668, 10, 14, 15, 2, -14 },
  { 1686, 12, 14, 15, 1, -14 },
  { 1707, 11, 20, 15, 2, -14 },
  { 1735, 11, 20, 15, 1, -14 },
  { 1763, 7, 13, 10, 2, -13 },
  { 1775, 9, 14, 12, 1, -14 },
  { 1791, 8, 16, 8, 0, -16 },
  { 1807, 10, 13, 15, 2, -13 },
  { 1824, 11, 13, 11, 0, -13 },
  { 1842, 17, 13, 18, 0, -13 },
  { 1870, 11, 13, 12, 1, -13 },
  { 1888, 11, 19, 11, 0, -13 },
  { 1915, 9, 13, 11, 1, -13 },
  { 1930, 7, 22, 9, 1, -18 },
  { 1950, 1, 25, 13, 6, -19 },
  { 1954, 7, 22, 9, 1, -18 },
  { 1974, 12, 2, 14, 1, -10 },
};

const GFXfont NotoSans_ExtraLight25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRALIGHT25PT7B_H_
