#ifndef _NOTOSANS_EXTRALIGHT36PT7B_H_
#define _NOTOSANS_EXTRALIGHT36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0x55, 0x55, 0x55, 0x00, 0xF0, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xA1, 0x42, 0x85, 0x08, 0x00, 0xC0, 0xC0, 0x04, 0x04, 0x00, 0x20,
  0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x04, 0x00,
  0x20, 0x20, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x40, 0xC0, 0x06, 0x06,
  0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0xC0, 0x06,
  0x06, 0x07, 0xFF, 0xFF, 0x81, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40, 0x40,
  0x06, 0x06, 0x00, 0x20, 0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x00, 0x40,
  0xC0, 0x00, 0x01, 0x00, 0x02, 0x00, 0x3F, 0xC1, 0xC8, 0xE6, 0x10, 0x08,
  0x20, 0x30, 0x40, 0x60, 0x80, 0xC1, 0x01, 0x82, 0x01, 0x84, 0x01, 0x88,
  0x01, 0xD0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x9C, 0x01, 0x0C, 0x02, 0x0C,
  0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x41, 0x80, 0x86, 0xE1,
  0x18, 0xFF, 0xE0, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x10,
  0x19, 0x80, 0x18, 0x18, 0x20, 0x08, 0x08, 0x10, 0x08, 0x0C, 0x0C, 0x04,
  0x04, 0x02, 0x04, 0x02, 0x01, 0x06, 0x01, 0x00, 0x82, 0x00, 0x80, 0x43,
  0x00, 0x40, 0x21, 0x00, 0x20, 0x11, 0x8E, 0x18, 0x18, 0x8F, 0xC4, 0x08,
  0x88, 0x33, 0x04, 0x4C, 0x08, 0xCC, 0x44, 0x04, 0x3C, 0x62, 0x03, 0x00,
  0x21, 0x01, 0x80, 0x30, 0x80, 0xC0, 0x10, 0x40, 0x60, 0x18, 0x20, 0x30,
  0x08, 0x10, 0x18, 0x0C, 0x08, 0x0C, 0x04, 0x06, 0x04, 0x04, 0x01, 0x06,
  0x06, 0x00, 0xC2, 0x02, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x60,
  0x00, 0x80, 0xC0, 0x06, 0x01, 0x00, 0x10, 0x06, 0x00, 0x40, 0x18, 0x01,
  0x00, 0x60, 0x06, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x60, 0x00, 0x66,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x33, 0x00, 0x03, 0x06, 0x00,
  0xD8, 0x0C, 0x02, 0x40, 0x18, 0x1B, 0x00, 0x30, 0x4C, 0x00, 0x63, 0x30,
  0x00, 0xC8, 0xC0, 0x01, 0xE3, 0x00, 0x03, 0x04, 0x00, 0x1E, 0x18, 0x00,
  0xCC, 0x38, 0x0E, 0x18, 0x3F, 0xE0, 0x30, 0xFF, 0xC0, 0x04, 0x21, 0x84,
  0x20, 0x86, 0x10, 0xC3, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x0C, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x81, 0xC0, 0xC0, 0x81,
  0x81, 0x83, 0x02, 0x06, 0x04, 0x08, 0x18, 0x30, 0x60, 0x40, 0x81, 0x02,
  0x04, 0x18, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x10, 0x60, 0xC3, 0x04, 0x18,
  0x60, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xE1,
  0x07, 0x3D, 0x3C, 0x03, 0xC0, 0x01, 0x80, 0x02, 0x40, 0x04, 0x60, 0x0C,
  0x20, 0x18, 0x30, 0x18, 0x18, 0x00, 0x10, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x33, 0x22, 0x66, 0x44,
  0xC0, 0xFF, 0x80, 0xF0, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x07, 0xE0, 0x0C, 0x38, 0x10,
  0x0C, 0x30, 0x06, 0x60, 0x02, 0x60, 0x02, 0x40, 0x03, 0x40, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x60,
  0x02, 0x60, 0x02, 0x20, 0x06, 0x10, 0x0C, 0x1C, 0x18, 0x07, 0xF0, 0x03,
  0x07, 0x0F, 0x33, 0x63, 0xC3, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x0F, 0xE0, 0x3C, 0x30, 0x60, 0x08, 0x40, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x0F, 0xE0, 0x38, 0x38, 0xC0, 0x0C, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x80, 0x0C, 0xE0, 0x18, 0x7F, 0xF0, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x02, 0x40, 0x00, 0xC8, 0x00,
  0x31, 0x00, 0x04, 0x20, 0x01, 0x04, 0x00, 0x60, 0x80, 0x18, 0x10, 0x02,
  0x02, 0x00, 0xC0, 0x40, 0x30, 0x08, 0x04, 0x01, 0x01, 0x00, 0x20, 0x60,
  0x04, 0x18, 0x00, 0x83, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x7F,
  0xFC, 0xFF, 0xF9, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x07, 0xFF, 0x04, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x40, 0x0C, 0xC0, 0x30, 0xFF, 0xC0,
  0x01, 0xFE, 0x01, 0xC1, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0xFC, 0x09,
  0xC7, 0x8D, 0x80, 0x67, 0x00, 0x13, 0x80, 0x0D, 0x80, 0x02, 0xC0, 0x01,
  0x60, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x26, 0x00, 0x11, 0x00, 0x18, 0xC0,
  0x0C, 0x20, 0x0C, 0x0C, 0x0C, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x07, 0xF0, 0x1C, 0x18, 0x30, 0x04, 0x60, 0x06, 0x60, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x60, 0x02, 0x20, 0x06, 0x30, 0x0C, 0x1C, 0x18, 0x07, 0x60,
  0x03, 0xC0, 0x0E, 0x70, 0x18, 0x0C, 0x20, 0x06, 0x60, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x60, 0x06,
  0x38, 0x0C, 0x0F, 0xF0, 0x07, 0xE0, 0x1C, 0x38, 0x30, 0x0C, 0x60, 0x04,
  0x40, 0x06, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x40, 0x05, 0x60, 0x0D, 0x38, 0x39, 0x0F, 0xE3,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x7F, 0xC0, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x32, 0x26, 0x64,
  0x4C, 0x00, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x00, 0x00, 0x3F, 0x87, 0x87, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00,
  0x66, 0x01, 0xFF, 0x02, 0x40, 0x30, 0x30, 0x24, 0x06, 0x03, 0x03, 0xC0,
  0xC0, 0x30, 0x38, 0x08, 0x03, 0x01, 0x80, 0x80, 0x20, 0x18, 0x18, 0x02,
  0x03, 0x81, 0x80, 0x20, 0x38, 0x18, 0x02, 0x03, 0x81, 0x80, 0x20, 0x28,
  0x08, 0x06, 0x02, 0xC0, 0xC0, 0x70, 0x4C, 0x06, 0x19, 0x8C, 0x40, 0x3F,
  0x0F, 0x86, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xB0, 0x00, 0x0C, 0x80, 0x00, 0x44, 0x00, 0x02, 0x30,
  0x00, 0x30, 0x80, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC0, 0x80, 0x04,
  0x06, 0x00, 0x60, 0x10, 0x02, 0x00, 0x80, 0x10, 0x06, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0xC0, 0x06, 0x04, 0x00, 0x10, 0x20, 0x00, 0xC3, 0x00,
  0x02, 0x10, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x02, 0x40, 0x00, 0x1E,
  0x00, 0x00, 0x40, 0xFF, 0x80, 0xFF, 0xF8, 0x80, 0x0C, 0x80, 0x06, 0x80,
  0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0x80,
  0x04, 0x80, 0x38, 0xFF, 0xE0, 0x80, 0x3C, 0x80, 0x06, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x06, 0x80, 0x78, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x78, 0x3C,
  0x18, 0x00, 0x86, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x60, 0x3F, 0xF8, 0xFF, 0x80, 0x1F,
  0xFF, 0x02, 0x00, 0x38, 0x40, 0x03, 0x88, 0x00, 0x19, 0x00, 0x01, 0x20,
  0x00, 0x34, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x68, 0x00, 0x09, 0x00,
  0x03, 0x20, 0x00, 0xC4, 0x00, 0x70, 0x80, 0x78, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFA, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xE8, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1E, 0x03,
  0xC1, 0x80, 0x02, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0x40, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0xC0, 0x00, 0x12,
  0x00, 0x00, 0x98, 0x00, 0x04, 0x60, 0x00, 0x21, 0x80, 0x01, 0x07, 0x80,
  0x38, 0x0F, 0xFF, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0xFE, 0x60, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x11, 0xFC, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x06, 0xFC, 0x80, 0x03,
  0x40, 0x03, 0x20, 0x03, 0x10, 0x03, 0x08, 0x03, 0x04, 0x03, 0x02, 0x03,
  0x01, 0x03, 0x00, 0x83, 0x00, 0x43, 0x00, 0x23, 0x00, 0x13, 0x80, 0x0B,
  0x60, 0x05, 0x10, 0x03, 0x0C, 0x01, 0x03, 0x00, 0x80, 0xC0, 0x40, 0x20,
  0x20, 0x18, 0x10, 0x06, 0x08, 0x01, 0x84, 0x00, 0x42, 0x00, 0x31, 0x00,
  0x0C, 0x80, 0x02, 0x40, 0x01, 0xC0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x03, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x2D, 0x00, 0x00, 0x5B, 0x00, 0x01, 0xB6, 0x00, 0x02, 0x64, 0x00, 0x0C,
  0xCC, 0x00, 0x11, 0x88, 0x00, 0x23, 0x18, 0x00, 0xC6, 0x30, 0x01, 0x0C,
  0x20, 0x06, 0x18, 0x60, 0x08, 0x30, 0x40, 0x30, 0x60, 0xC0, 0x60, 0xC1,
  0x80, 0x81, 0x81, 0x03, 0x03, 0x03, 0x04, 0x06, 0x02, 0x18, 0x0C, 0x06,
  0x20, 0x18, 0x04, 0x40, 0x30, 0x09, 0x80, 0x60, 0x1A, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x04, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x30,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x30, 0x06, 0x06, 0x01, 0x81, 0x80,
  0x60, 0x30, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x30, 0x60, 0x06, 0x18,
  0x00, 0x86, 0x00, 0x31, 0x80, 0x06, 0x60, 0x00, 0x98, 0x00, 0x36, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x07, 0x07, 0x80,
  0x38, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x00, 0x01, 0x86, 0x00, 0x01, 0x18,
  0x00, 0x03, 0x30, 0x00, 0x02, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x80, 0x00,
  0x13, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x06, 0x00, 0x04,
  0x06, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF,
  0xE2, 0x00, 0x64, 0x00, 0x68, 0x00, 0x50, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x68, 0x01, 0x90, 0x0E, 0x3F,
  0xF0, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0x07, 0x80, 0x38, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x18, 0x00, 0x03, 0x30, 0x00, 0x02, 0x40, 0x00, 0x06,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80,
  0x00, 0x0D, 0x80, 0x00, 0x13, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC6, 0x00,
  0x03, 0x06, 0x00, 0x04, 0x06, 0x00, 0x30, 0x07, 0x01, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0xFF, 0x80, 0xFF, 0xF0, 0x80, 0x18,
  0x80, 0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06,
  0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x18, 0xFF, 0xE0, 0xFF, 0x80,
  0x80, 0xC0, 0x80, 0x60, 0x80, 0x60, 0x80, 0x30, 0x80, 0x10, 0x80, 0x18,
  0x80, 0x0C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x07, 0xF8,
  0x1C, 0x1E, 0x30, 0x02, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0xC0, 0x18,
  0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00,
  0x14, 0x00, 0x06, 0xC0, 0x00, 0xC8, 0x00, 0x31, 0xC0, 0x0C, 0x1C, 0x07,
  0x00, 0xFF, 0x80, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x90, 0x00, 0x0C, 0xC0,
  0x00, 0x42, 0x00, 0x06, 0x10, 0x00, 0x30, 0xC0, 0x01, 0x02, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0xC0, 0x04, 0x02, 0x00, 0x60, 0x18, 0x02, 0x00, 0x40,
  0x30, 0x02, 0x01, 0x80, 0x18, 0x08, 0x00, 0x40, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x20, 0x00, 0x43, 0x00, 0x03, 0x10, 0x00, 0x08, 0x80, 0x00, 0x4C,
  0x00, 0x03, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x24, 0x00, 0x70, 0x00, 0x90,
  0x01, 0x40, 0x06, 0x60, 0x05, 0x80, 0x19, 0x80, 0x12, 0x00, 0x42, 0x00,
  0xC8, 0x01, 0x08, 0x02, 0x30, 0x0C, 0x30, 0x08, 0xC0, 0x30, 0x40, 0x21,
  0x00, 0x81, 0x01, 0x84, 0x06, 0x06, 0x04, 0x18, 0x18, 0x18, 0x10, 0x20,
  0x40, 0x20, 0xC0, 0x81, 0x00, 0x83, 0x03, 0x0C, 0x03, 0x08, 0x0C, 0x30,
  0x0C, 0x20, 0x10, 0x80, 0x11, 0x80, 0x42, 0x00, 0x44, 0x01, 0x98, 0x01,
  0x90, 0x02, 0x40, 0x02, 0xC0, 0x09, 0x00, 0x0B, 0x00, 0x2C, 0x00, 0x28,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x44, 0x00, 0x18, 0xC0, 0x06, 0x08, 0x00, 0x81,
  0x80, 0x30, 0x18, 0x0C, 0x01, 0x01, 0x00, 0x30, 0x60, 0x03, 0x08, 0x00,
  0x22, 0x00, 0x06, 0xC0, 0x00, 0x50, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x6C, 0x00, 0x08, 0x80, 0x03, 0x18, 0x00, 0xC1, 0x80, 0x10, 0x10, 0x06,
  0x03, 0x01, 0x80, 0x20, 0x20, 0x06, 0x0C, 0x00, 0x61, 0x00, 0x04, 0x40,
  0x00, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0x68, 0x00, 0x19, 0x80, 0x02, 0x10,
  0x00, 0xC3, 0x00, 0x10, 0x20, 0x06, 0x06, 0x00, 0x80, 0x40, 0x30, 0x0C,
  0x04, 0x00, 0xC1, 0x80, 0x08, 0x20, 0x01, 0x8C, 0x00, 0x13, 0x00, 0x03,
  0x40, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xFF, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0xFF, 0xFC, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x7F, 0xFF, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x6C,
  0x00, 0x22, 0x00, 0x21, 0x80, 0x10, 0x40, 0x10, 0x30, 0x08, 0x08, 0x08,
  0x06, 0x0C, 0x01, 0x04, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x1B, 0x00, 0x05,
  0x00, 0x03, 0xFF, 0xFE, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0xC0, 0x1F, 0xE0,
  0xC0, 0xE0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x03, 0xFC, 0x7C, 0x37, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0xC0, 0x35, 0x81, 0x93, 0xF8, 0x40, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xCF, 0xF0, 0xD8, 0x1C, 0xF0, 0x04, 0xA0, 0x06, 0xC0, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xE0, 0x06, 0xB0, 0x0C, 0x98, 0x18,
  0x8F, 0xF0, 0x07, 0xFC, 0x70, 0x13, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x10, 0x7F, 0xC0,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x0F, 0xF1, 0x18, 0x19, 0x30, 0x05, 0x60, 0x07,
  0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x07,
  0x30, 0x05, 0x18, 0x19, 0x0F, 0xF1, 0x0F, 0xF0, 0x18, 0x18, 0x30, 0x0C,
  0x20, 0x06, 0x40, 0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x06, 0x0F, 0xFC, 0x00, 0x40, 0x1F, 0xC1,
  0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x07, 0xFE,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x0F, 0xF1, 0x18, 0x09, 0x30, 0x05,
  0x60, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03,
  0x60, 0x05, 0x30, 0x05, 0x18, 0x19, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x60, 0x0C, 0x3F, 0xF8,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xCF, 0xF1, 0xB0, 0x33, 0xC0, 0x37, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x08, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x06, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x82, 0x0D, 0xF1, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x1B, 0x00,
  0xCC, 0x06, 0x30, 0x30, 0xC1, 0x83, 0x04, 0x0C, 0x20, 0x31, 0x00, 0xCC,
  0x03, 0x58, 0x0F, 0x30, 0x38, 0x40, 0xC1, 0x83, 0x03, 0x0C, 0x06, 0x30,
  0x08, 0xC0, 0x33, 0x00, 0x6C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x8F, 0xE0, 0xFE, 0x4C, 0x19, 0x81, 0xA8, 0x06, 0x80, 0x7C,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x20, 0x03,
  0x80, 0x10, 0x01, 0xC0, 0x08, 0x00, 0xE0, 0x04, 0x00, 0x70, 0x02, 0x00,
  0x38, 0x01, 0x00, 0x1C, 0x00, 0x80, 0x0E, 0x00, 0x40, 0x07, 0x00, 0x20,
  0x03, 0x80, 0x10, 0x01, 0xC0, 0x08, 0x00, 0xE0, 0x04, 0x00, 0x70, 0x02,
  0x00, 0x20, 0x8F, 0xF1, 0x30, 0x32, 0xC0, 0x37, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x08, 0x07, 0xF8, 0x0C, 0x06, 0x0C, 0x01, 0x8C, 0x00, 0x64, 0x00,
  0x32, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x09, 0x00, 0x0C, 0xC0, 0x04,
  0x30, 0x06, 0x0C, 0x0E, 0x01, 0xFC, 0x00, 0x87, 0xF0, 0x98, 0x1C, 0xB0,
  0x06, 0xE0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x02, 0xE0, 0x06, 0xF0, 0x0C, 0xD8, 0x18, 0xCF, 0xF0, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x0F, 0xF1, 0x18, 0x19, 0x30, 0x05, 0x60, 0x07, 0x40, 0x03, 0x40,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x05, 0x20, 0x0D, 0x18,
  0x19, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x8F, 0xF6, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x3F, 0xFB, 0x00, 0xB0, 0x01,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x16, 0x03,
  0xBF, 0xF0, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x81, 0xFF, 0xC6, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x3F, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x60, 0x1E, 0xE0, 0x6C, 0x7F, 0x08, 0xC0,
  0x03, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x10,
  0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x08, 0x10, 0x0C, 0x30, 0x04,
  0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x80, 0x18, 0x03, 0x80, 0x18, 0x02, 0xC0, 0x38, 0x02, 0x40, 0x2C,
  0x06, 0x40, 0x24, 0x06, 0x60, 0x64, 0x04, 0x60, 0x46, 0x04, 0x20, 0x42,
  0x0C, 0x20, 0xC2, 0x0C, 0x30, 0xC3, 0x08, 0x10, 0x81, 0x08, 0x11, 0x81,
  0x18, 0x19, 0x81, 0x98, 0x19, 0x00, 0x90, 0x09, 0x00, 0x90, 0x0B, 0x00,
  0xF0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0x06,
  0x60, 0x0C, 0x30, 0x08, 0x10, 0x18, 0x18, 0x30, 0x0C, 0x20, 0x06, 0x60,
  0x02, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x40, 0x0C, 0x60,
  0x08, 0x30, 0x18, 0x10, 0x30, 0x18, 0x20, 0x0C, 0x60, 0x06, 0xC0, 0x03,
  0xC0, 0x03, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C,
  0x10, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x10, 0x0C, 0x30,
  0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xC0, 0xF0, 0x60, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x83, 0xC0, 0xF0, 0x06, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x3C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x3E, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x20, 0x07, 0x01,
  0xC0, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x03, 0x0F, 0x83, 0x00, 0x7F, 0x00, 0xE0, 0xF1, 0xA0,
  0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraLight36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 7, 10, 12, 3, -26 },
  { 17, 21, 26, 23, 1, -26 },
  { 86, 15, 29, 21, 2, -27 },
  { 141, 25, 26, 29, 2, -26 },
  { 223, 22, 26, 25, 2, -26 },
  { 295, 1, 10, 7, 3, -26 },
  { 297, 6, 32, 10, 2, -26 },
  { 321, 7, 32, 10, 1, -26 },
  { 349, 16, 15, 20, 2, -27 },
  { 379, 17, 17, 21, 2, -21 },
  { 416, 4, 9, 7, 1, -4 },
  { 421, 9, 1, 12, 1, -10 },
  { 423, 2, 2, 8, 3, -2 },
  { 424, 12, 26, 12, 0, -26 },
  { 463, 16, 26, 21, 2, -26 },
  { 515, 8, 26, 21, 4, -26 },
  { 541, 16, 26, 21, 2, -26 },
  { 593, 16, 26, 21, 2, -26 },
  { 645, 19, 26, 21, 1, -26 },
  { 707, 15, 26, 21, 3, -26 },
  { 756, 17, 26, 21, 2, -26 },
  { 812, 16, 26, 21, 2, -26 },
  { 864, 16, 26, 21, 2, -26 },
  { 916, 16, 26, 21, 2, -26 },
  { 968, 2, 19, 8, 3, -19 },
  { 973, 4, 24, 8, 1, -19 },
  { 985, 17, 16, 21, 2, -21 },
  { 1019, 17, 9, 21, 2, -17 },
  { 1039, 17, 16, 21, 2, -21 },
  { 1073, 13, 26, 15, 1, -26 },
  { 1116, 28, 29, 32, 2, -25 },
  { 1218, 21, 26, 21, 0, -26 },
  { 1287, 16, 26, 22, 4, -26 },
  { 1339, 19, 26, 22, 2, -26 },
  { 1401, 19, 26, 25, 4, -26 },
  { 1463, 14, 26, 20, 4, -26 },
  { 1509, 14, 26, 18, 4, -26 },
  { 1555, 21, 26, 26, 2, -26 },
  { 1624, 18, 26, 26, 4, -26 },
  { 1683, 7, 26, 11, 2, -26 },
  { 1706, 8, 32, 9, -3, -26 },
  { 1738, 17, 26, 21, 4, -26 },
  { 1794, 14, 26, 18, 4, -26 },
  { 1840, 23, 26, 31, 4, -26 },
  { 1915, 18, 26, 26, 4, -26 },
  { 1974, 23, 26, 27, 2, -26 },
  { 2049, 15, 26, 21, 4, -26 },
  { 2098, 23, 32, 27, 2, -26 },
  { 2190, 16, 26, 21, 4, -26 },
  { 2242, 16, 26, 20, 2, -26 },
  { 2294, 18, 26, 19, 0, -26 },
  { 2353, 19, 26, 26, 3, -26 },
  { 2415, 21, 26, 21, 0, -26 },
  { 2484, 30, 26, 32, 1, -26 },
  { 2582, 19, 26, 19, 0, -26 },
  { 2644, 19, 26, 19, 0, -26 },
  { 2706, 18, 26, 21, 1, -26 },
  { 2765, 7, 32, 11, 3, -26 },
  { 2793, 12, 26, 12, 0, -26 },
  { 2832, 7, 32, 11, 1, -26 },
  { 2860, 17, 16, 21, 2, -26 },
  { 2894, 15, 1, 14, 0, 3 },
  { 2896, 7, 6, 9, 1, -28 },
  { 2902, 14, 19, 19, 2, -19 },
  { 2936, 16, 27, 21, 3, -27 },
  { 2990, 14, 19, 17, 2, -19 },
  { 3024, 16, 27, 21, 2, -27 },
  { 3078, 16, 19, 20, 2, -19 },
  { 3116, 13, 28, 10, 0, -28 },
  { 3162, 16, 28, 21, 2, -19 },
  { 3218, 15, 27, 21, 3, -27 },
  { 3269, 2, 26, 8, 3, -26 },
  { 3276, 7, 35, 8, -2, -26 },
  { 3307, 14, 27, 17, 3, -27 },
  { 3355, 2, 27, 8, 3, -27 },
  { 3362, 25, 19, 31, 3, -19 },
  { 3422, 15, 19, 21, 3, -19 },
  { 3458, 17, 19, 21, 2, -19 },
  { 3499, 16, 27, 21, 3, -19 },
  { 3553, 16, 27, 21, 2, -19 },
  { 3607, 10, 19, 14, 3, -19 },
  { 3631, 13, 19, 17, 2, -19 },
  { 3662, 11, 24, 12, 0, -24 },
  { 3695, 15, 19, 21, 3, -19 },
  { 3731, 16, 19, 16, 0, -19 },
  { 3769, 24, 19, 25, 1, -19 },
  { 3826, 16, 19, 18, 1, -19 },
  { 3864, 16, 28, 16, 0, -19 },
  { 3920, 14, 19, 17, 1, -19 },
  { 3954, 10, 32, 12, 1, -26 },
  { 3994, 1, 36, 19, 9, -27 },
  { 3999, 10, 32, 12, 1, -26 },
  { 4039, 17, 3, 21, 2, -14 },
};

const GFXfont NotoSans_ExtraLight36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRALIGHT36PT7B_H_
