#ifndef _NOTOSANS_EXTRALIGHT63PT7B_H_
#define _NOTOSANS_EXTRALIGHT63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight63pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF2,
  0xE0, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x76, 0x03, 0xB0, 0x1D, 0x80, 0xEC,
  0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x66, 0x01, 0x30, 0x09, 0x80,
  0x4C, 0x02, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0xFC, 0xCF, 0xF0, 0x78, 0x30, 0x1C, 0x38, 0x0C, 0x01,
  0x1C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x0C,
  0x00, 0x38, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0xE0,
  0x0C, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00,
  0x38, 0x0C, 0x00, 0x07, 0x83, 0x00, 0x00, 0xF8, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x33, 0xE0, 0x00, 0x0C, 0x3E, 0x00, 0x03, 0x03, 0xC0, 0x00, 0xC0, 0x78,
  0x00, 0x30, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xE8,
  0x00, 0xC0, 0x73, 0xC0, 0x30, 0x78, 0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x00, 0x18, 0x00, 0xE0,
  0x0E, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x38, 0x00, 0x03, 0x00, 0x06, 0x06,
  0x01, 0x80, 0x60, 0x01, 0xC1, 0xC1, 0xFE, 0x0C, 0x00, 0x38, 0x30, 0x7F,
  0xF1, 0xC0, 0x06, 0x0E, 0x1C, 0x0E, 0x18, 0x00, 0xC1, 0x87, 0x00, 0xE3,
  0x80, 0x38, 0x60, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x38, 0x01, 0xC7, 0x01,
  0x83, 0x06, 0x00, 0x18, 0x7D, 0xF0, 0xE0, 0xC0, 0x03, 0x07, 0xF8, 0x18,
  0x18, 0x00, 0x70, 0x18, 0x07, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0xE0,
  0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x00, 0x06, 0x03, 0x80, 0x03,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x70, 0x00, 0x60,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00,
  0x30, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x30, 0x70, 0x03, 0xC0, 0x00, 0xE1, 0xC0, 0x03, 0xC0,
  0x01, 0xC7, 0x00, 0x03, 0xC0, 0x03, 0x0E, 0x00, 0x03, 0xC0, 0x0E, 0x38,
  0x00, 0x03, 0xC0, 0x1C, 0x70, 0x00, 0x03, 0xC0, 0x30, 0xE0, 0x00, 0x03,
  0xC0, 0xE1, 0x80, 0x00, 0x03, 0xC3, 0x83, 0x00, 0x00, 0x03, 0xC7, 0x06,
  0x00, 0x00, 0x03, 0xDC, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x38, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x1F, 0x80,
  0x70, 0x00, 0x00, 0x7B, 0x80, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x70, 0x00,
  0x0F, 0x03, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0x80, 0x7F, 0xFF, 0xE0, 0x03,
  0x80, 0x3F, 0xFF, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xED,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x18, 0x01, 0x80, 0x1B, 0xE0, 0x30, 0x1F, 0xFF, 0x86, 0x1F,
  0xE0, 0xFE, 0xCF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x30, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x40, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x60, 0xC3, 0x86,
  0x0C, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x20, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x18, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0x70, 0x3C, 0xE0, 0xF1, 0xC3, 0x83, 0x9E, 0x07, 0x78, 0x0F, 0xC0,
  0x1D, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0xE0, 0x00, 0x1C, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x38, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0xC0, 0x00,
  0x07, 0x8F, 0x80, 0x01, 0xF0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x06, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC7,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x40, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x80, 0x00, 0x0F, 0x18, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0x80, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x0F, 0xC0, 0x06, 0x07, 0xFF, 0xC0, 0xE1, 0xFC, 0x7E, 0x0E,
  0x38, 0x00, 0x78, 0xE7, 0x00, 0x03, 0x8E, 0xC0, 0x00, 0x1C, 0xF8, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x73, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x1E, 0x00, 0x3E, 0x07,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x01,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x07, 0x98, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x03, 0xE3,
  0x80, 0x00, 0x37, 0x1E, 0x00, 0x07, 0x38, 0x78, 0x00, 0x71, 0xC1, 0xFC,
  0x7F, 0x0C, 0x03, 0xFF, 0xE0, 0x60, 0x01, 0xF8, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x01, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x6F, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x20, 0x0C, 0x3C, 0x78,
  0xF0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC3, 0x87,
  0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x30, 0x61, 0xC0, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xFC, 0x3C, 0x00, 0x78,
  0x40, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x38, 0x60, 0x00, 0x3F, 0xFF, 0x80, 0x0C, 0x70, 0x00, 0x3C, 0x03, 0xC0,
  0x06, 0x30, 0x00, 0x78, 0x00, 0x60, 0x03, 0x98, 0x00, 0x70, 0x00, 0x30,
  0x01, 0xDC, 0x00, 0x30, 0x00, 0x18, 0x00, 0x6C, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x36, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x1B, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x0D, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x06, 0x00, 0x01,
  0xC0, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x03, 0x80, 0x00,
  0x60, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x1B, 0x80, 0x0C, 0x00, 0x07, 0x00, 0x0C, 0xC0, 0x06, 0x00,
  0x03, 0xC0, 0x06, 0x60, 0x03, 0x80, 0x03, 0x60, 0x06, 0x30, 0x00, 0xC0,
  0x01, 0xB0, 0x07, 0x18, 0x00, 0x70, 0x01, 0x98, 0x03, 0x0E, 0x00, 0x1E,
  0x03, 0x87, 0x07, 0x03, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x01, 0x80, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x0F, 0xF0, 0x38, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x01, 0xF0, 0xE0,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1F, 0xF0, 0x03, 0x80, 0x00, 0x3F,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x03, 0xE0, 0x38, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x00,
  0x60, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x03, 0x00,
  0xF8, 0x00, 0x00, 0x30, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x7F, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x98, 0x1E, 0x3F,
  0xF8, 0x7F, 0xC0, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0xE3, 0xF0, 0x00, 0x03, 0x9C, 0xE0,
  0x00, 0x0E, 0xE3, 0xC0, 0x00, 0x3F, 0x07, 0x00, 0x00, 0xF8, 0x0E, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xDF, 0x60, 0x00, 0x00, 0x00, 0xEF, 0xB8, 0x00, 0x00, 0x00,
  0x67, 0xCC, 0x00, 0x00, 0x00, 0x73, 0xE7, 0x00, 0x00, 0x00, 0x39, 0xF3,
  0x80, 0x00, 0x00, 0x18, 0xF8, 0xC0, 0x00, 0x00, 0x1C, 0x7C, 0x70, 0x00,
  0x00, 0x0C, 0x3E, 0x18, 0x00, 0x00, 0x0E, 0x1F, 0x0E, 0x00, 0x00, 0x06,
  0x0F, 0x87, 0x00, 0x00, 0x03, 0x07, 0xC1, 0x80, 0x00, 0x03, 0x83, 0xE0,
  0xE0, 0x00, 0x01, 0x81, 0xF0, 0x30, 0x00, 0x01, 0xC0, 0xF8, 0x1C, 0x00,
  0x00, 0xC0, 0x7C, 0x0E, 0x00, 0x00, 0x60, 0x3E, 0x03, 0x00, 0x00, 0x70,
  0x1F, 0x01, 0xC0, 0x00, 0x30, 0x0F, 0x80, 0x60, 0x00, 0x38, 0x07, 0xC0,
  0x38, 0x00, 0x18, 0x03, 0xE0, 0x1C, 0x00, 0x0C, 0x01, 0xF0, 0x06, 0x00,
  0x0E, 0x00, 0xF8, 0x03, 0x80, 0x06, 0x00, 0x7C, 0x00, 0xC0, 0x07, 0x00,
  0x3E, 0x00, 0x70, 0x03, 0x00, 0x1F, 0x00, 0x18, 0x01, 0x80, 0x0F, 0x80,
  0x0E, 0x01, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0x80,
  0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x60, 0x00, 0xF8, 0x00, 0x30, 0x30, 0x00,
  0x7C, 0x00, 0x1C, 0x38, 0x00, 0x3E, 0x00, 0x0E, 0x18, 0x00, 0x1F, 0x00,
  0x03, 0x1C, 0x00, 0x0F, 0x80, 0x01, 0xCC, 0x00, 0x07, 0xC0, 0x00, 0x6E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x03,
  0xE7, 0x00, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0x03,
  0xE1, 0xC0, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x03,
  0xE0, 0x07, 0x80, 0x03, 0xE0, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xC0, 0x03,
  0xE0, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0x70, 0x03,
  0xE0, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x1C, 0x03,
  0xE0, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x07, 0x03,
  0xE0, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x01, 0xC3,
  0xE0, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x00, 0x73,
  0xE0, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0x80, 0x07, 0xF0, 0x70, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x87, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x38,
  0x00, 0x7F, 0x81, 0xC0, 0x00, 0x3E, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x03,
  0x80, 0x03, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x7C,
  0x00, 0x3E, 0x0F, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x80, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF0, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0xB8, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0xE0, 0x00,
  0x30, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x60,
  0x00, 0x70, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0,
  0x70, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0x38, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x38,
  0x00, 0x18, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x38, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x18, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0x01, 0xC0, 0x03, 0xC0, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0x83, 0xF8, 0x01, 0xC3, 0xC0, 0x00, 0xE7, 0x80, 0x00, 0x73,
  0x80, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFB, 0x80, 0x00, 0xDD, 0xC0, 0x00, 0xCE, 0x78, 0x01,
  0xC3, 0x1F, 0xFF, 0xC1, 0x83, 0xFF, 0x80, 0xC0, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x0F,
  0xF0, 0x06, 0x0F, 0xFF, 0xC0, 0xC3, 0xE0, 0x7C, 0x18, 0xE0, 0x03, 0xC3,
  0x30, 0x00, 0x1C, 0x6C, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x19, 0xE0, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x33, 0xE0, 0x00, 0x0E,
  0x6C, 0x00, 0x03, 0x8C, 0xC0, 0x00, 0xE1, 0x8E, 0x00, 0x78, 0x30, 0xFF,
  0xFE, 0x06, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x1F, 0x07, 0xC0, 0x01, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xC0, 0x70, 0x1F,
  0xFF, 0x07, 0x03, 0xE0, 0x7C, 0x70, 0xF0, 0x00, 0xE7, 0x1E, 0x00, 0x07,
  0x71, 0xC0, 0x00, 0x37, 0x38, 0x00, 0x01, 0xF3, 0x00, 0x00, 0x1F, 0x70,
  0x00, 0x00, 0xF6, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF6, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x01,
  0xF1, 0xC0, 0x00, 0x37, 0x1E, 0x00, 0x06, 0x70, 0xF8, 0x01, 0xC7, 0x03,
  0xFF, 0xF8, 0x70, 0x1F, 0xFE, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x83, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x0C, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x3E, 0x00, 0x1C, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3C, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x87, 0x03, 0xF0,
  0x7C, 0x70, 0xF0, 0x00, 0xE7, 0x1E, 0x00, 0x07, 0x71, 0xC0, 0x00, 0x3F,
  0x38, 0x00, 0x01, 0xF3, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF6, 0x00,
  0x00, 0x0F, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x01, 0x71, 0xC0, 0x00, 0x37,
  0x1E, 0x00, 0x06, 0x70, 0xF8, 0x01, 0xC7, 0x03, 0xFF, 0xF8, 0x70, 0x0F,
  0xFE, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x40, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x3F, 0x80, 0x3E, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0xFF, 0x01, 0x83, 0xFF, 0xE0, 0xC3, 0xE0, 0xFC,
  0x67, 0x80, 0x0F, 0x33, 0x00, 0x03, 0xDB, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x4F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x00, 0x40, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x83, 0xCF, 0xF8, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0,
  0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0x00, 0xC0,
  0x38, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC3,
  0xC0, 0x00, 0xC7, 0xE0, 0x00, 0xCE, 0xE0, 0x00, 0xDC, 0x70, 0x00, 0xD8,
  0x38, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x0C, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0xC7, 0xC1, 0xF0, 0x7C, 0x0F,
  0x8C, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0xDC, 0x00, 0x39, 0xC0, 0x01, 0xCD,
  0x80, 0x01, 0xD8, 0x00, 0x0E, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x3F, 0xC0, 0x60, 0xFF, 0xFC, 0x30, 0xF8, 0x3F,
  0x18, 0xE0, 0x03, 0xCC, 0xC0, 0x00, 0xF6, 0xC0, 0x00, 0x3B, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x1F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x0C, 0x0F, 0xFF, 0x80, 0xC3, 0xE0, 0x7C, 0x0C, 0x70, 0x01, 0xE0, 0xCE,
  0x00, 0x07, 0x0D, 0xC0, 0x00, 0x38, 0xD8, 0x00, 0x01, 0x8F, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x18, 0xD8,
  0x00, 0x03, 0x8D, 0xC0, 0x00, 0x70, 0xCE, 0x00, 0x0E, 0x0C, 0x78, 0x03,
  0xC0, 0xC3, 0xFF, 0xF8, 0x0C, 0x0F, 0xFE, 0x00, 0xC0, 0x0E, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x0C, 0x1F, 0x81, 0xF1, 0x87,
  0x80, 0x07, 0x31, 0xE0, 0x00, 0x76, 0x38, 0x00, 0x06, 0xCE, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x36, 0x70, 0x00, 0x0E, 0xC7, 0x80, 0x03, 0x98, 0x78, 0x00,
  0xE3, 0x07, 0xFF, 0xF8, 0x60, 0x3F, 0xFC, 0x0C, 0x00, 0x78, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x7F, 0x60, 0xFF, 0xF1, 0xF8, 0xF9, 0xC0, 0x0D, 0xC0, 0x06, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x7E, 0x03, 0xF1, 0xE0, 0x00, 0x67,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xA0, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x1B, 0x38, 0x00, 0x0C, 0xCF, 0x00, 0x07, 0x31, 0xE0, 0x07, 0x8C, 0x3F,
  0xFF, 0x83, 0x03, 0xFF, 0xC0, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x18, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x70, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x01, 0x80,
  0x01, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x38, 0x00, 0x0D,
  0x80, 0x00, 0xE7, 0x00, 0x01, 0xB0, 0x00, 0x18, 0x60, 0x00, 0x37, 0x00,
  0x07, 0x0C, 0x00, 0x0E, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0x38, 0x00, 0x31, 0xC0, 0x03, 0x03, 0x00, 0x0E, 0x18, 0x00, 0xE0, 0x70,
  0x01, 0x83, 0x00, 0x1C, 0x0E, 0x00, 0x30, 0x70, 0x03, 0x00, 0xC0, 0x0E,
  0x0E, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x00, 0xE0, 0x30, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x60, 0x01,
  0x81, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x83, 0x80, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x00, 0xE1, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x01, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x39, 0x80, 0x00, 0xCE,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x30, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x1C,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x70, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x38, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x3C, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1F,
  0x00, 0x3F, 0x80, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x09, 0xFF, 0xF0,
  0x00, 0x5E, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraLight63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 46, 15, 5, -45 },
  { 24, 13, 16, 21, 4, -45 },
  { 50, 37, 45, 41, 2, -45 },
  { 259, 26, 52, 36, 4, -48 },
  { 428, 43, 47, 50, 4, -46 },
  { 681, 39, 47, 45, 4, -46 },
  { 911, 3, 16, 12, 4, -45 },
  { 917, 11, 55, 17, 3, -45 },
  { 993, 12, 55, 17, 2, -45 },
  { 1076, 27, 26, 35, 4, -48 },
  { 1164, 30, 29, 36, 3, -37 },
  { 1273, 7, 15, 13, 2, -7 },
  { 1287, 15, 2, 20, 3, -18 },
  { 1291, 4, 5, 14, 5, -4 },
  { 1294, 19, 45, 21, 1, -45 },
  { 1401, 28, 47, 36, 4, -46 },
  { 1566, 15, 45, 36, 6, -45 },
  { 1651, 27, 46, 36, 4, -46 },
  { 1807, 28, 47, 36, 3, -46 },
  { 1972, 33, 45, 36, 2, -45 },
  { 2158, 27, 46, 36, 5, -45 },
  { 2314, 28, 47, 36, 4, -46 },
  { 2479, 29, 45, 36, 3, -45 },
  { 2643, 28, 47, 36, 4, -46 },
  { 2808, 29, 47, 36, 3, -46 },
  { 2979, 4, 35, 14, 5, -34 },
  { 2997, 7, 42, 14, 2, -34 },
  { 3034, 29, 29, 36, 3, -37 },
  { 3140, 29, 15, 36, 3, -30 },
  { 3195, 29, 29, 36, 3, -37 },
  { 3301, 22, 47, 26, 2, -46 },
  { 3431, 49, 51, 56, 3, -45 },
  { 3744, 37, 45, 37, 0, -45 },
  { 3953, 30, 45, 39, 6, -45 },
  { 4122, 33, 47, 39, 4, -46 },
  { 4316, 34, 45, 44, 6, -45 },
  { 4508, 25, 45, 35, 6, -45 },
  { 4649, 25, 45, 31, 6, -45 },
  { 4790, 36, 47, 45, 4, -46 },
  { 5002, 33, 45, 45, 6, -45 },
  { 5188, 11, 45, 19, 4, -45 },
  { 5250, 15, 56, 15, -6, -45 },
  { 5355, 30, 45, 36, 6, -45 },
  { 5524, 25, 45, 32, 6, -45 },
  { 5665, 41, 45, 54, 6, -45 },
  { 5896, 32, 45, 45, 6, -45 },
  { 6076, 40, 47, 48, 4, -46 },
  { 6311, 27, 45, 37, 6, -45 },
  { 6463, 40, 57, 48, 4, -46 },
  { 6748, 29, 45, 37, 6, -45 },
  { 6912, 28, 47, 34, 3, -46 },
  { 7077, 32, 45, 32, 0, -45 },
  { 7257, 33, 46, 45, 6, -45 },
  { 7447, 36, 45, 36, 0, -45 },
  { 7650, 52, 45, 56, 2, -45 },
  { 7943, 33, 45, 33, 0, -45 },
  { 8129, 33, 45, 33, 0, -45 },
  { 8315, 32, 45, 36, 2, -45 },
  { 8495, 13, 55, 20, 5, -45 },
  { 8585, 19, 45, 21, 1, -45 },
  { 8692, 12, 55, 20, 2, -45 },
  { 8775, 30, 28, 36, 3, -45 },
  { 8880, 25, 2, 25, 0, 6 },
  { 8887, 11, 10, 16, 3, -48 },
  { 8901, 25, 35, 33, 3, -34 },
  { 9011, 27, 49, 37, 6, -48 },
  { 9177, 24, 35, 30, 4, -34 },
  { 9282, 28, 49, 37, 4, -48 },
  { 9454, 27, 35, 34, 4, -34 },
  { 9573, 21, 48, 18, 1, -48 },
  { 9699, 28, 49, 37, 4, -34 },
  { 9871, 25, 48, 37, 6, -48 },
  { 10021, 4, 46, 14, 5, -46 },
  { 10044, 12, 61, 14, -3, -46 },
  { 10136, 24, 48, 30, 6, -48 },
  { 10280, 2, 48, 14, 6, -48 },
  { 10292, 44, 34, 55, 6, -34 },
  { 10479, 25, 34, 37, 6, -34 },
  { 10586, 29, 35, 37, 4, -34 },
  { 10713, 28, 49, 37, 6, -34 },
  { 10885, 27, 49, 37, 4, -34 },
  { 11051, 17, 34, 24, 6, -34 },
  { 11124, 23, 35, 29, 3, -34 },
  { 11225, 18, 43, 21, 1, -42 },
  { 11322, 26, 34, 37, 5, -33 },
  { 11433, 28, 33, 28, 0, -33 },
  { 11549, 43, 33, 44, 1, -33 },
  { 11727, 27, 33, 31, 2, -33 },
  { 11839, 28, 48, 28, 0, -33 },
  { 12007, 23, 33, 29, 3, -33 },
  { 12102, 18, 55, 22, 2, -45 },
  { 12226, 2, 64, 34, 16, -48 },
  { 12242, 18, 55, 22, 2, -45 },
  { 12366, 29, 6, 36, 3, -25 },
};

const GFXfont NotoSans_ExtraLight63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRALIGHT63PT7B_H_
