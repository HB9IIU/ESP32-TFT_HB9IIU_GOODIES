#ifndef _NOTOSANS_EXTRALIGHT48PT7B_H_
#define _NOTOSANS_EXTRALIGHT48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight48pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x49, 0x24, 0x92, 0x40, 0x00,
  0x07, 0xFC, 0xC0, 0xF0, 0x3C, 0x0D, 0x03, 0x40, 0xD0, 0x34, 0x0D, 0x03,
  0x40, 0xD0, 0x34, 0x0D, 0x02, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x80, 0x00, 0x30,
  0x04, 0x00, 0x01, 0x00, 0x60, 0x00, 0x08, 0x03, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0x80, 0x00, 0x30, 0x04, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x08, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x04, 0x00, 0x01, 0x00, 0x60, 0x00, 0x08, 0x03, 0x00, 0x00, 0xC0, 0x18,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x04, 0x00, 0x01, 0x80, 0x20, 0x00,
  0x08, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x04, 0x00, 0x01, 0x80, 0x20, 0x00, 0x08, 0x03, 0x00, 0x00, 0x40, 0x18,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xF8, 0x1E, 0x67, 0xE3, 0x86, 0x04,
  0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x70, 0x60, 0x03, 0x86,
  0x00, 0x1E, 0x60, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x6F, 0x00, 0x06, 0x3C, 0x00, 0x60, 0xE0, 0x06, 0x06, 0x00, 0x60, 0x30,
  0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03,
  0x00, 0x60, 0x60, 0x06, 0x0E, 0xC0, 0x63, 0xCF, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x20, 0x0F, 0xE0, 0x00, 0x60, 0x0C, 0x18, 0x00, 0x30, 0x0C,
  0x06, 0x00, 0x30, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0x80, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x04, 0x00,
  0x60, 0x0C, 0x06, 0x00, 0x20, 0x06, 0x06, 0x00, 0x10, 0x03, 0x03, 0x00,
  0x08, 0x01, 0x83, 0x00, 0x06, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x61, 0x87,
  0xE1, 0x80, 0x30, 0x87, 0xF8, 0xC0, 0x10, 0xC6, 0x06, 0x30, 0x18, 0x43,
  0x01, 0x18, 0x0C, 0x63, 0x00, 0xC6, 0x0C, 0x61, 0x80, 0x61, 0xFC, 0x30,
  0x80, 0x10, 0x78, 0x30, 0xC0, 0x0C, 0x00, 0x18, 0x60, 0x06, 0x00, 0x18,
  0x30, 0x03, 0x00, 0x08, 0x18, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x04,
  0x06, 0x00, 0x60, 0x06, 0x03, 0x00, 0x30, 0x06, 0x00, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x01,
  0x80, 0x06, 0x06, 0x00, 0xC0, 0x01, 0x86, 0x00, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x08, 0x00, 0x60, 0x00, 0x30, 0x01,
  0x80, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x19, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x07,
  0x03, 0x00, 0x0E, 0x30, 0x06, 0x00, 0x31, 0x80, 0x0C, 0x00, 0xC6, 0x00,
  0x18, 0x06, 0x30, 0x00, 0x30, 0x18, 0xC0, 0x00, 0x60, 0x63, 0x00, 0x00,
  0xC3, 0x0C, 0x00, 0x01, 0x98, 0x30, 0x00, 0x03, 0x60, 0xC0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xD8, 0x1C, 0x00, 0x0E, 0x30,
  0x38, 0x00, 0x70, 0x60, 0x7E, 0x1F, 0x00, 0xC0, 0x7F, 0xF0, 0x01, 0xC0,
  0xFD, 0x55, 0x55, 0x03, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60,
  0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xC0,
  0x60, 0x60, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x60, 0x1F, 0x06, 0x0F, 0x7E,
  0x67, 0xE0, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x01, 0x98, 0x00,
  0x18, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0x60, 0x0E, 0x03, 0x00, 0xC0, 0x38,
  0x18, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x39, 0xCC, 0x63, 0x19, 0x8C, 0x62, 0x31, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0x80,
  0xE0, 0x38, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x13, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x01, 0x83, 0x00, 0x18, 0x0C, 0x01, 0xC0, 0x3C, 0x3C, 0x00, 0xFF,
  0x80, 0x00, 0xE0, 0x3C, 0x1D, 0x87, 0x31, 0x86, 0xE0, 0xF8, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0x01, 0xC0, 0xE0, 0x03, 0x04, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x01, 0xE0, 0x1C, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0xC0, 0x00, 0xE3, 0xF0, 0x1F, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x1F, 0xFF, 0xE0, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x10,
  0x00, 0xFF, 0xFC, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x98, 0x00, 0x38,
  0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80,
  0x1E, 0x01, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x0F, 0xF0, 0x31,
  0xFB, 0xF0, 0xCE, 0x00, 0xE3, 0x60, 0x01, 0xCF, 0x00, 0x03, 0x38, 0x00,
  0x06, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x20,
  0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x0E, 0x00,
  0xE0, 0x1E, 0x0F, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0x80,
  0xF0, 0x30, 0x01, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00,
  0xC3, 0x80, 0x06, 0x0E, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0x79, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xC1, 0xC0, 0x38, 0x03, 0x83, 0x80, 0x0E,
  0x38, 0x00, 0x19, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0D,
  0x80, 0x00, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0xF8, 0x3E, 0x01, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0x81, 0xE0, 0x70, 0x03, 0x87,
  0x00, 0x0C, 0x30, 0x00, 0x33, 0x00, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x03,
  0xCC, 0x00, 0x36, 0x38, 0x07, 0x30, 0xFF, 0xE1, 0x81, 0xFC, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x01, 0x01, 0xE0, 0x0F, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x5F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x11, 0xCE,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1C,
  0xC6, 0x33, 0x18, 0xC6, 0x63, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xF8, 0xE0, 0x3C, 0x80,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x01, 0x08, 0x00, 0x7F, 0xF0, 0x0C, 0xC0, 0x0F, 0x03, 0x80, 0x66, 0x00,
  0xE0, 0x0C, 0x01, 0x60, 0x0E, 0x00, 0x60, 0x0F, 0x00, 0x60, 0x03, 0x00,
  0x78, 0x06, 0x00, 0x18, 0x03, 0xC0, 0x30, 0x00, 0xC0, 0x1C, 0x01, 0x00,
  0x06, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x07, 0x00, 0xC0, 0x01, 0x00, 0x38,
  0x06, 0x00, 0x08, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x0A, 0x00, 0x80, 0x06,
  0x00, 0xD0, 0x06, 0x00, 0x30, 0x06, 0xC0, 0x30, 0x03, 0xC0, 0x26, 0x00,
  0xC0, 0x16, 0x03, 0x30, 0x07, 0x03, 0x98, 0x30, 0x80, 0x1F, 0xF0, 0x7F,
  0x06, 0x00, 0x3E, 0x01, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x40, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x02, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x07, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x30, 0x04, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0x00, 0xFF, 0x0C, 0x00, 0x0E, 0x30,
  0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x1C, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0x00, 0x07, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0xEC, 0x00, 0x07, 0x30, 0x00, 0x78, 0xFF, 0xFF, 0x83, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x78,
  0x00, 0x10, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x80, 0xFC, 0x0F, 0x80,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x30, 0x1F, 0xF0, 0x0C, 0x00, 0x1E,
  0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x0F, 0x80, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xD8, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFB, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x1C,
  0x00, 0x02, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x70, 0x0F, 0xE0, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x3C, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0xC3, 0xCF, 0xF0, 0x18, 0x00,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0,
  0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x70, 0x00, 0x33, 0xE0, 0x00, 0xD9, 0xC0, 0x03, 0xC3,
  0x00, 0x0E, 0x06, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00,
  0x03, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xBD, 0x80, 0x00, 0x03, 0x7B, 0x00,
  0x00, 0x06, 0xF3, 0x00, 0x00, 0x19, 0xE6, 0x00, 0x00, 0x33, 0xCC, 0x00,
  0x00, 0x47, 0x8C, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x03, 0x1E, 0x18, 0x00,
  0x0C, 0x3C, 0x30, 0x00, 0x18, 0x78, 0x60, 0x00, 0x20, 0xF0, 0x60, 0x00,
  0xC1, 0xE0, 0xC0, 0x01, 0x83, 0xC0, 0xC0, 0x06, 0x07, 0x81, 0x80, 0x0C,
  0x0F, 0x03, 0x00, 0x10, 0x1E, 0x03, 0x00, 0x60, 0x3C, 0x06, 0x00, 0xC0,
  0x78, 0x06, 0x03, 0x00, 0xF0, 0x0C, 0x06, 0x01, 0xE0, 0x18, 0x18, 0x03,
  0xC0, 0x18, 0x30, 0x07, 0x80, 0x30, 0x60, 0x0F, 0x00, 0x31, 0x80, 0x1E,
  0x00, 0x63, 0x00, 0x3C, 0x00, 0xCC, 0x00, 0x78, 0x00, 0xD8, 0x00, 0xF0,
  0x01, 0xB0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x06, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xCC, 0x00, 0x03,
  0xC6, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC1, 0x80, 0x03,
  0xC1, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x70, 0x03,
  0xC0, 0x30, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0C, 0x03,
  0xC0, 0x06, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x03, 0x03, 0xC0, 0x01, 0x83,
  0xC0, 0x01, 0xC3, 0xC0, 0x00, 0xC3, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x73,
  0xC0, 0x00, 0x33, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x03, 0x80, 0x07,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x0C,
  0x0F, 0xF0, 0xC0, 0x03, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x0C, 0xC0, 0x01, 0x8C, 0x00, 0xF0, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x03, 0x80,
  0x07, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFC, 0x03, 0x01, 0xFE, 0x0C, 0x00, 0x1C,
  0x30, 0x00, 0x38, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x70,
  0xC0, 0x07, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x01, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xE3,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x70, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x07, 0x80, 0x7C, 0x70, 0x00,
  0x47, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x80, 0x01, 0xC7, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x63, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x30, 0x38, 0x00,
  0x70, 0x0F, 0x81, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x03, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x18, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x30,
  0x00, 0x34, 0x00, 0x06, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0x66,
  0x00, 0x0C, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x18, 0x00, 0x42, 0x00, 0x0C,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x08, 0x00,
  0xC3, 0x00, 0x18, 0x0C, 0x00, 0x81, 0x80, 0x18, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x06, 0x01, 0x80, 0x80, 0x30, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x03, 0x02, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x60, 0xC0,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x01, 0x06, 0x00, 0x20, 0xC0, 0x01, 0x84,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0B, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x83, 0x80, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0x30, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x38, 0x00, 0x06,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x9C, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xFF, 0xF0, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x06, 0x60, 0x00, 0x08, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x41, 0x80, 0x01, 0x81, 0x80, 0x02, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x70, 0x0E, 0x08, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0xF0, 0x1F, 0xFE, 0x1F, 0x00, 0xC7, 0x00, 0x19,
  0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xD8, 0x00, 0x5B, 0x80, 0x1B, 0x3C, 0x1E, 0x63,
  0xFF, 0x04, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x3F, 0x01, 0x87, 0xFF, 0x0C, 0xE0, 0x1C,
  0x6C, 0x00, 0x73, 0x60, 0x01, 0xDE, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xDE,
  0x00, 0x0E, 0xD8, 0x00, 0x66, 0xE0, 0x0E, 0x33, 0xC1, 0xE1, 0x87, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0xF0, 0x04, 0x70, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x01, 0x0F, 0x83, 0xC0, 0xFF, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x3F, 0x06, 0x0F, 0xFE, 0x30, 0xE0, 0x19, 0x8C, 0x00,
  0x6C, 0xC0, 0x01, 0xEE, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEE, 0x00, 0x0F,
  0x30, 0x00, 0x58, 0xE0, 0x06, 0xC3, 0xC1, 0xE6, 0x0F, 0xFC, 0x30, 0x00,
  0xFC, 0x00, 0x7F, 0xF0, 0x0E, 0x03, 0x81, 0xC0, 0x0C, 0x30, 0x00, 0x63,
  0x00, 0x06, 0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x02, 0x0F,
  0x81, 0xE0, 0x3F, 0xFC, 0x00, 0x7C, 0x01, 0xFF, 0x03, 0x81, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0xFF, 0xF0, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0xC3,
  0x80, 0x66, 0x30, 0x01, 0xB3, 0x00, 0x07, 0xB8, 0x00, 0x1D, 0x80, 0x00,
  0xEC, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x76, 0x00,
  0x03, 0xB8, 0x00, 0x3C, 0xC0, 0x01, 0x63, 0x80, 0x3B, 0x0F, 0x07, 0x98,
  0x3F, 0xF0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x38, 0xFC, 0x0F, 0x81, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0xFC, 0x0C, 0x3F, 0xF8, 0xCE, 0x01, 0xCD, 0x80, 0x0E, 0xD0, 0x00, 0x6F,
  0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x5F, 0xA0, 0x00, 0x03, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x01, 0x01, 0xC0, 0xE0, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE8, 0xE7, 0xE0, 0x80, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x01, 0x60, 0x00, 0xCC, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x03, 0x06, 0x00,
  0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03, 0x80, 0x60, 0xE0, 0x0C, 0x38,
  0x01, 0x86, 0x00, 0x31, 0xE0, 0x06, 0x6C, 0x00, 0xD8, 0xC0, 0x1E, 0x0C,
  0x03, 0x81, 0xC0, 0x60, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x30, 0x03,
  0x86, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x00, 0x07, 0x60, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8,
  0x01, 0xF8, 0x31, 0xFF, 0x81, 0xFF, 0x8C, 0xC0, 0x71, 0xC0, 0x73, 0x60,
  0x0E, 0xE0, 0x0E, 0xF0, 0x01, 0xB0, 0x01, 0xB8, 0x00, 0x38, 0x00, 0x6E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x30, 0x00, 0xFC, 0x0C, 0x3F, 0xF8, 0xCE, 0x01, 0xCD, 0x80, 0x0E, 0xD0,
  0x00, 0x6F, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xE0, 0x1C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00,
  0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x80, 0x06, 0x07, 0x00, 0x38,
  0x0F, 0x87, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0x0F, 0xFE, 0x0C,
  0x60, 0x1C, 0x33, 0x00, 0x38, 0xD8, 0x00, 0x73, 0xC0, 0x00, 0xCE, 0x00,
  0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x02, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00,
  0x06, 0xF0, 0x00, 0x33, 0xC0, 0x00, 0xCD, 0x80, 0x06, 0x33, 0x00, 0x70,
  0xC7, 0x07, 0x83, 0x0F, 0xFC, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0xC3, 0x80, 0xE6, 0x30, 0x01, 0xB3, 0x00,
  0x07, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xE8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x3C, 0xC0, 0x03,
  0x63, 0x00, 0x33, 0x0E, 0x07, 0x18, 0x3F, 0xF0, 0xC0, 0x10, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x01, 0xFF, 0x1F, 0xEC, 0xE0, 0x36, 0x00, 0xD0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0xFF, 0xE3, 0x80, 0x19, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1A, 0x00, 0x0E, 0xF8, 0x0F, 0x0F, 0xFF, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x1F, 0xFF,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00,
  0x1C, 0x20, 0x7F, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x60, 0x00, 0xF6, 0x00, 0x1B, 0x30, 0x03,
  0x33, 0xE1, 0xE3, 0x0F, 0xFC, 0x30, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x0C, 0x40, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0x60, 0x01,
  0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x10, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xC0,
  0x01, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0x80, 0x00, 0x6C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x60, 0x03, 0xC0, 0x02,
  0x60, 0x03, 0x40, 0x06, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x30, 0x06, 0x20, 0x0C, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C,
  0x10, 0x0C, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x10, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x04, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x02, 0x60, 0x03, 0x40, 0x03, 0x60,
  0x03, 0xC0, 0x03, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x39, 0x80, 0x03, 0x06, 0x00, 0x38,
  0x38, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x1C, 0x00, 0x60,
  0xC0, 0x01, 0x8C, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x70, 0x00, 0x31, 0x80, 0x03, 0x06,
  0x00, 0x38, 0x18, 0x01, 0x80, 0xE0, 0x18, 0x03, 0x01, 0xC0, 0x0C, 0x0C,
  0x00, 0x70, 0xC0, 0x01, 0x8C, 0x00, 0x06, 0xE0, 0x00, 0x18, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0C, 0x40, 0x00, 0x63, 0x00, 0x03, 0x18,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x06,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x10, 0x03, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0xC0, 0x01, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00,
  0x01, 0x98, 0x00, 0x0C, 0x80, 0x00, 0x2C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x21, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x03,
  0xE0, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x03, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x7C,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x03, 0x80, 0xF8, 0x04, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xCF, 0xC0, 0x38, 0x03, 0xC3, 0xA0, 0x03, 0xFC,
};

const GFXglyph NotoSans_ExtraLight48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 34, 11, 4, -34 },
  { 14, 10, 12, 16, 3, -34 },
  { 29, 29, 34, 31, 1, -34 },
  { 153, 20, 39, 27, 3, -36 },
  { 251, 33, 35, 38, 3, -35 },
  { 396, 30, 35, 34, 3, -35 },
  { 528, 2, 12, 9, 3, -34 },
  { 531, 9, 42, 13, 2, -34 },
  { 579, 9, 42, 13, 2, -34 },
  { 627, 20, 19, 26, 3, -36 },
  { 675, 22, 22, 27, 3, -28 },
  { 736, 5, 12, 10, 2, -6 },
  { 744, 12, 2, 15, 2, -14 },
  { 747, 3, 3, 11, 4, -3 },
  { 749, 14, 34, 16, 1, -34 },
  { 809, 21, 35, 27, 3, -35 },
  { 901, 11, 34, 27, 5, -34 },
  { 948, 21, 35, 27, 3, -35 },
  { 1040, 22, 35, 27, 2, -35 },
  { 1137, 26, 34, 27, 1, -34 },
  { 1248, 21, 34, 27, 3, -34 },
  { 1338, 22, 35, 27, 3, -35 },
  { 1435, 22, 34, 27, 3, -34 },
  { 1529, 21, 35, 27, 3, -35 },
  { 1621, 21, 36, 27, 3, -35 },
  { 1716, 3, 26, 11, 4, -26 },
  { 1726, 5, 32, 11, 2, -26 },
  { 1746, 22, 22, 27, 3, -28 },
  { 1807, 22, 12, 27, 3, -23 },
  { 1840, 22, 22, 27, 3, -28 },
  { 1901, 16, 35, 20, 2, -35 },
  { 1971, 37, 39, 42, 3, -34 },
  { 2152, 28, 34, 28, 0, -34 },
  { 2271, 22, 34, 30, 5, -34 },
  { 2365, 25, 35, 30, 3, -35 },
  { 2475, 26, 34, 34, 5, -34 },
  { 2586, 19, 34, 26, 5, -34 },
  { 2667, 19, 34, 24, 5, -34 },
  { 2748, 28, 35, 35, 3, -35 },
  { 2871, 24, 34, 34, 5, -34 },
  { 2973, 8, 34, 14, 3, -34 },
  { 3007, 12, 43, 12, -5, -34 },
  { 3072, 22, 34, 27, 5, -34 },
  { 3166, 18, 34, 24, 5, -34 },
  { 3243, 31, 34, 41, 5, -34 },
  { 3375, 24, 34, 34, 5, -34 },
  { 3477, 30, 35, 36, 3, -35 },
  { 3609, 20, 34, 28, 5, -34 },
  { 3694, 30, 43, 36, 3, -35 },
  { 3856, 22, 34, 28, 5, -34 },
  { 3950, 21, 35, 26, 3, -35 },
  { 4042, 25, 34, 25, 0, -34 },
  { 4149, 25, 34, 34, 5, -34 },
  { 4256, 27, 34, 27, 0, -34 },
  { 4371, 40, 34, 42, 1, -34 },
  { 4541, 25, 34, 25, 0, -34 },
  { 4648, 25, 34, 25, 0, -34 },
  { 4755, 24, 34, 28, 2, -34 },
  { 4857, 10, 42, 15, 4, -34 },
  { 4910, 14, 34, 16, 1, -34 },
  { 4970, 10, 42, 15, 1, -34 },
  { 5023, 23, 22, 27, 2, -35 },
  { 5087, 19, 2, 19, 0, 4 },
  { 5092, 8, 8, 12, 2, -37 },
  { 5100, 19, 26, 25, 2, -26 },
  { 5162, 21, 36, 28, 4, -36 },
  { 5257, 18, 26, 23, 3, -26 },
  { 5316, 21, 36, 28, 3, -36 },
  { 5411, 20, 26, 26, 3, -26 },
  { 5476, 16, 37, 14, 1, -37 },
  { 5550, 21, 38, 28, 3, -26 },
  { 5650, 20, 36, 28, 4, -36 },
  { 5740, 3, 35, 10, 4, -35 },
  { 5754, 9, 47, 10, -2, -35 },
  { 5807, 19, 36, 23, 4, -36 },
  { 5893, 2, 36, 10, 4, -36 },
  { 5902, 34, 26, 42, 4, -26 },
  { 6013, 20, 26, 28, 4, -26 },
  { 6078, 22, 26, 28, 3, -26 },
  { 6150, 22, 37, 28, 4, -26 },
  { 6252, 21, 37, 28, 3, -26 },
  { 6350, 14, 26, 18, 4, -26 },
  { 6396, 18, 26, 22, 2, -26 },
  { 6455, 13, 32, 16, 1, -32 },
  { 6507, 20, 25, 28, 4, -25 },
  { 6570, 21, 25, 21, 0, -25 },
  { 6636, 32, 25, 34, 1, -25 },
  { 6736, 21, 25, 23, 1, -25 },
  { 6802, 21, 37, 21, 0, -25 },
  { 6900, 18, 25, 22, 2, -25 },
  { 6957, 14, 42, 17, 1, -34 },
  { 7031, 2, 49, 26, 12, -37 },
  { 7044, 13, 42, 17, 2, -34 },
  { 7113, 22, 4, 27, 3, -19 },
};

const GFXfont NotoSans_ExtraLight48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRALIGHT48PT7B_H_
