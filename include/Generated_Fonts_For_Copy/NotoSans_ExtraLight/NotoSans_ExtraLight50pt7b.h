#ifndef _NOTOSANS_EXTRALIGHT50PT7B_H_
#define _NOTOSANS_EXTRALIGHT50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight50pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80,
  0x00, 0x1F, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x30, 0x18, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x80, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x10, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x10, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x04, 0x00, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x04, 0x00, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x20, 0x04, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFD, 0x0E, 0x10,
  0xF0, 0xC0, 0x80, 0x8C, 0x04, 0x00, 0x60, 0x20, 0x06, 0x01, 0x00, 0x30,
  0x08, 0x01, 0x80, 0x40, 0x0C, 0x02, 0x00, 0x70, 0x10, 0x01, 0x80, 0x80,
  0x0E, 0x04, 0x00, 0x38, 0x20, 0x00, 0xF1, 0x00, 0x01, 0xE8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x17, 0xC0, 0x00, 0x8F, 0x00, 0x04, 0x1C,
  0x00, 0x20, 0x70, 0x01, 0x01, 0x80, 0x08, 0x06, 0x00, 0x40, 0x30, 0x02,
  0x01, 0x80, 0x10, 0x0C, 0x00, 0x80, 0x60, 0x04, 0x06, 0x00, 0x20, 0x30,
  0x01, 0x03, 0x38, 0x08, 0x71, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x00,
  0x30, 0x07, 0x78, 0x00, 0x18, 0x03, 0x03, 0x00, 0x06, 0x01, 0x80, 0xC0,
  0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30,
  0x03, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0x0C, 0x18, 0x00, 0x30, 0x03, 0x06, 0x00, 0x0C, 0x00, 0xC3, 0x07,
  0xC3, 0x00, 0x20, 0x87, 0xF8, 0xC0, 0x18, 0x63, 0x83, 0x18, 0x06, 0x30,
  0xC0, 0x66, 0x03, 0x0C, 0x60, 0x18, 0xC0, 0xC6, 0x18, 0x03, 0x1D, 0xE1,
  0x86, 0x00, 0xC3, 0xF0, 0xC3, 0x00, 0x30, 0x00, 0x30, 0xC0, 0x0C, 0x00,
  0x18, 0x30, 0x03, 0x00, 0x04, 0x0C, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x30,
  0x01, 0x80, 0xC0, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x00, 0x30, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18,
  0x06, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x30, 0x00, 0xC0, 0xC0, 0x18, 0x00,
  0x1C, 0x70, 0x0C, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x38, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x63, 0x80, 0x70, 0x00, 0xC6, 0x00, 0x70, 0x03,
  0x18, 0x00, 0x70, 0x06, 0x30, 0x00, 0x70, 0x18, 0xC0, 0x00, 0x70, 0x31,
  0x80, 0x00, 0x70, 0xE3, 0x00, 0x00, 0x71, 0x86, 0x00, 0x00, 0x76, 0x0C,
  0x00, 0x00, 0x7C, 0x18, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0xF0, 0x30,
  0x00, 0x07, 0x70, 0x30, 0x00, 0x1C, 0x70, 0x38, 0x00, 0xF0, 0x70, 0x3E,
  0x1F, 0x80, 0x70, 0x3F, 0xFC, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0xAA, 0x80, 0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80,
  0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x07, 0xC0, 0x30,
  0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x18, 0x04, 0x03, 0xF8, 0x20, 0xF9,
  0xF9, 0x3F, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x05, 0x80, 0x00, 0x64,
  0x00, 0x06, 0x30, 0x00, 0x70, 0xC0, 0x03, 0x07, 0x00, 0x30, 0x18, 0x03,
  0x80, 0x60, 0x38, 0x03, 0x80, 0x40, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x19, 0xCE, 0x63, 0x19, 0xCC, 0x63, 0x31, 0x80, 0xFF,
  0xF0, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x38, 0x03, 0x00, 0xE0, 0x03, 0x01, 0x80,
  0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x08, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x05,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x46, 0x00, 0x01, 0x86, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x1C, 0x01,
  0x80, 0x1F, 0x1E, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x1C, 0x06, 0x83, 0xB0, 0xE6, 0x38, 0xDC, 0x1F, 0x03, 0x40, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0x1C, 0x1C, 0x00, 0x38, 0x40,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xF0, 0x03, 0x83,
  0x80, 0x01, 0x84, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0xE3, 0xF8, 0x1F, 0x80, 0xFF, 0xF8, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x7E, 0x0F,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x80, 0x00, 0xE6, 0x00, 0x1E, 0x3F, 0x07, 0xC0,
  0x7F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFD, 0xE0,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x3F,
  0xC0, 0x21, 0xFF, 0xE0, 0xC7, 0x00, 0xF1, 0x98, 0x00, 0x73, 0x60, 0x00,
  0x67, 0x80, 0x00, 0x6E, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x0F, 0x0F, 0x80, 0x0F,
  0xFC, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xE0, 0x0E, 0x06, 0x00, 0x1C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x38, 0x00,
  0x70, 0x70, 0x03, 0x80, 0xF0, 0x1C, 0x00, 0xF1, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x38, 0x78, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x70, 0xC0,
  0x00, 0xE7, 0x00, 0x01, 0x98, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0x30, 0x00, 0x38, 0x70, 0x01, 0xC0, 0xF0,
  0x3C, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE,
  0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x61, 0x80, 0x00, 0xCE,
  0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0xF3, 0x00, 0x06, 0xCE,
  0x00, 0x73, 0x0F, 0x0F, 0x8C, 0x1F, 0xF8, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x02, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x19, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0xE6, 0x31, 0x8C, 0xC6, 0x31, 0x18, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x7F, 0xFE, 0x30, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x00, 0x63, 0x00, 0x0F, 0xFE, 0x01, 0x98, 0x00, 0xF0, 0x38, 0x03,
  0x60, 0x07, 0x00, 0x60, 0x0D, 0x80, 0x30, 0x01, 0x80, 0x3C, 0x01, 0xC0,
  0x06, 0x00, 0xF0, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x10, 0x00, 0x60, 0x07,
  0x00, 0xC0, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x0E, 0x00, 0xF0, 0x0C, 0x00, 0x38, 0x03, 0xC0, 0x30, 0x00,
  0xE0, 0x1B, 0x00, 0x60, 0x07, 0x80, 0x6C, 0x01, 0xC0, 0x32, 0x03, 0x30,
  0x03, 0x81, 0x8C, 0x18, 0x60, 0x07, 0xFC, 0x1F, 0xC1, 0x80, 0x03, 0x80,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00,
  0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x83, 0x00, 0x0F, 0x86, 0x00, 0x03, 0xCC,
  0x00, 0x01, 0x98, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x70, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0x00, 0x0F, 0x86, 0x00, 0x01, 0xCC, 0x00, 0x01,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x39, 0x80,
  0x01, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x10, 0x0F,
  0xC1, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0x00, 0x1F, 0x80, 0x60, 0x00, 0x3C, 0x0C, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x0E, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x78,
  0x18, 0x00, 0x7C, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x20, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x07, 0x80, 0x00, 0x18, 0x0F,
  0x00, 0x01, 0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x0F, 0x9F, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x81, 0xCF, 0xF8, 0x7E, 0x00,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x80, 0x00,
  0xC7, 0x80, 0x00, 0xCC, 0xC0, 0x00, 0xD8, 0xE0, 0x00, 0xF0, 0x60, 0x00,
  0xE0, 0x30, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0x0D, 0xD8, 0x00,
  0x00, 0x1B, 0xCC, 0x00, 0x00, 0x1B, 0xCC, 0x00, 0x00, 0x1B, 0xCC, 0x00,
  0x00, 0x33, 0xC6, 0x00, 0x00, 0x33, 0xC6, 0x00, 0x00, 0x63, 0xC3, 0x00,
  0x00, 0x63, 0xC3, 0x00, 0x00, 0x63, 0xC3, 0x00, 0x00, 0xC3, 0xC1, 0x80,
  0x00, 0xC3, 0xC1, 0x80, 0x01, 0x83, 0xC0, 0xC0, 0x01, 0x83, 0xC0, 0xC0,
  0x01, 0x83, 0xC0, 0xC0, 0x03, 0x03, 0xC0, 0x60, 0x03, 0x03, 0xC0, 0x60,
  0x06, 0x03, 0xC0, 0x30, 0x06, 0x03, 0xC0, 0x30, 0x04, 0x03, 0xC0, 0x30,
  0x0C, 0x03, 0xC0, 0x18, 0x0C, 0x03, 0xC0, 0x18, 0x18, 0x03, 0xC0, 0x0C,
  0x18, 0x03, 0xC0, 0x0C, 0x30, 0x03, 0xC0, 0x0C, 0x30, 0x03, 0xC0, 0x06,
  0x30, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x03, 0x60, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01,
  0x80, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x07,
  0x9C, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xE1, 0x80, 0x00, 0xF0, 0xE0, 0x00,
  0x78, 0x38, 0x00, 0x3C, 0x0C, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x01, 0xC0,
  0x07, 0x80, 0x60, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x03,
  0x00, 0x78, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x18, 0x0F, 0x00,
  0x0E, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x00, 0xC1, 0xE0, 0x00, 0x30, 0xF0,
  0x00, 0x1C, 0x78, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x38,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x30, 0x03, 0xF1, 0x80, 0x01, 0xCC, 0x00, 0x07,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x06, 0xC0, 0x00, 0x66, 0x00, 0x07, 0x30, 0x00,
  0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x03, 0x00, 0x1F, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x07,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0xE1, 0x80,
  0x03, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x60, 0x03, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x07,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xE1,
  0xC0, 0x03, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x72, 0x00, 0x03, 0x8F, 0xC0, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00,
  0x7C, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x00, 0x00, 0x66, 0x00, 0x01, 0xE0, 0x00,
  0x19, 0x80, 0x00, 0x78, 0x00, 0x06, 0x30, 0x00, 0x1E, 0x00, 0x01, 0x8C,
  0x00, 0x0C, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xCC, 0x00, 0x0C, 0x18, 0x00, 0x33, 0x00, 0x06, 0x06, 0x00, 0x18, 0x60,
  0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x60, 0x60, 0x01, 0x86, 0x00, 0x18,
  0x0C, 0x00, 0x41, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x30, 0x03, 0x00, 0xC0,
  0x0C, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x03, 0x00, 0x70, 0x06, 0x01, 0x80,
  0x40, 0x18, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x06, 0x08,
  0x00, 0x41, 0x80, 0x01, 0x86, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x06,
  0x18, 0x00, 0x0C, 0x60, 0x01, 0x8E, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x06,
  0xC0, 0x00, 0x58, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x80,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00,
  0x60, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x1C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x18, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x03, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0xE0, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18,
  0xE0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xF0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x62, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0xC1, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x40,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x20, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x10,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x08, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFE, 0x00,
  0xFF, 0xF8, 0x1E, 0x01, 0xC1, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x7F, 0xF0, 0x7F, 0xF3, 0x1E, 0x00, 0x33, 0x80,
  0x03, 0x70, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x60, 0x00, 0xF6, 0x00, 0x1B, 0x30, 0x03, 0x33,
  0xC1, 0xE3, 0x0F, 0xFC, 0x30, 0x08, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x07, 0xF0, 0x0C, 0x3F, 0xFC, 0x18, 0xE0, 0x1C, 0x33,
  0x00, 0x1C, 0x6C, 0x00, 0x1C, 0xD0, 0x00, 0x19, 0xE0, 0x00, 0x33, 0x80,
  0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x03,
  0x70, 0x00, 0x0C, 0xF0, 0x00, 0x19, 0xA0, 0x00, 0x73, 0x60, 0x01, 0xC6,
  0x60, 0x07, 0x0C, 0x78, 0x7C, 0x18, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x1E, 0x01, 0x87, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x20,
  0xF8, 0x7C, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x3F, 0x83, 0x07, 0xFF, 0x8C, 0x3C, 0x07, 0x31, 0xC0, 0x06,
  0xCE, 0x00, 0x0F, 0x30, 0x00, 0x3D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60,
  0x00, 0x1C, 0xC0, 0x00, 0xF3, 0x80, 0x06, 0xC7, 0x00, 0x33, 0x0F, 0x83,
  0x8C, 0x0F, 0xFC, 0x30, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xC0, 0x70, 0x38, 0x01, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x19, 0x80,
  0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x10, 0x3C, 0x0F, 0x80, 0x7F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0xF8, 0xFF, 0xF8, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x00, 0xFE, 0x0C, 0x1F, 0xFE, 0x30, 0xE0, 0x1C, 0xC7, 0x00, 0x1B,
  0x38, 0x00, 0x3C, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80,
  0x00, 0x73, 0x00, 0x03, 0xCE, 0x00, 0x1B, 0x1C, 0x00, 0xCC, 0x3E, 0x0E,
  0x30, 0x3F, 0xF0, 0xC0, 0x08, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x90, 0x00, 0x1C, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x81, 0xFC, 0x0C, 0x3F, 0xF8, 0x63,
  0x80, 0xF3, 0x30, 0x01, 0x9B, 0x00, 0x06, 0xF0, 0x00, 0x37, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0C, 0xFF, 0x80, 0x00, 0x1B, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x01, 0xC0, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xCF, 0xF3, 0xF0, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0,
  0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C,
  0x1C, 0x00, 0xC3, 0x80, 0x0C, 0x78, 0x00, 0xC7, 0xC0, 0x0C, 0xCC, 0x00,
  0xD8, 0x60, 0x0F, 0x07, 0x00, 0xE0, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x0C,
  0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00,
  0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xFC, 0x00, 0xFC, 0x18, 0xFF, 0xE0, 0x7F,
  0xE3, 0x38, 0x0E, 0x38, 0x0E, 0x6C, 0x00, 0xEE, 0x00, 0x6D, 0x00, 0x0D,
  0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x03, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x0F,
  0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x07, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x01, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x07,
  0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x03, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0xFE, 0x06, 0x1F, 0xFE, 0x31, 0xC0, 0x79, 0x98,
  0x00, 0xCD, 0x80, 0x03, 0x68, 0x00, 0x1B, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x06, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3C, 0x03, 0x80, 0xE0,
  0x03, 0x83, 0x80, 0x03, 0x86, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x0E,
  0x00, 0x60, 0x0F, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0xFF, 0x01, 0x87, 0xFF, 0x83, 0x1C, 0x03, 0x86, 0x60, 0x03, 0x8D, 0x80,
  0x03, 0x9A, 0x00, 0x03, 0x3C, 0x00, 0x07, 0x70, 0x00, 0x06, 0xE0, 0x00,
  0x0D, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0D,
  0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xDE,
  0x00, 0x03, 0x36, 0x00, 0x0E, 0x6C, 0x00, 0x38, 0xCE, 0x00, 0xE1, 0x8F,
  0x0F, 0x83, 0x07, 0xFC, 0x06, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x0C, 0x1F, 0xFE, 0x30, 0xE0, 0x1C,
  0xC7, 0x00, 0x1B, 0x38, 0x00, 0x3C, 0xC0, 0x00, 0xF6, 0x00, 0x01, 0xD8,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x60,
  0x00, 0x1D, 0x80, 0x00, 0xF3, 0x00, 0x03, 0xCE, 0x00, 0x1B, 0x1C, 0x00,
  0xCC, 0x3C, 0x1E, 0x30, 0x3F, 0xE0, 0xC0, 0x08, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0xC0, 0xFF, 0x0F, 0xFC, 0xE0, 0x33, 0x00, 0xD8,
  0x03, 0x40, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0xF0, 0x07, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0xC0, 0x01, 0x9F, 0x81, 0xE0, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xFF, 0xFF,
  0xFF, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xE1, 0x03, 0xFC, 0x01, 0x80, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3D, 0x80, 0x01, 0x6E,
  0x00, 0x1B, 0x38, 0x03, 0x98, 0xF0, 0x78, 0xC3, 0xFF, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x01, 0xD8, 0x00, 0x06,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x66, 0x00, 0x1E, 0x00, 0x19, 0x80, 0x07, 0x80, 0x06, 0x60, 0x03, 0x20,
  0x03, 0x18, 0x00, 0xCC, 0x00, 0xC3, 0x00, 0x33, 0x00, 0x30, 0xC0, 0x18,
  0x40, 0x18, 0x30, 0x06, 0x18, 0x06, 0x06, 0x01, 0x86, 0x01, 0x81, 0x80,
  0xC1, 0x80, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x0C, 0x03,
  0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x60,
  0x06, 0x30, 0x06, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31,
  0x00, 0x18, 0x80, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x60, 0x00, 0x1D, 0xC0, 0x00,
  0xE3, 0x00, 0x03, 0x06, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x83, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x3B, 0x00, 0x00, 0xCE, 0x00, 0x06, 0x18, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xE0, 0x06, 0x01, 0x80, 0x30, 0x03, 0x01, 0xC0, 0x06, 0x06, 0x00,
  0x1C, 0x30, 0x00, 0x31, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x36, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x70,
  0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x04,
  0xC0, 0x00, 0x1A, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0xFC, 0x03, 0x80, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x01, 0xF8,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x38, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x0F, 0xC0, 0x38, 0x00, 0x1F, 0x80, 0x02, 0xFF,
  0xE0, 0x0F, 0x00, 0xF0, 0x34, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_ExtraLight50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 36, 12, 4, -36 },
  { 15, 9, 13, 17, 4, -36 },
  { 30, 30, 36, 32, 1, -36 },
  { 165, 21, 41, 29, 3, -38 },
  { 273, 34, 37, 40, 3, -36 },
  { 431, 31, 37, 35, 3, -36 },
  { 575, 2, 13, 9, 4, -36 },
  { 579, 10, 44, 13, 2, -36 },
  { 634, 9, 44, 13, 2, -36 },
  { 684, 21, 21, 28, 3, -38 },
  { 740, 23, 23, 29, 3, -29 },
  { 807, 5, 12, 10, 2, -6 },
  { 815, 12, 1, 16, 2, -14 },
  { 817, 3, 3, 12, 4, -3 },
  { 819, 15, 36, 17, 1, -36 },
  { 887, 23, 37, 29, 3, -36 },
  { 994, 11, 36, 29, 5, -36 },
  { 1044, 22, 36, 29, 3, -36 },
  { 1143, 23, 37, 29, 2, -36 },
  { 1250, 27, 36, 29, 1, -36 },
  { 1372, 21, 37, 29, 4, -36 },
  { 1470, 23, 37, 29, 3, -36 },
  { 1577, 23, 36, 29, 3, -36 },
  { 1681, 22, 37, 29, 3, -36 },
  { 1783, 22, 37, 29, 3, -36 },
  { 1885, 3, 27, 12, 4, -27 },
  { 1896, 5, 33, 12, 2, -27 },
  { 1917, 23, 23, 29, 3, -30 },
  { 1984, 23, 12, 29, 3, -24 },
  { 2019, 23, 23, 29, 3, -30 },
  { 2086, 17, 36, 21, 2, -36 },
  { 2163, 38, 40, 44, 3, -35 },
  { 2353, 29, 36, 30, 0, -36 },
  { 2484, 23, 36, 31, 5, -36 },
  { 2588, 26, 37, 31, 3, -36 },
  { 2709, 27, 36, 35, 5, -36 },
  { 2831, 20, 36, 28, 5, -36 },
  { 2921, 20, 36, 25, 5, -36 },
  { 3011, 29, 37, 36, 3, -36 },
  { 3146, 26, 36, 36, 5, -36 },
  { 3263, 9, 36, 15, 3, -36 },
  { 3304, 12, 45, 12, -5, -36 },
  { 3372, 24, 36, 29, 5, -36 },
  { 3480, 19, 36, 26, 5, -36 },
  { 3566, 32, 36, 43, 5, -36 },
  { 3710, 25, 36, 36, 5, -36 },
  { 3823, 32, 37, 38, 3, -36 },
  { 3971, 21, 36, 29, 5, -36 },
  { 4066, 32, 45, 38, 3, -36 },
  { 4246, 23, 36, 29, 5, -36 },
  { 4350, 22, 37, 27, 3, -36 },
  { 4452, 26, 36, 26, 0, -36 },
  { 4569, 26, 37, 36, 5, -36 },
  { 4690, 29, 36, 29, 0, -36 },
  { 4821, 42, 36, 44, 1, -36 },
  { 5010, 26, 36, 26, 0, -36 },
  { 5127, 26, 36, 26, 0, -36 },
  { 5244, 25, 36, 29, 2, -36 },
  { 5357, 11, 44, 16, 4, -36 },
  { 5418, 15, 36, 17, 1, -36 },
  { 5486, 11, 44, 16, 1, -36 },
  { 5547, 24, 22, 29, 2, -36 },
  { 5613, 20, 1, 20, 0, 5 },
  { 5616, 9, 8, 13, 2, -38 },
  { 5625, 20, 28, 26, 2, -27 },
  { 5695, 23, 39, 30, 4, -38 },
  { 5808, 19, 28, 24, 3, -27 },
  { 5875, 22, 39, 30, 3, -38 },
  { 5983, 21, 28, 27, 3, -27 },
  { 6057, 16, 38, 14, 1, -38 },
  { 6133, 22, 39, 30, 3, -27 },
  { 6241, 21, 38, 29, 4, -38 },
  { 6341, 3, 36, 11, 4, -36 },
  { 6355, 10, 48, 11, -3, -36 },
  { 6415, 20, 38, 24, 4, -38 },
  { 6510, 2, 38, 11, 4, -38 },
  { 6520, 35, 27, 43, 4, -27 },
  { 6639, 21, 27, 29, 4, -27 },
  { 6710, 23, 28, 29, 3, -27 },
  { 6791, 23, 39, 30, 4, -27 },
  { 6904, 22, 39, 30, 3, -27 },
  { 7012, 14, 27, 19, 4, -27 },
  { 7060, 19, 28, 23, 2, -27 },
  { 7127, 14, 34, 16, 1, -33 },
  { 7187, 21, 28, 29, 4, -27 },
  { 7261, 22, 27, 22, 0, -27 },
  { 7336, 34, 26, 35, 1, -26 },
  { 7447, 22, 27, 24, 1, -27 },
  { 7522, 22, 39, 22, 0, -27 },
  { 7630, 19, 27, 23, 2, -27 },
  { 7695, 15, 44, 17, 1, -36 },
  { 7778, 2, 50, 27, 12, -38 },
  { 7791, 14, 44, 17, 2, -36 },
  { 7868, 23, 5, 29, 3, -20 },
};

const GFXfont NotoSans_ExtraLight50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRALIGHT50PT7B_H_
