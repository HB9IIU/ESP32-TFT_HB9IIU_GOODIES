#ifndef _NOTOSANS_EXTRALIGHT31PT7B_H_
#define _NOTOSANS_EXTRALIGHT31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight31pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0xF0, 0xC6, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x0C, 0x10, 0x02, 0x04,
  0x00, 0x81, 0x00, 0x20, 0x41, 0xFF, 0xFF, 0x06, 0x08, 0x01, 0x02, 0x00,
  0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x03, 0x04, 0x0F, 0xFF, 0xF8, 0x20,
  0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x83, 0x00, 0x40, 0x80, 0x10, 0x20,
  0x04, 0x08, 0x00, 0x02, 0x00, 0x10, 0x01, 0xE0, 0x7F, 0xE6, 0x21, 0x61,
  0x02, 0x08, 0x10, 0x40, 0x82, 0x06, 0x10, 0x18, 0x80, 0x74, 0x00, 0xE0,
  0x01, 0xE0, 0x09, 0x80, 0x42, 0x02, 0x18, 0x10, 0x40, 0x82, 0x04, 0x30,
  0x21, 0x41, 0x1B, 0xFF, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x3E, 0x00,
  0x82, 0x10, 0x08, 0x30, 0x40, 0x41, 0x02, 0x04, 0x08, 0x10, 0x60, 0x40,
  0x82, 0x02, 0x04, 0x20, 0x10, 0x21, 0x00, 0x81, 0x10, 0x84, 0x08, 0x9F,
  0x30, 0x49, 0x84, 0x84, 0x48, 0x33, 0xE4, 0x40, 0x80, 0x66, 0x04, 0x02,
  0x30, 0x20, 0x21, 0x81, 0x01, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x08, 0x08, 0x20, 0x40, 0x61, 0x04, 0x01, 0xF0, 0x0F, 0xE0, 0x03, 0x06,
  0x00, 0xC0, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x60, 0x20, 0x04, 0x0C,
  0x00, 0xC3, 0x00, 0x0C, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x18, 0xC0,
  0x06, 0x0C, 0x04, 0x80, 0xC0, 0xA0, 0x0C, 0x24, 0x00, 0xC4, 0x80, 0x0D,
  0x10, 0x00, 0xE3, 0x00, 0x1C, 0x20, 0x06, 0xC7, 0x03, 0x8C, 0x3F, 0xC0,
  0xC0, 0xEA, 0xAA, 0x0C, 0x21, 0x0C, 0x20, 0x86, 0x10, 0x41, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC1, 0x04, 0x10, 0x60, 0x82, 0x04, 0x10, 0x20, 0xC0,
  0xC1, 0x82, 0x0C, 0x10, 0x60, 0x82, 0x08, 0x30, 0x41, 0x04, 0x10, 0x41,
  0x0C, 0x30, 0x82, 0x08, 0x61, 0x0C, 0x21, 0x0C, 0x00, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x61, 0x0C, 0xEF, 0x80, 0xC0, 0x05, 0x00,
  0x4C, 0x02, 0x20, 0x20, 0x83, 0x06, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0xFF, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x24, 0xB4, 0x94, 0xFF,
  0xF0, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x00, 0x1F, 0xC0, 0xC0, 0xC2, 0x01, 0x10, 0x06,
  0x40, 0x0B, 0x00, 0x28, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x02, 0xC0, 0x09, 0x00,
  0x24, 0x01, 0x88, 0x04, 0x30, 0x20, 0x3F, 0x00, 0x06, 0x1C, 0x4B, 0x1C,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x3F, 0xC7, 0x03, 0x10, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x7F, 0xFC, 0x1F, 0xE1, 0x80, 0x64, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x80, 0xFC, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x02, 0xC0, 0x30, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x50, 0x00, 0xD0, 0x00, 0x90, 0x01, 0x10, 0x02, 0x10, 0x06, 0x10, 0x04,
  0x10, 0x08, 0x10, 0x18, 0x10, 0x30, 0x10, 0x20, 0x10, 0x40, 0x10, 0xC0,
  0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x3F, 0xF0, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x04, 0xC0, 0x61, 0xFF, 0x00, 0x00, 0x40, 0x1F, 0xC0, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x0E, 0x09,
  0xCF, 0x2C, 0x06, 0xC0, 0x0B, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x05,
  0x00, 0x14, 0x00, 0xD8, 0x02, 0x20, 0x18, 0x40, 0xC0, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x00, 0x1F, 0xE0, 0xC0, 0xC4, 0x01, 0x90, 0x02, 0x40, 0x09, 0x00,
  0x24, 0x01, 0x98, 0x04, 0x30, 0x60, 0x36, 0x00, 0x78, 0x06, 0x38, 0x60,
  0x31, 0x00, 0x6C, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x90,
  0x06, 0x60, 0x30, 0x7F, 0x00, 0x1F, 0xC1, 0x81, 0x84, 0x01, 0x30, 0x04,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x01,
  0xD8, 0x0B, 0x3F, 0xC8, 0x08, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0xC1, 0xFC, 0x00, 0xB8, 0x00, 0x00, 0x03,
  0xC0, 0x23, 0x20, 0x00, 0x00, 0x00, 0x00, 0x02, 0x26, 0x64, 0x44, 0x80,
  0x00, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x02, 0x00, 0x00, 0xFF, 0x90, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x10, 0x06,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x08, 0x30,
  0x00, 0x04, 0x20, 0x00, 0x04, 0x40, 0x1E, 0x02, 0x40, 0x61, 0x82, 0x80,
  0x80, 0x82, 0x81, 0x01, 0x83, 0x83, 0x01, 0x81, 0x82, 0x01, 0x01, 0x82,
  0x01, 0x03, 0x82, 0x01, 0x03, 0x82, 0x01, 0x02, 0x82, 0x01, 0x02, 0x81,
  0x02, 0x84, 0x81, 0xCC, 0xCC, 0x40, 0x30, 0x70, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x01, 0x80, 0x01,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x01,
  0x30, 0x00, 0xC4, 0x00, 0x21, 0x00, 0x08, 0x60, 0x06, 0x08, 0x01, 0x03,
  0x00, 0x40, 0x40, 0x20, 0x10, 0x08, 0x06, 0x07, 0xFF, 0x81, 0x00, 0x20,
  0x40, 0x04, 0x20, 0x01, 0x08, 0x00, 0x66, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x00, 0xE0, 0x00, 0x10, 0xFF, 0xE1, 0x00, 0x62, 0x00, 0x24, 0x00, 0x68,
  0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x04, 0x80, 0x19, 0x00, 0xE3, 0xFF,
  0x04, 0x01, 0xC8, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x05,
  0x00, 0x0A, 0x00, 0x14, 0x00, 0x48, 0x03, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x0C, 0x01, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x01, 0x03, 0xFE, 0xFF, 0xC0, 0x40, 0x1C, 0x20, 0x03,
  0x10, 0x00, 0xC8, 0x00, 0x24, 0x00, 0x1A, 0x00, 0x05, 0x00, 0x02, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x05, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01, 0x20, 0x01, 0x10, 0x03,
  0x08, 0x07, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00,
  0x10, 0x00, 0xFF, 0xF0, 0xE0, 0x08, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0x40,
  0x00, 0x50, 0x00, 0x16, 0x00, 0x04, 0xC0, 0x01, 0x18, 0x00, 0x43, 0x80,
  0x30, 0x3F, 0xF0, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xF9,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x7C, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0F,
  0xF0, 0x80, 0x0D, 0x00, 0x32, 0x00, 0xC4, 0x03, 0x08, 0x0C, 0x10, 0x30,
  0x20, 0xC0, 0x43, 0x00, 0x8C, 0x01, 0x38, 0x02, 0xD0, 0x05, 0x30, 0x0C,
  0x30, 0x10, 0x20, 0x20, 0x20, 0x40, 0x60, 0x80, 0x61, 0x00, 0x42, 0x00,
  0x44, 0x00, 0xC8, 0x00, 0xD0, 0x00, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xA0, 0x00, 0x7A,
  0x00, 0x05, 0x90, 0x00, 0xD9, 0x00, 0x09, 0x98, 0x00, 0x98, 0x80, 0x19,
  0x8C, 0x01, 0x18, 0x40, 0x31, 0x84, 0x02, 0x18, 0x60, 0x21, 0x82, 0x06,
  0x18, 0x30, 0x41, 0x81, 0x0C, 0x18, 0x10, 0x81, 0x81, 0x88, 0x18, 0x09,
  0x01, 0x80, 0xD0, 0x18, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xA0, 0x01, 0xB0, 0x01, 0x90, 0x01, 0x88, 0x01, 0x8C,
  0x01, 0x84, 0x01, 0x82, 0x01, 0x83, 0x01, 0x81, 0x01, 0x80, 0x81, 0x80,
  0xC1, 0x80, 0x61, 0x80, 0x21, 0x80, 0x31, 0x80, 0x19, 0x80, 0x09, 0x80,
  0x0D, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x07, 0xFC, 0x00, 0xC0, 0x30,
  0x10, 0x01, 0x82, 0x00, 0x0C, 0x60, 0x00, 0x44, 0x00, 0x06, 0x40, 0x00,
  0x2C, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x02, 0xC0, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x66, 0x00, 0x04, 0x20, 0x00, 0xC1, 0x00, 0x18, 0x0C, 0x07, 0x00,
  0x7F, 0xC0, 0xFF, 0xC4, 0x03, 0x20, 0x05, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x0D, 0x07, 0xCF, 0xE0, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x07, 0xFC, 0x00, 0xC0, 0x30, 0x10, 0x01, 0x82, 0x00, 0x0C,
  0x60, 0x00, 0x44, 0x00, 0x06, 0x40, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00,
  0x28, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x02, 0xC0, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x66, 0x00, 0x04, 0x20,
  0x00, 0xC1, 0x00, 0x18, 0x0C, 0x07, 0x00, 0x7F, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0xFF, 0xC2,
  0x01, 0xC8, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02,
  0x80, 0x1A, 0x00, 0x48, 0x06, 0x3F, 0xF0, 0x81, 0x82, 0x02, 0x08, 0x0C,
  0x20, 0x18, 0x80, 0x22, 0x00, 0xC8, 0x01, 0x20, 0x06, 0x80, 0x0E, 0x00,
  0x10, 0x1F, 0xFB, 0x00, 0x90, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x28, 0x07, 0x7F,
  0xE0, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x02, 0x60,
  0x06, 0x38, 0x0C, 0x0F, 0xF0, 0xC0, 0x00, 0xD0, 0x00, 0x24, 0x00, 0x19,
  0x80, 0x04, 0x20, 0x01, 0x08, 0x00, 0xC3, 0x00, 0x20, 0x40, 0x08, 0x18,
  0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x30, 0x20, 0x04, 0x08, 0x01, 0x06,
  0x00, 0x61, 0x00, 0x08, 0x40, 0x02, 0x20, 0x00, 0x48, 0x00, 0x16, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0xF0, 0x03,
  0x00, 0x24, 0x01, 0x40, 0x19, 0x00, 0x50, 0x06, 0x40, 0x16, 0x01, 0x18,
  0x0C, 0x80, 0x42, 0x02, 0x20, 0x30, 0x80, 0x88, 0x08, 0x20, 0x23, 0x02,
  0x04, 0x10, 0x40, 0x81, 0x04, 0x10, 0x60, 0x41, 0x04, 0x10, 0x18, 0xC0,
  0x84, 0x02, 0x20, 0x23, 0x00, 0x88, 0x08, 0x80, 0x22, 0x03, 0x20, 0x0D,
  0x80, 0x48, 0x01, 0x40, 0x16, 0x00, 0x50, 0x05, 0x00, 0x14, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x03, 0x20, 0x06, 0x30,
  0x04, 0x10, 0x08, 0x08, 0x18, 0x0C, 0x10, 0x04, 0x30, 0x06, 0x20, 0x03,
  0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x02, 0x40, 0x06, 0x20, 0x04,
  0x20, 0x0C, 0x10, 0x08, 0x18, 0x10, 0x08, 0x30, 0x04, 0x20, 0x06, 0x40,
  0x02, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x10,
  0x0C, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04, 0x20, 0x06, 0x60, 0x02,
  0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F,
  0xFE, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0F, 0xC0, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0xFC, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x1F, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x09, 0x00, 0x12,
  0x00, 0x42, 0x00, 0x84, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x08, 0x60, 0x10,
  0x80, 0x13, 0x00, 0x2C, 0x00, 0x20, 0xFF, 0xF8, 0xC1, 0x82, 0x04, 0x0C,
  0x03, 0x81, 0xE7, 0x08, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x0F, 0xF9, 0x80, 0xD8, 0x06, 0x80, 0x3C, 0x01, 0xA0, 0x0D, 0x00,
  0xEC, 0x09, 0x3F, 0x88, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0xF0, 0x98, 0xE5, 0x01, 0xB0, 0x05, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x01, 0xE0, 0x0A, 0x81, 0x93, 0xF8, 0x03, 0xC1, 0xE7, 0x30, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x01, 0x0F, 0xF0, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC1, 0xC3, 0x1C,
  0xEC, 0x80, 0xF4, 0x01, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x40, 0x1D, 0x80, 0x73,
  0x02, 0xC7, 0xF1, 0x07, 0x80, 0xE7, 0x08, 0x0C, 0x80, 0x24, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x02, 0x0F, 0xF0, 0x03, 0xC0, 0xCC, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xFF, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x07, 0x80, 0x73, 0xB2, 0x03, 0xD0, 0x07, 0x40,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0D, 0x00, 0x36, 0x01, 0xCC, 0x0B, 0x1F, 0xCC, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x64, 0x03, 0x1F, 0xF8, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x38, 0x98, 0xEA,
  0x03, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xD0, 0x05,
  0x55, 0x55, 0x55, 0x50, 0x0C, 0x10, 0x00, 0x00, 0x00, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x43, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x02, 0x80, 0x48, 0x08, 0x81, 0x08, 0x20, 0x86, 0x08, 0xC0, 0x98,
  0x0B, 0x80, 0xA4, 0x0C, 0x60, 0x83, 0x08, 0x10, 0x80, 0x88, 0x0C, 0x80,
  0x68, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0x03, 0xC5, 0xCE, 0x73, 0xA8, 0x16,
  0x07, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x08, 0x07, 0x09, 0xCE, 0xA0, 0x3C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x07, 0x80, 0x73, 0x82, 0x01, 0x10, 0x02, 0x40,
  0x0A, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x0D, 0x00, 0x26, 0x01, 0x8C, 0x0C, 0x0F, 0xC0, 0x07, 0x82,
  0x73, 0x8A, 0x03, 0x30, 0x06, 0xC0, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02,
  0x80, 0x0E, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0B, 0x00, 0x6E, 0x01,
  0x2C, 0x18, 0x9F, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x07, 0x80, 0xE7, 0x48, 0x0E, 0x80, 0x3C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x0D, 0x00, 0x66, 0x05, 0x1F, 0xC8, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x07, 0x9D, 0xA0, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x0F, 0x83, 0x8F, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x00, 0x38, 0x06,
  0x7F, 0xC0, 0x10, 0x08, 0x04, 0x02, 0x0F, 0xF8, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01,
  0xF0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03, 0x60, 0xD3,
  0xF9, 0xC0, 0x0D, 0x00, 0x24, 0x01, 0x88, 0x04, 0x20, 0x10, 0xC0, 0xC1,
  0x02, 0x04, 0x08, 0x18, 0x40, 0x21, 0x00, 0x8C, 0x01, 0x20, 0x04, 0x80,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x30, 0x0A, 0x01, 0x80, 0x58, 0x0E,
  0x06, 0x40, 0x90, 0x22, 0x04, 0x81, 0x10, 0x26, 0x08, 0xC3, 0x10, 0xC2,
  0x10, 0x84, 0x10, 0x86, 0x20, 0xCC, 0x11, 0x02, 0x40, 0x90, 0x12, 0x06,
  0x80, 0xB0, 0x14, 0x07, 0x00, 0xA0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0xC0,
  0x1B, 0x01, 0x8C, 0x18, 0x20, 0x80, 0x88, 0x06, 0xC0, 0x14, 0x00, 0x40,
  0x05, 0x00, 0x6C, 0x02, 0x20, 0x20, 0x83, 0x06, 0x10, 0x19, 0x00, 0x58,
  0x01, 0xC0, 0x0D, 0x00, 0x24, 0x01, 0x88, 0x04, 0x20, 0x10, 0xC0, 0xC1,
  0x02, 0x04, 0x08, 0x18, 0x40, 0x21, 0x00, 0x8C, 0x01, 0x20, 0x04, 0x80,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x0F, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x30, 0x06, 0x00, 0x40, 0x0F, 0xFF, 0x07, 0x86, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x06, 0x00, 0xC0,
  0x20, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x07,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x60, 0x1C, 0x18, 0x18,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x18, 0x30,
  0x00, 0xFE, 0x06, 0x07, 0xE0, 0x06, 0x00,
};

const GFXglyph NotoSans_ExtraLight31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 22, 7, 3, -22 },
  { 7, 6, 8, 10, 2, -22 },
  { 13, 18, 22, 20, 1, -22 },
  { 63, 13, 26, 18, 2, -24 },
  { 106, 21, 22, 25, 2, -22 },
  { 164, 19, 22, 22, 2, -22 },
  { 217, 2, 8, 6, 2, -22 },
  { 219, 6, 27, 8, 1, -22 },
  { 240, 6, 27, 8, 1, -22 },
  { 261, 13, 13, 17, 2, -24 },
  { 283, 14, 14, 18, 2, -18 },
  { 308, 3, 8, 6, 1, -4 },
  { 311, 8, 1, 10, 1, -9 },
  { 312, 2, 2, 7, 3, -2 },
  { 313, 10, 22, 10, 0, -22 },
  { 341, 14, 22, 18, 2, -22 },
  { 380, 7, 22, 18, 3, -22 },
  { 400, 13, 22, 18, 2, -22 },
  { 436, 14, 22, 18, 1, -22 },
  { 475, 16, 22, 18, 1, -22 },
  { 519, 14, 22, 18, 2, -22 },
  { 558, 14, 23, 18, 2, -23 },
  { 599, 14, 22, 18, 2, -22 },
  { 638, 14, 22, 18, 2, -22 },
  { 677, 14, 22, 18, 2, -22 },
  { 716, 2, 17, 7, 3, -17 },
  { 721, 4, 21, 7, 1, -17 },
  { 732, 14, 14, 18, 2, -18 },
  { 757, 14, 8, 18, 2, -15 },
  { 771, 14, 14, 18, 2, -18 },
  { 796, 11, 22, 13, 1, -22 },
  { 827, 24, 25, 27, 2, -22 },
  { 902, 18, 22, 18, 0, -22 },
  { 952, 15, 22, 19, 3, -22 },
  { 994, 16, 22, 19, 2, -22 },
  { 1038, 17, 22, 22, 3, -22 },
  { 1085, 12, 22, 17, 3, -22 },
  { 1118, 12, 22, 15, 3, -22 },
  { 1151, 18, 23, 22, 2, -23 },
  { 1203, 16, 22, 22, 3, -22 },
  { 1247, 5, 22, 9, 2, -22 },
  { 1261, 7, 27, 7, -3, -22 },
  { 1285, 15, 22, 18, 3, -22 },
  { 1327, 12, 22, 16, 3, -22 },
  { 1360, 20, 22, 26, 3, -22 },
  { 1415, 16, 22, 22, 3, -22 },
  { 1459, 20, 22, 24, 2, -22 },
  { 1514, 13, 22, 18, 3, -22 },
  { 1550, 20, 27, 24, 2, -22 },
  { 1618, 14, 22, 18, 3, -22 },
  { 1657, 13, 22, 17, 2, -22 },
  { 1693, 16, 22, 16, 0, -22 },
  { 1737, 16, 22, 22, 3, -22 },
  { 1781, 18, 22, 18, 0, -22 },
  { 1831, 26, 22, 27, 1, -22 },
  { 1903, 16, 22, 16, 0, -22 },
  { 1947, 16, 22, 16, 0, -22 },
  { 1991, 16, 22, 18, 1, -22 },
  { 2035, 6, 27, 10, 3, -22 },
  { 2056, 10, 22, 10, 0, -22 },
  { 2084, 6, 27, 10, 1, -22 },
  { 2105, 15, 13, 18, 1, -22 },
  { 2130, 13, 1, 12, 0, 3 },
  { 2132, 6, 5, 8, 1, -24 },
  { 2136, 13, 17, 16, 1, -17 },
  { 2164, 13, 24, 18, 3, -24 },
  { 2203, 12, 17, 15, 2, -17 },
  { 2229, 14, 24, 18, 2, -24 },
  { 2271, 13, 17, 17, 2, -17 },
  { 2299, 11, 24, 9, 0, -24 },
  { 2332, 14, 24, 18, 2, -17 },
  { 2374, 12, 24, 18, 3, -24 },
  { 2410, 2, 22, 7, 2, -22 },
  { 2416, 6, 29, 7, -2, -22 },
  { 2438, 12, 24, 15, 3, -24 },
  { 2474, 1, 24, 7, 3, -24 },
  { 2477, 21, 17, 27, 3, -17 },
  { 2522, 12, 17, 18, 3, -17 },
  { 2548, 14, 17, 18, 2, -17 },
  { 2578, 14, 24, 18, 3, -17 },
  { 2620, 13, 24, 18, 2, -17 },
  { 2659, 8, 17, 12, 3, -17 },
  { 2676, 12, 17, 14, 1, -17 },
  { 2702, 9, 20, 10, 0, -20 },
  { 2725, 12, 16, 18, 3, -16 },
  { 2749, 14, 16, 14, 0, -16 },
  { 2777, 21, 16, 22, 0, -16 },
  { 2819, 13, 16, 15, 1, -16 },
  { 2845, 14, 24, 14, 0, -16 },
  { 2887, 12, 16, 14, 1, -16 },
  { 2911, 9, 27, 11, 1, -22 },
  { 2942, 1, 32, 17, 8, -24 },
  { 2946, 9, 27, 11, 1, -22 },
  { 2977, 14, 3, 18, 2, -12 },
};

const GFXfont NotoSans_ExtraLight31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRALIGHT31PT7B_H_
