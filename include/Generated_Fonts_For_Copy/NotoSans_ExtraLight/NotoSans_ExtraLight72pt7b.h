#ifndef _NOTOSANS_EXTRALIGHT72PT7B_H_
#define _NOTOSANS_EXTRALIGHT72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight72pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xDE, 0xFF, 0xFC, 0xC0, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0x60, 0x0D, 0x80, 0x36, 0x00,
  0xD8, 0x03, 0x60, 0x0D, 0x80, 0x30, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0xEF, 0xFC, 0x1F, 0x07,
  0x01, 0xE1, 0xE0, 0x38, 0x03, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x38, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x78, 0x03, 0x80,
  0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00,
  0x7C, 0x38, 0x00, 0x01, 0xFD, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xEF,
  0xE0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x07, 0x00, 0x18, 0x00, 0x38,
  0x00, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03,
  0x80, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1E, 0x00,
  0x07, 0x01, 0xE6, 0x00, 0x38, 0x1E, 0x3F, 0x81, 0xC7, 0xE1, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x18,
  0x01, 0x00, 0x38, 0x00, 0x1C, 0x0E, 0x07, 0xFC, 0x06, 0x00, 0x07, 0x03,
  0x03, 0xFF, 0x81, 0xC0, 0x01, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0xE0,
  0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x0C,
  0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x06, 0x00, 0x0C, 0x1C, 0x03,
  0x83, 0x83, 0x80, 0x03, 0x83, 0xC3, 0xC0, 0xC0, 0xE0, 0x00, 0xE0, 0x7F,
  0xE0, 0x70, 0x38, 0x00, 0x38, 0x07, 0xF0, 0x18, 0x0C, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x03, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0x00, 0x38, 0x38,
  0x00, 0x03, 0xC0, 0x01, 0xC3, 0x80, 0x00, 0x0F, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x06, 0x00, 0x00,
  0x03, 0xC0, 0x70, 0x70, 0x00, 0x00, 0x0F, 0x03, 0x83, 0x80, 0x00, 0x00,
  0x3C, 0x38, 0x1C, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0xE0, 0x00, 0x00, 0x03,
  0xDC, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x1C, 0x00, 0x00, 0x01, 0xEF, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF6, 0xDB, 0x6C, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x06, 0x00, 0x0B, 0xC0, 0x0C, 0x00, 0xFF, 0xE0, 0x18,
  0x0F, 0xE7, 0xF8, 0x30, 0xFF, 0x81, 0xFE, 0x6F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x20, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xC3, 0x87,
  0x0C, 0x18, 0x70, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x77,
  0xBF, 0xFF, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x01, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3D, 0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0x70,
  0x1F, 0x38, 0x1E, 0x1C, 0x1E, 0x0E, 0x3E, 0x07, 0x3C, 0x03, 0xBC, 0x01,
  0xFC, 0x00, 0xE8, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0xE0, 0x10, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xF0, 0x03, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF1, 0x80, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x7F, 0x80, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x80, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x3F,
  0xFF, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xE1, 0xE0, 0x03, 0xE0, 0xE7, 0x80,
  0x00, 0xF0, 0xEF, 0x00, 0x00, 0x78, 0xCC, 0x00, 0x00, 0x3C, 0xD8, 0x00,
  0x00, 0x1C, 0xF8, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x06, 0x38, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x0F,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1B, 0x38, 0x00, 0x00, 0x3F,
  0x1C, 0x00, 0x00, 0x77, 0x1E, 0x00, 0x00, 0xE7, 0x0F, 0x80, 0x03, 0xC7,
  0x07, 0xE0, 0x1F, 0x87, 0x01, 0xFF, 0xFE, 0x07, 0x00, 0x7F, 0xF8, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x10, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x27, 0xBF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xEF, 0xFF,
  0xCC, 0x04, 0x1E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x3F, 0xFB, 0xFE, 0x0F, 0x00, 0x0F,
  0x84, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x1C, 0x38, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0C, 0x38, 0x00, 0x0F,
  0x80, 0x0E, 0x00, 0x0E, 0x30, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x0E, 0x70,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x0E, 0x70, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x06, 0x60, 0x00, 0x70, 0x00, 0x06, 0x00, 0x06, 0x60, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07,
  0xE0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x07, 0xC0, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x06, 0xC0, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x06, 0xC0,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x06, 0xC0, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x0E, 0xC0, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x0E, 0xE0, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x0C, 0xE0, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x1C, 0xE0, 0x01,
  0xC0, 0x00, 0x36, 0x00, 0x1C, 0xE0, 0x00, 0xE0, 0x00, 0x76, 0x00, 0x38,
  0x60, 0x00, 0xF0, 0x00, 0x67, 0x00, 0x38, 0x70, 0x00, 0x78, 0x01, 0xC3,
  0x00, 0x70, 0x70, 0x00, 0x3E, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x38, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0E, 0x00, 0x01, 0xFF, 0x03, 0x80, 0x00, 0x03, 0xE0, 0xE0, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x00, 0x7C, 0x0E, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x38, 0x00, 0x07, 0xF8, 0x0E, 0x00, 0x00, 0x0F, 0x83,
  0x80, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x07,
  0xC3, 0x80, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x01, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x10, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0xE0,
  0x1C, 0x00, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x00, 0x3F,
  0x00, 0x70, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0xFF,
  0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC8, 0x07, 0xC7, 0xFF, 0xC3, 0xFF, 0xC0,
  0x3E, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x38, 0x3E, 0x00, 0x00, 0x0E,
  0x1F, 0x80, 0x00, 0x03, 0x8F, 0xF0, 0x00, 0x00, 0xE3, 0x9E, 0x00, 0x00,
  0x39, 0xC3, 0x80, 0x00, 0x0E, 0xE0, 0x70, 0x00, 0x03, 0xF0, 0x1E, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFD, 0xC0, 0x00, 0x00, 0x00,
  0x1D, 0xF9, 0x80, 0x00, 0x00, 0x00, 0x3B, 0xF3, 0x80, 0x00, 0x00, 0x00,
  0xE7, 0xE7, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xC7, 0x00, 0x00, 0x00, 0x03,
  0x1F, 0x8E, 0x00, 0x00, 0x00, 0x0E, 0x3F, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x7E, 0x1C, 0x00, 0x00, 0x00, 0x70, 0xFC, 0x38, 0x00, 0x00, 0x00, 0xE1,
  0xF8, 0x38, 0x00, 0x00, 0x01, 0x83, 0xF0, 0x70, 0x00, 0x00, 0x07, 0x07,
  0xE0, 0x60, 0x00, 0x00, 0x0E, 0x0F, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x1F,
  0x81, 0xC0, 0x00, 0x00, 0x70, 0x3F, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x7E,
  0x03, 0x80, 0x00, 0x03, 0x80, 0xFC, 0x03, 0x00, 0x00, 0x07, 0x01, 0xF8,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x07, 0xE0,
  0x0E, 0x00, 0x00, 0x60, 0x0F, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1F, 0x80,
  0x1C, 0x00, 0x03, 0x80, 0x3F, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x7E, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x30, 0x01, 0xF8, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0x80, 0x03,
  0x80, 0x18, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1F, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0x00, 0xFC, 0xE0,
  0x00, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x01,
  0xF8, 0x70, 0x00, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x00, 0x7E, 0x0F, 0x00,
  0x00, 0x03, 0xF0, 0x38, 0x00, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x00, 0xFC,
  0x07, 0x80, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x70, 0x00,
  0x01, 0xF8, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x0E, 0x00, 0x00, 0x7E, 0x00,
  0x38, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x00,
  0xFC, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0x80, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x3F, 0x00,
  0x00, 0x1E, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0x01, 0xC0,
  0x7E, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x1F, 0x80, 0x00,
  0x00, 0xE0, 0xFC, 0x00, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x00, 0x1E, 0x3F,
  0x00, 0x00, 0x00, 0x71, 0xF8, 0x00, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x00,
  0x0F, 0x7E, 0x00, 0x00, 0x00, 0x3B, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x02, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x01, 0xFE, 0x07, 0x00, 0x00, 0x3F,
  0x0E, 0x00, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x0F, 0x83, 0x80, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x02, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x38,
  0x00, 0x1F, 0xF0, 0x1C, 0x00, 0x00, 0x7C, 0x0E, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0xC0, 0x70, 0x00,
  0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x00, 0x83, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xE1, 0xFC, 0x00, 0x1F, 0x83,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x38,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x18, 0x00, 0x38, 0x00, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18,
  0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x38, 0x60,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x60, 0x00, 0x3C, 0x02, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x70, 0x3F, 0x80, 0x03, 0x87, 0xC0, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x1F, 0x70, 0x00,
  0x01, 0xBB, 0x80, 0x00, 0x1D, 0xCE, 0x00, 0x01, 0xCE, 0x78, 0x00, 0x1C,
  0x71, 0xF0, 0x03, 0xC3, 0x87, 0xFF, 0xFC, 0x1C, 0x0F, 0xFF, 0x80, 0xE0,
  0x07, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xF8, 0x00, 0xE0,
  0x3F, 0xFF, 0x00, 0xE0, 0xFF, 0xFF, 0x80, 0xE1, 0xE0, 0x03, 0xE0, 0xE3,
  0x80, 0x00, 0xF0, 0xE7, 0x00, 0x00, 0x78, 0xEE, 0x00, 0x00, 0x38, 0xEC,
  0x00, 0x00, 0x1C, 0xFC, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x0E, 0xF8,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF8, 0x00, 0x00, 0x1C, 0xF8,
  0x00, 0x00, 0x1C, 0xFC, 0x00, 0x00, 0x38, 0xEE, 0x00, 0x00, 0x78, 0xE7,
  0x00, 0x00, 0xF0, 0xE7, 0x80, 0x01, 0xE0, 0xE3, 0xE0, 0x0F, 0xC0, 0xE0,
  0xFF, 0xFF, 0x80, 0xE0, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0x80,
  0x07, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0x01, 0xF8, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x07, 0xF0, 0x07, 0x00, 0x3F, 0xFE, 0x07, 0x00, 0xFF, 0xFF, 0x87, 0x03,
  0xF0, 0x03, 0xC7, 0x07, 0xC0, 0x00, 0xE7, 0x0F, 0x00, 0x00, 0x77, 0x0E,
  0x00, 0x00, 0x37, 0x1C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x1F, 0x38,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0x1B, 0x1E,
  0x00, 0x00, 0x33, 0x0F, 0x00, 0x00, 0x73, 0x07, 0x80, 0x00, 0xE3, 0x03,
  0xF0, 0x07, 0xC3, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x7F, 0xFE, 0x03, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x1F,
  0x80, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x9F, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x03, 0x00, 0xFF, 0xFF, 0x83, 0x03,
  0xF0, 0x03, 0xC3, 0x07, 0x80, 0x00, 0xE7, 0x0F, 0x00, 0x00, 0x77, 0x0E,
  0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x1F, 0x38,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0x3F, 0x1E,
  0x00, 0x00, 0x37, 0x0F, 0x00, 0x00, 0x77, 0x07, 0x80, 0x01, 0xE7, 0x03,
  0xF0, 0x07, 0xC7, 0x01, 0xFF, 0xFF, 0x07, 0x00, 0x7F, 0xFE, 0x07, 0x00,
  0x07, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0x80,
  0xFF, 0xFC, 0x0E, 0x0F, 0xFF, 0xF8, 0x38, 0x78, 0x01, 0xF0, 0xE3, 0x80,
  0x01, 0xE3, 0x9C, 0x00, 0x03, 0xCE, 0xE0, 0x00, 0x07, 0xBB, 0x00, 0x00,
  0x0E, 0xF8, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xCC, 0x3E, 0x3F, 0xF0, 0xFF,
  0x80, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x2E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0xE1, 0xF8, 0x00, 0x0E, 0x3B, 0x80, 0x00, 0xE7, 0x9C, 0x00, 0x0E, 0x70,
  0xE0, 0x00, 0xEE, 0x0F, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0xF8, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x1C, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x03,
  0x87, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x71, 0xE0, 0x0F, 0x83, 0xE0, 0x0F,
  0x8E, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x71, 0xDC, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x3B, 0x00, 0x00, 0x77, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0E, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1B, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x03,
  0x80, 0xFF, 0xFC, 0x0E, 0x0F, 0xFF, 0xF8, 0x38, 0x78, 0x01, 0xF0, 0xE3,
  0x80, 0x01, 0xE3, 0x9C, 0x00, 0x03, 0xCE, 0xE0, 0x00, 0x07, 0xBB, 0x00,
  0x00, 0x0E, 0xF8, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0x00, 0x6F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xE0, 0x3F, 0xFF, 0x00, 0xE0, 0xFF, 0xFF,
  0xC0, 0xE1, 0xE0, 0x03, 0xE0, 0xE3, 0xC0, 0x00, 0xF0, 0xE7, 0x00, 0x00,
  0x78, 0xE6, 0x00, 0x00, 0x38, 0xEC, 0x00, 0x00, 0x1C, 0xFC, 0x00, 0x00,
  0x1C, 0xF8, 0x00, 0x00, 0x0E, 0xF8, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF8, 0x00, 0x00,
  0x0E, 0xF8, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x1C, 0xEC, 0x00, 0x00,
  0x38, 0xEE, 0x00, 0x00, 0x78, 0xE7, 0x00, 0x00, 0xF0, 0xE3, 0x80, 0x01,
  0xE0, 0xE1, 0xF0, 0x07, 0xC0, 0xE0, 0xFF, 0xFF, 0x80, 0xE0, 0x3F, 0xFE,
  0x00, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x03, 0x00, 0xFF, 0xFF, 0x83, 0x03, 0xE0, 0x03,
  0xC7, 0x07, 0x80, 0x00, 0xE7, 0x0F, 0x00, 0x00, 0x77, 0x0E, 0x00, 0x00,
  0x37, 0x1C, 0x00, 0x00, 0x3F, 0x38, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00,
  0x0F, 0x30, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x1F, 0x38, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00,
  0x77, 0x0F, 0x00, 0x00, 0xE7, 0x07, 0x80, 0x01, 0xC7, 0x03, 0xE0, 0x07,
  0x87, 0x01, 0xFF, 0xFF, 0x07, 0x00, 0x7F, 0xFC, 0x07, 0x00, 0x0F, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xCE, 0x07, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3E, 0x01, 0xE7, 0x80, 0x0E, 0x60, 0x00, 0xEC, 0x00, 0x0E, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x07, 0xC0, 0x03, 0xE1, 0xC0, 0x00, 0x08,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3A, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xCF, 0xC0, 0x01, 0xF1,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x07, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFC, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x1B,
  0x78, 0x00, 0x01, 0xD9, 0xE0, 0x00, 0x1C, 0xC7, 0x80, 0x03, 0xC6, 0x3F,
  0x00, 0x7C, 0x30, 0x7F, 0xFF, 0xC1, 0x81, 0xFF, 0xF8, 0x0C, 0x00, 0x7C,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x18,
  0x00, 0x06, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x87, 0x00, 0x07, 0x03, 0x80, 0x01, 0x83, 0x80, 0x03, 0x80,
  0xE0, 0x01, 0xC1, 0xC0, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x0C,
  0x00, 0x38, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x06, 0x03, 0x80, 0x06, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x81,
  0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60,
  0xE0, 0x00, 0x30, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x30, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x77, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x83,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x5F, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE3, 0xF4, 0x00, 0x01, 0xFF, 0xF2, 0x00,
  0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraLight72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 52, 17, 6, -51 },
  { 34, 14, 18, 24, 5, -51 },
  { 66, 43, 51, 47, 2, -51 },
  { 341, 29, 59, 41, 5, -55 },
  { 555, 50, 53, 58, 4, -52 },
  { 887, 45, 53, 51, 4, -52 },
  { 1186, 3, 18, 13, 5, -51 },
  { 1193, 14, 62, 19, 3, -51 },
  { 1302, 13, 62, 19, 3, -51 },
  { 1403, 31, 30, 40, 4, -55 },
  { 1520, 33, 33, 41, 4, -42 },
  { 1657, 7, 17, 14, 3, -8 },
  { 1672, 17, 3, 23, 3, -21 },
  { 1679, 5, 6, 17, 6, -5 },
  { 1683, 22, 51, 24, 1, -51 },
  { 1824, 33, 53, 41, 4, -52 },
  { 2043, 17, 51, 41, 7, -51 },
  { 2152, 32, 52, 41, 4, -52 },
  { 2360, 33, 53, 41, 3, -52 },
  { 2579, 38, 52, 41, 2, -52 },
  { 2826, 32, 52, 41, 5, -51 },
  { 3034, 32, 53, 41, 5, -52 },
  { 3246, 33, 51, 41, 4, -51 },
  { 3457, 33, 53, 41, 4, -52 },
  { 3676, 32, 53, 41, 4, -52 },
  { 3888, 5, 40, 17, 6, -39 },
  { 3913, 8, 48, 17, 3, -39 },
  { 3961, 33, 32, 41, 4, -42 },
  { 4093, 33, 17, 41, 4, -34 },
  { 4164, 33, 32, 41, 4, -42 },
  { 4296, 25, 53, 30, 2, -52 },
  { 4462, 56, 58, 64, 4, -51 },
  { 4868, 42, 52, 42, 0, -52 },
  { 5141, 34, 51, 45, 7, -51 },
  { 5358, 37, 53, 45, 5, -52 },
  { 5604, 39, 51, 50, 7, -51 },
  { 5853, 28, 51, 40, 7, -51 },
  { 6032, 28, 51, 36, 7, -51 },
  { 6211, 41, 53, 52, 5, -52 },
  { 6483, 37, 51, 51, 7, -51 },
  { 6719, 13, 51, 21, 4, -51 },
  { 6802, 17, 64, 17, -7, -51 },
  { 6938, 34, 51, 41, 7, -51 },
  { 7155, 28, 51, 37, 7, -51 },
  { 7334, 47, 51, 61, 7, -51 },
  { 7634, 37, 51, 51, 7, -51 },
  { 7870, 45, 53, 55, 5, -52 },
  { 8169, 31, 51, 42, 7, -51 },
  { 8367, 45, 64, 55, 5, -52 },
  { 8727, 33, 51, 42, 7, -51 },
  { 8938, 31, 53, 39, 4, -52 },
  { 9144, 37, 51, 37, 0, -51 },
  { 9380, 38, 52, 52, 7, -51 },
  { 9627, 41, 51, 41, 0, -51 },
  { 9889, 60, 51, 63, 2, -51 },
  { 10272, 38, 51, 38, 0, -51 },
  { 10515, 37, 51, 37, 0, -51 },
  { 10751, 36, 51, 42, 3, -51 },
  { 10981, 15, 62, 23, 6, -51 },
  { 11098, 22, 51, 24, 1, -51 },
  { 11239, 15, 62, 23, 2, -51 },
  { 11356, 35, 32, 41, 3, -52 },
  { 11496, 29, 2, 29, 0, 7 },
  { 11504, 13, 11, 18, 3, -55 },
  { 11522, 29, 40, 38, 3, -39 },
  { 11667, 32, 56, 42, 6, -55 },
  { 11891, 28, 40, 34, 4, -39 },
  { 12031, 32, 56, 42, 4, -55 },
  { 12255, 31, 40, 39, 4, -39 },
  { 12410, 24, 55, 21, 1, -55 },
  { 12575, 32, 56, 42, 4, -39 },
  { 12799, 30, 55, 42, 6, -55 },
  { 13006, 4, 52, 16, 6, -52 },
  { 13032, 14, 69, 16, -4, -52 },
  { 13153, 28, 55, 34, 6, -55 },
  { 13346, 3, 55, 16, 6, -55 },
  { 13367, 51, 39, 63, 6, -39 },
  { 13616, 30, 39, 42, 6, -39 },
  { 13763, 34, 40, 42, 4, -39 },
  { 13933, 32, 56, 42, 6, -39 },
  { 14157, 32, 56, 42, 4, -39 },
  { 14381, 20, 39, 28, 6, -39 },
  { 14479, 27, 40, 33, 3, -39 },
  { 14614, 21, 48, 24, 1, -47 },
  { 14740, 29, 39, 42, 6, -38 },
  { 14882, 32, 38, 32, 0, -38 },
  { 15034, 49, 38, 51, 1, -38 },
  { 15267, 31, 38, 35, 2, -38 },
  { 15415, 32, 55, 32, 0, -38 },
  { 15635, 27, 38, 33, 3, -38 },
  { 15764, 20, 62, 25, 2, -51 },
  { 15919, 3, 73, 39, 18, -55 },
  { 15947, 20, 62, 25, 3, -51 },
  { 16102, 33, 7, 41, 4, -29 },
};

const GFXfont NotoSans_ExtraLight72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRALIGHT72PT7B_H_
