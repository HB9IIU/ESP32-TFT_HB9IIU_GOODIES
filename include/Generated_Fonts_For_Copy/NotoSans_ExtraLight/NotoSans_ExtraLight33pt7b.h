#ifndef _NOTOSANS_EXTRALIGHT33PT7B_H_
#define _NOTOSANS_EXTRALIGHT33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFA, 0xAA, 0xA0, 0x0F, 0xC7, 0x8F, 0x1E, 0x1C, 0x28,
  0x50, 0xA1, 0x42, 0x00, 0x81, 0x00, 0x30, 0x20, 0x04, 0x04, 0x00, 0x81,
  0x80, 0x10, 0x20, 0x02, 0x04, 0x00, 0xC0, 0x80, 0x10, 0x10, 0x7F, 0xFF,
  0xE0, 0x40, 0x80, 0x08, 0x10, 0x01, 0x02, 0x00, 0x60, 0x40, 0x08, 0x18,
  0x01, 0x02, 0x00, 0x20, 0x40, 0xFF, 0xFF, 0xC1, 0x81, 0x00, 0x20, 0x20,
  0x04, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x06, 0x04, 0x00, 0x81, 0x80,
  0x02, 0x00, 0x08, 0x00, 0xFE, 0x0C, 0x8E, 0x62, 0x03, 0x08, 0x08, 0x20,
  0x20, 0x80, 0xC2, 0x03, 0x08, 0x06, 0x20, 0x0E, 0x80, 0x0E, 0x00, 0x0F,
  0x00, 0x27, 0x00, 0x86, 0x02, 0x08, 0x08, 0x30, 0x20, 0x40, 0x83, 0x02,
  0x0C, 0x08, 0x28, 0x23, 0x3F, 0xF8, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x40, 0xC6, 0x00, 0x81, 0x04, 0x02, 0x06, 0x0C, 0x0C, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x60, 0x20, 0x20, 0x80, 0x40, 0x42, 0x00, 0x80,
  0x84, 0x01, 0x01, 0x10, 0x02, 0x02, 0x27, 0xE6, 0x0C, 0x98, 0x44, 0x13,
  0x20, 0x4C, 0x44, 0x40, 0x87, 0x19, 0x81, 0x00, 0x23, 0x02, 0x00, 0xC6,
  0x06, 0x01, 0x0C, 0x0C, 0x04, 0x18, 0x10, 0x08, 0x10, 0x20, 0x20, 0x20,
  0x40, 0xC0, 0x40, 0x81, 0x00, 0x42, 0x06, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0xC3, 0x00, 0x18, 0x18, 0x01, 0x00, 0x80, 0x30, 0x08, 0x03, 0x00, 0x80,
  0x10, 0x08, 0x01, 0x01, 0x80, 0x08, 0x30, 0x00, 0xC6, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x19, 0x80, 0x03, 0x0C, 0x03, 0x60, 0x60, 0x2C, 0x03,
  0x02, 0xC0, 0x18, 0x48, 0x00, 0xC4, 0x80, 0x06, 0x88, 0x00, 0x38, 0xC0,
  0x03, 0x86, 0x00, 0x6C, 0x30, 0x18, 0x61, 0xFF, 0x03, 0xFF, 0xD5, 0x40,
  0x06, 0x18, 0x20, 0x81, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x60,
  0x40, 0x60, 0xC1, 0x02, 0x0C, 0x10, 0x60, 0x82, 0x0C, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x30, 0x86, 0x10, 0x42, 0x18, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x81, 0x07, 0x84, 0x71, 0xDE,
  0x00, 0xC0, 0x07, 0x80, 0x12, 0x00, 0x84, 0x06, 0x18, 0x30, 0x30, 0x40,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x32, 0x26, 0x64, 0x4C, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x07, 0xC0,
  0x38, 0xE0, 0xC0, 0x61, 0x00, 0x44, 0x00, 0xC8, 0x00, 0xB0, 0x01, 0x60,
  0x02, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x09, 0x00, 0x12, 0x00, 0x26,
  0x00, 0x86, 0x03, 0x06, 0x0C, 0x07, 0xF0, 0x01, 0x07, 0x0D, 0x19, 0x61,
  0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x0F, 0x80, 0xE3, 0x8E, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x3F,
  0xFF, 0x0F, 0xC1, 0xE1, 0xCC, 0x01, 0xA0, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x40, 0x06, 0x07, 0xE0, 0x00, 0xF0,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x6C, 0x03, 0x1F, 0xF8, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x05, 0x00, 0x04, 0x80, 0x04, 0x40, 0x06, 0x20, 0x02, 0x10,
  0x02, 0x08, 0x03, 0x04, 0x03, 0x02, 0x01, 0x01, 0x01, 0x00, 0x81, 0x80,
  0x41, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x7F, 0xFF, 0xC0, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x3F, 0xF8,
  0x7F, 0xF0, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0x81, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x03, 0x30, 0x0C, 0x3F, 0xF0, 0x01, 0xF8, 0x0E, 0x08, 0x30,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x81, 0x03, 0x3F, 0xC4, 0x80, 0x4A, 0x00, 0x58, 0x00, 0xB0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x32, 0x00, 0x46, 0x01,
  0x86, 0x06, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x07, 0xC0, 0x30, 0xE0, 0x80, 0x63, 0x00, 0x64, 0x00, 0x48, 0x00,
  0x90, 0x01, 0x20, 0x06, 0x20, 0x18, 0x60, 0x60, 0x3B, 0x80, 0x1C, 0x00,
  0xCE, 0x06, 0x03, 0x18, 0x03, 0x20, 0x02, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x4C, 0x01, 0x8C, 0x06, 0x0F, 0xF0, 0x0F, 0x80,
  0x78, 0xC1, 0x80, 0x42, 0x00, 0x4C, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x40,
  0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1A, 0x00, 0x76, 0x01, 0x66, 0x0C,
  0x83, 0xF1, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x3F, 0xC0, 0xBC, 0x00, 0x00, 0x00, 0xF0,
  0x23, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x32, 0x26, 0x64, 0x4C, 0x00,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00,
  0x3F, 0x0F, 0x1C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x03, 0x03, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x31, 0x00, 0x00, 0x09, 0x80, 0x7C, 0x06, 0x80, 0xE1,
  0x81, 0xC0, 0xC0, 0x40, 0xC0, 0x40, 0x20, 0x60, 0x40, 0x10, 0x30, 0x20,
  0x18, 0x18, 0x10, 0x0C, 0x0C, 0x08, 0x06, 0x06, 0x04, 0x03, 0x03, 0x02,
  0x01, 0x81, 0x81, 0x01, 0x41, 0x40, 0x41, 0xA1, 0xB0, 0x3F, 0x8F, 0x88,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x58, 0x00, 0x09, 0x00, 0x03, 0x20,
  0x00, 0x46, 0x00, 0x18, 0x40, 0x02, 0x0C, 0x00, 0x40, 0x80, 0x18, 0x10,
  0x02, 0x03, 0x00, 0x40, 0x20, 0x10, 0x04, 0x03, 0xFF, 0xC0, 0xC0, 0x08,
  0x10, 0x01, 0x82, 0x00, 0x10, 0xC0, 0x02, 0x10, 0x00, 0x66, 0x00, 0x04,
  0x80, 0x00, 0x90, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x80, 0xFF, 0xF8, 0xC0,
  0x0C, 0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x18, 0xFF, 0xE0, 0xC0, 0x78, 0xC0, 0x04, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x38, 0xFF, 0xE0, 0x00, 0xFE, 0x01, 0xC3, 0xC3,
  0x00, 0x23, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x02, 0x07, 0xFE, 0xFE, 0x00,
  0x3F, 0xFC, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x30, 0x00, 0x6C,
  0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xB0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x02, 0x30, 0x03, 0x0C,
  0x07, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFC,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0x00, 0x78, 0x3C, 0x38, 0x00, 0x8C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x03, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x40, 0x00, 0x28, 0x00, 0x05, 0x80, 0x00, 0x90, 0x00, 0x13, 0x00, 0x02,
  0x30, 0x00, 0x41, 0xC0, 0x18, 0x0F, 0xFE, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x8C, 0xF8, 0xC0, 0x03,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xC0,
  0xC1, 0x80, 0xC3, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0xDE, 0x00, 0xF2, 0x00,
  0xE1, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0xC0, 0x60, 0xC0, 0x30,
  0xC0, 0x18, 0xC0, 0x08, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xD0, 0x00, 0x2F, 0x40, 0x00, 0xBD, 0x80, 0x06, 0xF2, 0x00, 0x13, 0xCC,
  0x00, 0xCF, 0x10, 0x02, 0x3C, 0x40, 0x08, 0xF1, 0x80, 0x63, 0xC2, 0x01,
  0x0F, 0x0C, 0x0C, 0x3C, 0x10, 0x20, 0xF0, 0x40, 0x83, 0xC1, 0x86, 0x0F,
  0x02, 0x10, 0x3C, 0x0C, 0xC0, 0xF0, 0x12, 0x03, 0xC0, 0x48, 0x0F, 0x01,
  0xE0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x1D, 0x00, 0x0E, 0xC0, 0x07, 0x30, 0x03, 0x88, 0x01,
  0xC6, 0x00, 0xE1, 0x80, 0x70, 0x40, 0x38, 0x30, 0x1C, 0x0C, 0x0E, 0x02,
  0x07, 0x01, 0x83, 0x80, 0x61, 0xC0, 0x10, 0xE0, 0x0C, 0x70, 0x03, 0x38,
  0x00, 0x9C, 0x00, 0x2E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0x01, 0xFC,
  0x00, 0x3C, 0x38, 0x03, 0x00, 0x70, 0x20, 0x00, 0x83, 0x00, 0x02, 0x30,
  0x00, 0x19, 0x00, 0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x40, 0x00, 0x12, 0x00, 0x00, 0x98, 0x00, 0x0C,
  0x40, 0x00, 0x43, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x38, 0x0E, 0x00, 0x7F,
  0xC0, 0xFE, 0x03, 0xFF, 0x8C, 0x01, 0xB0, 0x02, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x06, 0xC0, 0x73,
  0xFF, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0xFC, 0x00, 0x3C, 0x38,
  0x03, 0x00, 0x70, 0x20, 0x00, 0x83, 0x00, 0x02, 0x30, 0x00, 0x19, 0x00,
  0x00, 0x48, 0x00, 0x02, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x40, 0x00, 0x12, 0x00, 0x00, 0x98, 0x00, 0x0C, 0x40, 0x00, 0x43,
  0x00, 0x06, 0x0C, 0x00, 0x60, 0x38, 0x0E, 0x00, 0x7F, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0xFF, 0x00, 0xFF, 0xF0, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x04,
  0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x08,
  0xC0, 0x30, 0xFF, 0xE0, 0xFF, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0xC0, 0x20,
  0xC0, 0x30, 0xC0, 0x10, 0xC0, 0x18, 0xC0, 0x08, 0xC0, 0x04, 0xC0, 0x06,
  0xC0, 0x03, 0x07, 0xE0, 0xF0, 0xF6, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x68, 0x03, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x2C, 0x00, 0x09, 0x00, 0x02, 0x60, 0x01, 0x0C, 0x00,
  0xC1, 0x80, 0xE0, 0x3F, 0xE0, 0x80, 0x00, 0x78, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x62, 0x00, 0x08, 0x40, 0x01, 0x0C, 0x00, 0x60, 0x80, 0x08,
  0x10, 0x03, 0x03, 0x00, 0x40, 0x20, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x40,
  0x08, 0x08, 0x01, 0x83, 0x00, 0x10, 0x40, 0x02, 0x18, 0x00, 0x62, 0x00,
  0x04, 0x40, 0x00, 0x98, 0x00, 0x1A, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00,
  0x02, 0x00, 0x80, 0x04, 0x00, 0x38, 0x00, 0x80, 0x05, 0x00, 0x38, 0x01,
  0xA0, 0x05, 0x00, 0x24, 0x00, 0xA0, 0x04, 0xC0, 0x36, 0x01, 0x88, 0x04,
  0x40, 0x31, 0x00, 0x88, 0x04, 0x20, 0x11, 0x00, 0x86, 0x06, 0x30, 0x30,
  0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81, 0x86, 0x0C, 0x10, 0x30, 0x80,
  0x86, 0x02, 0x10, 0x10, 0x80, 0x42, 0x02, 0x10, 0x0C, 0xC0, 0x66, 0x00,
  0x90, 0x04, 0xC0, 0x12, 0x00, 0x90, 0x02, 0x40, 0x12, 0x00, 0x78, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x40,
  0x01, 0xB0, 0x00, 0x88, 0x00, 0x82, 0x00, 0xC1, 0x80, 0x40, 0x40, 0x60,
  0x10, 0x60, 0x0C, 0x20, 0x02, 0x30, 0x01, 0x90, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0B, 0x00, 0x0C, 0x80, 0x0C, 0x60, 0x04, 0x18, 0x06,
  0x04, 0x02, 0x03, 0x02, 0x00, 0x83, 0x00, 0x21, 0x00, 0x19, 0x00, 0x05,
  0x80, 0x01, 0x80, 0x00, 0xA0, 0x00, 0xD8, 0x00, 0x44, 0x00, 0x43, 0x00,
  0x60, 0x80, 0x20, 0x60, 0x30, 0x10, 0x10, 0x0C, 0x18, 0x02, 0x08, 0x01,
  0x8C, 0x00, 0x44, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x03, 0xFF, 0xFC, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x00, 0x80, 0x01,
  0xC0, 0x01, 0x40, 0x03, 0x60, 0x02, 0x20, 0x06, 0x30, 0x04, 0x10, 0x0C,
  0x18, 0x08, 0x08, 0x18, 0x0C, 0x10, 0x04, 0x30, 0x06, 0x20, 0x02, 0x40,
  0x03, 0xC0, 0x01, 0xFF, 0xF8, 0xC0, 0x81, 0x06, 0x04, 0x07, 0x87, 0xCE,
  0x40, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x07, 0xF3, 0x81,
  0x60, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0xC0, 0xD3, 0xF9,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x43, 0xE0, 0x9C, 0x71, 0x60, 0x33, 0x80, 0x26, 0x00, 0x6C, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x2C, 0x00, 0xD8, 0x01, 0x28, 0x06, 0x58, 0x18, 0x8F, 0xE0, 0x03,
  0xE0, 0x71, 0xCC, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x18, 0x08, 0x7F, 0x80, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x83, 0xE3, 0x1C, 0x76, 0x60, 0x2D,
  0x80, 0x3A, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x68, 0x01, 0xD8, 0x03,
  0x98, 0x1B, 0x1F, 0xE6, 0x07, 0xC0, 0x79, 0x83, 0x01, 0x18, 0x02, 0x40,
  0x0B, 0x00, 0x3C, 0x00, 0x60, 0x01, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x38, 0x08, 0x3F, 0xE0,
  0x03, 0xF0, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0xFF, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x07, 0xC0, 0x38, 0xEC, 0xC0, 0x7B, 0x00, 0x74, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xD0, 0x03, 0xB0, 0x07, 0x30, 0x36, 0x1F, 0xCC,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x20, 0x0C, 0x78,
  0x70, 0x3F, 0x80, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0xF8, 0x9C, 0xF5, 0x00, 0xB0, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0xB0, 0x02, 0xAA, 0xAA,
  0xAA, 0xAA, 0x04, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0xA2, 0x78, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x02, 0x80, 0x64, 0x02, 0x20, 0x21,
  0x02, 0x08, 0x20, 0x43, 0x02, 0x30, 0x13, 0x00, 0xB4, 0x07, 0x30, 0x30,
  0xC1, 0x02, 0x08, 0x08, 0x40, 0x62, 0x01, 0x90, 0x04, 0x80, 0x18, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0x81, 0xF1, 0x31, 0x8E, 0x32, 0x80, 0xB0, 0x16,
  0x01, 0xC0, 0x3C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x07, 0xC4, 0xE7, 0xA8, 0x05,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x07, 0xC0, 0x38, 0xE0, 0xC0, 0x63, 0x00, 0x64, 0x00, 0x58, 0x00,
  0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x68, 0x00, 0xD0, 0x01, 0x10, 0x06, 0x18, 0x18, 0x1F, 0xC0, 0x07,
  0xC1, 0x38, 0xE2, 0xC0, 0x65, 0x00, 0x4C, 0x00, 0xD8, 0x00, 0xA0, 0x01,
  0x40, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x2C, 0x00, 0x58,
  0x00, 0xB0, 0x03, 0x50, 0x0C, 0xB0, 0x31, 0x1F, 0xC2, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00,
  0x07, 0xC0, 0x71, 0x93, 0x01, 0x58, 0x03, 0x40, 0x0F, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x14, 0x00, 0xD8, 0x07, 0x30, 0x34, 0x7F, 0x90, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x07, 0xCE,
  0xE8, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x00, 0x0F, 0xC1, 0xC3, 0x98, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x18, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0xC0, 0x33, 0xFE,
  0x00, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x3F, 0xF1, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x60, 0x08, 0x03, 0xF0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0F, 0x00, 0xAC, 0x0D, 0x3F, 0x88, 0xC0, 0x06, 0x80,
  0x09, 0x00, 0x31, 0x00, 0x42, 0x01, 0x86, 0x02, 0x04, 0x04, 0x08, 0x18,
  0x18, 0x20, 0x10, 0x40, 0x31, 0x80, 0x22, 0x00, 0x4C, 0x00, 0xD0, 0x00,
  0xA0, 0x01, 0xC0, 0x01, 0x00, 0xC0, 0x18, 0x06, 0x80, 0x30, 0x09, 0x80,
  0xA0, 0x11, 0x01, 0x60, 0x62, 0x02, 0x40, 0x86, 0x0C, 0x81, 0x0C, 0x11,
  0x82, 0x08, 0x21, 0x0C, 0x10, 0xC2, 0x10, 0x31, 0x06, 0x20, 0x22, 0x04,
  0x40, 0x4C, 0x09, 0x80, 0x90, 0x1A, 0x01, 0xA0, 0x14, 0x01, 0xC0, 0x28,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x40, 0xC0, 0x0D, 0x80, 0x43, 0x03, 0x04,
  0x08, 0x08, 0x40, 0x33, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x1E, 0x00,
  0xCC, 0x02, 0x10, 0x10, 0x20, 0xC0, 0xC2, 0x01, 0x10, 0x02, 0xC0, 0x0C,
  0xC0, 0x06, 0x80, 0x09, 0x80, 0x31, 0x00, 0x42, 0x01, 0x86, 0x02, 0x04,
  0x04, 0x08, 0x18, 0x18, 0x20, 0x10, 0x40, 0x31, 0x80, 0x22, 0x00, 0x4C,
  0x00, 0xD0, 0x00, 0xA0, 0x01, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x7F,
  0xF8, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0x80, 0x08,
  0x00, 0xFF, 0xF8, 0x00, 0x83, 0xC3, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x83, 0x81, 0xE0, 0x10, 0x0C, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x3C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x1C,
  0x0E, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x03, 0x00, 0x80, 0x60, 0xF0, 0x00, 0x7E, 0x03, 0x07, 0x0E, 0x01, 0xE0,
};

const GFXglyph NotoSans_ExtraLight33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 24, 8, 3, -24 },
  { 7, 7, 9, 11, 2, -24 },
  { 15, 19, 24, 21, 1, -24 },
  { 72, 14, 27, 19, 2, -25 },
  { 120, 23, 24, 26, 2, -24 },
  { 189, 20, 24, 23, 2, -24 },
  { 249, 2, 9, 6, 2, -24 },
  { 252, 7, 29, 9, 1, -24 },
  { 278, 6, 29, 9, 1, -24 },
  { 300, 14, 14, 18, 2, -25 },
  { 325, 15, 15, 19, 2, -19 },
  { 354, 4, 8, 7, 1, -4 },
  { 358, 8, 2, 11, 1, -10 },
  { 360, 2, 2, 8, 3, -2 },
  { 361, 11, 24, 11, 0, -24 },
  { 394, 15, 24, 19, 2, -24 },
  { 439, 8, 24, 19, 3, -24 },
  { 463, 14, 24, 19, 2, -24 },
  { 505, 14, 24, 19, 2, -24 },
  { 547, 17, 24, 19, 1, -24 },
  { 598, 15, 24, 19, 2, -24 },
  { 643, 15, 24, 19, 2, -24 },
  { 688, 15, 24, 19, 2, -24 },
  { 733, 15, 24, 19, 2, -24 },
  { 778, 15, 24, 19, 2, -24 },
  { 823, 2, 18, 8, 3, -18 },
  { 828, 4, 22, 8, 1, -18 },
  { 839, 15, 15, 19, 2, -19 },
  { 868, 15, 8, 19, 2, -16 },
  { 883, 15, 15, 19, 2, -19 },
  { 912, 12, 24, 14, 1, -24 },
  { 948, 25, 26, 29, 2, -23 },
  { 1030, 19, 24, 19, 0, -24 },
  { 1087, 16, 24, 21, 3, -24 },
  { 1135, 17, 24, 20, 2, -24 },
  { 1186, 18, 24, 23, 3, -24 },
  { 1240, 13, 24, 18, 3, -24 },
  { 1279, 13, 24, 16, 3, -24 },
  { 1318, 19, 24, 24, 2, -24 },
  { 1375, 17, 24, 24, 3, -24 },
  { 1426, 6, 24, 10, 2, -24 },
  { 1444, 8, 30, 8, -3, -24 },
  { 1474, 16, 24, 19, 3, -24 },
  { 1522, 13, 24, 17, 3, -24 },
  { 1561, 22, 24, 28, 3, -24 },
  { 1627, 17, 24, 23, 3, -24 },
  { 1678, 21, 24, 25, 2, -24 },
  { 1741, 14, 24, 19, 3, -24 },
  { 1783, 21, 30, 25, 2, -24 },
  { 1862, 16, 24, 19, 3, -24 },
  { 1910, 14, 24, 18, 2, -24 },
  { 1952, 17, 24, 17, 0, -24 },
  { 2003, 18, 24, 24, 3, -24 },
  { 2057, 19, 24, 19, 0, -24 },
  { 2114, 27, 24, 29, 1, -24 },
  { 2195, 17, 24, 17, 0, -24 },
  { 2246, 17, 24, 17, 0, -24 },
  { 2297, 17, 24, 19, 1, -24 },
  { 2348, 7, 29, 10, 3, -24 },
  { 2374, 11, 24, 11, 0, -24 },
  { 2407, 7, 29, 10, 1, -24 },
  { 2433, 16, 15, 19, 1, -24 },
  { 2463, 13, 1, 13, 0, 3 },
  { 2465, 6, 5, 8, 1, -25 },
  { 2469, 12, 18, 17, 2, -18 },
  { 2496, 15, 25, 19, 3, -25 },
  { 2543, 13, 18, 16, 2, -18 },
  { 2573, 15, 25, 19, 2, -25 },
  { 2620, 14, 18, 18, 2, -18 },
  { 2652, 12, 25, 10, 0, -25 },
  { 2690, 15, 26, 19, 2, -18 },
  { 2739, 13, 25, 19, 3, -25 },
  { 2780, 2, 24, 7, 3, -24 },
  { 2786, 7, 32, 7, -2, -24 },
  { 2814, 13, 25, 16, 3, -25 },
  { 2855, 1, 25, 7, 3, -25 },
  { 2859, 23, 18, 29, 3, -18 },
  { 2911, 13, 18, 19, 3, -18 },
  { 2941, 15, 18, 19, 2, -18 },
  { 2975, 15, 26, 19, 3, -18 },
  { 3024, 14, 26, 19, 2, -18 },
  { 3070, 9, 18, 13, 3, -18 },
  { 3091, 13, 18, 15, 1, -18 },
  { 3121, 10, 22, 11, 0, -22 },
  { 3149, 13, 17, 19, 3, -17 },
  { 3177, 15, 17, 15, 0, -17 },
  { 3209, 23, 17, 23, 0, -17 },
  { 3258, 14, 17, 16, 1, -17 },
  { 3288, 15, 25, 15, 0, -17 },
  { 3335, 13, 17, 15, 1, -17 },
  { 3363, 9, 29, 11, 1, -24 },
  { 3396, 1, 33, 18, 8, -25 },
  { 3401, 10, 29, 11, 1, -24 },
  { 3438, 15, 3, 19, 2, -13 },
};

const GFXfont NotoSans_ExtraLight33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRALIGHT33PT7B_H_
