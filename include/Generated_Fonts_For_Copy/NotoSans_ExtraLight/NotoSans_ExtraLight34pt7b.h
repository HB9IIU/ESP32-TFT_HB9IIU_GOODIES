#ifndef _NOTOSANS_EXTRALIGHT34PT7B_H_
#define _NOTOSANS_EXTRALIGHT34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC3, 0x87, 0x0A, 0x14, 0x28,
  0x50, 0xA1, 0x42, 0x00, 0x81, 0x80, 0x08, 0x10, 0x01, 0x81, 0x00, 0x10,
  0x10, 0x01, 0x01, 0x00, 0x10, 0x30, 0x01, 0x02, 0x07, 0xFF, 0xFF, 0x02,
  0x02, 0x00, 0x20, 0x20, 0x02, 0x06, 0x00, 0x20, 0x40, 0x06, 0x04, 0x00,
  0x40, 0x40, 0x04, 0x04, 0x0F, 0xFF, 0xFE, 0x04, 0x08, 0x00, 0x40, 0x80,
  0x0C, 0x08, 0x00, 0x80, 0x80, 0x08, 0x18, 0x00, 0x81, 0x00, 0x08, 0x10,
  0x01, 0x81, 0x00, 0x01, 0x00, 0x04, 0x00, 0x7C, 0x07, 0xFE, 0x61, 0x09,
  0x04, 0x0C, 0x10, 0x30, 0x40, 0xC1, 0x03, 0x04, 0x04, 0x10, 0x0C, 0x40,
  0x1D, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x4C, 0x01, 0x08, 0x04, 0x30, 0x10,
  0x40, 0x41, 0x01, 0x04, 0x04, 0x10, 0x10, 0xB0, 0x4E, 0x7F, 0xE0, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x08, 0x00, 0x00, 0x7E, 0x00, 0xC1, 0x84, 0x01,
  0x02, 0x0C, 0x04, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x41, 0x00, 0x80, 0x86, 0x01, 0x01, 0x08, 0x02, 0x02, 0x31, 0xC6,
  0x04, 0x4E, 0x64, 0x19, 0x10, 0x4C, 0x22, 0x60, 0xCF, 0xC8, 0x80, 0x84,
  0x11, 0x01, 0x00, 0x42, 0x02, 0x01, 0x84, 0x04, 0x02, 0x08, 0x08, 0x0C,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x40, 0x60, 0x40, 0x80, 0x41, 0x82, 0x00,
  0xC6, 0x0C, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x06, 0x06, 0x00,
  0x20, 0x10, 0x01, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x40, 0x30, 0x02, 0x01,
  0x00, 0x18, 0x18, 0x00, 0x61, 0x80, 0x01, 0xB0, 0x00, 0x07, 0x00, 0x00,
  0xF8, 0x00, 0x0C, 0x60, 0x00, 0x81, 0x80, 0x48, 0x06, 0x06, 0xC0, 0x18,
  0x26, 0x00, 0x61, 0x20, 0x01, 0x91, 0x00, 0x07, 0x8C, 0x00, 0x18, 0x20,
  0x01, 0xE1, 0x80, 0x19, 0x86, 0x03, 0x86, 0x1F, 0xF0, 0x18, 0xFD, 0x55,
  0x40, 0x06, 0x10, 0x60, 0x83, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C,
  0x18, 0x30, 0x60, 0xC0, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20,
  0x60, 0x40, 0x60, 0xC0, 0xC0, 0xC0, 0x81, 0x81, 0x02, 0x06, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04,
  0x18, 0x20, 0xC1, 0x0C, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x18, 0x21, 0x9E, 0x4F, 0x83, 0xE0, 0x03, 0x80, 0x0D, 0x00,
  0x11, 0x00, 0x43, 0x01, 0x83, 0x06, 0x02, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x32, 0x22, 0x64, 0x4C, 0xFF, 0x80, 0xF0, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x01, 0x80, 0x1F, 0xE0,
  0x40, 0x61, 0x00, 0x46, 0x00, 0x48, 0x00, 0x90, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x36, 0x00, 0x44,
  0x01, 0x8C, 0x02, 0x0C, 0x18, 0x0F, 0xE0, 0x03, 0x07, 0x19, 0x31, 0xE1,
  0x41, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x80, 0x3F, 0xC1, 0x80,
  0xC2, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xFF, 0xFE, 0x03, 0x00, 0x7F, 0xE3, 0x80, 0x64,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x07, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x60, 0x1C, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x02, 0xC0,
  0x01, 0xB0, 0x00, 0x4C, 0x00, 0x23, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x02,
  0x0C, 0x01, 0x03, 0x00, 0xC0, 0xC0, 0x20, 0x30, 0x10, 0x0C, 0x0C, 0x03,
  0x06, 0x00, 0xC1, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x3F,
  0xFC, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC2, 0x01, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0xB8, 0x0E, 0x1F, 0xF0, 0x00, 0x78, 0x03, 0xFC,
  0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC7, 0xE0, 0xCC, 0x38, 0xF0, 0x0C, 0xE0, 0x06,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0x40, 0x02, 0x40, 0x02,
  0x60, 0x02, 0x20, 0x06, 0x30, 0x0C, 0x18, 0x18, 0x07, 0xF0, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x01, 0x80, 0x3F, 0xE0, 0xC0,
  0x63, 0x00, 0x66, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x60, 0x0C,
  0x60, 0x30, 0x60, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0x86, 0x0C, 0x06, 0x30,
  0x02, 0x40, 0x07, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x28, 0x00,
  0xD8, 0x03, 0x18, 0x0C, 0x0F, 0xF0, 0x03, 0x00, 0x3F, 0xC0, 0xC0, 0x43,
  0x00, 0x44, 0x00, 0xD8, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1E, 0x00, 0x34, 0x00, 0xAC, 0x03, 0x47, 0xB8, 0x83, 0xC1,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x7F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x33, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x32, 0x26, 0x64, 0x4C, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0x04, 0x0F, 0xFC, 0x80, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x03, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0x18, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x09, 0x80, 0x7F, 0x82, 0x40, 0x60, 0x40, 0x70, 0x30, 0x10, 0x18,
  0x08, 0x04, 0x06, 0x06, 0x01, 0x01, 0x81, 0x00, 0x40, 0x60, 0x40, 0x10,
  0x18, 0x10, 0x04, 0x06, 0x04, 0x01, 0x01, 0x81, 0x00, 0xC0, 0xE0, 0x60,
  0x30, 0x2C, 0x0C, 0x12, 0x11, 0x01, 0xF8, 0xF8, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0xD0, 0x00, 0x09, 0x00, 0x00, 0x98, 0x00, 0x18, 0x80, 0x01, 0x08,
  0x00, 0x30, 0xC0, 0x02, 0x04, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x40,
  0x20, 0x04, 0x03, 0x00, 0xC0, 0x10, 0x0F, 0xFF, 0x01, 0x80, 0x18, 0x10,
  0x00, 0x81, 0x00, 0x0C, 0x30, 0x00, 0x42, 0x00, 0x04, 0x60, 0x00, 0x64,
  0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x03, 0xFF, 0xF0, 0xC0, 0x1C, 0xC0,
  0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x78, 0xFF, 0xF0, 0xC0, 0x0C, 0xC0, 0x06, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x02, 0xC0, 0x06, 0xC0, 0x3C, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0xFF, 0xF0,
  0x60, 0x04, 0x30, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x02, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x18, 0x03, 0x83, 0x00, 0x18, 0x60,
  0x01, 0x8C, 0x00, 0x19, 0x80, 0x01, 0x30, 0x00, 0x36, 0x00, 0x02, 0xC0,
  0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00,
  0x02, 0x60, 0x00, 0xCC, 0x00, 0x31, 0x80, 0x1C, 0x30, 0x1E, 0x07, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0x07, 0x00, 0x20, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00,
  0x36, 0x00, 0x03, 0x30, 0x00, 0x31, 0x00, 0x03, 0x0C, 0x00, 0x30, 0x70,
  0x07, 0x01, 0xFF, 0xC0, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x8C, 0xF8, 0xC0, 0x03,
  0xC0, 0x04, 0xC0, 0x08, 0xC0, 0x10, 0xC0, 0x20, 0xC0, 0x40, 0xC0, 0x80,
  0xC1, 0x80, 0xC3, 0x00, 0xC6, 0x00, 0xCE, 0x00, 0xD2, 0x00, 0xE3, 0x00,
  0xC1, 0x80, 0xC0, 0x80, 0xC0, 0x40, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x10,
  0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01,
  0xF4, 0x00, 0x05, 0xD0, 0x00, 0x37, 0x60, 0x00, 0x9C, 0x80, 0x02, 0x73,
  0x00, 0x19, 0xC4, 0x00, 0x47, 0x10, 0x03, 0x1C, 0x60, 0x08, 0x70, 0x80,
  0x21, 0xC3, 0x01, 0x87, 0x04, 0x04, 0x1C, 0x10, 0x30, 0x70, 0x60, 0x81,
  0xC0, 0x82, 0x07, 0x03, 0x18, 0x1C, 0x04, 0x40, 0x70, 0x13, 0x01, 0xC0,
  0x68, 0x07, 0x00, 0xA0, 0x1C, 0x03, 0x80, 0x70, 0x04, 0x01, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x40, 0x03, 0xD8, 0x00, 0xF3, 0x00, 0x3C,
  0x40, 0x0F, 0x18, 0x03, 0xC3, 0x00, 0xF0, 0x40, 0x3C, 0x18, 0x0F, 0x03,
  0x03, 0xC0, 0x40, 0xF0, 0x18, 0x3C, 0x03, 0x0F, 0x00, 0x43, 0xC0, 0x18,
  0xF0, 0x03, 0x3C, 0x00, 0x4F, 0x00, 0x1B, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x1C,
  0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x90,
  0x00, 0x06, 0x40, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02,
  0xC0, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x01, 0x98, 0x00, 0x04, 0x20,
  0x00, 0x30, 0x40, 0x00, 0x81, 0x80, 0x0C, 0x01, 0x80, 0x60, 0x03, 0xFE,
  0x00, 0xFF, 0xE1, 0x80, 0x73, 0x00, 0x36, 0x00, 0x2C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0B, 0x00, 0x36, 0x00, 0xCC,
  0x0F, 0x1F, 0xF0, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x1C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x80, 0x00, 0x46, 0x00, 0x01, 0x90, 0x00, 0x06, 0x40, 0x00, 0x0B, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0x09, 0x00, 0x00, 0x24,
  0x00, 0x01, 0x98, 0x00, 0x04, 0x20, 0x00, 0x30, 0x40, 0x00, 0x81, 0x80,
  0x0C, 0x01, 0x80, 0x60, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x00,
  0xFF, 0xE0, 0xC0, 0x38, 0xC0, 0x0C, 0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x08, 0xC0, 0x30,
  0xFF, 0xE0, 0xC0, 0xC0, 0xC0, 0x40, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x10,
  0xC0, 0x18, 0xC0, 0x08, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03,
  0x01, 0x80, 0x3F, 0xF8, 0xC0, 0x13, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x60, 0x1C, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x02, 0x60,
  0x01, 0x8C, 0x00, 0xC1, 0xC0, 0x60, 0x1F, 0xF0, 0xC0, 0x00, 0x28, 0x00,
  0x0D, 0x00, 0x01, 0x30, 0x00, 0x22, 0x00, 0x0C, 0x60, 0x01, 0x04, 0x00,
  0x60, 0x80, 0x0C, 0x18, 0x01, 0x01, 0x00, 0x60, 0x20, 0x08, 0x06, 0x01,
  0x00, 0x40, 0x60, 0x0C, 0x08, 0x00, 0x83, 0x00, 0x10, 0x60, 0x03, 0x08,
  0x00, 0x23, 0x00, 0x04, 0x40, 0x00, 0xC8, 0x00, 0x0B, 0x00, 0x01, 0x40,
  0x00, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0x40, 0x0E, 0x00, 0x24, 0x00, 0xB0, 0x02, 0x60, 0x09, 0x00, 0x62, 0x00,
  0x90, 0x04, 0x20, 0x19, 0x00, 0x42, 0x01, 0x18, 0x04, 0x30, 0x10, 0x80,
  0xC1, 0x01, 0x08, 0x08, 0x10, 0x30, 0xC0, 0x81, 0x82, 0x04, 0x18, 0x18,
  0x20, 0x41, 0x80, 0x86, 0x04, 0x10, 0x08, 0x40, 0x61, 0x00, 0xC4, 0x02,
  0x30, 0x04, 0x40, 0x22, 0x00, 0x4C, 0x03, 0x20, 0x04, 0x80, 0x16, 0x00,
  0x68, 0x01, 0x60, 0x03, 0x80, 0x14, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x88, 0x00, 0x43, 0x00, 0x30,
  0x60, 0x18, 0x08, 0x04, 0x03, 0x03, 0x00, 0x61, 0x80, 0x08, 0x40, 0x03,
  0x30, 0x00, 0x48, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x48,
  0x00, 0x33, 0x00, 0x18, 0x40, 0x04, 0x08, 0x03, 0x03, 0x00, 0x80, 0x40,
  0x40, 0x18, 0x30, 0x03, 0x08, 0x00, 0x44, 0x00, 0x1B, 0x00, 0x03, 0xC0,
  0x00, 0xD0, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x0C, 0x10, 0x02, 0x06, 0x01,
  0x00, 0x80, 0xC0, 0x30, 0x20, 0x04, 0x18, 0x01, 0x84, 0x00, 0x23, 0x00,
  0x0C, 0x80, 0x01, 0x60, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0xFE, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xE0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x48, 0x00, 0x64, 0x00, 0x21, 0x00, 0x30, 0x80, 0x10, 0x20,
  0x18, 0x10, 0x08, 0x04, 0x08, 0x02, 0x04, 0x00, 0x84, 0x00, 0x42, 0x00,
  0x12, 0x00, 0x0B, 0x00, 0x02, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x0C, 0x1F,
  0xE3, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x0F, 0xF9, 0xC0, 0x50, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x05, 0x60, 0x49, 0xFC, 0x40, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x8F, 0xE1, 0x30, 0x32,
  0x80, 0x36, 0x00, 0x2C, 0x00, 0x58, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xB0, 0x03,
  0x50, 0x04, 0x90, 0x31, 0x1F, 0xC0, 0x07, 0xF8, 0xE0, 0x4C, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x08, 0x7F, 0xC0,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x0F, 0xE2, 0x30, 0x24, 0x80, 0x2B, 0x00, 0x34, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x68, 0x00, 0xD0, 0x01, 0xB0, 0x05, 0x38, 0x12, 0x1F,
  0xC4, 0x0F, 0xE0, 0x30, 0x60, 0xC0, 0x23, 0x00, 0x64, 0x00, 0x58, 0x00,
  0xB0, 0x01, 0x40, 0x03, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x0C, 0x1F, 0xF0, 0x03,
  0xF0, 0x61, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0xFF,
  0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0F, 0xE2, 0x30, 0x34, 0x80, 0x2B, 0x00, 0x34, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x68, 0x00, 0xD0, 0x01, 0x90, 0x05, 0x38, 0x12, 0x1F, 0xC4,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x70,
  0x38, 0x3F, 0xC0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x8F, 0xE2, 0x40, 0xEA, 0x00, 0xB0, 0x03,
  0xC0, 0x0F, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x10, 0xBC, 0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x04, 0x0C, 0x18, 0x00,
  0x00, 0x00, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06,
  0xF8, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x34, 0x03, 0x20, 0x31, 0x01, 0x08, 0x10, 0x41, 0x02,
  0x10, 0x11, 0x80, 0x9C, 0x05, 0xB0, 0x38, 0x81, 0x82, 0x08, 0x18, 0x40,
  0x62, 0x01, 0x10, 0x04, 0x80, 0x34, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x8F, 0xC1, 0xF8, 0xB0, 0x66, 0x06, 0xA0, 0x34, 0x02, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03,
  0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03,
  0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x80, 0x18, 0x03,
  0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x8F, 0xE2, 0x60, 0xEA, 0x00, 0xB0,
  0x03, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x0F, 0xF0, 0x18, 0x18, 0x20, 0x0C, 0x60, 0x06, 0x40, 0x02,
  0xC0, 0x02, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x60, 0x06, 0x20, 0x0C, 0x18, 0x18,
  0x0F, 0xF0, 0x8F, 0xE1, 0x30, 0x32, 0x80, 0x35, 0x00, 0x2C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xB8, 0x03, 0x50, 0x04, 0x98, 0x39, 0x1F, 0xC2,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x00, 0x0F, 0xE2, 0x30, 0x24, 0x80, 0x2B, 0x00, 0x34, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xD0, 0x03, 0xB0, 0x05, 0x30, 0x32, 0x3F,
  0xC4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x8F, 0xC8, 0x28, 0x18, 0x0C, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x00, 0x1F, 0xF9, 0x80, 0x98, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0xC0, 0x33, 0xFF, 0x00, 0x10, 0x04, 0x01, 0x00, 0x40,
  0xFF, 0xC4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x60, 0x08, 0x01, 0xF0, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x01, 0xD0, 0x07, 0x60, 0x64, 0xFF, 0x10, 0xC0, 0x02, 0x80, 0x0D, 0x00,
  0x13, 0x00, 0x62, 0x00, 0x84, 0x01, 0x04, 0x06, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x60, 0x20, 0x80, 0x63, 0x00, 0x44, 0x00, 0xC8, 0x00, 0xB0, 0x01,
  0x40, 0x03, 0x80, 0x02, 0x00, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0B, 0x00,
  0xE0, 0x32, 0x03, 0x40, 0x64, 0x04, 0x80, 0x88, 0x09, 0x81, 0x18, 0x31,
  0x06, 0x10, 0x42, 0x08, 0x20, 0x86, 0x10, 0x63, 0x04, 0x20, 0x44, 0x08,
  0xC0, 0x88, 0x19, 0x01, 0x30, 0x12, 0x03, 0x40, 0x24, 0x02, 0x80, 0x58,
  0x05, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x40, 0x0C, 0xC0,
  0x10, 0x80, 0x60, 0x81, 0x81, 0x82, 0x01, 0x88, 0x01, 0x30, 0x01, 0xC0,
  0x03, 0x00, 0x07, 0x00, 0x1A, 0x00, 0x62, 0x00, 0x86, 0x03, 0x04, 0x0C,
  0x04, 0x10, 0x0C, 0x40, 0x0D, 0x80, 0x0C, 0xC0, 0x02, 0x80, 0x0D, 0x00,
  0x13, 0x00, 0x62, 0x00, 0x86, 0x01, 0x04, 0x06, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x60, 0x20, 0x80, 0x63, 0x00, 0x44, 0x00, 0xC8, 0x00, 0xB0, 0x01,
  0x40, 0x03, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x00, 0x02, 0x00, 0x08, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x07,
  0xFF, 0xC0, 0x03, 0xC1, 0x80, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x0C, 0x0C, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x10, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x0C, 0x0C, 0x06, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x60, 0xF0,
  0x00, 0x1C, 0x00, 0xFF, 0x01, 0x81, 0xFE, 0x00, 0x10,
};

const GFXglyph NotoSans_ExtraLight34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 24, 8, 3, -24 },
  { 7, 7, 9, 11, 2, -24 },
  { 15, 20, 24, 22, 1, -24 },
  { 75, 14, 28, 19, 2, -26 },
  { 124, 23, 25, 27, 2, -25 },
  { 196, 21, 25, 24, 2, -25 },
  { 262, 2, 9, 6, 2, -24 },
  { 265, 7, 29, 9, 1, -24 },
  { 291, 7, 29, 9, 1, -24 },
  { 317, 15, 14, 19, 2, -26 },
  { 344, 16, 16, 19, 2, -20 },
  { 376, 4, 8, 7, 1, -4 },
  { 380, 9, 1, 11, 1, -10 },
  { 382, 2, 2, 8, 3, -2 },
  { 383, 11, 24, 11, 0, -24 },
  { 416, 15, 25, 19, 2, -25 },
  { 463, 8, 24, 19, 3, -24 },
  { 487, 15, 25, 19, 2, -25 },
  { 534, 15, 25, 19, 2, -25 },
  { 581, 18, 24, 19, 1, -24 },
  { 635, 15, 24, 19, 2, -24 },
  { 680, 16, 25, 19, 2, -25 },
  { 730, 15, 24, 19, 2, -24 },
  { 775, 15, 25, 19, 2, -25 },
  { 822, 15, 25, 19, 2, -25 },
  { 869, 2, 18, 8, 3, -18 },
  { 874, 4, 22, 8, 1, -18 },
  { 885, 16, 15, 19, 2, -20 },
  { 915, 16, 8, 19, 2, -16 },
  { 931, 16, 15, 19, 2, -20 },
  { 961, 12, 25, 14, 1, -25 },
  { 999, 26, 27, 30, 2, -24 },
  { 1087, 20, 24, 20, 0, -24 },
  { 1147, 16, 24, 21, 3, -24 },
  { 1195, 18, 25, 21, 2, -25 },
  { 1252, 19, 24, 24, 3, -24 },
  { 1309, 14, 24, 19, 3, -24 },
  { 1351, 14, 24, 17, 3, -24 },
  { 1393, 20, 25, 25, 2, -25 },
  { 1456, 18, 24, 24, 3, -24 },
  { 1510, 6, 24, 10, 2, -24 },
  { 1528, 8, 30, 8, -3, -24 },
  { 1558, 16, 24, 19, 3, -24 },
  { 1606, 14, 24, 17, 3, -24 },
  { 1648, 22, 24, 29, 3, -24 },
  { 1714, 18, 24, 24, 3, -24 },
  { 1768, 22, 25, 26, 2, -25 },
  { 1837, 15, 24, 20, 3, -24 },
  { 1882, 22, 31, 26, 2, -25 },
  { 1968, 16, 24, 20, 3, -24 },
  { 2016, 15, 25, 19, 2, -25 },
  { 2063, 17, 24, 18, 0, -24 },
  { 2114, 18, 24, 24, 3, -24 },
  { 2168, 19, 24, 19, 0, -24 },
  { 2225, 28, 24, 30, 1, -24 },
  { 2309, 18, 24, 18, 0, -24 },
  { 2363, 18, 24, 18, 0, -24 },
  { 2417, 17, 24, 20, 1, -24 },
  { 2468, 7, 29, 11, 3, -24 },
  { 2494, 11, 24, 11, 0, -24 },
  { 2527, 7, 29, 11, 1, -24 },
  { 2553, 17, 15, 19, 1, -24 },
  { 2585, 14, 1, 14, 0, 3 },
  { 2587, 6, 5, 9, 1, -26 },
  { 2591, 13, 18, 18, 2, -18 },
  { 2621, 15, 26, 20, 3, -26 },
  { 2670, 13, 18, 16, 2, -18 },
  { 2700, 15, 26, 20, 2, -26 },
  { 2749, 15, 18, 19, 2, -18 },
  { 2783, 12, 26, 10, 0, -26 },
  { 2822, 15, 26, 20, 2, -18 },
  { 2871, 14, 26, 20, 3, -26 },
  { 2917, 2, 25, 7, 3, -25 },
  { 2924, 7, 33, 7, -2, -25 },
  { 2953, 13, 26, 16, 3, -26 },
  { 2996, 1, 26, 7, 3, -26 },
  { 3000, 24, 18, 30, 3, -18 },
  { 3054, 14, 18, 20, 3, -18 },
  { 3086, 16, 18, 20, 2, -18 },
  { 3122, 15, 26, 20, 3, -18 },
  { 3171, 15, 26, 20, 2, -18 },
  { 3220, 9, 18, 13, 3, -18 },
  { 3241, 13, 18, 16, 1, -18 },
  { 3271, 10, 22, 11, 0, -22 },
  { 3299, 14, 18, 20, 3, -18 },
  { 3331, 15, 18, 15, 0, -18 },
  { 3365, 23, 18, 24, 1, -18 },
  { 3417, 15, 18, 17, 1, -18 },
  { 3451, 15, 26, 15, 0, -18 },
  { 3500, 13, 18, 16, 1, -18 },
  { 3530, 10, 29, 12, 1, -24 },
  { 3567, 2, 34, 18, 8, -26 },
  { 3576, 10, 29, 12, 1, -24 },
  { 3613, 16, 4, 19, 2, -14 },
};

const GFXfont NotoSans_ExtraLight34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRALIGHT34PT7B_H_
