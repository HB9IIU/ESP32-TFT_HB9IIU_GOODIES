#ifndef _NOTOSANS_EXTRALIGHT67PT7B_H_
#define _NOTOSANS_EXTRALIGHT67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight67pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x47, 0xBF, 0xEF, 0x20, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x10,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0xF8, 0x60, 0x7C, 0x1E, 0x06,
  0x00, 0x83, 0x80, 0x60, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x60, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x78, 0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x1E,
  0x06, 0x00, 0x00, 0xF8, 0x60, 0x00, 0x03, 0xE6, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x63, 0xE0, 0x00, 0x06, 0x0F, 0x80, 0x00, 0x60, 0x3C, 0x00, 0x06,
  0x01, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0x60, 0x07,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x60, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x01, 0xCC, 0x00, 0x60, 0x38, 0xF8,
  0x06, 0x1F, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x07, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x00,
  0xC0, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0xC0, 0xE0, 0x7F, 0x03, 0x80, 0x07, 0x03, 0x07,
  0xFF, 0x06, 0x00, 0x1C, 0x1C, 0x3C, 0x1E, 0x18, 0x00, 0x60, 0xE0, 0xE0,
  0x1C, 0x70, 0x01, 0x83, 0x07, 0x00, 0x70, 0xC0, 0x0E, 0x1C, 0x18, 0x00,
  0xC3, 0x80, 0x70, 0x60, 0xE0, 0x03, 0x87, 0x03, 0x83, 0x83, 0x00, 0x06,
  0x0F, 0xFC, 0x0C, 0x0C, 0x00, 0x18, 0x1F, 0xE0, 0x70, 0x70, 0x00, 0x60,
  0x04, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x70, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFB, 0x80, 0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x1E, 0x00,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x00, 0x30, 0x70, 0x00, 0x03, 0x80, 0x1C,
  0x38, 0x00, 0x00, 0x70, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x83, 0x80,
  0x00, 0x01, 0xC0, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x38, 0x00, 0x00,
  0x07, 0x18, 0x0E, 0x00, 0x00, 0x00, 0xEE, 0x03, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x3C, 0x00,
  0x00, 0x78, 0x38, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1C, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xED, 0xB6, 0xDB, 0x6D, 0xB6,
  0xC0, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x30, 0x00, 0xBC, 0x01, 0x80, 0x1D, 0xFC, 0x0C,
  0x07, 0xF3, 0xFC, 0x61, 0xFE, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x63, 0x8C,
  0x30, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x23, 0xDF, 0xF7, 0x90, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF8,
  0x07, 0xF0, 0x1E, 0xE0, 0xF1, 0xC3, 0xC3, 0x8F, 0x07, 0x78, 0x0F, 0xE0,
  0x1F, 0x80, 0x3A, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xC0, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x0F, 0x0F, 0xE0, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x71,
  0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0x7E, 0x00, 0x1F, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF0,
  0x01, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x06, 0x03, 0xFF, 0xC0, 0x0C, 0x1F, 0xFF, 0xE0, 0x18,
  0x78, 0x01, 0xF0, 0x31, 0xC0, 0x00, 0xF0, 0xE7, 0x00, 0x00, 0x71, 0xD8,
  0x00, 0x00, 0xE3, 0xF0, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x00, 0xCF, 0x00,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x07, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0C, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x07, 0xDC, 0x00,
  0x00, 0x1F, 0x38, 0x00, 0x00, 0xDC, 0xE0, 0x00, 0x07, 0x71, 0xE0, 0x00,
  0x79, 0xC3, 0xC0, 0x07, 0xC6, 0x07, 0xFF, 0xFC, 0x18, 0x07, 0xFF, 0xC0,
  0x60, 0x02, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x02, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x73, 0xFE, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x7B, 0xFE, 0xF2, 0x00, 0x0E, 0x0F, 0x1F, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60,
  0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0xFC, 0x01, 0xF0, 0x60, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1C, 0x38, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xC3, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x0E, 0x70, 0x00, 0x3C, 0x00, 0x30,
  0x00, 0xE7, 0x00, 0x07, 0x00, 0x03, 0x00, 0x06, 0x60, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x6E, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x06, 0xE0, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x6E, 0x00, 0x38, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x07, 0xC0,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x06,
  0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x06, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x06, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00, 0xEC, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x0C, 0xC0, 0x03, 0x00, 0x00, 0xF0, 0x00, 0xCC, 0x00, 0x38,
  0x00, 0x1F, 0x00, 0x1C, 0xE0, 0x01, 0x80, 0x01, 0xB0, 0x01, 0x8E, 0x00,
  0x1C, 0x00, 0x33, 0x80, 0x38, 0x60, 0x00, 0xE0, 0x07, 0x1C, 0x07, 0x06,
  0x00, 0x07, 0xC7, 0xE1, 0xF3, 0xE0, 0x70, 0x00, 0x3F, 0xF8, 0x0F, 0xFC,
  0x03, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x5A, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x00, 0x3E, 0x0C,
  0x00, 0x00, 0x1E, 0x18, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x00, 0x1E, 0x60,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x0F, 0x0C, 0x00, 0x00, 0x7C, 0x18, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x1F, 0x81, 0x80, 0x00, 0x03,
  0xC3, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x07, 0x8C, 0x00,
  0x00, 0x7C, 0x18, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x0E,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x80,
  0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0xC0,
  0x00, 0x01, 0xF0, 0x0C, 0x00, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x00, 0x3C,
  0x0C, 0x00, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x00, 0x0F, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0x1E, 0x0C, 0x00, 0x00,
  0x03, 0xC0, 0xC0, 0x00, 0x00, 0xF8, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0xC0,
  0x00, 0x0F, 0xC0, 0x0C, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0x00,
  0x01, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x1E, 0x01, 0x80, 0x00, 0x78, 0x03,
  0x00, 0x01, 0xE0, 0x06, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x1E, 0x00, 0x18,
  0x00, 0x78, 0x00, 0x30, 0x01, 0xE0, 0x00, 0x60, 0x07, 0x80, 0x00, 0xC0,
  0x1E, 0x00, 0x01, 0x80, 0x78, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x06, 0x07,
  0x80, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x18, 0x7E, 0x00, 0x00, 0x31, 0xFE,
  0x00, 0x00, 0x67, 0x9C, 0x00, 0x00, 0xCE, 0x1C, 0x00, 0x01, 0xB8, 0x3C,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x78, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x70, 0x01, 0x80, 0x00, 0xF0, 0x03, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xE0,
  0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0xC1,
  0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x07, 0x98, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xBD, 0xC0, 0x00, 0x00, 0x00, 0x77, 0xB8, 0x00, 0x00, 0x00, 0x0E, 0xF3,
  0x00, 0x00, 0x00, 0x01, 0x9E, 0x70, 0x00, 0x00, 0x00, 0x73, 0xCE, 0x00,
  0x00, 0x00, 0x0C, 0x78, 0xE0, 0x00, 0x00, 0x03, 0x8F, 0x1C, 0x00, 0x00,
  0x00, 0x71, 0xE1, 0x80, 0x00, 0x00, 0x0C, 0x3C, 0x38, 0x00, 0x00, 0x03,
  0x87, 0x87, 0x00, 0x00, 0x00, 0x60, 0xF0, 0x70, 0x00, 0x00, 0x1C, 0x1E,
  0x0E, 0x00, 0x00, 0x03, 0x83, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x78, 0x1C,
  0x00, 0x00, 0x1C, 0x0F, 0x01, 0x80, 0x00, 0x03, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x60, 0x00, 0x03,
  0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0x78, 0x03, 0x80, 0x00, 0xE0, 0x0F, 0x00,
  0x30, 0x00, 0x18, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x60,
  0x00, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x18, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x00,
  0x78, 0x00, 0x30, 0x06, 0x00, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x3C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xF0, 0x00, 0x18, 0x30, 0x00, 0x1E, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x07, 0xC7, 0x00, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x00, 0x1F, 0x07, 0x00, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x00, 0x7C, 0x07, 0x00, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x01, 0xF0, 0x07, 0x00,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x07,
  0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x7C,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x38, 0x01,
  0xF0, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x1F, 0x00, 0x00, 0x38,
  0x07, 0xC0, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x00,
  0x38, 0x1F, 0x00, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x00, 0xE1, 0xF0, 0x00,
  0x00, 0x38, 0x7C, 0x00, 0x00, 0x07, 0x1F, 0x00, 0x00, 0x00, 0xE7, 0xC0,
  0x00, 0x00, 0x39, 0xF0, 0x00, 0x00, 0x07, 0x7C, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x0C, 0x00, 0x03, 0xF0, 0xC0, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x3C, 0xC0,
  0x00, 0x01, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0xF0, 0xC0, 0x00, 0x3E, 0x0C, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x81, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x06, 0x00, 0x00, 0xFC, 0x0C, 0x00, 0x00, 0x7C, 0x18, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x1C, 0x60,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x70, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0F, 0x00, 0xC0, 0x07,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x38,
  0x03, 0x00, 0x00, 0x78, 0x06, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xE0,
  0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x07, 0x98, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0xF0, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x40, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x60,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x07, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x0C,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x0C,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x01,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0x80, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x06,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x30, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x07, 0x18, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xE0, 0x3C,
  0x00, 0x3C, 0x08, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x3F, 0x80, 0x0C, 0x3E, 0x00, 0x03, 0x1E, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x6D, 0xC0, 0x00, 0x33, 0x38, 0x00, 0x1C,
  0xCF, 0x80, 0x1E, 0x31, 0xFF, 0xFE, 0x0C, 0x1F, 0xFF, 0x03, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x0F,
  0xFC, 0x00, 0xE0, 0xFF, 0xFC, 0x03, 0x0F, 0xC0, 0xFC, 0x0C, 0x78, 0x00,
  0x78, 0x33, 0x80, 0x00, 0xF0, 0xCC, 0x00, 0x01, 0xE3, 0x60, 0x00, 0x03,
  0x8D, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x33,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0xF8,
  0x00, 0x00, 0xE3, 0x60, 0x00, 0x07, 0x8C, 0xC0, 0x00, 0x3C, 0x33, 0x80,
  0x01, 0xE0, 0xC7, 0x80, 0x1F, 0x03, 0x07, 0xFF, 0xF8, 0x0C, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x1F, 0xC0, 0xF8, 0x0F, 0x80, 0x02, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x0F, 0xFC, 0x07, 0x00, 0xFF, 0xFC, 0x1C, 0x0F, 0xC0,
  0xF8, 0x70, 0x78, 0x00, 0x79, 0xC3, 0xC0, 0x00, 0x67, 0x1E, 0x00, 0x00,
  0xDC, 0x70, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x1F,
  0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x60, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xCC,
  0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x7C, 0x70, 0x00, 0x03, 0x71, 0xE0,
  0x00, 0x1D, 0xC3, 0xC0, 0x00, 0xE7, 0x07, 0xC0, 0x0F, 0x1C, 0x0F, 0xFF,
  0xF8, 0x70, 0x0F, 0xFF, 0x81, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0x1F, 0x00, 0x0F,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0xC0, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x1C, 0x03, 0xFF, 0xF0, 0x70, 0x3F, 0x83, 0xF1, 0xC1, 0xE0, 0x01, 0xE7,
  0x0F, 0x00, 0x01, 0xDC, 0x78, 0x00, 0x03, 0x71, 0xC0, 0x00, 0x07, 0xCE,
  0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x03, 0xD8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x7C, 0xE0, 0x00,
  0x01, 0xF1, 0xC0, 0x00, 0x0D, 0xC7, 0x80, 0x00, 0x77, 0x0F, 0x00, 0x03,
  0x9C, 0x1F, 0x00, 0x3C, 0x70, 0x3F, 0xFF, 0xE1, 0xC0, 0x3F, 0xFE, 0x07,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0xC0, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x01, 0xFF, 0x80, 0xE0, 0xFF, 0xFC, 0x1C, 0x7E, 0x07,
  0xE3, 0x9E, 0x00, 0x1E, 0x77, 0x00, 0x01, 0xCC, 0xC0, 0x00, 0x1D, 0xB0,
  0x00, 0x01, 0xBE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0x80, 0x2F, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0x20, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x1C, 0x87, 0xCF, 0xF8, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x87, 0x80, 0x00, 0xE3, 0xF0, 0x00, 0x31, 0xDE, 0x00, 0x0C, 0xE3,
  0x80, 0x03, 0x70, 0x70, 0x00, 0xF8, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x78,
  0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x0F, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0x83, 0xFF, 0xE0, 0x0F,
  0xFF, 0x83, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0xC6, 0x38, 0x01, 0xE1, 0xE0,
  0x07, 0x8C, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9B, 0x00, 0x01, 0xCC, 0x00,
  0x03, 0xB6, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x06, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x3F,
  0xF0, 0x18, 0x1F, 0xFF, 0x83, 0x0F, 0xC0, 0xFC, 0x63, 0xC0, 0x03, 0xCC,
  0xE0, 0x00, 0x39, 0x98, 0x00, 0x03, 0xB6, 0x00, 0x00, 0x37, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x1F, 0xF0, 0x03, 0x03, 0xFF, 0xF8, 0x0C, 0x1F, 0x03, 0xF0, 0x30,
  0xE0, 0x01, 0xE0, 0xC7, 0x00, 0x03, 0xC3, 0x30, 0x00, 0x03, 0x8D, 0xC0,
  0x00, 0x0E, 0x36, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00,
  0x73, 0x60, 0x00, 0x03, 0x8F, 0xC0, 0x00, 0x1E, 0x3B, 0x80, 0x00, 0xF0,
  0xE7, 0x00, 0x07, 0x83, 0x8F, 0x00, 0x7C, 0x0E, 0x1F, 0xFF, 0xE0, 0x38,
  0x1F, 0xFE, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x18, 0x07, 0xFF, 0xE0, 0xC0, 0xFC,
  0x0F, 0x86, 0x0F, 0x00, 0x0E, 0x30, 0xF0, 0x00, 0x39, 0x8E, 0x00, 0x00,
  0xEC, 0x70, 0x00, 0x03, 0x67, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x6C, 0xF0, 0x00, 0x03, 0x63, 0x80, 0x00, 0x33, 0x0F,
  0x00, 0x07, 0x18, 0x3C, 0x00, 0x78, 0xC0, 0xFF, 0xFF, 0x06, 0x01, 0xFF,
  0xE0, 0x30, 0x01, 0xF8, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x3F, 0xF8, 0x3F, 0xFB, 0x0F, 0xC7, 0x63, 0x80, 0x0C, 0xE0, 0x01,
  0xB8, 0x00, 0x36, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0xC3,
  0x80, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0x7C, 0x00, 0x1E,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xF0, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x03, 0xF3, 0x80, 0x00,
  0x73, 0x1E, 0x00, 0x0E, 0x30, 0xF0, 0x03, 0xC3, 0x07, 0xFF, 0xF8, 0x30,
  0x3F, 0xFE, 0x03, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x70, 0x06, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xC0,
  0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x18, 0x0E,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xDC, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x67, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0x18, 0x00, 0x06, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x33, 0x80,
  0x01, 0x87, 0x00, 0x03, 0x9C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00,
  0xE0, 0xE0, 0x00, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x30,
  0x38, 0x00, 0x60, 0x60, 0x03, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x07,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x01, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x80,
  0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x70, 0x00, 0xE1,
  0xC0, 0x01, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x60,
  0x00, 0x31, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x38, 0x00,
  0x0E, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xEC, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70,
  0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x06,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x02, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xC0,
  0x03, 0xF8, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x05, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0xE8, 0x00, 0x1F, 0xFF, 0x90, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x80,
  0x00,
};

const GFXglyph NotoSans_ExtraLight67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 49, 16, 5, -48 },
  { 32, 13, 17, 23, 5, -48 },
  { 60, 39, 48, 43, 2, -48 },
  { 294, 28, 55, 38, 4, -51 },
  { 487, 46, 50, 54, 4, -49 },
  { 775, 42, 50, 47, 4, -49 },
  { 1038, 3, 17, 12, 5, -48 },
  { 1045, 12, 59, 18, 3, -48 },
  { 1134, 13, 59, 18, 2, -48 },
  { 1230, 29, 28, 37, 4, -51 },
  { 1332, 31, 31, 38, 4, -39 },
  { 1453, 6, 17, 13, 3, -8 },
  { 1466, 16, 2, 22, 3, -19 },
  { 1470, 5, 6, 15, 5, -5 },
  { 1474, 20, 48, 22, 1, -48 },
  { 1594, 30, 50, 38, 4, -49 },
  { 1782, 15, 48, 38, 7, -48 },
  { 1872, 29, 49, 38, 4, -49 },
  { 2050, 30, 50, 38, 3, -49 },
  { 2238, 35, 48, 38, 2, -48 },
  { 2448, 29, 49, 38, 5, -48 },
  { 2626, 31, 50, 38, 4, -49 },
  { 2820, 30, 48, 38, 4, -48 },
  { 3000, 30, 50, 38, 4, -49 },
  { 3188, 30, 50, 38, 4, -49 },
  { 3376, 5, 37, 15, 5, -36 },
  { 3400, 8, 45, 15, 2, -36 },
  { 3445, 31, 31, 38, 4, -40 },
  { 3566, 31, 16, 38, 4, -32 },
  { 3628, 31, 31, 38, 4, -40 },
  { 3749, 24, 50, 28, 2, -49 },
  { 3899, 52, 54, 59, 4, -47 },
  { 4250, 39, 48, 40, 0, -48 },
  { 4484, 31, 48, 42, 7, -48 },
  { 4670, 35, 50, 41, 4, -49 },
  { 4889, 36, 48, 47, 7, -48 },
  { 5105, 26, 48, 37, 7, -48 },
  { 5261, 26, 48, 33, 7, -48 },
  { 5417, 39, 50, 48, 4, -49 },
  { 5661, 34, 48, 48, 7, -48 },
  { 5865, 12, 48, 20, 4, -48 },
  { 5937, 16, 60, 16, -6, -48 },
  { 6057, 31, 48, 38, 7, -48 },
  { 6243, 26, 48, 34, 7, -48 },
  { 6399, 43, 48, 57, 7, -48 },
  { 6657, 34, 48, 48, 7, -48 },
  { 6861, 43, 50, 51, 4, -49 },
  { 7130, 28, 48, 39, 7, -48 },
  { 7298, 43, 60, 51, 4, -49 },
  { 7621, 31, 48, 39, 7, -48 },
  { 7807, 29, 50, 36, 4, -49 },
  { 7989, 34, 48, 35, 0, -48 },
  { 8193, 36, 49, 48, 6, -48 },
  { 8414, 38, 48, 38, 0, -48 },
  { 8642, 55, 48, 59, 2, -48 },
  { 8972, 35, 48, 35, 0, -48 },
  { 9182, 35, 48, 35, 0, -48 },
  { 9392, 34, 48, 39, 2, -48 },
  { 9596, 14, 59, 21, 6, -48 },
  { 9700, 20, 48, 22, 1, -48 },
  { 9820, 13, 59, 21, 2, -48 },
  { 9916, 32, 30, 38, 3, -48 },
  { 10036, 27, 2, 27, 0, 6 },
  { 10043, 11, 10, 17, 3, -51 },
  { 10057, 26, 37, 35, 3, -36 },
  { 10178, 30, 52, 40, 6, -51 },
  { 10373, 26, 37, 32, 4, -36 },
  { 10494, 30, 52, 40, 4, -51 },
  { 10689, 29, 37, 37, 4, -36 },
  { 10824, 22, 51, 19, 1, -51 },
  { 10965, 30, 52, 40, 4, -36 },
  { 11160, 27, 51, 39, 6, -51 },
  { 11333, 4, 49, 15, 5, -49 },
  { 11358, 12, 65, 15, -3, -49 },
  { 11456, 26, 51, 31, 6, -51 },
  { 11622, 3, 51, 15, 6, -51 },
  { 11642, 47, 36, 58, 6, -36 },
  { 11854, 27, 36, 39, 6, -36 },
  { 11976, 31, 37, 39, 4, -36 },
  { 12120, 30, 52, 40, 6, -36 },
  { 12315, 29, 52, 40, 4, -36 },
  { 12504, 19, 36, 26, 6, -36 },
  { 12590, 25, 37, 31, 3, -36 },
  { 12706, 19, 45, 22, 1, -44 },
  { 12813, 28, 37, 39, 5, -36 },
  { 12943, 30, 36, 30, 0, -36 },
  { 13078, 45, 35, 47, 1, -35 },
  { 13275, 29, 36, 33, 2, -36 },
  { 13406, 30, 52, 30, 0, -36 },
  { 13601, 25, 36, 31, 3, -36 },
  { 13714, 19, 59, 23, 2, -48 },
  { 13855, 2, 68, 36, 17, -51 },
  { 13872, 19, 59, 23, 2, -48 },
  { 14013, 31, 7, 38, 4, -27 },
};

const GFXfont NotoSans_ExtraLight67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRALIGHT67PT7B_H_
