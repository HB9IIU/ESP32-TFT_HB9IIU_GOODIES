#ifndef _NOTOSANS_EXTRALIGHT10PT7B_H_
#define _NOTOSANS_EXTRALIGHT10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x28, 0xA7, 0xCA, 0xFD, 0x45, 0x00, 0x4F, 0xCC, 0x65,
  0x5E, 0x40, 0xCA, 0xAB, 0x3B, 0x35, 0x54, 0xC0, 0xF2, 0x46, 0x28, 0x96,
  0x2F, 0x40, 0xC0, 0x5A, 0xA9, 0x40, 0xD5, 0x55, 0x80, 0x44, 0xF6, 0xA0,
  0x44, 0xF4, 0x40, 0xC0, 0xE0, 0x80, 0x24, 0xA5, 0x20, 0xF9, 0x99, 0x99,
  0xF0, 0x75, 0x54, 0xF1, 0x12, 0x48, 0xF0, 0xF8, 0x42, 0x60, 0x87, 0xE0,
  0x10, 0xA2, 0x92, 0xFC, 0x20, 0x80, 0xF8, 0xE1, 0x11, 0xF0, 0xF8, 0xE9,
  0x99, 0xF0, 0xF1, 0x22, 0x24, 0x40, 0xF9, 0x96, 0x99, 0xF0, 0xF9, 0x9B,
  0x51, 0xE0, 0x08, 0x0C, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80,
  0xF1, 0x12, 0x40, 0x40, 0x7D, 0x06, 0xEE, 0x5C, 0xB6, 0xE0, 0x3C, 0x20,
  0xC5, 0x12, 0x7A, 0x18, 0x40, 0xF4, 0x65, 0xE8, 0xC7, 0xC0, 0x7C, 0x21,
  0x08, 0x41, 0xE0, 0xF4, 0x63, 0x18, 0xC7, 0xC0, 0xF8, 0x8F, 0x88, 0xF0,
  0xF8, 0x8F, 0x88, 0x80, 0x7C, 0x21, 0x38, 0xC5, 0xE0, 0x8C, 0x63, 0xF8,
  0xC6, 0x20, 0xFE, 0x55, 0x55, 0xC0, 0x9D, 0x31, 0x8A, 0x4A, 0x20, 0x88,
  0x88, 0x88, 0xF0, 0x86, 0x1C, 0x73, 0xAE, 0xD9, 0x40, 0x8C, 0x73, 0x59,
  0xCE, 0x20, 0x7A, 0x18, 0x61, 0x86, 0x17, 0x80, 0xF9, 0x9F, 0x88, 0x80,
  0x7A, 0x18, 0x61, 0x86, 0x16, 0x84, 0x08, 0xF4, 0x65, 0xCA, 0x4A, 0x20,
  0xF8, 0x86, 0x11, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x8C, 0x63, 0x18,
  0xC5, 0xE0, 0x86, 0x24, 0x92, 0x50, 0xC2, 0x00, 0x88, 0xCC, 0x95, 0x4A,
  0xA5, 0x51, 0x30, 0x88, 0x8A, 0x88, 0x45, 0x26, 0x20, 0x8A, 0x54, 0x42,
  0x10, 0x80, 0x78, 0x44, 0x42, 0x23, 0xE0, 0xEA, 0xAA, 0xC0, 0x91, 0x22,
  0x48, 0xD5, 0x55, 0xC0, 0x21, 0x93, 0x90, 0xF0, 0x90, 0x71, 0x79, 0xF0,
  0x88, 0xE9, 0x99, 0x9F, 0xF2, 0x4E, 0x11, 0x79, 0x99, 0x9F, 0xF9, 0xE8,
  0xF0, 0x2B, 0xA4, 0x92, 0xF9, 0x99, 0xF1, 0xF0, 0x88, 0xE9, 0x99, 0x99,
  0x3E, 0x05, 0x55, 0xC0, 0x88, 0x9A, 0xCC, 0xA9, 0xFF, 0xFF, 0x26, 0x4C,
  0x99, 0x20, 0xF9, 0x99, 0x90, 0xF9, 0x99, 0xF0, 0xF9, 0x99, 0xF8, 0x80,
  0xF9, 0x99, 0xF1, 0x10, 0xF2, 0x48, 0xFC, 0x21, 0xF0, 0x5D, 0x24, 0x98,
  0x99, 0x99, 0xF0, 0x99, 0x56, 0x20, 0x93, 0x25, 0xB3, 0x64, 0x40, 0xDB,
  0x08, 0xA8, 0x80, 0x99, 0x56, 0x22, 0xC0, 0x72, 0x24, 0xF0, 0x69, 0x2C,
  0x92, 0x20, 0xFF, 0xC0, 0xC9, 0x22, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraLight10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 2, 2, 3, 1, -7 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 6, 7, 8, 1, -7 },
  { 20, 6, 7, 7, 1, -7 },
  { 26, 1, 2, 2, 0, -7 },
  { 27, 2, 9, 3, 0, -7 },
  { 30, 2, 9, 3, 0, -7 },
  { 33, 4, 5, 6, 1, -8 },
  { 36, 4, 5, 6, 1, -6 },
  { 39, 1, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 1, -1 },
  { 42, 3, 7, 3, 0, -7 },
  { 45, 4, 7, 6, 1, -7 },
  { 49, 2, 7, 6, 1, -7 },
  { 51, 4, 7, 6, 1, -7 },
  { 55, 5, 7, 6, 0, -7 },
  { 60, 6, 7, 6, 0, -7 },
  { 66, 4, 7, 6, 1, -7 },
  { 70, 4, 7, 6, 1, -7 },
  { 74, 4, 7, 6, 1, -7 },
  { 78, 4, 7, 6, 1, -7 },
  { 82, 4, 7, 6, 1, -7 },
  { 86, 1, 5, 2, 1, -5 },
  { 87, 1, 6, 2, 0, -5 },
  { 88, 4, 5, 6, 1, -6 },
  { 91, 4, 3, 6, 1, -5 },
  { 93, 4, 5, 6, 1, -6 },
  { 96, 4, 7, 4, 0, -7 },
  { 100, 7, 8, 9, 1, -7 },
  { 107, 6, 7, 6, 0, -7 },
  { 113, 5, 7, 6, 1, -7 },
  { 118, 5, 7, 6, 1, -7 },
  { 123, 5, 7, 7, 1, -7 },
  { 128, 4, 7, 6, 1, -7 },
  { 132, 4, 7, 5, 1, -7 },
  { 136, 5, 7, 7, 1, -7 },
  { 141, 5, 7, 7, 1, -7 },
  { 146, 1, 7, 3, 1, -7 },
  { 147, 2, 9, 2, -1, -7 },
  { 150, 5, 7, 6, 1, -7 },
  { 155, 4, 7, 5, 1, -7 },
  { 159, 6, 7, 9, 1, -7 },
  { 165, 5, 7, 7, 1, -7 },
  { 170, 6, 7, 8, 1, -7 },
  { 176, 4, 7, 6, 1, -7 },
  { 180, 6, 9, 8, 1, -7 },
  { 187, 5, 7, 6, 1, -7 },
  { 192, 4, 7, 5, 1, -7 },
  { 196, 5, 7, 5, 0, -7 },
  { 201, 5, 7, 7, 1, -7 },
  { 206, 6, 7, 6, 0, -7 },
  { 212, 9, 7, 9, 0, -7 },
  { 220, 5, 7, 5, 0, -7 },
  { 225, 5, 7, 5, 0, -7 },
  { 230, 5, 7, 6, 0, -7 },
  { 235, 2, 9, 3, 1, -7 },
  { 238, 3, 7, 3, 0, -7 },
  { 241, 2, 9, 3, 0, -7 },
  { 244, 5, 4, 6, 0, -7 },
  { 247, 4, 1, 4, 0, 1 },
  { 248, 2, 2, 3, 0, -8 },
  { 249, 4, 5, 5, 0, -5 },
  { 252, 4, 8, 6, 1, -8 },
  { 256, 3, 5, 5, 1, -5 },
  { 258, 4, 8, 6, 1, -8 },
  { 262, 4, 5, 5, 1, -5 },
  { 265, 3, 8, 3, 0, -8 },
  { 268, 4, 7, 6, 1, -5 },
  { 272, 4, 8, 6, 1, -8 },
  { 276, 1, 7, 2, 1, -7 },
  { 277, 2, 9, 2, -1, -7 },
  { 280, 4, 8, 5, 1, -8 },
  { 284, 1, 8, 2, 1, -8 },
  { 285, 7, 5, 9, 1, -5 },
  { 290, 4, 5, 6, 1, -5 },
  { 293, 4, 5, 6, 1, -5 },
  { 296, 4, 7, 6, 1, -5 },
  { 300, 4, 7, 6, 1, -5 },
  { 304, 3, 5, 4, 1, -5 },
  { 306, 4, 5, 5, 0, -5 },
  { 309, 3, 7, 3, 0, -7 },
  { 312, 4, 5, 6, 1, -5 },
  { 315, 4, 5, 4, 0, -5 },
  { 318, 7, 5, 7, 0, -5 },
  { 323, 5, 5, 5, 0, -5 },
  { 327, 4, 7, 4, 0, -5 },
  { 331, 4, 5, 5, 0, -5 },
  { 334, 3, 9, 3, 0, -7 },
  { 338, 1, 10, 5, 2, -8 },
  { 340, 3, 9, 3, 0, -7 },
  { 344, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_ExtraLight10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRALIGHT10PT7B_H_
