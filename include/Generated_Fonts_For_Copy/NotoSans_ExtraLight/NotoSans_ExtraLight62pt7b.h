#ifndef _NOTOSANS_EXTRALIGHT62PT7B_H_
#define _NOTOSANS_EXTRALIGHT62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight62pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x60,
  0xE0, 0x3F, 0x01, 0xF8, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC,
  0x06, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80,
  0xCC, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x18, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0xF0, 0xC3, 0xF0, 0xF0, 0x30, 0x18, 0x38, 0x0C,
  0x00, 0x1C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00,
  0xE0, 0x0C, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x30,
  0x00, 0x3C, 0x0C, 0x00, 0x07, 0xC3, 0x00, 0x00, 0x7C, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xDF, 0x00,
  0x00, 0x31, 0xF0, 0x00, 0x0C, 0x1E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0,
  0x38, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x70, 0x00,
  0xC0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x03,
  0xCE, 0x00, 0xC1, 0xE3, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x30, 0x01, 0xC3, 0xC0, 0x00, 0x18, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x80,
  0x70, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0x30,
  0x00, 0xE0, 0x60, 0x00, 0x0C, 0x00, 0x30, 0x30, 0x3F, 0x83, 0x00, 0x0C,
  0x0C, 0x1F, 0xF0, 0xC0, 0x03, 0x06, 0x0E, 0x0E, 0x38, 0x01, 0xC3, 0x87,
  0x01, 0xC6, 0x00, 0x60, 0xC3, 0x80, 0x39, 0xC0, 0x18, 0x70, 0xC0, 0x06,
  0x38, 0x0C, 0x18, 0x30, 0x01, 0x87, 0x0F, 0x0E, 0x1C, 0x00, 0x70, 0xFF,
  0x83, 0x07, 0x00, 0x1C, 0x1F, 0x81, 0x81, 0x80, 0x03, 0x00, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x30, 0x00, 0x1C, 0x06, 0x00,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x30, 0x00, 0x70, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x06,
  0x00, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x00, 0x3E, 0xF8, 0x01, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x70, 0x03, 0x80, 0x00, 0xC3,
  0x80, 0x07, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x00, 0x63, 0x80, 0x00, 0x38, 0x01, 0x8E, 0x00, 0x00, 0x70, 0x0E, 0x30,
  0x00, 0x00, 0xE0, 0x30, 0xC0, 0x00, 0x01, 0xC1, 0xC3, 0x00, 0x00, 0x03,
  0x8E, 0x0C, 0x00, 0x00, 0x07, 0x30, 0x30, 0x00, 0x00, 0x0F, 0xC0, 0xE0,
  0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x78, 0x06, 0x00, 0x00, 0x03,
  0xF0, 0x1C, 0x00, 0x00, 0x1C, 0xE0, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0xF0,
  0x00, 0x0F, 0x03, 0x81, 0xF0, 0x00, 0xF8, 0x07, 0x01, 0xFF, 0xFF, 0x80,
  0x1E, 0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0xE0, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x78, 0x03,
  0x00, 0x7F, 0xC0, 0xC0, 0xFC, 0xFE, 0x31, 0xFC, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80,
  0x60, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0xF0, 0x06,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x60, 0xC3, 0x86,
  0x0C, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x0E, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x30,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x0F, 0xC0, 0x7B, 0x03, 0x8C, 0x3C, 0x31, 0xE0,
  0xCE, 0x03, 0xF0, 0x0D, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF0, 0xFC, 0x03,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x86, 0x00, 0x00, 0x38, 0x40, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0xDF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E,
  0x1F, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x01,
  0x80, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x3F, 0xF0, 0x0E, 0x1F, 0xFF, 0xC0,
  0xE3, 0xC0, 0x1F, 0x0E, 0x70, 0x00, 0x78, 0xCC, 0x00, 0x01, 0xCD, 0x80,
  0x00, 0x1C, 0xD8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x81, 0xF0, 0x07, 0x80, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03,
  0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x01, 0xE0, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x78,
  0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0xF0, 0x01,
  0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0xF3, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x01, 0xB1, 0xC0, 0x00, 0x73, 0x0E,
  0x00, 0x0E, 0x30, 0x7C, 0x07, 0xC3, 0x03, 0xFF, 0xF0, 0x70, 0x07, 0xFC,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xF3, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF6, 0x0E, 0x3C, 0x78,
  0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE1, 0xC3, 0x87,
  0x0C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0xC0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xFE, 0x0F, 0xE0, 0xFC, 0x18, 0x00, 0x78, 0x80, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x18, 0x00, 0x07,
  0xFF, 0xC0, 0x06, 0x38, 0x00, 0x1F, 0xFF, 0xC0, 0x06, 0x30, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x70, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0x60, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x60, 0x03, 0x80,
  0x00, 0xC0, 0x03, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x60, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0x03, 0xE0, 0x07, 0x00,
  0x00, 0xC0, 0x03, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x03, 0xE0, 0x06, 0x00,
  0x00, 0xC0, 0x03, 0xE0, 0x06, 0x00, 0x01, 0xC0, 0x03, 0xE0, 0x06, 0x00,
  0x01, 0xC0, 0x03, 0xE0, 0x06, 0x00, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00,
  0x01, 0xC0, 0x06, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x06, 0x60, 0x03, 0x00,
  0x03, 0xC0, 0x0E, 0x60, 0x03, 0x80, 0x06, 0xC0, 0x0C, 0x60, 0x01, 0xC0,
  0x0E, 0x60, 0x1C, 0x70, 0x00, 0xE0, 0x1C, 0x70, 0x38, 0x30, 0x00, 0x7F,
  0xF8, 0x3F, 0xF0, 0x30, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x38, 0x00,
  0x0F, 0xC1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC1,
  0xC0, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0x80,
  0x00, 0x7C, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x03, 0xF8, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0E, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x1C,
  0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1F, 0x80,
  0x70, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x40,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xEF, 0xF0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xFF, 0xFF,
  0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x03, 0xCE, 0x1F, 0x1F, 0xFC, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x0E, 0x77, 0x00,
  0x00, 0x77, 0x1C, 0x00, 0x03, 0xB0, 0x70, 0x00, 0x1F, 0x03, 0x80, 0x00,
  0xF0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03,
  0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1B, 0xEC, 0x00, 0x00, 0x00, 0x3B, 0xEE, 0x00, 0x00, 0x00, 0x33,
  0xE6, 0x00, 0x00, 0x00, 0x33, 0xE7, 0x00, 0x00, 0x00, 0x73, 0xE7, 0x00,
  0x00, 0x00, 0x63, 0xE3, 0x00, 0x00, 0x00, 0xE3, 0xE3, 0x80, 0x00, 0x00,
  0xC3, 0xE1, 0x80, 0x00, 0x00, 0xC3, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0xE1,
  0xC0, 0x00, 0x01, 0x83, 0xE0, 0xC0, 0x00, 0x03, 0x83, 0xE0, 0xE0, 0x00,
  0x03, 0x03, 0xE0, 0x60, 0x00, 0x03, 0x03, 0xE0, 0x70, 0x00, 0x07, 0x03,
  0xE0, 0x70, 0x00, 0x06, 0x03, 0xE0, 0x30, 0x00, 0x0E, 0x03, 0xE0, 0x38,
  0x00, 0x0C, 0x03, 0xE0, 0x18, 0x00, 0x0C, 0x03, 0xE0, 0x1C, 0x00, 0x1C,
  0x03, 0xE0, 0x0C, 0x00, 0x18, 0x03, 0xE0, 0x0C, 0x00, 0x38, 0x03, 0xE0,
  0x0E, 0x00, 0x30, 0x03, 0xE0, 0x06, 0x00, 0x30, 0x03, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0xE0, 0x03, 0x00, 0x60, 0x03, 0xE0, 0x03, 0x00, 0xE0, 0x03,
  0xE0, 0x03, 0x80, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0xC0, 0x03, 0xE0, 0x01,
  0xC1, 0xC0, 0x03, 0xE0, 0x00, 0xC1, 0x80, 0x03, 0xE0, 0x00, 0xC3, 0x80,
  0x03, 0xE0, 0x00, 0xE3, 0x00, 0x03, 0xE0, 0x00, 0x67, 0x00, 0x03, 0xE0,
  0x00, 0x77, 0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x07, 0xE7, 0x00, 0x00,
  0x07, 0xE3, 0x80, 0x00, 0x07, 0xE3, 0x80, 0x00, 0x07, 0xE1, 0xC0, 0x00,
  0x07, 0xE0, 0xE0, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x07, 0xE0, 0x70, 0x00,
  0x07, 0xE0, 0x38, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x07, 0xE0, 0x1C, 0x00,
  0x07, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x07, 0x00,
  0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0,
  0x07, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x70,
  0x07, 0xE0, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x38, 0x07, 0xE0, 0x00, 0x1C,
  0x07, 0xE0, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x07,
  0x07, 0xE0, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x03, 0x87, 0xE0, 0x00, 0x01,
  0xC7, 0xE0, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x00,
  0x77, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x30, 0xE0,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x0E, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x78, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x0F,
  0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x38, 0x00, 0x3F, 0x81, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78,
  0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x3E, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x0E,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0xF8, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x88, 0x00, 0x00,
  0x70, 0xF8, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x60,
  0xF0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x00, 0x38, 0x06, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00,
  0x07, 0x30, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x60, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x30, 0x01, 0x80, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x06, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01,
  0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x38, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x03, 0x80, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x1F, 0x00, 0x3C,
  0x08, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xFF, 0x03, 0xFE, 0x03, 0x0F, 0x80, 0x03, 0x1C, 0x00, 0x03,
  0x38, 0x00, 0x03, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1B, 0x60, 0x00, 0x1B, 0x70, 0x00, 0x73, 0x3C, 0x00, 0xE3,
  0x1F, 0xFF, 0xC3, 0x0F, 0xFF, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x7F,
  0xF0, 0x0E, 0x1F, 0xFF, 0xC0, 0xE3, 0xC0, 0x1E, 0x0E, 0x70, 0x00, 0x70,
  0xEE, 0x00, 0x03, 0x8E, 0xC0, 0x00, 0x1C, 0xF8, 0x00, 0x01, 0xCF, 0x80,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x0C, 0xF8, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x38,
  0xEC, 0x00, 0x03, 0x8E, 0xE0, 0x00, 0xF0, 0xE7, 0x80, 0x1E, 0x0C, 0x3F,
  0xFF, 0xC0, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xFC, 0x0F, 0x80, 0x18, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x01, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x3F,
  0xF8, 0x18, 0x1F, 0xFF, 0xC3, 0x07, 0x80, 0x3C, 0x61, 0xC0, 0x01, 0xCC,
  0x70, 0x00, 0x1D, 0x9C, 0x00, 0x01, 0xB3, 0x80, 0x00, 0x1E, 0xE0, 0x00,
  0x03, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0F, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x6C, 0xE0, 0x00, 0x1D,
  0x8F, 0x00, 0x07, 0x30, 0xF0, 0x01, 0xC6, 0x0F, 0xFF, 0xF0, 0xC0, 0x7F,
  0xF8, 0x18, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x20, 0x78, 0x00, 0x38, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x38, 0x02, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x60, 0x7F, 0xFF, 0x0C, 0x1E, 0x00, 0x71, 0x87, 0x00,
  0x07, 0x31, 0xC0, 0x00, 0x36, 0x70, 0x00, 0x06, 0xCC, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x0F, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xB3, 0xC0,
  0x00, 0x76, 0x3C, 0x00, 0x1C, 0xC3, 0xC0, 0x07, 0x18, 0x1F, 0xFF, 0xC3,
  0x01, 0xFF, 0xE0, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x20, 0x00, 0x03, 0x83, 0x80, 0x01, 0xF0, 0x7F, 0x81, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x03, 0xFF, 0x81, 0x87, 0xFF, 0xF0, 0xC7, 0x80, 0x3C, 0x67,
  0x00, 0x0F, 0x36, 0x00, 0x03, 0x9F, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xEF, 0xFF, 0x40,
  0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC8, 0x78, 0xFF,
  0x07, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x07, 0x60, 0x00, 0x1C,
  0xC0, 0x00, 0x71, 0x80, 0x01, 0xC3, 0x00, 0x07, 0x06, 0x00, 0x1C, 0x0C,
  0x00, 0x70, 0x18, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x0E, 0x00, 0xC0,
  0x38, 0x01, 0x80, 0xE0, 0x03, 0x03, 0x80, 0x06, 0x0E, 0x00, 0x0C, 0x38,
  0x00, 0x18, 0xF8, 0x00, 0x33, 0xB8, 0x00, 0x66, 0x38, 0x00, 0xD8, 0x30,
  0x01, 0xE0, 0x70, 0x03, 0x80, 0x70, 0x06, 0x00, 0x70, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xC0, 0x00, 0xC1,
  0x80, 0x01, 0xC3, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xCC, 0x00, 0x01, 0x98,
  0x00, 0x03, 0xB0, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x81, 0xFF, 0x80, 0x1F, 0xFC, 0x18,
  0x7F, 0xFC, 0x07, 0xFF, 0xC3, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x6E, 0x00,
  0x3C, 0xE0, 0x01, 0xCD, 0x80, 0x03, 0x98, 0x00, 0x1D, 0xE0, 0x00, 0x36,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x37, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x80, 0xFF, 0xE0, 0x61, 0xFF, 0xFC, 0x31, 0xE0,
  0x0F, 0x19, 0xC0, 0x03, 0xCD, 0x80, 0x00, 0xE6, 0x80, 0x00, 0x3B, 0xC0,
  0x00, 0x0D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x1E,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0xFF, 0xE0, 0x18, 0x3F, 0xFF, 0x03, 0x1E, 0x00, 0xF0, 0x67, 0x00, 0x07,
  0x0D, 0xC0, 0x00, 0x71, 0xB0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x67, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0x7C, 0x00, 0x01, 0xCD, 0x80, 0x00,
  0x71, 0x9C, 0x00, 0x1C, 0x31, 0xC0, 0x0F, 0x06, 0x1F, 0xFF, 0xC0, 0xC0,
  0xFF, 0xE0, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x30, 0x1F, 0xFF, 0xC3,
  0x03, 0xC0, 0x1E, 0x30, 0x70, 0x00, 0x73, 0x0E, 0x00, 0x03, 0xB1, 0xC0,
  0x00, 0x1B, 0x18, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x0F,
  0x38, 0x00, 0x01, 0xB1, 0x80, 0x00, 0x1B, 0x1C, 0x00, 0x03, 0x30, 0xE0,
  0x00, 0x73, 0x07, 0x80, 0x1E, 0x30, 0x3F, 0xFF, 0x83, 0x00, 0xFF, 0xF0,
  0x30, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xE1, 0xFF, 0xF3, 0xC0, 0x39,
  0x80, 0x0D, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x78, 0x00,
  0xF1, 0xC0, 0x00, 0x47, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xD0, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x07, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x1F,
  0x70, 0x00, 0x0D, 0xCE, 0x00, 0x06, 0x71, 0xE0, 0x07, 0x1C, 0x3F, 0xFF,
  0x87, 0x07, 0xFF, 0x81, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x60, 0x06, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x76, 0x00, 0x01, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x78, 0x00,
  0x06, 0x70, 0x00, 0x1B, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x30, 0x00, 0x30, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0x38, 0x00,
  0x71, 0x80, 0x07, 0x06, 0x00, 0x18, 0x60, 0x01, 0x81, 0x80, 0x06, 0x1C,
  0x00, 0x60, 0x70, 0x03, 0x83, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0xC0, 0x0E,
  0x03, 0x00, 0x30, 0x38, 0x03, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x06, 0x01, 0x80, 0x70, 0x18, 0x01, 0x80, 0xE0,
  0x0C, 0x06, 0x00, 0x70, 0x30, 0x03, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0xE0,
  0xE0, 0x03, 0x07, 0x00, 0x18, 0x30, 0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00,
  0x38, 0x60, 0x01, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x71, 0xC0, 0x01, 0x8E,
  0x00, 0x0C, 0x60, 0x00, 0x73, 0x00, 0x03, 0x18, 0x00, 0x1C, 0xC0, 0x00,
  0xEE, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80,
  0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70,
  0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60,
  0x06, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x78, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x5E, 0x0F, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0xEC, 0x00, 0x1F, 0xFE, 0x40, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraLight62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 45, 14, 5, -44 },
  { 24, 13, 16, 21, 4, -44 },
  { 50, 36, 44, 40, 2, -44 },
  { 248, 26, 51, 35, 4, -47 },
  { 414, 42, 46, 50, 4, -45 },
  { 656, 38, 46, 44, 4, -45 },
  { 875, 3, 16, 11, 4, -44 },
  { 881, 11, 54, 16, 3, -44 },
  { 956, 12, 54, 16, 2, -44 },
  { 1037, 26, 25, 34, 4, -47 },
  { 1119, 29, 29, 35, 3, -36 },
  { 1225, 7, 15, 12, 2, -7 },
  { 1239, 15, 2, 20, 2, -18 },
  { 1243, 4, 5, 14, 5, -4 },
  { 1246, 19, 44, 21, 1, -44 },
  { 1351, 28, 46, 35, 4, -45 },
  { 1512, 14, 44, 35, 6, -44 },
  { 1589, 27, 45, 35, 4, -45 },
  { 1741, 28, 46, 35, 3, -45 },
  { 1902, 34, 45, 35, 1, -45 },
  { 2094, 27, 45, 35, 4, -44 },
  { 2246, 28, 46, 35, 4, -45 },
  { 2407, 29, 44, 35, 3, -44 },
  { 2567, 27, 46, 35, 4, -45 },
  { 2723, 28, 46, 35, 3, -45 },
  { 2884, 4, 34, 14, 5, -33 },
  { 2901, 7, 41, 14, 2, -33 },
  { 2937, 29, 29, 35, 3, -37 },
  { 3043, 29, 14, 35, 3, -29 },
  { 3094, 29, 29, 35, 3, -37 },
  { 3200, 22, 46, 26, 2, -45 },
  { 3327, 48, 50, 55, 3, -44 },
  { 3627, 37, 44, 37, 0, -44 },
  { 3831, 29, 44, 39, 6, -44 },
  { 3991, 32, 46, 38, 4, -45 },
  { 4175, 33, 44, 43, 6, -44 },
  { 4357, 24, 44, 34, 6, -44 },
  { 4489, 24, 44, 31, 6, -44 },
  { 4621, 36, 46, 45, 4, -45 },
  { 4828, 32, 44, 44, 6, -44 },
  { 5004, 11, 44, 18, 4, -44 },
  { 5065, 15, 55, 15, -6, -44 },
  { 5169, 29, 44, 35, 6, -44 },
  { 5329, 24, 44, 32, 6, -44 },
  { 5461, 40, 44, 53, 6, -44 },
  { 5681, 32, 44, 44, 6, -44 },
  { 5857, 39, 46, 47, 4, -45 },
  { 6082, 26, 44, 36, 6, -44 },
  { 6225, 39, 56, 47, 4, -45 },
  { 6498, 29, 44, 36, 6, -44 },
  { 6658, 28, 46, 34, 3, -45 },
  { 6819, 32, 44, 32, 0, -44 },
  { 6995, 33, 45, 44, 6, -44 },
  { 7181, 35, 44, 35, 0, -44 },
  { 7374, 51, 44, 55, 2, -44 },
  { 7655, 33, 44, 33, 0, -44 },
  { 7837, 32, 44, 32, 0, -44 },
  { 8013, 31, 44, 36, 2, -44 },
  { 8184, 13, 54, 20, 5, -44 },
  { 8272, 19, 44, 21, 1, -44 },
  { 8377, 12, 54, 20, 2, -44 },
  { 8458, 30, 28, 35, 3, -45 },
  { 8563, 25, 2, 25, 0, 6 },
  { 8570, 11, 9, 16, 2, -47 },
  { 8583, 24, 34, 32, 3, -33 },
  { 8685, 28, 48, 37, 5, -47 },
  { 8853, 23, 34, 29, 4, -33 },
  { 8951, 27, 48, 37, 4, -47 },
  { 9113, 26, 34, 34, 4, -33 },
  { 9224, 21, 47, 18, 1, -47 },
  { 9348, 27, 48, 37, 4, -33 },
  { 9510, 25, 47, 36, 6, -47 },
  { 9657, 4, 45, 13, 5, -45 },
  { 9680, 12, 60, 13, -3, -45 },
  { 9770, 23, 47, 29, 6, -47 },
  { 9906, 2, 47, 13, 6, -47 },
  { 9918, 43, 33, 54, 6, -33 },
  { 10096, 25, 33, 36, 6, -33 },
  { 10200, 28, 34, 36, 4, -33 },
  { 10319, 27, 48, 37, 6, -33 },
  { 10481, 28, 48, 37, 3, -33 },
  { 10649, 17, 33, 24, 6, -33 },
  { 10720, 23, 34, 29, 3, -33 },
  { 10818, 18, 42, 20, 1, -41 },
  { 10913, 26, 34, 36, 5, -33 },
  { 11024, 28, 33, 28, 0, -33 },
  { 11140, 42, 33, 44, 1, -33 },
  { 11314, 28, 33, 30, 1, -33 },
  { 11430, 28, 48, 28, 0, -33 },
  { 11598, 23, 33, 28, 3, -33 },
  { 11693, 17, 54, 21, 2, -44 },
  { 11808, 3, 62, 33, 15, -47 },
  { 11832, 18, 54, 21, 2, -44 },
  { 11954, 29, 6, 35, 3, -25 },
};

const GFXfont NotoSans_ExtraLight62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRALIGHT62PT7B_H_
