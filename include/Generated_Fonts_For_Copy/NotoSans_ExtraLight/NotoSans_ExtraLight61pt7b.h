#ifndef _NOTOSANS_EXTRALIGHT61PT7B_H_
#define _NOTOSANS_EXTRALIGHT61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight61pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x20,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x36, 0x03,
  0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x78, 0x60, 0x78, 0x70, 0x30, 0x04, 0x70, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x38, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01, 0xE1, 0x80, 0x00,
  0x7C, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x06, 0x3E, 0x00, 0x03, 0x07, 0x80, 0x01, 0x80,
  0xE0, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0E, 0x00,
  0x18, 0x0E, 0x70, 0x0C, 0x1E, 0x3F, 0xC6, 0x7E, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x30, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x07, 0x00, 0x06,
  0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0x80, 0x30, 0x00, 0x38, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x06, 0x03, 0x00, 0x00, 0x60, 0x01, 0x81, 0xC0, 0x00,
  0x18, 0x00, 0x60, 0x60, 0x3C, 0x06, 0x00, 0x18, 0x38, 0x3F, 0xC1, 0x80,
  0x06, 0x0C, 0x1C, 0x78, 0x70, 0x03, 0x87, 0x0E, 0x07, 0x0C, 0x00, 0xC1,
  0x87, 0x00, 0xE3, 0x00, 0x70, 0xC1, 0x80, 0x18, 0x60, 0x18, 0x30, 0xE0,
  0x06, 0x1C, 0x0E, 0x18, 0x30, 0x01, 0xC3, 0xFF, 0x0E, 0x0C, 0x00, 0x30,
  0x3F, 0x03, 0x03, 0x00, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x03, 0x00, 0x00,
  0x60, 0x70, 0x00, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x00, 0x0C, 0x07,
  0x00, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00,
  0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x18, 0x00, 0x60, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x0C, 0x00, 0x03, 0x81, 0xC0,
  0x06, 0x00, 0x00, 0x79, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x71,
  0xC0, 0x07, 0x00, 0x03, 0x8C, 0x00, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0x70,
  0x01, 0xCE, 0x00, 0x01, 0xC0, 0x0C, 0x70, 0x00, 0x07, 0x00, 0x63, 0x00,
  0x00, 0x1C, 0x07, 0x18, 0x00, 0x00, 0x70, 0x30, 0xC0, 0x00, 0x01, 0xC3,
  0x86, 0x00, 0x00, 0x07, 0x38, 0x30, 0x00, 0x00, 0x1D, 0x81, 0x80, 0x00,
  0x00, 0x7C, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x1F, 0x01,
  0xC0, 0x00, 0x03, 0xDC, 0x07, 0x00, 0x00, 0x3C, 0x70, 0x3C, 0x00, 0x03,
  0x81, 0xC0, 0xF8, 0x00, 0xF8, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x1C, 0x03,
  0xFF, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xDB,
  0x6D, 0xB6, 0xDB, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0xBC, 0x03, 0x01, 0xFF,
  0xE0, 0x83, 0xFC, 0x7F, 0x27, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0x60, 0x01,
  0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x04, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x71, 0xC7, 0x1C, 0x63,
  0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0x20, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x07, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x70, 0x00, 0x06, 0x07, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x70, 0x07, 0xC0, 0x3B, 0x03, 0xCC, 0x1E, 0x30, 0xE0, 0xCF, 0x03, 0x78,
  0x0F, 0x80, 0x34, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x01, 0xF0,
  0x0F, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x20, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x70,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x07, 0x1F, 0x00, 0x07, 0xC1, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xA0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x07, 0x00, 0x01, 0x80, 0x07, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xCF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xF0, 0x02, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x03,
  0xF8, 0x03, 0x83, 0xFF, 0xE0, 0x71, 0xF0, 0x1F, 0x0C, 0x70, 0x00, 0xF1,
  0x9C, 0x00, 0x07, 0x37, 0x00, 0x00, 0x66, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0x70, 0x03, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x70, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x00,
  0x7D, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x3C, 0x00,
  0x07, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x03, 0x87, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1F, 0x1C, 0x00, 0x07, 0x71,
  0xE0, 0x00, 0xE7, 0x0F, 0x80, 0x3C, 0x60, 0x3F, 0xFF, 0x06, 0x00, 0xFF,
  0xC0, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x3F, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF2, 0x0C, 0x3C,
  0x78, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xE1, 0xC3,
  0x86, 0x0C, 0x38, 0x70, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0xC0, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xFC,
  0x3E, 0x01, 0xF0, 0x80, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xFE, 0x00, 0x0C,
  0x18, 0x00, 0x1F, 0xFF, 0xC0, 0x0C, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x0E,
  0x30, 0x00, 0x70, 0x00, 0xC0, 0x06, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x06,
  0x60, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x60, 0x03, 0x80, 0x01, 0xC0, 0x06,
  0x60, 0x03, 0x00, 0x01, 0x80, 0x06, 0x60, 0x07, 0x00, 0x01, 0x80, 0x07,
  0xE0, 0x07, 0x00, 0x01, 0x80, 0x07, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x07,
  0xC0, 0x06, 0x00, 0x01, 0x80, 0x06, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x06,
  0xC0, 0x06, 0x00, 0x01, 0x80, 0x06, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x06,
  0xC0, 0x06, 0x00, 0x01, 0x80, 0x06, 0xE0, 0x06, 0x00, 0x03, 0x80, 0x0E,
  0xE0, 0x06, 0x00, 0x03, 0x80, 0x0C, 0x60, 0x07, 0x00, 0x07, 0x80, 0x0C,
  0x60, 0x03, 0x00, 0x06, 0xC0, 0x18, 0x60, 0x03, 0x80, 0x0C, 0xC0, 0x38,
  0x60, 0x01, 0xC0, 0x18, 0xE0, 0x70, 0x70, 0x00, 0xFF, 0xF0, 0x7F, 0xE0,
  0x30, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xE0,
  0x00, 0x7E, 0x0E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0x7C,
  0x07, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x1F, 0x80, 0x70, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x04, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x06,
  0x1C, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x18, 0x1E, 0x00, 0x00,
  0x03, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xCF, 0x7F, 0x1F,
  0xF8, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x3F, 0x00, 0x00, 0x73, 0xB8, 0x00, 0x03,
  0xB8, 0xE0, 0x00, 0x1F, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xD8,
  0x00, 0x00, 0x00, 0x1F, 0xDC, 0x00, 0x00, 0x00, 0x3F, 0xDC, 0x00, 0x00,
  0x00, 0x37, 0xCC, 0x00, 0x00, 0x00, 0x37, 0xCE, 0x00, 0x00, 0x00, 0x77,
  0xC6, 0x00, 0x00, 0x00, 0x67, 0xC7, 0x00, 0x00, 0x00, 0xE7, 0xC7, 0x00,
  0x00, 0x00, 0xC7, 0xC3, 0x00, 0x00, 0x00, 0xC7, 0xC3, 0x80, 0x00, 0x01,
  0xC7, 0xC1, 0x80, 0x00, 0x01, 0x87, 0xC1, 0xC0, 0x00, 0x03, 0x87, 0xC1,
  0xC0, 0x00, 0x03, 0x07, 0xC0, 0xC0, 0x00, 0x03, 0x07, 0xC0, 0xE0, 0x00,
  0x07, 0x07, 0xC0, 0x60, 0x00, 0x06, 0x07, 0xC0, 0x70, 0x00, 0x0E, 0x07,
  0xC0, 0x70, 0x00, 0x0C, 0x07, 0xC0, 0x30, 0x00, 0x0C, 0x07, 0xC0, 0x38,
  0x00, 0x1C, 0x07, 0xC0, 0x18, 0x00, 0x18, 0x07, 0xC0, 0x1C, 0x00, 0x38,
  0x07, 0xC0, 0x1C, 0x00, 0x30, 0x07, 0xC0, 0x0C, 0x00, 0x30, 0x07, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0xC0, 0x06, 0x00, 0x60, 0x07, 0xC0, 0x07, 0x00,
  0xE0, 0x07, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0xC0, 0x03, 0x00, 0xC0, 0x07,
  0xC0, 0x03, 0x81, 0xC0, 0x07, 0xC0, 0x01, 0x81, 0x80, 0x07, 0xC0, 0x01,
  0xC3, 0x80, 0x07, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0xC0, 0x00, 0xC7, 0x00,
  0x07, 0xC0, 0x00, 0xE6, 0x00, 0x07, 0xC0, 0x00, 0x66, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x3C, 0x0E,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xE0,
  0x07, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x01, 0xC0,
  0x3C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xB4, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0x80,
  0x01, 0xF0, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x8E, 0x00, 0x07, 0xC3, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xBF, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x03,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x18,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x07, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80,
  0x7F, 0x07, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x07,
  0xC3, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x37, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x30, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x63, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x38, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x70, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x0C, 0x00,
  0x1C, 0x03, 0x80, 0x06, 0x03, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x60,
  0x01, 0x80, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x03, 0x80, 0x60,
  0x03, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0E,
  0x00, 0x18, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x86, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0x61, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xE0, 0x00,
  0x06, 0x30, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x30, 0x00, 0x18,
  0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0,
  0x1F, 0xC0, 0xF8, 0x1E, 0x00, 0x3C, 0x10, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xE7, 0x0F, 0xC0, 0x07,
  0x1E, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1B, 0x60, 0x00, 0x33, 0x70, 0x00, 0x73,
  0x38, 0x00, 0xE3, 0x1F, 0xFF, 0xC3, 0x0F, 0xFF, 0x03, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x80, 0x38,
  0x3F, 0xFE, 0x07, 0x1F, 0x83, 0xE0, 0xE7, 0x00, 0x0E, 0x1D, 0xC0, 0x00,
  0xE3, 0xB0, 0x00, 0x0E, 0x7C, 0x00, 0x00, 0xCF, 0x80, 0x00, 0x1D, 0xE0,
  0x00, 0x01, 0xBC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x0C, 0xF8, 0x00, 0x03, 0x9D, 0x80, 0x00, 0xE3, 0x38, 0x00,
  0x38, 0x63, 0x80, 0x1E, 0x0C, 0x3F, 0xFF, 0x81, 0x81, 0xFF, 0xE0, 0x00,
  0x05, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xE0, 0xF8,
  0x3C, 0x00, 0x10, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0x81, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x7F, 0x01, 0xC0, 0x7F, 0xFC, 0x38, 0x3F, 0x07, 0xC7, 0x0F,
  0x00, 0x1C, 0xE3, 0x80, 0x01, 0xDC, 0xE0, 0x00, 0x1B, 0x9C, 0x00, 0x01,
  0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xD8, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1F, 0x30, 0x00, 0x03, 0xE7,
  0x00, 0x00, 0xDC, 0x70, 0x00, 0x3B, 0x87, 0x80, 0x1E, 0x30, 0x7F, 0xFF,
  0x06, 0x03, 0xFF, 0xC0, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x20, 0x78, 0x00,
  0x70, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFE, 0x1C, 0x1F, 0x83, 0xE3, 0x87, 0x80, 0x0E, 0x71, 0xC0,
  0x00, 0x6E, 0x70, 0x00, 0x07, 0xCE, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x0F,
  0x70, 0x00, 0x01, 0xEC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xEC, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x0F, 0x9C, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x6E, 0x3C,
  0x00, 0x1D, 0xC3, 0xC0, 0x0F, 0x38, 0x3F, 0xFF, 0x87, 0x01, 0xFF, 0xE0,
  0xE0, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x07, 0x87, 0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xFE, 0x03, 0x83,
  0xFF, 0xE1, 0xC7, 0xC0, 0xF8, 0xE7, 0x00, 0x1E, 0x77, 0x00, 0x03, 0xBB,
  0x00, 0x01, 0xDF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0C, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0xFF, 0x8F, 0xF0, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x02,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0,
  0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0xE0, 0x00, 0xE7, 0x60, 0x00,
  0xE6, 0x70, 0x00, 0xEC, 0x38, 0x00, 0xF8, 0x1C, 0x00, 0xF0, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0x80,
  0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x30,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x18,
  0x3F, 0xFC, 0x03, 0xFF, 0xC3, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x73, 0x80,
  0x3C, 0x70, 0x03, 0xCE, 0xC0, 0x03, 0x9C, 0x00, 0x1D, 0xF0, 0x00, 0x3B,
  0x00, 0x03, 0xBC, 0x00, 0x03, 0xC0, 0x00, 0x37, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x60, 0x7F, 0xFC, 0x30, 0xF8,
  0x1F, 0x18, 0xE0, 0x03, 0xCE, 0xE0, 0x00, 0x77, 0x60, 0x00, 0x3B, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0xF0,
  0x00, 0xE0, 0x1E, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x0C, 0x0F, 0xFF, 0x80, 0xE1, 0xF0, 0x7C, 0x0E, 0x78, 0x00,
  0xE0, 0xE6, 0x00, 0x07, 0x0E, 0xC0, 0x00, 0x38, 0xF8, 0x00, 0x01, 0xCF,
  0x80, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xCF, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x01, 0xCF, 0x80, 0x00,
  0x38, 0xEC, 0x00, 0x07, 0x0E, 0xE0, 0x00, 0xF0, 0xE7, 0x80, 0x1E, 0x0E,
  0x1F, 0xFF, 0x80, 0xE0, 0xFF, 0xF0, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFE, 0x0C, 0x0F, 0xC1, 0xF1, 0x83, 0xC0, 0x07, 0x30, 0xE0, 0x00,
  0x76, 0x38, 0x00, 0x06, 0xC6, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x30,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x8C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x36, 0x1C, 0x00,
  0x0C, 0xC1, 0xE0, 0x07, 0x18, 0x1F, 0xDF, 0xC3, 0x00, 0xFF, 0xE0, 0x60,
  0x01, 0xE0, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x3F, 0x70, 0xFF, 0xF8, 0xF8, 0xFC, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xC1, 0xF8, 0x1F, 0xCE, 0x00, 0x06, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xEE, 0x00, 0x0F, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xB0, 0x00, 0x03, 0xDC, 0x00, 0x03,
  0x6E, 0x00, 0x03, 0xB3, 0x80, 0x03, 0x98, 0xF0, 0x07, 0x8C, 0x3F, 0xFF,
  0x86, 0x0F, 0xFF, 0x03, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x07, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x1C,
  0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x03, 0x00, 0x07,
  0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x60, 0x38, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x80, 0x00, 0xCE,
  0x00, 0x03, 0xC0, 0x00, 0x67, 0x00, 0x03, 0x70, 0x00, 0x71, 0x80, 0x01,
  0x98, 0x00, 0x38, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0x70, 0x00, 0xE7, 0x00,
  0x0C, 0x38, 0x00, 0x61, 0x80, 0x0E, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x06,
  0x00, 0x38, 0x70, 0x03, 0x03, 0x80, 0x18, 0x38, 0x01, 0x80, 0xC0, 0x0C,
  0x0C, 0x01, 0xC0, 0x60, 0x0E, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x80, 0x60, 0x38, 0x03,
  0x01, 0x80, 0x38, 0x18, 0x01, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xE0,
  0x06, 0x0E, 0x00, 0x30, 0x60, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xC3,
  0x00, 0x0E, 0x38, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x39, 0xC0, 0x01,
  0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xEE, 0x00, 0x06, 0x60, 0x00, 0x36, 0x00,
  0x03, 0x30, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x0D, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x0C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x06, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x01,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x06,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0x70, 0x00, 0x07,
  0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0xC0, 0x38, 0x00, 0x18, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x01, 0x80,
  0x38, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x38, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x86,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x78, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1E, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x01, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x01, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x06, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x13, 0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x3F, 0xFE, 0x80,
  0x00, 0xFF, 0x80,
};

const GFXglyph NotoSans_ExtraLight61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 45, 14, 5, -44 },
  { 24, 12, 16, 21, 4, -44 },
  { 48, 36, 44, 39, 2, -44 },
  { 246, 25, 50, 35, 4, -46 },
  { 403, 42, 45, 49, 3, -44 },
  { 640, 37, 45, 43, 4, -44 },
  { 849, 3, 16, 11, 4, -44 },
  { 855, 11, 54, 16, 3, -44 },
  { 930, 12, 54, 16, 2, -44 },
  { 1011, 26, 25, 34, 4, -46 },
  { 1093, 28, 29, 35, 3, -36 },
  { 1195, 6, 15, 12, 2, -7 },
  { 1207, 15, 3, 20, 2, -18 },
  { 1213, 4, 5, 14, 5, -4 },
  { 1216, 19, 44, 20, 1, -44 },
  { 1321, 27, 45, 35, 4, -44 },
  { 1473, 14, 44, 35, 6, -44 },
  { 1550, 27, 44, 35, 3, -44 },
  { 1699, 27, 45, 35, 3, -44 },
  { 1851, 33, 44, 35, 1, -44 },
  { 2033, 27, 45, 35, 4, -44 },
  { 2185, 27, 45, 35, 4, -44 },
  { 2337, 28, 44, 35, 3, -44 },
  { 2491, 27, 45, 35, 4, -44 },
  { 2643, 28, 45, 35, 3, -44 },
  { 2801, 4, 34, 14, 5, -33 },
  { 2818, 7, 41, 14, 2, -33 },
  { 2854, 28, 28, 35, 3, -36 },
  { 2952, 28, 15, 35, 3, -29 },
  { 3005, 28, 28, 35, 3, -36 },
  { 3103, 21, 45, 25, 2, -44 },
  { 3222, 48, 49, 54, 3, -43 },
  { 3516, 36, 44, 36, 0, -44 },
  { 3714, 28, 44, 38, 6, -44 },
  { 3868, 32, 45, 38, 4, -44 },
  { 4048, 33, 44, 43, 6, -44 },
  { 4230, 24, 44, 34, 6, -44 },
  { 4362, 24, 44, 30, 6, -44 },
  { 4494, 35, 45, 44, 4, -44 },
  { 4691, 31, 44, 44, 6, -44 },
  { 4862, 12, 44, 18, 3, -44 },
  { 4928, 15, 55, 15, -6, -44 },
  { 5032, 29, 44, 35, 6, -44 },
  { 5192, 24, 44, 31, 6, -44 },
  { 5324, 40, 44, 52, 6, -44 },
  { 5544, 31, 44, 43, 6, -44 },
  { 5715, 38, 45, 46, 4, -44 },
  { 5929, 26, 44, 35, 6, -44 },
  { 6072, 38, 54, 46, 4, -44 },
  { 6329, 28, 44, 36, 6, -44 },
  { 6483, 27, 45, 33, 3, -44 },
  { 6635, 31, 44, 31, 0, -44 },
  { 6806, 32, 45, 44, 6, -44 },
  { 6986, 35, 44, 35, 0, -44 },
  { 7179, 50, 44, 54, 2, -44 },
  { 7454, 32, 44, 32, 0, -44 },
  { 7630, 32, 44, 32, 0, -44 },
  { 7806, 31, 44, 35, 2, -44 },
  { 7977, 13, 54, 19, 5, -44 },
  { 8065, 19, 44, 20, 1, -44 },
  { 8170, 12, 54, 19, 2, -44 },
  { 8251, 29, 27, 35, 3, -44 },
  { 8349, 25, 2, 25, 0, 6 },
  { 8356, 11, 10, 16, 2, -47 },
  { 8370, 24, 34, 32, 3, -33 },
  { 8472, 27, 47, 36, 5, -46 },
  { 8631, 23, 34, 29, 4, -33 },
  { 8729, 27, 47, 36, 4, -46 },
  { 8888, 26, 34, 33, 4, -33 },
  { 8999, 20, 47, 18, 1, -47 },
  { 9117, 27, 48, 36, 4, -33 },
  { 9279, 25, 46, 36, 5, -46 },
  { 9423, 4, 44, 13, 5, -44 },
  { 9445, 12, 59, 13, -3, -44 },
  { 9534, 24, 46, 29, 5, -46 },
  { 9672, 3, 46, 13, 5, -46 },
  { 9690, 43, 33, 53, 5, -33 },
  { 9868, 25, 33, 36, 5, -33 },
  { 9972, 28, 34, 35, 4, -33 },
  { 10091, 28, 47, 36, 5, -33 },
  { 10256, 27, 47, 36, 3, -33 },
  { 10415, 17, 33, 23, 5, -33 },
  { 10486, 22, 34, 28, 3, -33 },
  { 10580, 17, 41, 20, 1, -40 },
  { 10668, 25, 33, 36, 5, -32 },
  { 10772, 27, 32, 27, 0, -32 },
  { 10880, 41, 32, 43, 1, -32 },
  { 11044, 27, 32, 30, 1, -32 },
  { 11152, 27, 47, 27, 0, -32 },
  { 11311, 23, 32, 28, 2, -32 },
  { 11403, 17, 54, 21, 2, -44 },
  { 11518, 2, 61, 33, 15, -46 },
  { 11534, 17, 54, 21, 2, -44 },
  { 11649, 28, 5, 35, 3, -24 },
};

const GFXfont NotoSans_ExtraLight61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRALIGHT61PT7B_H_
