#ifndef _NOTOSANS_EXTRALIGHT41PT7B_H_
#define _NOTOSANS_EXTRALIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight41pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x24, 0x80, 0x01, 0x7E,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x00, 0x20,
  0x10, 0x00, 0x60, 0x10, 0x00, 0x60, 0x30, 0x00, 0x40, 0x30, 0x00, 0x40,
  0x20, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0x60, 0x3F, 0xFF, 0xFF, 0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00,
  0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x02, 0x01,
  0x00, 0x02, 0x01, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x04, 0x03,
  0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x03, 0xFF, 0x83, 0x18, 0x63,
  0x0C, 0x03, 0x06, 0x01, 0x03, 0x00, 0x81, 0x80, 0x40, 0xC0, 0x20, 0x60,
  0x18, 0x30, 0x0C, 0x18, 0x03, 0x8C, 0x00, 0xF6, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0xFC, 0x00, 0x63, 0x80, 0x30, 0xE0, 0x18, 0x30, 0x0C, 0x08,
  0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x80, 0x60, 0xD0, 0x30,
  0xCF, 0x1B, 0xC3, 0xFF, 0x80, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x30, 0x0C, 0x30, 0x01, 0x00, 0xC0,
  0xC0, 0x18, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x01, 0x00, 0xC0,
  0x40, 0x18, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x60, 0x06, 0x01, 0x82, 0x00,
  0x30, 0x0C, 0x30, 0x01, 0x80, 0x61, 0x00, 0x04, 0x03, 0x18, 0x78, 0x20,
  0x10, 0x8E, 0x61, 0x00, 0x8C, 0xC1, 0x8C, 0x0C, 0x46, 0x06, 0x30, 0xC6,
  0x20, 0x30, 0xFC, 0x63, 0x00, 0x83, 0xC2, 0x18, 0x04, 0x00, 0x30, 0xC0,
  0x20, 0x01, 0x06, 0x01, 0x00, 0x18, 0x30, 0x0C, 0x00, 0x81, 0x80, 0x40,
  0x0C, 0x0C, 0x02, 0x00, 0x40, 0x60, 0x10, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x08, 0x0C, 0x03, 0x00, 0x60, 0x40, 0x30, 0x01, 0x86, 0x01, 0x00, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x70, 0x00, 0x30,
  0x04, 0x00, 0x08, 0x01, 0x80, 0x02, 0x00, 0x60, 0x00, 0x80, 0x18, 0x00,
  0x20, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0x38, 0x01, 0x8C, 0x07, 0x00, 0x62,
  0x00, 0xE0, 0x11, 0x80, 0x1C, 0x0C, 0x40, 0x03, 0x82, 0x10, 0x00, 0x71,
  0x8C, 0x00, 0x0E, 0x41, 0x00, 0x01, 0xF0, 0x40, 0x00, 0x38, 0x18, 0x00,
  0x0E, 0x06, 0x00, 0x06, 0xC0, 0xC0, 0x07, 0x18, 0x1C, 0x07, 0x83, 0x01,
  0xFF, 0x80, 0x70, 0xFF, 0xFA, 0xA0, 0x06, 0x18, 0x20, 0xC1, 0x06, 0x08,
  0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x18, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x02, 0x06, 0x0C, 0x0C, 0x08, 0x18,
  0x18, 0xE0, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x02,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0xE0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x0F, 0x04, 0x1C, 0xF9, 0x3E, 0x03, 0xF8, 0x00, 0x30, 0x00, 0x1A,
  0x00, 0x04, 0xC0, 0x02, 0x18, 0x01, 0x82, 0x00, 0xC0, 0xC0, 0x70, 0x18,
  0x08, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x1F, 0xFF, 0xFC, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x33, 0x66, 0x66, 0x4C, 0xC8, 0xFF, 0xFF, 0xF0, 0x5F, 0x80, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0x80, 0x30, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x60,
  0x01, 0x08, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0x4C, 0x00, 0x09, 0x00,
  0x01, 0xA0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x34, 0x00,
  0x06, 0xC0, 0x00, 0x98, 0x00, 0x13, 0x00, 0x06, 0x20, 0x00, 0xC6, 0x00,
  0x10, 0x60, 0x06, 0x0C, 0x01, 0x80, 0xE0, 0xE0, 0x07, 0xF8, 0x00, 0x01,
  0x81, 0xC3, 0xA3, 0x13, 0x0F, 0x05, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0xE0, 0x03, 0xFF,
  0x03, 0x80, 0xE1, 0x80, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0x07, 0x80, 0x73, 0x80,
  0x0C, 0x40, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1A, 0x00, 0x0C, 0xF0, 0x0E, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x58, 0x00, 0x03, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x46, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC1,
  0x80, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x02, 0x01, 0x80,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x10, 0x01, 0x80, 0xC0,
  0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xFF, 0xFF, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x82, 0x00, 0x7F,
  0xF8, 0x18, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC8, 0x00, 0x63, 0xC0, 0x70, 0x3F,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC3, 0xF8, 0x23, 0xC7, 0x89, 0x80, 0x32,
  0x80, 0x06, 0xE0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00,
  0x63, 0x00, 0x18, 0x60, 0x0C, 0x0C, 0x0E, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0,
  0x70, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x08, 0x40, 0x01, 0x98, 0x00, 0x33,
  0x00, 0x06, 0x20, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x0C, 0x01, 0x80,
  0xE0, 0xE0, 0x07, 0x70, 0x00, 0x3C, 0x00, 0x3D, 0xE0, 0x0C, 0x07, 0x03,
  0x00, 0x70, 0xC0, 0x03, 0x30, 0x00, 0x64, 0x00, 0x06, 0x80, 0x00, 0xF0,
  0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x03, 0x18,
  0x00, 0xC1, 0xC0, 0x70, 0x0F, 0xF8, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x80,
  0x70, 0x38, 0x18, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x03, 0x10, 0x00, 0x36,
  0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x06, 0x80, 0x01, 0xD8, 0x00, 0x79, 0x80, 0x1B, 0x18, 0x06, 0x61,
  0xFF, 0x88, 0x0F, 0x81, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x02, 0x03, 0x80, 0x7F, 0xC0, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x2F, 0xC0, 0x37, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x26, 0x66, 0x4C, 0xC8, 0x80, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x07, 0x01, 0xFF, 0xE1, 0x80, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x70, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00,
  0x0C, 0x10, 0x00, 0x00, 0x06, 0x30, 0x01, 0xF8, 0x06, 0x20, 0x0F, 0xFE,
  0x02, 0x60, 0x18, 0x06, 0x03, 0x40, 0x30, 0x06, 0x03, 0x40, 0x20, 0x06,
  0x03, 0xC0, 0x60, 0x04, 0x03, 0xC0, 0x40, 0x04, 0x01, 0xC0, 0x40, 0x04,
  0x03, 0xC0, 0x40, 0x04, 0x03, 0xC0, 0x40, 0x04, 0x03, 0xC0, 0x40, 0x04,
  0x03, 0xC0, 0x40, 0x0C, 0x02, 0xC0, 0x60, 0x0C, 0x06, 0x40, 0x60, 0x1E,
  0x04, 0x40, 0x30, 0x32, 0x0C, 0x60, 0x1F, 0xE3, 0xF8, 0x60, 0x03, 0x00,
  0x40, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x36, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x43, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x00,
  0x00, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0x40, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x07, 0xFF, 0xF0, 0x0C, 0x00, 0x30, 0x08, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x08, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x18, 0x03, 0xE3, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x1B,
  0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0xE1, 0xFF, 0xF0, 0x30, 0x07, 0xC6,
  0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x0E, 0x60, 0x3F, 0x8F, 0xFF, 0x80, 0x00, 0x0E, 0x00,
  0x07, 0xFF, 0x80, 0xE0, 0x0E, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x03, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x03, 0x00, 0x7C, 0x0C, 0x00, 0x38,
  0x30, 0x00, 0x38, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x63, 0x00, 0x07, 0x0C, 0x00, 0x78, 0x30, 0x7F, 0x80, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xF8, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x10, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x58,
  0x00, 0x00, 0xB0, 0x00, 0x01, 0x30, 0x00, 0x02, 0x70, 0x00, 0x04, 0x70,
  0x00, 0x08, 0x70, 0x00, 0x10, 0x3C, 0x01, 0xE0, 0x1F, 0xFF, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0x80, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x68, 0x73, 0xF8, 0xC0, 0x00, 0xF8, 0x00, 0x33, 0x00,
  0x0C, 0x60, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x0E, 0x00, 0x63, 0x80, 0x0C, 0x60,
  0x01, 0x96, 0x00, 0x34, 0x60, 0x07, 0x0E, 0x00, 0xC0, 0xC0, 0x18, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x18, 0x30, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xBD, 0x80, 0x00, 0x37, 0xB0, 0x00, 0x06, 0xF2, 0x00, 0x00,
  0x9E, 0x60, 0x00, 0x33, 0xC4, 0x00, 0x04, 0x78, 0xC0, 0x01, 0x8F, 0x18,
  0x00, 0x31, 0xE1, 0x00, 0x04, 0x3C, 0x30, 0x01, 0x87, 0x82, 0x00, 0x20,
  0xF0, 0x60, 0x0C, 0x1E, 0x0C, 0x01, 0x83, 0xC0, 0x80, 0x60, 0x78, 0x18,
  0x0C, 0x0F, 0x01, 0x01, 0x01, 0xE0, 0x30, 0x60, 0x3C, 0x06, 0x08, 0x07,
  0x80, 0x43, 0x00, 0xF0, 0x0C, 0x60, 0x1E, 0x00, 0x88, 0x03, 0xC0, 0x1B,
  0x00, 0x78, 0x03, 0x40, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0x40, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3D, 0x80, 0x01, 0xE6, 0x00, 0x0F, 0x30, 0x00, 0x78, 0xC0, 0x03,
  0xC3, 0x00, 0x1E, 0x18, 0x00, 0xF0, 0x60, 0x07, 0x81, 0x80, 0x3C, 0x0C,
  0x01, 0xE0, 0x30, 0x0F, 0x00, 0xC0, 0x78, 0x06, 0x03, 0xC0, 0x18, 0x1E,
  0x00, 0x60, 0xF0, 0x03, 0x07, 0x80, 0x0C, 0x3C, 0x00, 0x31, 0xE0, 0x01,
  0x8F, 0x00, 0x06, 0x78, 0x00, 0x1B, 0xC0, 0x00, 0xDE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x70, 0x07, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x40, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0x80,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8,
  0x60, 0x1F, 0x30, 0x01, 0xD8, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x16, 0x00, 0x1B, 0x00, 0x39, 0xFF, 0xF0, 0xFF, 0x80, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x70, 0x07, 0x00, 0x30, 0x00,
  0x60, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x0C, 0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x11, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0xFF, 0xF8, 0x18, 0x07, 0xC3, 0x00, 0x1C, 0x60, 0x00, 0xCC, 0x00,
  0x19, 0x80, 0x01, 0x30, 0x00, 0x26, 0x00, 0x04, 0xC0, 0x00, 0x98, 0x00,
  0x13, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x1F,
  0x07, 0xFF, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x06, 0x00, 0xF0,
  0x03, 0xFF, 0xE1, 0xC0, 0x18, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1A, 0x00,
  0x0C, 0xF0, 0x0E, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C,
  0x00, 0x01, 0x90, 0x00, 0x06, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80,
  0x0E, 0x03, 0x80, 0xF0, 0x03, 0xFF, 0x00, 0xC0, 0x00, 0x06, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x13, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x04, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x10, 0x00, 0x60,
  0x30, 0x00, 0x80, 0x60, 0x03, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x30, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x02, 0x03, 0x00, 0x06,
  0x04, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x30, 0x00, 0x18, 0x40, 0x00, 0x31,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xD0,
  0x00, 0x30, 0x00, 0x36, 0x00, 0x1E, 0x00, 0x09, 0x80, 0x07, 0x80, 0x06,
  0x60, 0x01, 0x20, 0x01, 0x88, 0x00, 0x48, 0x00, 0x43, 0x00, 0x33, 0x00,
  0x30, 0xC0, 0x0C, 0xC0, 0x0C, 0x10, 0x02, 0x10, 0x03, 0x04, 0x01, 0x86,
  0x00, 0x81, 0x80, 0x61, 0x80, 0x60, 0x60, 0x10, 0x20, 0x18, 0x08, 0x04,
  0x08, 0x06, 0x03, 0x03, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0x30,
  0x20, 0x10, 0x30, 0x04, 0x08, 0x06, 0x08, 0x01, 0x86, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x21, 0x80, 0x08, 0x40, 0x08, 0x60, 0x02, 0x30, 0x03, 0x10,
  0x00, 0xCC, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x13, 0x00, 0x04, 0x80, 0x04,
  0xC0, 0x01, 0x60, 0x01, 0xA0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0xC1, 0x00, 0x06, 0x06, 0x00, 0x10, 0x0C, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x60, 0x10, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x32, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x16, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30,
  0x00, 0x18, 0x60, 0x00, 0xC0, 0x80, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00,
  0xC0, 0x08, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00,
  0x03, 0x18, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1B, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0x60, 0x00, 0xC1, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x20,
  0x03, 0x01, 0x80, 0x30, 0x06, 0x01, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x80,
  0x06, 0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x03, 0x60, 0x00, 0x0B,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x01, 0x80, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0xFF, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xB0, 0x00, 0x19,
  0x00, 0x01, 0x18, 0x00, 0x30, 0x80, 0x02, 0x0C, 0x00, 0x60, 0x40, 0x04,
  0x06, 0x00, 0xC0, 0x20, 0x08, 0x03, 0x01, 0x80, 0x10, 0x30, 0x01, 0x83,
  0x00, 0x08, 0x60, 0x00, 0xC6, 0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x07, 0xF0, 0x3F,
  0x3C, 0x30, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x07, 0xFF, 0x1E, 0x03, 0x30, 0x03, 0x60,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x60,
  0x09, 0x70, 0x31, 0x1F, 0xE1, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x21, 0xFE, 0x08, 0xE1, 0xC2, 0x40, 0x18, 0xA0, 0x03, 0x38, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x02, 0xC0,
  0x00, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x80, 0x0C, 0xB0, 0x06, 0x27, 0x07,
  0x08, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xC7, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x03, 0x03, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x7F, 0x0C, 0x3C,
  0x39, 0x8E, 0x01, 0xB3, 0x00, 0x16, 0x60, 0x01, 0xD8, 0x00, 0x3B, 0x00,
  0x07, 0x40, 0x00, 0x68, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00,
  0x1D, 0x80, 0x03, 0x98, 0x00, 0xF1, 0x80, 0x36, 0x1C, 0x0C, 0xC1, 0xFF,
  0x18, 0x03, 0xF8, 0x03, 0xC7, 0x81, 0xC0, 0x30, 0x40, 0x04, 0x30, 0x01,
  0x98, 0x00, 0x26, 0x00, 0x0D, 0x00, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x01, 0x0E, 0x03,
  0x80, 0xFF, 0xC0, 0x01, 0xFC, 0x0C, 0x10, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0xFF, 0x8F, 0xFE, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x03, 0xF8,
  0x61, 0xE1, 0xCC, 0x60, 0x0D, 0x98, 0x00, 0xF3, 0x00, 0x0E, 0xC0, 0x01,
  0xD8, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03,
  0x60, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x07, 0x8C, 0x01, 0xB0, 0xE0, 0xE6,
  0x0F, 0xF8, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x60, 0x06, 0x0F, 0xFF, 0x80,
  0x1F, 0xC0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xF0, 0x8E, 0x3C,
  0xB0, 0x06, 0xA0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x5F, 0x80, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x80, 0x02, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0xFC, 0xF8, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x1E, 0x00, 0x64, 0x00, 0xC8, 0x03, 0x10, 0x0C, 0x20, 0x30,
  0x40, 0xC0, 0x83, 0x01, 0x0C, 0x02, 0x30, 0x04, 0xF0, 0x0B, 0x30, 0x14,
  0x60, 0x30, 0x60, 0x40, 0x60, 0x80, 0x61, 0x00, 0xC2, 0x00, 0xC4, 0x00,
  0xC8, 0x00, 0x90, 0x01, 0xA0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x87,
  0xE0, 0x3F, 0x89, 0xC7, 0x8F, 0x1C, 0xB0, 0x1D, 0x80, 0x6A, 0x00, 0xD0,
  0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x87, 0xF8, 0x8E, 0x3C, 0x90, 0x06, 0xA0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x03, 0xFC, 0x01, 0xE1, 0xE0, 0x70, 0x0E, 0x18, 0x00, 0xC3, 0x00, 0x0C,
  0xC0, 0x00, 0x98, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0x64, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0xC0,
  0xE0, 0x70, 0x07, 0xF8, 0x00, 0x83, 0xF8, 0x23, 0x87, 0x09, 0x80, 0x62,
  0x80, 0x0C, 0xE0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x02, 0xC0, 0x01, 0xB8, 0x00, 0x6A, 0x00, 0x32,
  0xC0, 0x18, 0x9C, 0x1C, 0x21, 0xFE, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x43, 0xC3, 0x91, 0x80, 0x34,
  0xC0, 0x05, 0x30, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x14, 0x00, 0x05, 0x00, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x14,
  0xE0, 0x0D, 0x1C, 0x0E, 0x41, 0xFE, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x87, 0xF3, 0xCE, 0xC0, 0x50, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x00,
  0x0F, 0xF8, 0x78, 0x7D, 0x80, 0x12, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x6E, 0x03, 0x8F, 0xFE, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x07, 0xFF, 0xFF, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x61, 0x03, 0xF0, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0,
  0x01, 0xD8, 0x00, 0xA6, 0x00, 0xD3, 0x81, 0xC8, 0x7F, 0x84, 0xC0, 0x00,
  0xF0, 0x00, 0x36, 0x00, 0x09, 0x80, 0x06, 0x20, 0x01, 0x8C, 0x00, 0x43,
  0x00, 0x30, 0x40, 0x0C, 0x18, 0x06, 0x02, 0x01, 0x80, 0xC0, 0x40, 0x30,
  0x30, 0x04, 0x0C, 0x01, 0x82, 0x00, 0x61, 0x80, 0x08, 0x40, 0x03, 0x30,
  0x00, 0x4C, 0x00, 0x1A, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xA0, 0x05,
  0x80, 0x24, 0x00, 0xB0, 0x04, 0xC0, 0x32, 0x01, 0x98, 0x06, 0x40, 0x31,
  0x00, 0x8C, 0x04, 0x30, 0x30, 0x80, 0x86, 0x06, 0x10, 0x30, 0x40, 0x83,
  0x06, 0x08, 0x30, 0x60, 0x81, 0x86, 0x04, 0x30, 0x30, 0x80, 0xC6, 0x02,
  0x30, 0x18, 0xC0, 0x66, 0x01, 0x10, 0x0C, 0x80, 0x36, 0x00, 0xB0, 0x06,
  0xC0, 0x16, 0x00, 0x50, 0x03, 0x80, 0x0A, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0x98, 0x00, 0x63, 0x00, 0x30, 0x60, 0x18,
  0x18, 0x04, 0x03, 0x03, 0x00, 0x61, 0x80, 0x08, 0xC0, 0x03, 0x30, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0xCC, 0x00, 0x61,
  0x80, 0x10, 0x60, 0x0C, 0x0C, 0x06, 0x01, 0x83, 0x00, 0x20, 0xC0, 0x0C,
  0x60, 0x01, 0xB0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0x00, 0x36, 0x00, 0x09,
  0x80, 0x06, 0x20, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x30, 0x40, 0x0C, 0x18,
  0x06, 0x02, 0x01, 0x80, 0xC0, 0x40, 0x30, 0x30, 0x04, 0x0C, 0x01, 0x82,
  0x00, 0x21, 0x80, 0x08, 0x40, 0x03, 0x30, 0x00, 0x4C, 0x00, 0x1A, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xF0, 0x3C, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x38,
  0x0E, 0x00, 0x78, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x01, 0xE0, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0x3C, 0x1E,
  0x0E, 0x00, 0xFF, 0x00, 0x01, 0x00,
};

const GFXglyph NotoSans_ExtraLight41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 29, 10, 3, -29 },
  { 12, 8, 10, 14, 3, -29 },
  { 22, 24, 29, 26, 1, -29 },
  { 109, 17, 33, 23, 3, -31 },
  { 180, 29, 30, 33, 2, -30 },
  { 289, 26, 30, 29, 2, -30 },
  { 387, 2, 10, 8, 3, -29 },
  { 390, 7, 35, 11, 2, -29 },
  { 421, 8, 35, 11, 1, -29 },
  { 456, 18, 17, 23, 2, -31 },
  { 495, 19, 19, 23, 2, -24 },
  { 541, 4, 10, 8, 2, -5 },
  { 546, 10, 2, 13, 2, -12 },
  { 549, 3, 3, 9, 3, -3 },
  { 551, 13, 29, 14, 0, -29 },
  { 599, 19, 30, 23, 2, -30 },
  { 671, 9, 29, 23, 4, -29 },
  { 704, 18, 30, 23, 2, -30 },
  { 772, 18, 30, 23, 2, -30 },
  { 840, 22, 29, 23, 1, -29 },
  { 920, 18, 29, 23, 3, -29 },
  { 986, 18, 30, 23, 3, -30 },
  { 1054, 19, 29, 23, 2, -29 },
  { 1123, 19, 30, 23, 2, -30 },
  { 1195, 19, 30, 23, 2, -30 },
  { 1267, 3, 22, 9, 3, -22 },
  { 1276, 4, 27, 9, 2, -22 },
  { 1290, 19, 19, 23, 2, -24 },
  { 1336, 19, 9, 23, 2, -19 },
  { 1358, 19, 19, 23, 2, -24 },
  { 1404, 15, 30, 17, 1, -30 },
  { 1461, 32, 33, 36, 2, -29 },
  { 1593, 24, 29, 24, 0, -29 },
  { 1680, 19, 29, 25, 4, -29 },
  { 1749, 21, 30, 25, 3, -30 },
  { 1828, 22, 29, 29, 4, -29 },
  { 1908, 16, 29, 23, 4, -29 },
  { 1966, 16, 29, 20, 4, -29 },
  { 2024, 23, 30, 30, 3, -30 },
  { 2111, 21, 29, 29, 4, -29 },
  { 2188, 8, 29, 12, 2, -29 },
  { 2217, 10, 36, 10, -4, -29 },
  { 2262, 19, 29, 23, 4, -29 },
  { 2331, 16, 29, 21, 4, -29 },
  { 2389, 27, 29, 35, 4, -29 },
  { 2487, 21, 29, 29, 4, -29 },
  { 2564, 26, 30, 31, 3, -30 },
  { 2662, 17, 29, 24, 4, -29 },
  { 2724, 26, 37, 31, 3, -30 },
  { 2845, 19, 29, 24, 4, -29 },
  { 2914, 18, 30, 22, 2, -30 },
  { 2982, 21, 29, 21, 0, -29 },
  { 3059, 22, 29, 29, 4, -29 },
  { 3139, 23, 29, 23, 0, -29 },
  { 3223, 34, 29, 36, 1, -29 },
  { 3347, 22, 29, 22, 0, -29 },
  { 3427, 21, 29, 21, 0, -29 },
  { 3504, 21, 29, 24, 1, -29 },
  { 3581, 8, 35, 13, 4, -29 },
  { 3616, 13, 29, 14, 0, -29 },
  { 3664, 8, 35, 13, 1, -29 },
  { 3699, 20, 18, 23, 2, -29 },
  { 3744, 17, 1, 16, 0, 4 },
  { 3747, 7, 6, 11, 2, -31 },
  { 3753, 16, 22, 21, 2, -22 },
  { 3797, 18, 31, 24, 4, -31 },
  { 3867, 16, 22, 19, 2, -22 },
  { 3911, 19, 31, 24, 2, -31 },
  { 3985, 18, 22, 22, 2, -22 },
  { 4035, 14, 31, 12, 0, -31 },
  { 4090, 19, 32, 24, 2, -22 },
  { 4166, 16, 31, 24, 4, -31 },
  { 4228, 3, 30, 9, 3, -30 },
  { 4240, 8, 40, 9, -2, -30 },
  { 4280, 15, 31, 19, 4, -31 },
  { 4339, 1, 31, 9, 4, -31 },
  { 4343, 28, 22, 36, 4, -22 },
  { 4420, 16, 22, 24, 4, -22 },
  { 4464, 19, 22, 24, 2, -22 },
  { 4517, 18, 32, 24, 4, -22 },
  { 4589, 18, 32, 24, 2, -22 },
  { 4661, 11, 22, 16, 4, -22 },
  { 4692, 15, 22, 19, 2, -22 },
  { 4734, 12, 27, 13, 0, -27 },
  { 4775, 17, 22, 24, 3, -22 },
  { 4822, 18, 22, 18, 0, -22 },
  { 4872, 27, 22, 29, 1, -22 },
  { 4947, 18, 22, 20, 1, -22 },
  { 4997, 18, 32, 18, 0, -22 },
  { 5069, 15, 22, 19, 2, -22 },
  { 5111, 12, 35, 14, 1, -29 },
  { 5164, 2, 41, 22, 10, -31 },
  { 5175, 12, 35, 14, 1, -29 },
  { 5228, 19, 4, 23, 2, -16 },
};

const GFXfont NotoSans_ExtraLight41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRALIGHT41PT7B_H_
