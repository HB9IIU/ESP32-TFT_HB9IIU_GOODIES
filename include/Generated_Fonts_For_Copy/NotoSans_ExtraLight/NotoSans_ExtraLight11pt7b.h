#ifndef _NOTOSANS_EXTRALIGHT11PT7B_H_
#define _NOTOSANS_EXTRALIGHT11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x24, 0x49, 0xD9, 0x42, 0x9F, 0x92, 0x24, 0x7C, 0xCC,
  0x75, 0x5E, 0x40, 0xC5, 0x52, 0xA5, 0xBD, 0xA5, 0x4A, 0xA7, 0x72, 0x49,
  0x18, 0xA6, 0x58, 0xBD, 0xE0, 0x29, 0x49, 0x22, 0x44, 0x95, 0x55, 0x60,
  0x4D, 0x69, 0x21, 0x3E, 0x42, 0x00, 0x60, 0xE0, 0x80, 0x12, 0x22, 0x44,
  0x88, 0x74, 0x63, 0x18, 0xC6, 0x3E, 0x74, 0x92, 0x49, 0xE1, 0x11, 0x24,
  0x8F, 0xF1, 0x17, 0x11, 0x1F, 0x08, 0x62, 0x8A, 0x4B, 0xF0, 0x82, 0xF4,
  0x21, 0xE0, 0x84, 0x3E, 0x7C, 0x21, 0xE8, 0xC6, 0x3E, 0xF8, 0x84, 0x22,
  0x11, 0x08, 0xF4, 0x64, 0xC9, 0x46, 0x3E, 0xE4, 0xA3, 0x1F, 0x04, 0x5C,
  0x84, 0x40, 0x18, 0x3E, 0x30, 0x60, 0x80, 0xFF, 0xC0, 0xC1, 0x86, 0xC8,
  0x00, 0xF1, 0x11, 0x24, 0x04, 0x3C, 0x42, 0x99, 0xA5, 0xA5, 0xA5, 0xBA,
  0x80, 0x7C, 0x10, 0xC2, 0x92, 0x79, 0x18, 0x61, 0xF4, 0x63, 0xE8, 0xC6,
  0x3E, 0x7C, 0x21, 0x08, 0x42, 0x0F, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x7E,
  0xF8, 0x8F, 0x88, 0x8F, 0xF8, 0x88, 0xF8, 0x88, 0x7E, 0x08, 0x20, 0x9E,
  0x18, 0x5F, 0x86, 0x18, 0x7F, 0x86, 0x18, 0x61, 0xEA, 0xAB, 0x24, 0x92,
  0x49, 0x38, 0x8C, 0xA9, 0x8A, 0x4A, 0x51, 0x88, 0x88, 0x88, 0x8F, 0x83,
  0x07, 0x1E, 0x3A, 0x75, 0x64, 0xC9, 0x86, 0x1C, 0x69, 0x96, 0x58, 0xE1,
  0x79, 0x0A, 0x0C, 0x18, 0x30, 0x61, 0x3C, 0xF4, 0x63, 0x1F, 0x42, 0x10,
  0x79, 0x0A, 0x0C, 0x18, 0x30, 0x61, 0x3C, 0x08, 0x08, 0xF4, 0x63, 0x1F,
  0x4A, 0x31, 0xF8, 0x8C, 0x31, 0x1F, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x5E, 0x86, 0x14, 0x52, 0x48, 0xA3, 0x04,
  0x88, 0xC4, 0x53, 0x2A, 0x95, 0x32, 0x98, 0x8C, 0x42, 0x85, 0x25, 0x08,
  0x31, 0x44, 0xA1, 0x86, 0x24, 0x8C, 0x20, 0x82, 0x08, 0x7C, 0x20, 0x84,
  0x20, 0x84, 0x3F, 0xEA, 0xAA, 0xB0, 0x88, 0x44, 0x42, 0x21, 0xE4, 0x92,
  0x49, 0x3C, 0x10, 0xC4, 0x92, 0x84, 0xF0, 0xC0, 0xE1, 0x79, 0x9F, 0x84,
  0x3D, 0x18, 0xC6, 0x3E, 0x78, 0x88, 0x8F, 0x08, 0x5F, 0x18, 0xC6, 0x3F,
  0x79, 0xF8, 0x8F, 0x74, 0xE4, 0x44, 0x44, 0x7C, 0x63, 0x18, 0xFC, 0x22,
  0xE0, 0x88, 0xF9, 0x99, 0x99, 0xBF, 0x20, 0x92, 0x49, 0x27, 0x00, 0x88,
  0x9A, 0xCA, 0xA9, 0xFF, 0xFE, 0x91, 0x91, 0x91, 0x91, 0x91, 0xF9, 0x99,
  0x99, 0x74, 0x63, 0x18, 0xF8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x80, 0x79,
  0x99, 0x9F, 0x11, 0x10, 0xF2, 0x49, 0x00, 0x74, 0x18, 0x20, 0xF8, 0x5D,
  0x24, 0x98, 0x99, 0x99, 0x9F, 0x8C, 0x54, 0xA5, 0x10, 0x91, 0x99, 0x5A,
  0x6A, 0x64, 0x24, 0x8A, 0x88, 0x45, 0x44, 0x8C, 0x54, 0xA5, 0x10, 0x88,
  0x80, 0x78, 0x88, 0x44, 0x7C, 0x29, 0x2C, 0x92, 0x44, 0xFF, 0xE0, 0xC2,
  0x22, 0x32, 0x22, 0x2C, 0xF8,
};

const GFXglyph NotoSans_ExtraLight11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 2, 3, 4, 1, -8 },
  { 3, 7, 8, 7, 0, -8 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 7, 8, 9, 1, -8 },
  { 22, 6, 8, 8, 1, -8 },
  { 28, 1, 3, 2, 1, -8 },
  { 29, 3, 10, 3, 0, -8 },
  { 33, 2, 10, 3, 0, -8 },
  { 36, 4, 4, 6, 1, -8 },
  { 38, 5, 5, 6, 1, -6 },
  { 42, 2, 2, 2, 0, -1 },
  { 43, 3, 1, 4, 0, -3 },
  { 44, 1, 1, 3, 1, -1 },
  { 45, 4, 8, 4, 0, -8 },
  { 49, 5, 8, 6, 1, -8 },
  { 54, 3, 8, 6, 1, -8 },
  { 57, 4, 8, 6, 1, -8 },
  { 61, 4, 8, 6, 1, -8 },
  { 65, 6, 8, 6, 0, -8 },
  { 71, 5, 8, 6, 1, -8 },
  { 76, 5, 8, 6, 1, -8 },
  { 81, 5, 8, 6, 1, -8 },
  { 86, 5, 8, 6, 1, -8 },
  { 91, 5, 8, 6, 1, -8 },
  { 96, 1, 6, 3, 1, -6 },
  { 97, 2, 7, 3, 0, -6 },
  { 99, 5, 5, 6, 1, -6 },
  { 103, 5, 2, 6, 1, -5 },
  { 105, 5, 5, 6, 1, -6 },
  { 109, 4, 8, 5, 0, -8 },
  { 113, 8, 9, 10, 1, -8 },
  { 122, 6, 8, 6, 0, -8 },
  { 128, 5, 8, 7, 1, -8 },
  { 133, 5, 8, 7, 1, -8 },
  { 138, 6, 8, 8, 1, -8 },
  { 144, 4, 8, 6, 1, -8 },
  { 148, 4, 8, 5, 1, -8 },
  { 152, 6, 8, 8, 1, -8 },
  { 158, 6, 8, 8, 1, -8 },
  { 164, 2, 8, 3, 1, -8 },
  { 166, 3, 10, 3, -1, -8 },
  { 170, 5, 8, 6, 1, -8 },
  { 175, 4, 8, 6, 1, -8 },
  { 179, 7, 8, 9, 1, -8 },
  { 186, 6, 8, 8, 1, -8 },
  { 192, 7, 8, 8, 1, -8 },
  { 199, 5, 8, 6, 1, -8 },
  { 204, 7, 10, 8, 1, -8 },
  { 213, 5, 8, 6, 1, -8 },
  { 218, 4, 8, 6, 1, -8 },
  { 222, 6, 8, 6, 0, -8 },
  { 228, 6, 8, 8, 1, -8 },
  { 234, 6, 8, 6, 0, -8 },
  { 240, 9, 8, 10, 0, -8 },
  { 249, 6, 8, 6, 0, -8 },
  { 255, 6, 8, 6, 0, -8 },
  { 261, 6, 8, 6, 0, -8 },
  { 267, 2, 10, 3, 1, -8 },
  { 270, 4, 8, 4, 0, -8 },
  { 274, 3, 10, 3, 0, -8 },
  { 278, 6, 5, 6, 0, -8 },
  { 282, 4, 1, 4, 0, 1 },
  { 283, 2, 1, 3, 0, -8 },
  { 284, 4, 6, 6, 1, -6 },
  { 287, 5, 8, 6, 1, -8 },
  { 292, 4, 6, 5, 1, -6 },
  { 295, 5, 8, 6, 1, -8 },
  { 300, 4, 6, 6, 1, -6 },
  { 303, 4, 8, 3, 0, -8 },
  { 307, 5, 9, 6, 1, -6 },
  { 313, 4, 8, 6, 1, -8 },
  { 317, 1, 8, 2, 1, -8 },
  { 318, 3, 11, 2, -1, -8 },
  { 323, 4, 8, 5, 1, -8 },
  { 327, 1, 8, 2, 1, -8 },
  { 328, 8, 6, 10, 1, -6 },
  { 334, 4, 6, 6, 1, -6 },
  { 337, 5, 6, 6, 1, -6 },
  { 341, 5, 9, 6, 1, -6 },
  { 347, 4, 9, 6, 1, -6 },
  { 352, 3, 6, 4, 1, -6 },
  { 355, 5, 6, 5, 0, -6 },
  { 359, 3, 7, 4, 0, -7 },
  { 362, 4, 6, 6, 1, -6 },
  { 365, 5, 6, 5, 0, -6 },
  { 369, 8, 6, 8, 0, -6 },
  { 375, 5, 6, 5, 0, -6 },
  { 379, 5, 9, 5, 0, -6 },
  { 385, 5, 6, 5, 0, -6 },
  { 389, 3, 10, 4, 0, -8 },
  { 393, 1, 11, 6, 2, -8 },
  { 395, 4, 10, 4, 0, -8 },
  { 400, 5, 1, 6, 1, -4 },
};

const GFXfont NotoSans_ExtraLight11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRALIGHT11PT7B_H_
