#ifndef _NOTOSANS_EXTRALIGHT54PT7B_H_
#define _NOTOSANS_EXTRALIGHT54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight54pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x06, 0x7F, 0x70, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x04, 0x00, 0x40, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x40, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x80, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x10, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0xFE, 0x01, 0xF2, 0x3F, 0x07, 0x04, 0x06, 0x1C,
  0x08, 0x00, 0x70, 0x10, 0x00, 0xC0, 0x20, 0x01, 0x80, 0x40, 0x07, 0x00,
  0x80, 0x0E, 0x01, 0x00, 0x1C, 0x02, 0x00, 0x18, 0x04, 0x00, 0x30, 0x08,
  0x00, 0x70, 0x10, 0x00, 0x70, 0x20, 0x00, 0x78, 0x40, 0x00, 0x3C, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x09, 0xF0,
  0x00, 0x10, 0xF0, 0x00, 0x20, 0x70, 0x00, 0x40, 0x70, 0x00, 0x80, 0x60,
  0x01, 0x00, 0xE0, 0x02, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x08, 0x03, 0x00,
  0x10, 0x06, 0x00, 0x20, 0x18, 0x00, 0x40, 0x30, 0x00, 0x80, 0xE8, 0x01,
  0x03, 0x8F, 0x02, 0x3E, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x0C, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x0E, 0x0E, 0x00, 0x06, 0x00,
  0x60, 0x38, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x60,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x60, 0x03,
  0x03, 0x00, 0x03, 0x00, 0x18, 0x18, 0x00, 0x18, 0x00, 0xC1, 0x81, 0xC0,
  0xC0, 0x06, 0x18, 0x3F, 0xC3, 0x00, 0x30, 0xC3, 0x8F, 0x18, 0x03, 0x0C,
  0x30, 0x18, 0xC0, 0x18, 0x63, 0x80, 0x63, 0x01, 0x86, 0x18, 0x03, 0x1C,
  0x1C, 0x30, 0xC0, 0x1C, 0x7F, 0xC3, 0x06, 0x00, 0x60, 0xF8, 0x18, 0x60,
  0x03, 0x00, 0x01, 0x83, 0x00, 0x18, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x00,
  0xC0, 0xC0, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x00, 0x60, 0x30, 0x01,
  0x80, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x0E,
  0x06, 0x00, 0x60, 0x00, 0x38, 0xE0, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00,
  0x6F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x30, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0xC1, 0x80, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0C, 0x70, 0x00, 0x60,
  0x06, 0x18, 0x00, 0x0C, 0x01, 0x86, 0x00, 0x01, 0x80, 0xE3, 0x80, 0x00,
  0x30, 0x30, 0xC0, 0x00, 0x06, 0x1C, 0x30, 0x00, 0x00, 0xC6, 0x0E, 0x00,
  0x00, 0x1B, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0x7C, 0x03, 0x00, 0x00, 0x39, 0x80, 0xE0, 0x00, 0x3C, 0x30,
  0x1E, 0x00, 0x3C, 0x0E, 0x03, 0xF9, 0xFE, 0x01, 0xC0, 0x3F, 0xFC, 0x00,
  0x3C, 0x00, 0xA0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x70,
  0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0xC0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x40, 0x0C, 0x01, 0xF0, 0x18, 0x0F, 0xFC,
  0x20, 0xFC, 0x3F, 0x4F, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x05,
  0x80, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC3, 0x00, 0x03, 0x03,
  0x00, 0x0C, 0x07, 0x00, 0x38, 0x06, 0x00, 0xE0, 0x07, 0x00, 0x80, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x61, 0x8E, 0x38,
  0xC3, 0x0C, 0x61, 0x86, 0x10, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x67, 0xF7,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0x60, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x0E, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x03, 0xC0, 0x3E, 0x03, 0xB0, 0x79, 0x87, 0x0C, 0x70, 0x6F, 0x03,
  0xE0, 0x1A, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1E, 0x01, 0xE0,
  0x78, 0x00, 0x70, 0x20, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3E, 0x00, 0xF0, 0xF0, 0x00, 0x38,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x38,
  0xE0, 0x00, 0x70, 0xFF, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x1C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0,
  0x0C, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x03,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x67, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE4, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x1F, 0xC3, 0xF8, 0x07,
  0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x7E, 0x00, 0xC1, 0xFF, 0xC0, 0xC7, 0x80, 0xF0, 0xCC,
  0x00, 0x38, 0xD8, 0x00, 0x1C, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x1C, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x70, 0x07, 0xE3, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x18, 0x00,
  0x1C, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x70, 0x03, 0xC1, 0xC0, 0x00, 0xF7,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x81, 0xE0, 0x0F, 0x00,
  0x70, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x07, 0xC1,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x38, 0x30, 0x00,
  0x1C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x0F, 0x30, 0x00, 0x1B, 0x38, 0x00, 0x33, 0x1E, 0x00,
  0xE3, 0x07, 0xFF, 0xC3, 0x03, 0xFF, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x1F,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x6F, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7F, 0x70, 0x18, 0xF3,
  0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x18, 0xE3, 0x8C, 0x30, 0xC7, 0x18, 0x61, 0x8C,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xC3, 0xC0, 0x3C,
  0x40, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0xFF, 0xE0, 0x06, 0x30, 0x00, 0xF8, 0x7C, 0x01, 0x98, 0x00,
  0x70, 0x02, 0x00, 0x66, 0x00, 0x30, 0x00, 0x80, 0x19, 0x80, 0x18, 0x00,
  0x60, 0x03, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xF0, 0x03, 0x00, 0x06, 0x00,
  0x3C, 0x01, 0xC0, 0x01, 0x80, 0x0F, 0x00, 0x60, 0x00, 0x60, 0x03, 0xC0,
  0x18, 0x00, 0x18, 0x00, 0xF0, 0x06, 0x00, 0x06, 0x00, 0x3C, 0x01, 0x80,
  0x01, 0x80, 0x0F, 0x00, 0x60, 0x00, 0x60, 0x06, 0xC0, 0x18, 0x00, 0x18,
  0x01, 0xB0, 0x06, 0x00, 0x0E, 0x00, 0x6C, 0x01, 0xC0, 0x03, 0x80, 0x1B,
  0x00, 0x30, 0x01, 0xA0, 0x0C, 0xC0, 0x0E, 0x00, 0x6C, 0x07, 0x18, 0x01,
  0xC0, 0x73, 0x03, 0x86, 0x00, 0x3F, 0xF8, 0x7F, 0xC1, 0x80, 0x07, 0xF8,
  0x0F, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x30, 0x07, 0xFC, 0x18, 0x00, 0x0F,
  0x0C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x38, 0xC0, 0x00, 0x38, 0x60, 0x01, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x0C, 0x00, 0x07, 0x86, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x98, 0x00, 0x07, 0x8C, 0x00, 0x0F, 0x87, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x20, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x03, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x08, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xC0, 0x3F,
  0xF0, 0x0C, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x07, 0xC0, 0xC0, 0x03, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0x03, 0x07, 0x80, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x03,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x1F, 0xEF, 0xFC, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x73, 0x9F, 0x1F, 0xF0, 0x3C,
  0x00, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18,
  0x03, 0x80, 0x0C, 0x03, 0x80, 0x06, 0x03, 0x80, 0x03, 0x03, 0x80, 0x01,
  0x83, 0x80, 0x00, 0xC3, 0x80, 0x00, 0x63, 0xC0, 0x00, 0x33, 0xF0, 0x00,
  0x1B, 0x9C, 0x00, 0x0F, 0x86, 0x00, 0x07, 0x83, 0x80, 0x03, 0x00, 0xE0,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x03, 0x00,
  0x03, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x30,
  0x00, 0x07, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0xC0, 0x00, 0x00, 0x0F, 0xB0, 0x00,
  0x00, 0x03, 0xE6, 0x00, 0x00, 0x01, 0xB9, 0x80, 0x00, 0x00, 0x6F, 0x70,
  0x00, 0x00, 0x3B, 0xCC, 0x00, 0x00, 0x0C, 0xF3, 0x00, 0x00, 0x03, 0x3C,
  0x60, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x00, 0x63, 0xC7, 0x00, 0x00, 0x38,
  0xF0, 0xC0, 0x00, 0x0C, 0x3C, 0x30, 0x00, 0x03, 0x0F, 0x06, 0x00, 0x01,
  0x83, 0xC1, 0x80, 0x00, 0x60, 0xF0, 0x70, 0x00, 0x30, 0x3C, 0x0C, 0x00,
  0x0C, 0x0F, 0x03, 0x00, 0x03, 0x03, 0xC0, 0x60, 0x01, 0x80, 0xF0, 0x18,
  0x00, 0x60, 0x3C, 0x07, 0x00, 0x30, 0x0F, 0x00, 0xC0, 0x0C, 0x03, 0xC0,
  0x30, 0x03, 0x00, 0xF0, 0x06, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x60, 0x0F,
  0x00, 0x70, 0x30, 0x03, 0xC0, 0x0C, 0x0C, 0x00, 0xF0, 0x03, 0x07, 0x00,
  0x3C, 0x00, 0x61, 0x80, 0x0F, 0x00, 0x18, 0x60, 0x03, 0xC0, 0x07, 0x30,
  0x00, 0xF0, 0x00, 0xCC, 0x00, 0x3C, 0x00, 0x37, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0F, 0x0C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x81,
  0x80, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x30, 0x00,
  0x78, 0x07, 0x00, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x06, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x00, 0xC0, 0x1E, 0x00, 0x1C, 0x03,
  0xC0, 0x01, 0xC0, 0x78, 0x00, 0x18, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x38, 0x3C, 0x00, 0x03, 0x07, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x63, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0D, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x18, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x0C, 0x01, 0xFC, 0x30, 0x00, 0x78, 0xC0, 0x00, 0x73,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xEC,
  0x00, 0x07, 0x30, 0x00, 0x38, 0xC0, 0x0F, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x3F,
  0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0xE0, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x0F, 0x00, 0x3E, 0x1C, 0x00,
  0x04, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x70, 0xFF, 0x8F, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x20,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x61, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x70, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xFC, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E, 0x0C, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x70, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00,
  0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0xE7, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x30,
  0x00, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x30, 0x00,
  0x30, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60,
  0xC0, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x60,
  0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x07,
  0x00, 0xC0, 0x0C, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x06, 0x01, 0x80, 0x30, 0x0E, 0x00, 0x60,
  0x18, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x30, 0x30,
  0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x30, 0x00,
  0xC1, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x80, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x63, 0x00,
  0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x77, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x60, 0x00, 0x07, 0x80, 0x00, 0x16, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x06,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x38, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x0E,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C,
  0x60, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x07, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0x80, 0x78,
  0x20, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x7F, 0xFC, 0x1F, 0xF0, 0x63, 0xC0, 0x03, 0x38, 0x00,
  0x1B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xDF, 0x00, 0x0C,
  0xDC, 0x00, 0xE6, 0x7C, 0x3C, 0x31, 0xFF, 0xC1, 0x80, 0x40, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0xFF, 0x00, 0xC3, 0xFF, 0xC0, 0xCF, 0x00, 0xF0, 0xDC, 0x00, 0x38, 0xD8,
  0x00, 0x18, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x1C, 0xF0,
  0x00, 0x18, 0xD8, 0x00, 0x38, 0xCC, 0x00, 0xF0, 0xC7, 0x87, 0xE0, 0x83,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xF0,
  0x06, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x02, 0x07, 0xE3, 0xF0, 0x1F, 0xFF, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0xFF, 0x83, 0x03, 0xFF, 0xC3, 0x07, 0x00, 0x73, 0x0E, 0x00, 0x3B,
  0x1C, 0x00, 0x1B, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x30, 0x00, 0x0F,
  0x38, 0x00, 0x0B, 0x1C, 0x00, 0x1B, 0x0E, 0x00, 0x73, 0x07, 0xE3, 0xE3,
  0x01, 0xFF, 0x83, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x1E, 0x03, 0xC0, 0x70, 0x01, 0x81, 0xC0, 0x01, 0x87, 0x00, 0x03, 0x8C,
  0x00, 0x03, 0x38, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x30,
  0x3F, 0x0F, 0xE0, 0x1F, 0xFF, 0x00, 0x02, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x1F, 0xFC, 0x3F, 0xFF, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x83, 0x03, 0xFF, 0xE3,
  0x07, 0x00, 0x73, 0x0E, 0x00, 0x1B, 0x18, 0x00, 0x0B, 0x38, 0x00, 0x0F,
  0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x38, 0x00, 0x0B, 0x1C, 0x00, 0x1B,
  0x0E, 0x00, 0x73, 0x07, 0xC3, 0xE3, 0x01, 0xFF, 0x83, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x20, 0x00, 0x38, 0x3E, 0x00, 0xF0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0xFF, 0x03,
  0x0F, 0xFF, 0x0C, 0xF0, 0x0E, 0x37, 0x00, 0x1C, 0xD8, 0x00, 0x3B, 0xC0,
  0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x90, 0x73, 0xFC, 0x3E,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x0C,
  0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0, 0x07, 0x0C, 0x00, 0xE0, 0xC0, 0x1C,
  0x0C, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18,
  0x00, 0xC3, 0x00, 0x0C, 0x78, 0x00, 0xCD, 0xC0, 0x0D, 0xCC, 0x00, 0xF8,
  0x60, 0x0F, 0x07, 0x00, 0xE0, 0x38, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x0C,
  0x00, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00, 0x1C,
  0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xFE, 0x00, 0x7F, 0x83,
  0x1F, 0xFC, 0x07, 0xFF, 0x0C, 0xE0, 0x3C, 0x78, 0x0E, 0x36, 0x00, 0x73,
  0x80, 0x1C, 0xF0, 0x00, 0xEC, 0x00, 0x3B, 0x80, 0x01, 0xE0, 0x00, 0x6E,
  0x00, 0x07, 0x80, 0x01, 0xB8, 0x00, 0x1C, 0x00, 0x06, 0xC0, 0x00, 0x30,
  0x00, 0x1B, 0x00, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x00, 0x01, 0xF0,
  0x00, 0x0C, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0xC0,
  0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x00,
  0x01, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x00, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00,
  0x07, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x80, 0xFF, 0x03, 0x0F, 0xFF, 0x0C, 0xF0, 0x0E, 0x37, 0x00, 0x1C,
  0xD8, 0x00, 0x3B, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x00,
  0xE1, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x0E, 0x00, 0x7C, 0x7E,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xC0, 0xFF, 0x00, 0xC3, 0xFF,
  0xC0, 0xC7, 0x00, 0xF0, 0xCC, 0x00, 0x38, 0xD8, 0x00, 0x18, 0xF0, 0x00,
  0x0C, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0C, 0xF0, 0x00, 0x0C, 0xF0, 0x00, 0x18, 0xD8, 0x00,
  0x38, 0xCE, 0x00, 0xF0, 0xC7, 0xC7, 0xE0, 0xC1, 0xFF, 0x80, 0xC0, 0x10,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x03, 0x03, 0xFF, 0xC3, 0x07, 0x00, 0x73, 0x0C, 0x00,
  0x33, 0x18, 0x00, 0x1B, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x0F, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x30, 0x00,
  0x0F, 0x38, 0x00, 0x1B, 0x18, 0x00, 0x3B, 0x0E, 0x00, 0x73, 0x07, 0xC7,
  0xE3, 0x03, 0xFF, 0x83, 0x00, 0x10, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC1, 0xFF, 0x8F, 0xFF, 0x38,
  0x06, 0xE0, 0x0D, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x1C, 0x00, 0xE3, 0x80, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0xE0, 0x00, 0xEF, 0xE0, 0xFC,
  0x3F, 0xFF, 0x00, 0x14, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0x18, 0x0F,
  0xF0, 0x02, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xB0, 0x00, 0x0B,
  0x70, 0x00, 0x36, 0x70, 0x00, 0xCC, 0xF0, 0x03, 0x18, 0xFC, 0x7C, 0x30,
  0x7F, 0xF0, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C,
  0x38, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x38,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x36, 0x00,
  0x0F, 0x00, 0x07, 0x60, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x06,
  0x30, 0x01, 0x98, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x01, 0x8C,
  0x00, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x18, 0x03, 0x06, 0x01, 0xC1, 0x80,
  0x30, 0x60, 0x18, 0x18, 0x07, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x03, 0x80, 0xC0, 0xE0, 0x30, 0x30, 0x0E, 0x0C, 0x03,
  0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x1C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00,
  0x6C, 0x00, 0x1E, 0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x01, 0x81, 0xC0, 0x01,
  0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x66, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x76, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x03, 0x81, 0xC0, 0x03,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x18,
  0x00, 0x18, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x01, 0xC1, 0x80, 0x00,
  0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0x00, 0x3F, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0xE0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x07, 0xC0, 0x3E, 0x00, 0x40, 0x00, 0x06, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x78, 0x03, 0xF1, 0xE8, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0x00,
};

const GFXglyph NotoSans_ExtraLight54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 39, 13, 4, -39 },
  { 21, 10, 14, 18, 4, -39 },
  { 39, 32, 39, 35, 1, -39 },
  { 195, 23, 44, 31, 3, -41 },
  { 322, 37, 40, 43, 3, -39 },
  { 507, 34, 40, 38, 3, -39 },
  { 677, 2, 14, 10, 4, -39 },
  { 681, 10, 48, 14, 2, -39 },
  { 741, 10, 48, 14, 2, -39 },
  { 801, 23, 22, 30, 3, -41 },
  { 865, 25, 25, 31, 3, -32 },
  { 944, 6, 13, 11, 2, -6 },
  { 954, 13, 2, 17, 2, -16 },
  { 958, 4, 4, 12, 4, -4 },
  { 960, 16, 39, 18, 1, -39 },
  { 1038, 25, 40, 31, 3, -39 },
  { 1163, 13, 39, 31, 5, -39 },
  { 1227, 24, 39, 31, 3, -39 },
  { 1344, 24, 40, 31, 3, -39 },
  { 1464, 29, 39, 31, 1, -39 },
  { 1606, 23, 40, 31, 4, -39 },
  { 1721, 24, 40, 31, 4, -39 },
  { 1841, 25, 39, 31, 3, -39 },
  { 1963, 24, 40, 31, 3, -39 },
  { 2083, 24, 40, 31, 3, -39 },
  { 2203, 4, 29, 12, 4, -29 },
  { 2218, 6, 36, 12, 2, -29 },
  { 2245, 25, 25, 31, 3, -32 },
  { 2324, 25, 12, 31, 3, -25 },
  { 2362, 25, 25, 31, 3, -32 },
  { 2441, 19, 39, 23, 2, -39 },
  { 2534, 42, 43, 48, 3, -38 },
  { 2760, 32, 39, 32, 0, -39 },
  { 2916, 25, 39, 34, 6, -39 },
  { 3038, 29, 40, 33, 3, -39 },
  { 3183, 28, 39, 38, 6, -39 },
  { 3320, 20, 39, 30, 6, -39 },
  { 3418, 20, 39, 27, 6, -39 },
  { 3516, 32, 40, 39, 3, -39 },
  { 3676, 27, 39, 39, 6, -39 },
  { 3808, 10, 39, 16, 3, -39 },
  { 3857, 13, 49, 13, -5, -39 },
  { 3937, 25, 39, 31, 6, -39 },
  { 4059, 20, 39, 28, 6, -39 },
  { 4157, 34, 39, 46, 6, -39 },
  { 4323, 27, 39, 38, 6, -39 },
  { 4455, 35, 40, 41, 3, -39 },
  { 4630, 22, 39, 31, 6, -39 },
  { 4738, 35, 48, 41, 3, -39 },
  { 4948, 24, 39, 32, 6, -39 },
  { 5065, 24, 40, 29, 3, -39 },
  { 5185, 28, 39, 28, 0, -39 },
  { 5322, 29, 40, 39, 5, -39 },
  { 5467, 31, 39, 31, 0, -39 },
  { 5619, 44, 39, 48, 2, -39 },
  { 5834, 28, 39, 28, 0, -39 },
  { 5971, 28, 39, 28, 0, -39 },
  { 6108, 27, 39, 31, 2, -39 },
  { 6240, 11, 48, 17, 5, -39 },
  { 6306, 16, 39, 18, 1, -39 },
  { 6384, 11, 48, 17, 1, -39 },
  { 6450, 26, 24, 31, 2, -39 },
  { 6528, 22, 2, 22, 0, 5 },
  { 6534, 10, 8, 14, 2, -41 },
  { 6544, 21, 30, 28, 3, -29 },
  { 6623, 24, 42, 32, 5, -41 },
  { 6749, 21, 30, 26, 3, -29 },
  { 6828, 24, 42, 32, 3, -41 },
  { 6954, 23, 30, 29, 3, -29 },
  { 7041, 18, 41, 16, 1, -41 },
  { 7134, 24, 42, 32, 3, -29 },
  { 7260, 22, 41, 31, 5, -41 },
  { 7373, 4, 39, 12, 4, -39 },
  { 7393, 11, 52, 12, -3, -39 },
  { 7465, 20, 41, 25, 5, -41 },
  { 7568, 2, 41, 12, 5, -41 },
  { 7579, 38, 29, 47, 5, -29 },
  { 7717, 22, 29, 31, 5, -29 },
  { 7797, 25, 30, 31, 3, -29 },
  { 7891, 24, 42, 32, 5, -29 },
  { 8017, 24, 42, 32, 3, -29 },
  { 8143, 15, 29, 21, 5, -29 },
  { 8198, 20, 30, 25, 2, -29 },
  { 8273, 15, 37, 18, 1, -36 },
  { 8343, 23, 30, 31, 4, -29 },
  { 8430, 24, 29, 24, 0, -29 },
  { 8517, 36, 29, 38, 1, -29 },
  { 8648, 24, 29, 26, 1, -29 },
  { 8735, 24, 42, 24, 0, -29 },
  { 8861, 21, 29, 25, 2, -29 },
  { 8938, 16, 48, 19, 1, -39 },
  { 9034, 2, 54, 29, 13, -41 },
  { 9048, 15, 48, 19, 2, -39 },
  { 9138, 25, 6, 31, 3, -22 },
};

const GFXfont NotoSans_ExtraLight54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRALIGHT54PT7B_H_
