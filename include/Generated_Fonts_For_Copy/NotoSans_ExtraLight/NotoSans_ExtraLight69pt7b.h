#ifndef _NOTOSANS_EXTRALIGHT69PT7B_H_
#define _NOTOSANS_EXTRALIGHT69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight69pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x6F,
  0xFF, 0xF6, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xDC, 0xFF, 0x81, 0xE0, 0xE0,
  0x3C, 0x1C, 0x07, 0x00, 0x41, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x03,
  0xE7, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xBF, 0x80, 0x00, 0x1C, 0x3E,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x71, 0x00, 0x1C, 0x0F, 0x0F, 0x80,
  0xE1, 0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x02,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x06, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x07, 0x03, 0xF8, 0x1C, 0x00,
  0x1C, 0x1C, 0x0F, 0xFC, 0x18, 0x00, 0x30, 0x38, 0x7C, 0x3C, 0x30, 0x00,
  0x60, 0xE0, 0xE0, 0x1C, 0x70, 0x01, 0xC1, 0x83, 0x80, 0x18, 0x60, 0x03,
  0x07, 0x06, 0x00, 0x38, 0xE0, 0x0E, 0x0C, 0x1C, 0x00, 0x30, 0xE0, 0x38,
  0x38, 0x38, 0x00, 0x61, 0xF1, 0xF0, 0x60, 0x60, 0x00, 0xE0, 0xFF, 0x81,
  0xC1, 0xC0, 0x01, 0xC0, 0x7C, 0x03, 0x03, 0x80, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70,
  0x03, 0x80, 0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x01, 0xC0, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xC3, 0xC0, 0x00, 0x3C, 0x00, 0x38, 0x70,
  0x00, 0x03, 0xC0, 0x07, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xC3, 0x80, 0x00,
  0x03, 0xC0, 0x38, 0x70, 0x00, 0x00, 0x3C, 0x0E, 0x0E, 0x00, 0x00, 0x03,
  0xC1, 0xC1, 0xC0, 0x00, 0x00, 0x3C, 0x70, 0x38, 0x00, 0x00, 0x03, 0xDC,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x3C, 0x00,
  0x00, 0x03, 0xBC, 0x03, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0x80, 0x3E, 0x00, 0x3F, 0x00,
  0x38, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xED, 0xB6,
  0xD8, 0x00, 0x78, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0C, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x2F, 0x80, 0x30, 0x07, 0xBF, 0xC0,
  0xC0, 0xFF, 0x3F, 0xE3, 0x1F, 0xE0, 0x0F, 0xEF, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x03,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x78, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x38,
  0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x86, 0x0C, 0x38, 0x60,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0xF6, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xF7, 0x01, 0xE7, 0x07,
  0xC7, 0x0F, 0x07, 0x1E, 0x07, 0x7C, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0x40,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xDF, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x07, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0xFC,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x08, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x90, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x78, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x37, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x80, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1E, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x1F, 0xFE, 0x00, 0x70, 0x7F, 0xFF, 0x80, 0x61, 0xF8, 0x07,
  0xC0, 0x63, 0xC0, 0x00, 0xF0, 0x67, 0x00, 0x00, 0x70, 0x6E, 0x00, 0x00,
  0x38, 0x6C, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x0F, 0xB8, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x6E, 0x70, 0x00,
  0x01, 0xDC, 0x70, 0x00, 0x07, 0x38, 0x78, 0x00, 0x3C, 0x70, 0x7E, 0x07,
  0xE0, 0xC0, 0x3F, 0xFF, 0x81, 0x80, 0x1F, 0xF8, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x10,
  0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0xF6, 0x1C, 0x3C,
  0x78, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xC3, 0x87,
  0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x78, 0x00, 0xF8, 0x40, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0x87, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0E, 0x38, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x31, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0x9C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x0E, 0xE0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x76, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x03, 0xF0, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x0F, 0x80, 0x07, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x07, 0x80,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x03, 0x80, 0x03,
  0xE0, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x60, 0x00, 0x07, 0x00, 0x06, 0xC0, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x36, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0xB0, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x1D, 0xC0, 0x03, 0x80, 0x01, 0xF0, 0x01, 0xCE, 0x00,
  0x1C, 0x00, 0x0D, 0xC0, 0x0E, 0x30, 0x00, 0x70, 0x00, 0xC6, 0x00, 0xE1,
  0x80, 0x01, 0xE0, 0x1C, 0x38, 0x0E, 0x0E, 0x00, 0x07, 0xFF, 0xC0, 0xFF,
  0xE0, 0x70, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0xE0,
  0x00, 0x03, 0xF0, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x03, 0xE0, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x03, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x80, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x1F, 0xF0,
  0x01, 0xC0, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x70, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x07, 0x87, 0x00, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xDC, 0x00,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x0F, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x38, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0xF8, 0x0E, 0x00,
  0x00, 0x1F, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x03, 0x80, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0xE3, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00,
  0xE1, 0xF0, 0x00, 0x00, 0xE3, 0xB8, 0x00, 0x00, 0xE7, 0x3C, 0x00, 0x00,
  0xEE, 0x1C, 0x00, 0x00, 0xFC, 0x0E, 0x00, 0x00, 0xF8, 0x07, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xB8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1B, 0xF7, 0x00, 0x00, 0x00, 0x01, 0xDF,
  0xB8, 0x00, 0x00, 0x00, 0x0E, 0xFD, 0xC0, 0x00, 0x00, 0x00, 0xE7, 0xE7,
  0x00, 0x00, 0x00, 0x07, 0x3F, 0x38, 0x00, 0x00, 0x00, 0x31, 0xF8, 0xE0,
  0x00, 0x00, 0x03, 0x8F, 0xC7, 0x00, 0x00, 0x00, 0x1C, 0x7E, 0x18, 0x00,
  0x00, 0x01, 0xC3, 0xF0, 0xE0, 0x00, 0x00, 0x0E, 0x1F, 0x87, 0x00, 0x00,
  0x00, 0x60, 0xFC, 0x1C, 0x00, 0x00, 0x07, 0x07, 0xE0, 0xE0, 0x00, 0x00,
  0x38, 0x3F, 0x03, 0x00, 0x00, 0x03, 0x81, 0xF8, 0x1C, 0x00, 0x00, 0x1C,
  0x0F, 0xC0, 0xE0, 0x00, 0x00, 0xC0, 0x7E, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0xF0, 0x1C, 0x00, 0x00, 0x70, 0x1F, 0x80, 0x60, 0x00, 0x07, 0x00, 0xFC,
  0x03, 0x80, 0x00, 0x38, 0x07, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x3F, 0x00,
  0x70, 0x00, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x00, 0xC0, 0x0F, 0xC0, 0x0C,
  0x00, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80,
  0x03, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01,
  0x80, 0x07, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xF8, 0x00, 0x70, 0x06, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x7E, 0x00, 0x0E, 0x03, 0x00, 0x03, 0xF0, 0x00, 0x30, 0x38, 0x00, 0x1F,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xF8, 0x00,
  0x06, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xB8, 0x00, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x00, 0x3F, 0x78, 0x00, 0x00,
  0x07, 0xE7, 0x80, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x00, 0x1F, 0x8F, 0x00,
  0x00, 0x03, 0xF0, 0xF0, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x00, 0x0F, 0xC0,
  0xE0, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00, 0x3F, 0x01, 0xC0, 0x00, 0x07,
  0xE0, 0x1C, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x38, 0x00,
  0x03, 0xF0, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x07,
  0x00, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x07, 0xE0,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x03,
  0xF0, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x0F, 0xC0, 0x00, 0x3C,
  0x01, 0xF8, 0x00, 0x03, 0x80, 0x3F, 0x00, 0x00, 0x38, 0x07, 0xE0, 0x00,
  0x07, 0x80, 0xFC, 0x00, 0x00, 0x70, 0x1F, 0x80, 0x00, 0x07, 0x03, 0xF0,
  0x00, 0x00, 0xF0, 0x7E, 0x00, 0x00, 0x0E, 0x0F, 0xC0, 0x00, 0x00, 0xE1,
  0xF8, 0x00, 0x00, 0x1E, 0x3F, 0x00, 0x00, 0x01, 0xC7, 0xE0, 0x00, 0x00,
  0x1C, 0xFC, 0x00, 0x00, 0x03, 0xDF, 0x80, 0x00, 0x00, 0x3B, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x38, 0x00, 0x3F, 0xC1, 0xC0, 0x00, 0x1F, 0x0E, 0x00, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F,
  0x87, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0xE0, 0x00, 0x07,
  0xC0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x8C, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x18, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x07, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x70, 0x06, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x00,
  0x0E, 0x00, 0x30, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0xC0, 0xFC, 0x07, 0x80, 0x03, 0xC0, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x01, 0x83, 0xF0, 0x00,
  0x30, 0xF0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x07, 0x70, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xD8, 0x00,
  0x00, 0xDB, 0x80, 0x00, 0x3B, 0x78, 0x00, 0x06, 0x67, 0x80, 0x03, 0x8C,
  0x78, 0x01, 0xE1, 0x87, 0xFF, 0xF8, 0x30, 0x7F, 0xFC, 0x06, 0x00, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x0F, 0xFC, 0x00, 0xE0, 0xFF, 0xFE, 0x01, 0xC3, 0xF0, 0x3F, 0x03,
  0x8E, 0x00, 0x0F, 0x07, 0x38, 0x00, 0x0F, 0x0E, 0xE0, 0x00, 0x0F, 0x1F,
  0x80, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0x0E, 0x7C, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x19, 0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x0E,
  0x3F, 0x00, 0x00, 0x38, 0x77, 0x00, 0x00, 0xF0, 0xC7, 0x00, 0x03, 0xC1,
  0x87, 0x80, 0x1F, 0x03, 0x07, 0xFF, 0xF8, 0x06, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x03,
  0xF8, 0x1F, 0x01, 0xF0, 0x00, 0x20, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x0F,
  0xC0, 0x07, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x0F, 0xFC, 0x07, 0x00, 0xFF, 0xFE, 0x0E, 0x03, 0xF0, 0x3E, 0x1C, 0x1F,
  0x00, 0x0E, 0x38, 0x78, 0x00, 0x0E, 0x70, 0xE0, 0x00, 0x0E, 0xE3, 0x80,
  0x00, 0x0D, 0xCE, 0x00, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0x1F, 0x70, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7B, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x0F, 0xC7,
  0x00, 0x00, 0x1B, 0x8F, 0x00, 0x00, 0x67, 0x0F, 0x00, 0x01, 0xCE, 0x0F,
  0xC0, 0x0F, 0x1C, 0x07, 0xFF, 0xF8, 0x38, 0x03, 0xFF, 0xE0, 0x70, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x3F,
  0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xC0, 0x10, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x0E, 0x01, 0xFF, 0xFC, 0x1C, 0x0F, 0xE0, 0x7C, 0x38, 0x3E,
  0x00, 0x1E, 0x70, 0xF0, 0x00, 0x0C, 0xE1, 0xC0, 0x00, 0x0D, 0xC7, 0x00,
  0x00, 0x1F, 0x9C, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x3E, 0x60, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xF6, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E,
  0xC0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1B, 0x8E,
  0x00, 0x00, 0x37, 0x0E, 0x00, 0x00, 0xCE, 0x1F, 0x00, 0x07, 0x9C, 0x1F,
  0x80, 0x3E, 0x38, 0x0F, 0xFF, 0xF0, 0x70, 0x07, 0xFF, 0x80, 0xE0, 0x00,
  0xF8, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x20, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03,
  0xC0, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xFF,
  0x80, 0xE0, 0xFF, 0xFE, 0x0E, 0x1F, 0x01, 0xF8, 0xE3, 0x80, 0x07, 0xCE,
  0x70, 0x00, 0x1C, 0xEC, 0x00, 0x00, 0xEF, 0xC0, 0x00, 0x0E, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x77, 0xFF, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x80, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x20, 0x38, 0xFF, 0xC3, 0xFE, 0x00, 0x80,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x81,
  0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0xE1, 0xF0, 0x00, 0x1C, 0x77, 0x00, 0x03, 0x9C, 0xE0, 0x00, 0x77,
  0x0E, 0x00, 0x0F, 0xC0, 0xE0, 0x01, 0xF0, 0x0E, 0x00, 0x3C, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xC0,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0xC3, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0xC7,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0xEC,
  0x00, 0x07, 0x30, 0x00, 0x0E, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x06, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x1F, 0xF8, 0x0C, 0x0F, 0xFF, 0xE0, 0xC1, 0xF0, 0x1F, 0x8C, 0x38, 0x00,
  0x7C, 0xE7, 0x00, 0x01, 0xCE, 0xC0, 0x00, 0x0E, 0xFC, 0x00, 0x00, 0xEF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x38, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x1F, 0xF8, 0x01, 0x80, 0xFF, 0xFC,
  0x03, 0x07, 0xE0, 0x7E, 0x07, 0x1E, 0x00, 0x1E, 0x0E, 0x70, 0x00, 0x1E,
  0x1D, 0xC0, 0x00, 0x1E, 0x3B, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0x1C,
  0xF8, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x00, 0xCF, 0x80, 0x00, 0x03, 0x9F, 0x00, 0x00,
  0x07, 0x3F, 0x00, 0x00, 0x1C, 0x76, 0x00, 0x00, 0x78, 0xEE, 0x00, 0x01,
  0xE1, 0xCF, 0x00, 0x07, 0x83, 0x8F, 0x80, 0x3E, 0x07, 0x0F, 0xFF, 0xF8,
  0x0E, 0x07, 0xFF, 0xC0, 0x1C, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x0C, 0x03,
  0xFF, 0xF8, 0x30, 0x3F, 0x01, 0xF0, 0xC1, 0xF0, 0x00, 0xE3, 0x0F, 0x00,
  0x01, 0xCC, 0x78, 0x00, 0x03, 0xB1, 0xC0, 0x00, 0x06, 0xCE, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x06, 0xC7, 0x00, 0x00, 0x3B, 0x1E, 0x00, 0x01, 0xCC, 0x3C,
  0x00, 0x0E, 0x30, 0x7C, 0x00, 0xF0, 0xC0, 0xFF, 0xFF, 0x83, 0x00, 0xFF,
  0xF8, 0x0C, 0x00, 0x3F, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x8F, 0xC3, 0xF3, 0xC0, 0x0E,
  0xE0, 0x01, 0xD8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0xFC, 0x07, 0xF8, 0x78, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x30, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE3,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x10, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xF0, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x37, 0x78, 0x00, 0x07,
  0x73, 0xC0, 0x00, 0xE3, 0x1F, 0x00, 0x7C, 0x30, 0xFF, 0xFF, 0x83, 0x03,
  0xFF, 0xE0, 0x30, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xDC, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x38, 0x30,
  0x00, 0x18, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x70, 0xC0, 0x01, 0xC0, 0xE0,
  0x00, 0xE1, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x83, 0x80, 0x06, 0x01, 0xC0,
  0x07, 0x03, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x07, 0x00,
  0x18, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x60, 0x18, 0x00, 0x70, 0x18,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0xE0,
  0x01, 0x81, 0x80, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00,
  0x0E, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x19, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x70, 0x18, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x60, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0x7F, 0xFF, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x01,
  0xFC, 0x7E, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_ExtraLight69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 50, 16, 6, -49 },
  { 26, 13, 18, 23, 5, -49 },
  { 56, 41, 49, 45, 2, -49 },
  { 308, 29, 56, 39, 4, -52 },
  { 511, 47, 51, 55, 4, -50 },
  { 811, 43, 51, 49, 4, -50 },
  { 1086, 3, 18, 13, 5, -49 },
  { 1093, 13, 60, 18, 3, -49 },
  { 1191, 13, 60, 18, 2, -49 },
  { 1289, 30, 28, 38, 4, -52 },
  { 1394, 32, 32, 39, 4, -40 },
  { 1522, 7, 17, 14, 3, -8 },
  { 1537, 16, 3, 22, 3, -20 },
  { 1543, 4, 6, 16, 6, -5 },
  { 1546, 21, 49, 23, 1, -49 },
  { 1675, 31, 51, 39, 4, -50 },
  { 1873, 16, 49, 39, 7, -49 },
  { 1971, 30, 50, 39, 4, -50 },
  { 2159, 31, 51, 39, 3, -50 },
  { 2357, 37, 50, 39, 2, -50 },
  { 2589, 30, 50, 39, 5, -49 },
  { 2777, 32, 51, 39, 4, -50 },
  { 2981, 31, 49, 39, 4, -49 },
  { 3171, 31, 51, 39, 4, -50 },
  { 3369, 31, 51, 39, 4, -50 },
  { 3567, 4, 38, 16, 6, -37 },
  { 3586, 7, 46, 16, 3, -37 },
  { 3627, 32, 32, 39, 4, -41 },
  { 3755, 32, 17, 39, 4, -33 },
  { 3823, 32, 32, 39, 4, -41 },
  { 3951, 24, 51, 29, 2, -50 },
  { 4104, 53, 56, 61, 4, -49 },
  { 4475, 41, 49, 41, 0, -49 },
  { 4727, 32, 49, 43, 7, -49 },
  { 4923, 37, 51, 43, 4, -50 },
  { 5159, 37, 49, 48, 7, -49 },
  { 5386, 27, 49, 38, 7, -49 },
  { 5552, 27, 49, 34, 7, -49 },
  { 5718, 40, 51, 50, 4, -50 },
  { 5973, 35, 49, 49, 7, -49 },
  { 6188, 12, 49, 20, 4, -49 },
  { 6262, 16, 61, 17, -6, -49 },
  { 6384, 32, 49, 39, 7, -49 },
  { 6580, 27, 49, 35, 7, -49 },
  { 6746, 45, 49, 59, 7, -49 },
  { 7022, 35, 49, 49, 7, -49 },
  { 7237, 44, 51, 52, 4, -50 },
  { 7518, 29, 49, 40, 7, -49 },
  { 7696, 44, 62, 52, 4, -50 },
  { 8037, 32, 49, 40, 7, -49 },
  { 8233, 30, 51, 38, 4, -50 },
  { 8425, 35, 49, 36, 0, -49 },
  { 8640, 37, 50, 49, 6, -49 },
  { 8872, 39, 49, 39, 0, -49 },
  { 9111, 57, 49, 61, 2, -49 },
  { 9461, 36, 49, 36, 0, -49 },
  { 9682, 36, 49, 36, 0, -49 },
  { 9903, 35, 49, 40, 2, -49 },
  { 10118, 14, 60, 22, 6, -49 },
  { 10223, 21, 49, 23, 1, -49 },
  { 10352, 14, 60, 22, 2, -49 },
  { 10457, 33, 31, 39, 3, -50 },
  { 10585, 28, 3, 28, 0, 6 },
  { 10596, 12, 11, 18, 3, -53 },
  { 10613, 27, 38, 36, 3, -37 },
  { 10742, 31, 53, 41, 6, -52 },
  { 10948, 27, 38, 33, 4, -37 },
  { 11077, 31, 53, 41, 4, -52 },
  { 11283, 30, 38, 38, 4, -37 },
  { 11426, 23, 53, 20, 1, -53 },
  { 11579, 31, 54, 41, 4, -37 },
  { 11789, 28, 52, 40, 6, -52 },
  { 11971, 5, 50, 15, 5, -50 },
  { 12003, 14, 67, 15, -4, -50 },
  { 12121, 27, 52, 32, 6, -52 },
  { 12297, 3, 52, 15, 6, -52 },
  { 12317, 48, 37, 60, 6, -37 },
  { 12539, 28, 37, 40, 6, -37 },
  { 12669, 32, 38, 40, 4, -37 },
  { 12821, 31, 53, 41, 6, -37 },
  { 13027, 30, 53, 41, 4, -37 },
  { 13226, 19, 37, 26, 6, -37 },
  { 13314, 26, 38, 32, 3, -37 },
  { 13438, 20, 46, 23, 1, -45 },
  { 13553, 28, 38, 40, 6, -37 },
  { 13686, 31, 37, 31, 0, -37 },
  { 13830, 47, 37, 49, 1, -37 },
  { 14048, 30, 37, 34, 2, -37 },
  { 14187, 31, 54, 31, 0, -37 },
  { 14397, 26, 37, 32, 3, -37 },
  { 14518, 19, 60, 24, 2, -49 },
  { 14661, 3, 70, 37, 17, -53 },
  { 14688, 20, 60, 24, 2, -49 },
  { 14838, 32, 7, 39, 4, -28 },
};

const GFXfont NotoSans_ExtraLight69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRALIGHT69PT7B_H_
