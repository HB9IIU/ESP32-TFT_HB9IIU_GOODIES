#ifndef _NOTOSANS_EXTRALIGHT66PT7B_H_
#define _NOTOSANS_EXTRALIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight66pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xEF, 0xFD, 0xE4, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0,
  0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x30, 0x00,
  0x01, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x06, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0x80, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xE6,
  0x7F, 0xC1, 0xE0, 0x60, 0x38, 0x3C, 0x06, 0x00, 0x83, 0x80, 0x60, 0x00,
  0x70, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00, 0x38,
  0x06, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x0F, 0x06, 0x00, 0x00, 0x7C, 0x60,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x06, 0x7C, 0x00, 0x00, 0x61, 0xF0, 0x00, 0x06,
  0x07, 0x80, 0x00, 0x60, 0x3C, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x60, 0x0E,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x60, 0x07, 0x00, 0x06, 0x00, 0x70, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x80,
  0x06, 0x07, 0x8F, 0x80, 0x61, 0xF0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0xCF, 0x80,
  0x00, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x18, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x30, 0x38, 0x00, 0x01, 0x80, 0x03, 0x81,
  0x80, 0xFC, 0x0E, 0x00, 0x1C, 0x1C, 0x1F, 0xF8, 0x70, 0x00, 0xC0, 0xC1,
  0xE1, 0xE1, 0x80, 0x06, 0x0E, 0x1C, 0x03, 0x8C, 0x00, 0x70, 0x60, 0xC0,
  0x1C, 0x70, 0x03, 0x87, 0x0E, 0x00, 0x71, 0xC0, 0x38, 0x30, 0x60, 0x03,
  0x8F, 0x03, 0x83, 0x87, 0x00, 0x0C, 0x3E, 0x7C, 0x18, 0x38, 0x00, 0x70,
  0xFF, 0x81, 0x81, 0xC0, 0x03, 0x80, 0xF0, 0x1C, 0x0C, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x30, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0x83, 0xC0, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x03,
  0xC0, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0x00, 0x61, 0xC0, 0x00, 0x3C, 0x00,
  0x70, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x70,
  0x00, 0x00, 0xF0, 0x1C, 0x38, 0x00, 0x00, 0x3C, 0x1C, 0x1C, 0x00, 0x00,
  0x0F, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0xCE, 0x07, 0x00, 0x00, 0x00, 0xFE,
  0x03, 0x80, 0x00, 0x00, 0x3F, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x00, 0x0F, 0xE0, 0x0E, 0x00, 0x00,
  0x0F, 0x38, 0x07, 0x80, 0x00, 0x0F, 0x0E, 0x01, 0xE0, 0x00, 0x1F, 0x03,
  0x80, 0x7C, 0x00, 0x3E, 0x00, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x38, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0xF8, 0x06, 0x01, 0xFF, 0xF0, 0x60, 0xFF, 0x1F, 0xE6, 0x7F, 0x80,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xF0, 0x02, 0x00, 0x04,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x71,
  0xC7, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x18, 0x63, 0x8C, 0x30, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x77, 0xFE, 0xF2, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x7C, 0x01, 0xF8, 0x0F, 0x70, 0x3C, 0xE0, 0xF1, 0xC7, 0x83, 0x9E, 0x07,
  0x78, 0x0F, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x82, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x20, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x3E,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x38, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x07, 0x8C, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFE,
  0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x07, 0xFE, 0x00, 0x60, 0x7F, 0xFE, 0x01, 0x87, 0xE0, 0x7E,
  0x06, 0x3C, 0x00, 0x3C, 0x39, 0xC0, 0x00, 0x38, 0xEE, 0x00, 0x00, 0x73,
  0xF0, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0x7F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x07, 0x18, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x1B, 0x38, 0x00, 0x01, 0x98, 0xE0, 0x00, 0x3C, 0xC3,
  0xC0, 0x03, 0x86, 0x0F, 0xC1, 0xF8, 0x70, 0x3F, 0xFF, 0x03, 0x80, 0x3F,
  0xC0, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x10, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x77,
  0xFE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xDE, 0x40, 0x0E, 0x1F,
  0x1F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38,
  0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xC0, 0x07,
  0x84, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x01, 0xA0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xC1,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0E, 0x38, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xE3, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06, 0x30, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x63, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x06, 0x70, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x77, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x07, 0x60, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x76, 0x00, 0x18, 0x00, 0x03, 0x00, 0x07, 0x60, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x76, 0x00, 0x38, 0x00, 0x03, 0x00, 0x07, 0x60,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x7E, 0x00, 0x30, 0x00, 0x03, 0x00, 0x06,
  0xE0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x66, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x06, 0x60, 0x03, 0x80, 0x00, 0x70, 0x00, 0x66, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x0E, 0x60, 0x03, 0x80, 0x00, 0x70, 0x00, 0xC6, 0x00, 0x18, 0x00,
  0x0F, 0x00, 0x0C, 0x60, 0x01, 0xC0, 0x01, 0xF8, 0x01, 0x87, 0x00, 0x0E,
  0x00, 0x19, 0x80, 0x38, 0x70, 0x00, 0xF0, 0x07, 0x1C, 0x07, 0x03, 0x00,
  0x07, 0xC1, 0xE0, 0xF1, 0xE0, 0x38, 0x00, 0x1F, 0xFC, 0x07, 0xFC, 0x03,
  0x80, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x0C, 0x00, 0x07, 0xF8, 0x30, 0x00, 0x01, 0xF0,
  0xC0, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x03, 0xB0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xF0,
  0xC0, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x30,
  0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x07, 0xC3, 0x00, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x1E, 0x30, 0x00, 0x01, 0xF0, 0xC0, 0x00, 0x7F, 0x83, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x04, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x04, 0x00,
  0x7E, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x03, 0x00, 0x07, 0xFE, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x0C, 0x00,
  0x00, 0x1F, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x00, 0x0F, 0x06,
  0x00, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x00, 0x1E, 0x30, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x00, 0x78, 0x18, 0x00, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x0F,
  0x80, 0x60, 0x00, 0x0F, 0xE0, 0x0C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xB0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xE7, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00,
  0x18, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x00, 0x30, 0x3C, 0x00, 0x00,
  0x00, 0xC0, 0x7C, 0x00, 0x00, 0x03, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x0F, 0x40, 0x3C, 0xFF, 0xF1, 0xFF, 0x80, 0x78, 0x00, 0xC0, 0x00,
  0x00, 0x3D, 0x80, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x03, 0xC6, 0x00, 0x00,
  0x0F, 0x0C, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x03,
  0xC0, 0x60, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x3C, 0x01, 0x80, 0x00, 0xF0,
  0x03, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x18, 0x00, 0xF0, 0x00, 0x30, 0x03, 0xC0, 0x00, 0x60, 0x0F, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0x18, 0x7E, 0x00, 0x00, 0x31,
  0xDE, 0x00, 0x00, 0x67, 0x1C, 0x00, 0x00, 0xDC, 0x1C, 0x00, 0x01, 0xF0,
  0x1C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x78, 0x00, 0x60, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x70, 0x01, 0x80, 0x00, 0x70, 0x03, 0x00, 0x00,
  0xF0, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01,
  0xE0, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0x07,
  0x80, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xDC, 0x00, 0x00, 0x00, 0x06, 0xF7, 0x00, 0x00, 0x00, 0x03, 0xBC,
  0xC0, 0x00, 0x00, 0x00, 0xCF, 0x38, 0x00, 0x00, 0x00, 0x73, 0xCE, 0x00,
  0x00, 0x00, 0x1C, 0xF1, 0xC0, 0x00, 0x00, 0x06, 0x3C, 0x70, 0x00, 0x00,
  0x03, 0x8F, 0x0C, 0x00, 0x00, 0x00, 0xC3, 0xC3, 0x80, 0x00, 0x00, 0x70,
  0xF0, 0x60, 0x00, 0x00, 0x1C, 0x3C, 0x1C, 0x00, 0x00, 0x06, 0x0F, 0x07,
  0x00, 0x00, 0x03, 0x83, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0xF0, 0x38, 0x00,
  0x00, 0x70, 0x3C, 0x06, 0x00, 0x00, 0x1C, 0x0F, 0x01, 0xC0, 0x00, 0x06,
  0x03, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xF0, 0x0C, 0x00, 0x00, 0xC0, 0x3C,
  0x03, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x60, 0x00, 0x1C, 0x03, 0xC0, 0x1C,
  0x00, 0x06, 0x00, 0xF0, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0xC0, 0x00,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x03, 0xC0, 0x06, 0x00, 0x1C, 0x00,
  0xF0, 0x01, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x00, 0x60,
  0x1C, 0x00, 0x3C, 0x00, 0x1C, 0x06, 0x00, 0x0F, 0x00, 0x07, 0x03, 0x80,
  0x03, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x3C,
  0x00, 0x06, 0x1C, 0x00, 0x0F, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0xC0, 0x01, 0xFE, 0x0C, 0x00, 0x01, 0xF0, 0xC0, 0x00, 0x07,
  0x8C, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x01, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x1F,
  0xE0, 0x30, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x07, 0x83, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0,
  0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0x7B, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0xF8, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x07,
  0x8F, 0x80, 0x03, 0xF0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x40, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x03, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x70, 0x60, 0x00, 0x06, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18,
  0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x03,
  0x80, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x07, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x1C, 0x03, 0x80,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x1C, 0x18, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0C,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x00, 0x78, 0x0C, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0x1C, 0x3F, 0x00, 0x07, 0x1E,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF6, 0x00, 0x00, 0x6D, 0xC0,
  0x00, 0x33, 0x38, 0x00, 0x38, 0xCF, 0x00, 0x1C, 0x31, 0xFF, 0xFE, 0x0C,
  0x1F, 0xFE, 0x03, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x1E,
  0x00, 0x18, 0x0F, 0xFF, 0x00, 0xC1, 0xFF, 0xFE, 0x06, 0x1E, 0x00, 0xF8,
  0x31, 0xC0, 0x01, 0xE1, 0x9C, 0x00, 0x07, 0x8D, 0xC0, 0x00, 0x1C, 0x6C,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x39, 0xF0, 0x00, 0x01, 0xCD, 0x80,
  0x00, 0x1C, 0x6E, 0x00, 0x01, 0xC3, 0x38, 0x00, 0x1E, 0x18, 0xF0, 0x03,
  0xE0, 0xC3, 0xFF, 0xFC, 0x06, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3E, 0x00,
  0x70, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x1E, 0x00, 0x60, 0x0F, 0xFF, 0x03, 0x01, 0xFF, 0xFC, 0x18, 0x3E, 0x00,
  0x78, 0xC3, 0xC0, 0x00, 0xE6, 0x1C, 0x00, 0x03, 0x31, 0xC0, 0x00, 0x0D,
  0x9C, 0x00, 0x00, 0x6C, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xB3,
  0x80, 0x00, 0x0D, 0x8E, 0x00, 0x00, 0xCC, 0x3C, 0x00, 0x0C, 0x60, 0xF8,
  0x01, 0xC3, 0x03, 0xFF, 0xFC, 0x18, 0x07, 0xFF, 0xC0, 0xC0, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x20, 0x3E, 0x00, 0x1E,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0x80, 0x40, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0xC0, 0x7F, 0xFF, 0x86, 0x0F, 0x80, 0x1E, 0x30, 0xF0, 0x00, 0x39, 0x87,
  0x00, 0x00, 0xEC, 0x70, 0x00, 0x03, 0xE7, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x6C, 0xF0, 0x00, 0x03, 0x63, 0xC0, 0x00,
  0x37, 0x0F, 0x00, 0x07, 0x38, 0x3E, 0x00, 0x71, 0xC0, 0xFF, 0xFF, 0x0E,
  0x01, 0xFF, 0xE0, 0x70, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x86, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x81, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x01, 0xE0, 0x06, 0x03, 0xFF, 0xC0, 0xC1, 0xFF, 0xFE, 0x18,
  0x78, 0x03, 0xE3, 0x1C, 0x00, 0x1E, 0x66, 0x00, 0x01, 0xCD, 0x80, 0x00,
  0x1D, 0xB0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x37, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1C, 0x6F, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xCE, 0xF8,
  0xFF, 0x07, 0xC0, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x1E, 0xC0, 0x00, 0x1E, 0x60, 0x00, 0x1E, 0x30,
  0x00, 0x0E, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x03,
  0x00, 0x0E, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x0E, 0x00,
  0x30, 0x0E, 0x00, 0x18, 0x0F, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x07, 0x00,
  0x03, 0x07, 0x80, 0x01, 0x87, 0xC0, 0x00, 0xC7, 0x70, 0x00, 0x67, 0x1C,
  0x00, 0x37, 0x0F, 0x00, 0x1F, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0x00, 0x1E, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0x70, 0x30, 0x00, 0x3C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x86,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x79, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x0C, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x31, 0xE0,
  0x1E, 0x0F, 0x00, 0x78, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xF3, 0x70, 0x00,
  0x39, 0x80, 0x01, 0xED, 0x80, 0x00, 0xEC, 0x00, 0x03, 0xBC, 0x00, 0x01,
  0xF0, 0x00, 0x06, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x80, 0x18,
  0x0F, 0xFF, 0x03, 0x07, 0xFF, 0xF8, 0x61, 0xE0, 0x0F, 0x8C, 0x70, 0x00,
  0x79, 0x98, 0x00, 0x07, 0x36, 0x00, 0x00, 0x76, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xDE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x06, 0x03, 0xFF, 0xC0,
  0x30, 0x7F, 0xFF, 0x81, 0x87, 0x80, 0x3E, 0x0C, 0x70, 0x00, 0x78, 0x67,
  0x00, 0x00, 0xE3, 0x70, 0x00, 0x03, 0x9B, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x0E, 0x6C, 0x00, 0x00, 0x73, 0x70, 0x00, 0x07, 0x19, 0x80, 0x00,
  0x78, 0xCF, 0x00, 0x07, 0x86, 0x3E, 0x00, 0xF8, 0x30, 0x7F, 0xFF, 0x01,
  0x81, 0xFF, 0xF0, 0x0C, 0x00, 0x78, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0xC0, 0x7F, 0xFF, 0x06, 0x0F, 0x80, 0x1C,
  0x30, 0xF0, 0x00, 0x71, 0x8F, 0x00, 0x00, 0xCC, 0x70, 0x00, 0x03, 0xE7,
  0x00, 0x00, 0x1F, 0x30, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x1E, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0x7C, 0xE0,
  0x00, 0x07, 0xE3, 0x80, 0x00, 0x77, 0x0E, 0x00, 0x07, 0x38, 0x3C, 0x00,
  0xF1, 0xC0, 0xFF, 0xFF, 0x0E, 0x01, 0xFF, 0xE0, 0x70, 0x01, 0xF0, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x0C, 0x30, 0x3F, 0xFC, 0x3F, 0xFF, 0x1E, 0x01,
  0xCE, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x1E, 0x00, 0x1E,
  0x38, 0x00, 0x02, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x80, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x06, 0xCE, 0x00, 0x01, 0xD8, 0xE0,
  0x00, 0x73, 0x1F, 0x00, 0x3C, 0x60, 0xFF, 0xFF, 0x0C, 0x0F, 0xFF, 0x81,
  0x80, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x38, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x70, 0x03,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x01, 0x98, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0x18, 0x00, 0x06, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x73,
  0x00, 0x03, 0x87, 0x00, 0x03, 0x98, 0x00, 0x1C, 0x38, 0x00, 0x18, 0xE0,
  0x00, 0xC0, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x18, 0x00,
  0x70, 0x38, 0x00, 0x60, 0xE0, 0x03, 0x80, 0xC0, 0x07, 0x07, 0x00, 0x18,
  0x06, 0x00, 0x38, 0x18, 0x01, 0xC0, 0x38, 0x01, 0x80, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x38,
  0x06, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x06, 0x03,
  0x80, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x18,
  0xE0, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x30,
  0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x76, 0x00, 0x00, 0xDC, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x1C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0x70, 0x03, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x70, 0x0C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x87, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x07, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x05, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x3E, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_ExtraLight66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 48, 15, 5, -47 },
  { 31, 13, 17, 22, 5, -47 },
  { 59, 39, 47, 43, 2, -47 },
  { 289, 28, 54, 38, 4, -50 },
  { 478, 45, 49, 53, 4, -48 },
  { 754, 41, 49, 47, 4, -48 },
  { 1006, 2, 17, 12, 5, -47 },
  { 1011, 12, 57, 17, 3, -47 },
  { 1097, 13, 57, 17, 2, -47 },
  { 1190, 28, 27, 36, 4, -50 },
  { 1285, 30, 31, 38, 4, -39 },
  { 1402, 6, 17, 13, 3, -8 },
  { 1415, 16, 2, 21, 3, -19 },
  { 1419, 5, 5, 15, 5, -4 },
  { 1423, 20, 47, 22, 1, -47 },
  { 1541, 30, 49, 38, 4, -48 },
  { 1725, 15, 47, 38, 7, -47 },
  { 1814, 29, 48, 38, 4, -48 },
  { 1988, 30, 49, 38, 3, -48 },
  { 2172, 35, 47, 38, 2, -47 },
  { 2378, 28, 48, 38, 5, -47 },
  { 2546, 30, 49, 38, 4, -48 },
  { 2730, 30, 47, 38, 4, -47 },
  { 2907, 29, 49, 38, 4, -48 },
  { 3085, 29, 49, 38, 4, -48 },
  { 3263, 5, 36, 15, 5, -35 },
  { 3286, 8, 44, 15, 2, -35 },
  { 3330, 30, 30, 38, 4, -39 },
  { 3443, 30, 15, 38, 4, -31 },
  { 3500, 30, 30, 38, 4, -39 },
  { 3613, 23, 49, 28, 2, -48 },
  { 3754, 52, 53, 58, 3, -47 },
  { 4099, 39, 47, 39, 0, -47 },
  { 4329, 30, 47, 41, 7, -47 },
  { 4506, 35, 49, 41, 4, -48 },
  { 4721, 35, 47, 46, 7, -47 },
  { 4927, 25, 47, 36, 7, -47 },
  { 5074, 25, 47, 33, 7, -47 },
  { 5221, 38, 49, 48, 4, -48 },
  { 5454, 33, 47, 47, 7, -47 },
  { 5648, 12, 47, 19, 4, -47 },
  { 5719, 15, 59, 16, -6, -47 },
  { 5830, 31, 47, 38, 7, -47 },
  { 6013, 25, 47, 34, 7, -47 },
  { 6160, 42, 47, 56, 7, -47 },
  { 6407, 33, 47, 47, 7, -47 },
  { 6601, 42, 49, 50, 4, -48 },
  { 6859, 28, 47, 38, 7, -47 },
  { 7024, 42, 59, 50, 4, -48 },
  { 7334, 30, 47, 39, 7, -47 },
  { 7511, 28, 49, 36, 4, -48 },
  { 7683, 34, 47, 34, 0, -47 },
  { 7883, 35, 48, 47, 6, -47 },
  { 8093, 38, 47, 38, 0, -47 },
  { 8317, 54, 47, 58, 2, -47 },
  { 8635, 35, 47, 35, 0, -47 },
  { 8841, 34, 47, 34, 0, -47 },
  { 9041, 33, 47, 38, 2, -47 },
  { 9235, 13, 57, 21, 6, -47 },
  { 9328, 20, 47, 22, 1, -47 },
  { 9446, 13, 57, 21, 2, -47 },
  { 9539, 32, 29, 38, 3, -47 },
  { 9655, 27, 2, 27, 0, 6 },
  { 9662, 11, 11, 17, 3, -51 },
  { 9678, 26, 37, 34, 3, -36 },
  { 9799, 29, 51, 39, 6, -50 },
  { 9984, 25, 37, 31, 4, -36 },
  { 10100, 29, 51, 39, 4, -50 },
  { 10285, 28, 37, 36, 4, -36 },
  { 10415, 22, 50, 19, 1, -50 },
  { 10553, 29, 52, 39, 4, -36 },
  { 10742, 27, 50, 38, 6, -50 },
  { 10911, 4, 48, 14, 5, -48 },
  { 10935, 12, 64, 14, -3, -48 },
  { 11031, 25, 50, 31, 6, -50 },
  { 11188, 2, 50, 14, 6, -50 },
  { 11201, 46, 36, 57, 6, -36 },
  { 11408, 27, 36, 38, 6, -36 },
  { 11530, 30, 37, 38, 4, -36 },
  { 11669, 29, 51, 39, 6, -36 },
  { 11854, 29, 51, 39, 4, -36 },
  { 12039, 18, 36, 25, 6, -36 },
  { 12120, 24, 37, 30, 3, -36 },
  { 12231, 19, 45, 22, 1, -44 },
  { 12338, 27, 36, 38, 5, -35 },
  { 12460, 29, 35, 29, 0, -35 },
  { 12587, 45, 35, 47, 1, -35 },
  { 12784, 28, 35, 32, 2, -35 },
  { 12907, 29, 51, 29, 0, -35 },
  { 13092, 25, 35, 30, 3, -35 },
  { 13202, 18, 57, 23, 2, -47 },
  { 13331, 3, 66, 36, 16, -50 },
  { 13356, 19, 57, 23, 2, -47 },
  { 13492, 30, 6, 38, 4, -26 },
};

const GFXfont NotoSans_ExtraLight66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRALIGHT66PT7B_H_
