#ifndef _NOTOSANS_EXTRALIGHT47PT7B_H_
#define _NOTOSANS_EXTRALIGHT47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xB6, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x00,
  0x07, 0xFC, 0xC0, 0xF0, 0x3C, 0x0F, 0x02, 0xC0, 0x90, 0x24, 0x09, 0x02,
  0x40, 0x90, 0x24, 0x09, 0x02, 0x40, 0x80, 0x00, 0x18, 0x02, 0x00, 0x01,
  0x80, 0x20, 0x00, 0x18, 0x06, 0x00, 0x01, 0x00, 0x60, 0x00, 0x10, 0x06,
  0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x20, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x03, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x08, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x02, 0x00,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x60, 0x00, 0x10,
  0x06, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x04, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x20, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x60, 0x08, 0x00, 0x06,
  0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x83, 0xC4, 0x1C, 0x70, 0x40, 0x46,
  0x04, 0x00, 0xC0, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0x40, 0x0C, 0x04, 0x00,
  0xC0, 0x40, 0x0C, 0x04, 0x00, 0x60, 0x40, 0x07, 0x04, 0x00, 0x3C, 0x40,
  0x00, 0xF4, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x5E, 0x00, 0x04,
  0x38, 0x00, 0x41, 0xC0, 0x04, 0x0E, 0x00, 0x40, 0x60, 0x04, 0x02, 0x00,
  0x40, 0x20, 0x04, 0x03, 0x00, 0x40, 0x20, 0x04, 0x06, 0x00, 0x40, 0x60,
  0x04, 0x0C, 0xC0, 0x43, 0x8F, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0F, 0x80, 0x00, 0xC0,
  0x3F, 0xC0, 0x00, 0x80, 0x70, 0x60, 0x01, 0x80, 0x60, 0x30, 0x01, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x0C, 0x00, 0x80, 0x18, 0x0C, 0x00, 0x80, 0x18, 0x18, 0x00,
  0x80, 0x18, 0x10, 0x00, 0x80, 0x18, 0x30, 0x00, 0x80, 0x18, 0x20, 0x00,
  0xC0, 0x18, 0x60, 0x60, 0xC0, 0x10, 0xC3, 0xF8, 0xC0, 0x30, 0xC6, 0x1C,
  0xC0, 0x31, 0x8C, 0x06, 0x60, 0x31, 0x8C, 0x06, 0x70, 0x63, 0x18, 0x02,
  0x3F, 0xC2, 0x18, 0x03, 0x0F, 0x86, 0x18, 0x03, 0x00, 0x04, 0x18, 0x03,
  0x00, 0x0C, 0x18, 0x03, 0x00, 0x18, 0x18, 0x03, 0x00, 0x18, 0x18, 0x03,
  0x00, 0x30, 0x18, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x80, 0x0C, 0x06,
  0x01, 0x80, 0x0C, 0x0C, 0x03, 0x00, 0x07, 0x1C, 0x03, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18,
  0x01, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x0C, 0x70, 0x1C, 0x00,
  0x66, 0x00, 0x70, 0x06, 0x30, 0x01, 0xC0, 0x33, 0x00, 0x07, 0x01, 0x18,
  0x00, 0x1C, 0x18, 0xC0, 0x00, 0x70, 0xC6, 0x00, 0x01, 0xCC, 0x30, 0x00,
  0x07, 0xC1, 0x80, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x0F,
  0xC1, 0xC0, 0x00, 0xE7, 0x07, 0x00, 0x1C, 0x1C, 0x1F, 0x07, 0xC0, 0x60,
  0x3F, 0xF8, 0x01, 0xC0, 0xFF, 0xD5, 0x55, 0x40, 0x01, 0x81, 0x81, 0x80,
  0xC0, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30,
  0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x06, 0x07, 0xF8, 0x41, 0xF1, 0xF4,
  0xF8, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0xB0, 0x00, 0x19, 0x80, 0x03,
  0x0C, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x1C, 0x03, 0x80,
  0x80, 0x10, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x01, 0xFF, 0xFF, 0xF0, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x39, 0x8C, 0x66, 0x31, 0x8C, 0x46, 0x20, 0xFF, 0xFF, 0xFC, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0xE0, 0x30, 0x01, 0x83, 0x00,
  0x06, 0x18, 0x00, 0x31, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x12, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0,
  0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x03, 0x01, 0x80, 0x30,
  0x07, 0x07, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x40, 0x70, 0x3C, 0x19, 0x1C,
  0x4E, 0x16, 0x07, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x38, 0x03, 0x06, 0x00, 0x18, 0x40,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0x00, 0x70, 0xE0, 0x00,
  0xC4, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xD8,
  0x00, 0x1C, 0xFC, 0x07, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x01, 0x80,
  0x06, 0x01, 0x80, 0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0xBF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x20, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x98, 0x00, 0x38, 0xFC, 0x0F, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x3E, 0x03, 0x0F, 0xFE, 0x19, 0xE0, 0x38, 0xDC, 0x00, 0x66, 0x80, 0x01,
  0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x40, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x01, 0x81, 0x80,
  0x18, 0x07, 0x03, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0x00, 0x70, 0x70, 0x01, 0xC3,
  0x00, 0x06, 0x30, 0x00, 0x11, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x80, 0x0C, 0x06,
  0x01, 0xC0, 0x1C, 0x38, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3C, 0xF0,
  0x03, 0x80, 0xE0, 0x70, 0x01, 0x83, 0x00, 0x06, 0x30, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0x30, 0x00, 0x19, 0xC0, 0x01, 0x87, 0x00,
  0x18, 0x1E, 0x07, 0x80, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0,
  0x07, 0x00, 0xE0, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x33, 0x00,
  0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x0D,
  0x00, 0x00, 0x28, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x60, 0x00, 0x5B, 0x80, 0x06, 0xCE, 0x00, 0xE6, 0x3F, 0x7C, 0x20,
  0x7F, 0x81, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x3C, 0x03, 0xFF, 0x80,
  0x03, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x18, 0xC6, 0x63, 0x18, 0x8C, 0x62, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0xF8, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x20,
  0xC0, 0x03, 0xF8, 0x01, 0x8C, 0x00, 0x7F, 0xF0, 0x0C, 0x60, 0x0E, 0x00,
  0x80, 0x26, 0x00, 0xE0, 0x04, 0x01, 0xB0, 0x06, 0x00, 0x20, 0x0D, 0x80,
  0x60, 0x03, 0x00, 0x6C, 0x03, 0x00, 0x18, 0x03, 0x40, 0x30, 0x00, 0xC0,
  0x1A, 0x01, 0x80, 0x06, 0x00, 0xF0, 0x0C, 0x00, 0x30, 0x07, 0x80, 0x60,
  0x01, 0x80, 0x3C, 0x03, 0x00, 0x0C, 0x01, 0xA0, 0x18, 0x00, 0x60, 0x09,
  0x00, 0xC0, 0x07, 0x00, 0xC8, 0x03, 0x00, 0x28, 0x06, 0x60, 0x18, 0x03,
  0x40, 0x63, 0x00, 0x60, 0x33, 0x07, 0x18, 0x01, 0xFF, 0x0F, 0xF0, 0x60,
  0x07, 0xE0, 0x3E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x08, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x02, 0x0C,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x01, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x04, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x0C, 0x00, 0x7C, 0x30, 0x00, 0x38,
  0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x33, 0x00, 0x01, 0x8C, 0x00, 0x1C, 0x30, 0x0F, 0xE0, 0xFF, 0xFE, 0x03,
  0x00, 0x1F, 0x0C, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xCC,
  0x00, 0x07, 0x30, 0x00, 0x78, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x78, 0x00, 0xC0, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x02, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x30, 0x03, 0xF0, 0x18, 0x00, 0x1C, 0x0C, 0x00,
  0x03, 0x86, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x01, 0xC3, 0x00, 0x03, 0xC1, 0x80,
  0x07, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xB0,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0x20, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x18, 0x1E, 0x00, 0x03, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xFF, 0xE0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x38, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30,
  0x0C, 0xCF, 0x1F, 0xC0, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xCC, 0x00, 0x06,
  0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0x30,
  0x03, 0x80, 0xC0, 0x1C, 0x03, 0x00, 0xE0, 0x0C, 0x07, 0x00, 0x30, 0x38,
  0x00, 0xC1, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0x33, 0xC0, 0x00,
  0xDD, 0x80, 0x03, 0xE7, 0x00, 0x0F, 0x0C, 0x00, 0x38, 0x18, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x01, 0xC3,
  0x00, 0x03, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xEC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x60, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x06, 0xF2, 0x00, 0x00,
  0x13, 0xCC, 0x00, 0x00, 0xCF, 0x30, 0x00, 0x03, 0x3C, 0x60, 0x00, 0x18,
  0xF1, 0x80, 0x00, 0x63, 0xC2, 0x00, 0x01, 0x0F, 0x0C, 0x00, 0x0C, 0x3C,
  0x30, 0x00, 0x30, 0xF0, 0x60, 0x01, 0x83, 0xC1, 0x80, 0x06, 0x0F, 0x02,
  0x00, 0x10, 0x3C, 0x0C, 0x00, 0xC0, 0xF0, 0x30, 0x03, 0x03, 0xC0, 0x60,
  0x18, 0x0F, 0x01, 0x80, 0x60, 0x3C, 0x03, 0x03, 0x00, 0xF0, 0x0C, 0x0C,
  0x03, 0xC0, 0x30, 0x30, 0x0F, 0x00, 0x61, 0x80, 0x3C, 0x01, 0x86, 0x00,
  0xF0, 0x03, 0x30, 0x03, 0xC0, 0x0C, 0xC0, 0x0F, 0x00, 0x33, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00,
  0x0C, 0x00, 0x30, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x98, 0x00, 0x03, 0xDC, 0x00, 0x03,
  0xCC, 0x00, 0x03, 0xC6, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xC3, 0x00, 0x03,
  0xC1, 0x80, 0x03, 0xC1, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0x60, 0x03,
  0xC0, 0x70, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x1C, 0x03,
  0xC0, 0x0C, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x03, 0x03,
  0xC0, 0x01, 0x83, 0xC0, 0x01, 0xC3, 0xC0, 0x00, 0xC3, 0xC0, 0x00, 0x63,
  0xC0, 0x00, 0x73, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xE0,
  0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x18, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xF0, 0x7E,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xC0, 0x1F,
  0x0C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0x8C,
  0x00, 0x70, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x18, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x30, 0x03, 0xE1, 0x80, 0x03, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x33,
  0x00, 0x01, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18,
  0x00, 0x38, 0xC0, 0x03, 0x86, 0x03, 0xF0, 0x3F, 0xFE, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x61, 0x80, 0x03, 0x8C, 0x00, 0x0C,
  0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xFE, 0x1C, 0x00, 0xE3, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE8, 0x00, 0x1C, 0xFC, 0x0F,
  0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0x60, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x07, 0xC0, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0xC0, 0x18, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0xC0, 0x00, 0x70, 0x00,
  0x0D, 0x80, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0x40, 0x00, 0x66, 0x00,
  0x02, 0xC0, 0x00, 0xC6, 0x00, 0x0D, 0x80, 0x01, 0x8C, 0x00, 0x1B, 0x00,
  0x03, 0x18, 0x00, 0x23, 0x00, 0x0C, 0x10, 0x00, 0xC6, 0x00, 0x18, 0x30,
  0x01, 0x8C, 0x00, 0x30, 0x60, 0x03, 0x08, 0x00, 0xC0, 0xC0, 0x04, 0x18,
  0x01, 0x80, 0xC0, 0x18, 0x30, 0x03, 0x01, 0x80, 0x30, 0x60, 0x06, 0x03,
  0x00, 0x60, 0x60, 0x18, 0x06, 0x00, 0x80, 0xC0, 0x30, 0x06, 0x03, 0x01,
  0x80, 0x60, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x18, 0x08, 0x03, 0x03, 0x00,
  0x10, 0x30, 0x06, 0x06, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x00, 0x60, 0xC0,
  0x08, 0x30, 0x00, 0xC1, 0x00, 0x18, 0x60, 0x00, 0x86, 0x00, 0x30, 0xC0,
  0x01, 0x8C, 0x00, 0x21, 0x80, 0x03, 0x18, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0xCC, 0x00, 0x06, 0xC0, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x01, 0x20,
  0x00, 0x1A, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x01, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x01, 0x80, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x60, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x66, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xC0,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30,
  0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x00, 0xA0,
  0x00, 0x03, 0x60, 0x00, 0x04, 0x40, 0x00, 0x18, 0xC0, 0x00, 0x20, 0x80,
  0x00, 0xC1, 0x80, 0x01, 0x01, 0x00, 0x06, 0x03, 0x00, 0x08, 0x02, 0x00,
  0x30, 0x06, 0x00, 0x40, 0x04, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x08, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x10, 0x60, 0x00, 0x31, 0x80, 0x00, 0x23, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x60,
  0x30, 0x18, 0x1C, 0x0C, 0x02, 0x01, 0x03, 0xFE, 0x03, 0xF1, 0xE0, 0x60,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x7F, 0xF0, 0x7E,
  0x06, 0x38, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0xC0, 0x06, 0xDC, 0x01,
  0x99, 0xC0, 0xE3, 0x1F, 0xF8, 0x60, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x87,
  0xFC, 0x0C, 0x78, 0x78, 0x66, 0x00, 0xE3, 0x60, 0x03, 0x9E, 0x00, 0x0C,
  0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x05, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0x70, 0x00,
  0x1B, 0x80, 0x00, 0xDE, 0x00, 0x0C, 0xD0, 0x00, 0xE6, 0xC0, 0x0E, 0x33,
  0xC1, 0xE1, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x81, 0xF0, 0xF0, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x07, 0xFC, 0x30, 0xF0, 0x71,
  0x8E, 0x00, 0xCC, 0xE0, 0x03, 0x66, 0x00, 0x0F, 0x60, 0x00, 0x3B, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0xEC,
  0x00, 0x0F, 0x30, 0x00, 0xD8, 0xC0, 0x0C, 0xC3, 0xC1, 0xC6, 0x0F, 0xFC,
  0x30, 0x03, 0xFE, 0x00, 0xF0, 0xF0, 0x1C, 0x01, 0x83, 0x80, 0x0C, 0x30,
  0x00, 0xC6, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x20, 0xF0,
  0x1E, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x07, 0xFF, 0x8F, 0xFF, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x03, 0xFE, 0x18, 0x7C, 0x38, 0xC7, 0x00, 0x66, 0x70, 0x01, 0xB3, 0x00,
  0x07, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x05, 0x98, 0x00, 0x6C, 0x60, 0x06,
  0x61, 0xE0, 0xE3, 0x07, 0xFE, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE3, 0x00, 0x0E, 0x1F, 0xC3, 0xE0, 0x1F, 0xFC, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x61, 0xFF, 0x0C, 0x78, 0xF9, 0x98, 0x03, 0xB6, 0x00, 0x37, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x10, 0xDF, 0x00, 0x00, 0x1B, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xD8, 0x03, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0x93, 0xCF, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x01,
  0x8C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x0E, 0x03,
  0x07, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x0C, 0x70, 0x03, 0x36, 0x00, 0xD9,
  0xC0, 0x3C, 0x30, 0x0E, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x30, 0x06,
  0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x1B,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFC, 0x07, 0xF8, 0x67, 0x87, 0x0F, 0x0F, 0x36, 0x01, 0xCE, 0x01, 0xDA,
  0x00, 0x74, 0x00, 0x6E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x07, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x01,
  0xE0, 0x00, 0x40, 0x00, 0xF0, 0x00, 0x20, 0x00, 0x78, 0x00, 0x10, 0x00,
  0x3C, 0x00, 0x08, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x02, 0x00,
  0x07, 0x80, 0x01, 0x00, 0x03, 0xC0, 0x00, 0x80, 0x01, 0xE0, 0x00, 0x40,
  0x00, 0xF0, 0x00, 0x20, 0x00, 0x78, 0x00, 0x10, 0x00, 0x3C, 0x00, 0x08,
  0x00, 0x1E, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x07, 0x80, 0x01,
  0x00, 0x03, 0xC0, 0x00, 0x80, 0x01, 0x80, 0xC3, 0xFE, 0x18, 0xE1, 0xF3,
  0x30, 0x07, 0x6C, 0x00, 0x6F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x03, 0xFE, 0x00, 0x3E, 0x1E,
  0x01, 0xC0, 0x0C, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xE0, 0x01, 0x81, 0xC0, 0x0C, 0x03, 0xC1,
  0xE0, 0x03, 0xFE, 0x00, 0xC1, 0xFE, 0x06, 0x3C, 0x3C, 0x33, 0x00, 0x71,
  0xB0, 0x00, 0xCF, 0x00, 0x06, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6F, 0x00, 0x06, 0x6C,
  0x00, 0x73, 0x70, 0x07, 0x19, 0xE0, 0xF0, 0xC3, 0xFE, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x10, 0xF0, 0x71, 0x1C, 0x01, 0x93, 0x00,
  0x0D, 0x70, 0x00, 0x56, 0x00, 0x07, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x53, 0x00, 0x0D, 0x38, 0x01,
  0x91, 0xE0, 0x71, 0x07, 0xFC, 0x10, 0x06, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0xC3, 0xFE, 0x7C,
  0xF7, 0x01, 0xA0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0F, 0xFE, 0x07, 0x87, 0xE3, 0x00, 0x09, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x68, 0x00, 0x33, 0xE0, 0x38, 0x3F, 0xFC, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x03, 0xFF, 0xFF, 0xFF,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x84,
  0x0F, 0xE0, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0E, 0xC0, 0x03, 0xDC, 0x00, 0xD9, 0xE0, 0xF1, 0x0F,
  0xF8, 0x20, 0xC0, 0x00, 0x1A, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0x40, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x30,
  0x03, 0x01, 0x80, 0x08, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x0C,
  0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1B, 0x00, 0x1E, 0x00, 0x36,
  0x00, 0x2C, 0x00, 0xCC, 0x00, 0xC8, 0x01, 0x88, 0x01, 0x98, 0x03, 0x18,
  0x02, 0x30, 0x06, 0x30, 0x0C, 0x20, 0x18, 0x60, 0x18, 0x60, 0x30, 0x60,
  0x20, 0xC0, 0x60, 0xC0, 0xC0, 0x80, 0x81, 0x81, 0x81, 0x83, 0x01, 0x02,
  0x03, 0x06, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x18, 0x06, 0x10, 0x0C, 0x20,
  0x0C, 0x60, 0x08, 0xC0, 0x08, 0xC0, 0x19, 0x80, 0x19, 0x80, 0x32, 0x00,
  0x36, 0x00, 0x2C, 0x00, 0x6C, 0x00, 0x78, 0x00, 0x58, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x31,
  0x80, 0x03, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x07, 0x01,
  0x80, 0x18, 0x1C, 0x00, 0x60, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xE0, 0x00,
  0x36, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60,
  0x00, 0x31, 0x80, 0x03, 0x06, 0x00, 0x38, 0x30, 0x01, 0x80, 0xC0, 0x18,
  0x03, 0x01, 0x80, 0x1C, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x8C, 0x00, 0x0E,
  0xE0, 0x00, 0x38, 0xC0, 0x00, 0x1A, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0,
  0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x18,
  0x18, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x30, 0x03, 0x01, 0x80, 0x08, 0x08, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x0C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x18, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x23, 0x80, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0C, 0x01, 0xF0, 0x1E, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x07, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x07, 0x80, 0x7C, 0x07, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x07, 0x80, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0x00, 0x70, 0x1E, 0x07, 0x00, 0x3F, 0xE0, 0x00,
  0x1C, 0x00,
};

const GFXglyph NotoSans_ExtraLight47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 34, 11, 4, -34 },
  { 14, 10, 13, 16, 3, -34 },
  { 31, 28, 34, 30, 1, -34 },
  { 150, 20, 39, 27, 3, -36 },
  { 248, 32, 34, 38, 3, -34 },
  { 384, 29, 34, 33, 3, -34 },
  { 508, 2, 13, 9, 3, -34 },
  { 512, 9, 41, 12, 2, -34 },
  { 559, 8, 41, 12, 2, -34 },
  { 600, 20, 20, 26, 3, -36 },
  { 650, 21, 22, 27, 3, -28 },
  { 708, 5, 11, 9, 2, -5 },
  { 715, 11, 2, 15, 2, -14 },
  { 718, 3, 3, 11, 4, -3 },
  { 720, 14, 34, 16, 1, -34 },
  { 780, 21, 34, 27, 3, -34 },
  { 870, 10, 34, 27, 5, -34 },
  { 913, 20, 34, 27, 3, -34 },
  { 998, 21, 34, 27, 2, -34 },
  { 1088, 25, 34, 27, 1, -34 },
  { 1195, 21, 34, 27, 3, -34 },
  { 1285, 21, 34, 27, 3, -34 },
  { 1375, 21, 34, 27, 3, -34 },
  { 1465, 21, 34, 27, 3, -34 },
  { 1555, 21, 35, 27, 3, -34 },
  { 1647, 3, 25, 11, 4, -25 },
  { 1657, 5, 31, 11, 2, -25 },
  { 1677, 21, 22, 27, 3, -28 },
  { 1735, 21, 11, 27, 3, -22 },
  { 1764, 21, 22, 27, 3, -28 },
  { 1822, 16, 34, 20, 2, -34 },
  { 1890, 37, 38, 41, 2, -33 },
  { 2066, 28, 34, 28, 0, -34 },
  { 2185, 22, 34, 29, 5, -34 },
  { 2279, 25, 34, 29, 3, -34 },
  { 2386, 25, 34, 33, 5, -34 },
  { 2493, 18, 34, 26, 5, -34 },
  { 2570, 18, 34, 23, 5, -34 },
  { 2647, 27, 34, 34, 3, -34 },
  { 2762, 24, 34, 34, 5, -34 },
  { 2864, 8, 34, 14, 3, -34 },
  { 2898, 11, 42, 11, -4, -34 },
  { 2956, 22, 34, 27, 5, -34 },
  { 3050, 18, 34, 24, 5, -34 },
  { 3127, 30, 34, 40, 5, -34 },
  { 3255, 24, 34, 33, 5, -34 },
  { 3357, 30, 34, 36, 3, -34 },
  { 3485, 20, 34, 27, 5, -34 },
  { 3570, 30, 42, 36, 3, -34 },
  { 3728, 21, 34, 28, 5, -34 },
  { 3818, 20, 34, 26, 3, -34 },
  { 3903, 24, 34, 24, 0, -34 },
  { 4005, 25, 34, 34, 4, -34 },
  { 4112, 27, 34, 27, 0, -34 },
  { 4227, 39, 34, 41, 1, -34 },
  { 4393, 25, 34, 25, 0, -34 },
  { 4500, 24, 34, 24, 0, -34 },
  { 4602, 23, 34, 27, 2, -34 },
  { 4700, 10, 41, 15, 4, -34 },
  { 4752, 14, 34, 16, 1, -34 },
  { 4812, 10, 41, 15, 1, -34 },
  { 4864, 23, 21, 27, 2, -34 },
  { 4925, 19, 2, 19, 0, 4 },
  { 4930, 8, 8, 12, 2, -36 },
  { 4938, 19, 25, 24, 2, -25 },
  { 4998, 21, 36, 28, 4, -36 },
  { 5093, 18, 25, 22, 3, -25 },
  { 5150, 21, 36, 28, 3, -36 },
  { 5245, 20, 25, 26, 3, -25 },
  { 5308, 15, 36, 14, 1, -36 },
  { 5376, 21, 36, 28, 3, -25 },
  { 5471, 19, 36, 27, 4, -36 },
  { 5557, 3, 34, 10, 4, -34 },
  { 5570, 9, 45, 10, -2, -34 },
  { 5621, 18, 36, 22, 4, -36 },
  { 5702, 2, 36, 10, 4, -36 },
  { 5711, 33, 25, 41, 4, -25 },
  { 5815, 19, 25, 27, 4, -25 },
  { 5875, 22, 25, 27, 3, -25 },
  { 5944, 21, 36, 28, 4, -25 },
  { 6039, 20, 36, 28, 3, -25 },
  { 6129, 13, 25, 18, 4, -25 },
  { 6170, 18, 25, 22, 2, -25 },
  { 6227, 13, 31, 15, 1, -31 },
  { 6278, 19, 25, 27, 4, -25 },
  { 6338, 21, 25, 21, 0, -25 },
  { 6404, 31, 25, 33, 1, -25 },
  { 6501, 21, 25, 23, 1, -25 },
  { 6567, 21, 36, 21, 0, -25 },
  { 6662, 18, 25, 22, 2, -25 },
  { 6719, 14, 41, 16, 1, -34 },
  { 6791, 1, 48, 25, 12, -36 },
  { 6797, 13, 41, 16, 2, -34 },
  { 6864, 21, 5, 27, 3, -19 },
};

const GFXfont NotoSans_ExtraLight47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRALIGHT47PT7B_H_
