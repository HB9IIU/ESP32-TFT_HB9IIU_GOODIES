#ifndef _NOTOSANS_EXTRALIGHT51PT7B_H_
#define _NOTOSANS_EXTRALIGHT51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight51pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x60, 0x00, 0x00, 0x0E, 0xFE, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xB0, 0x2C, 0x0B, 0x02, 0xC0, 0xB0, 0x28, 0x0A, 0x02, 0x80, 0x80,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x10, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xC0, 0x08, 0x01, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xE0, 0x04, 0x00, 0xC0, 0x00, 0x08, 0x01, 0x80, 0x00, 0x30,
  0x02, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x02, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x40, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x01, 0x80, 0x10, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0x99, 0xF8,
  0xE0, 0xC0, 0x8E, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0, 0x0C,
  0x06, 0x00, 0x30, 0x30, 0x00, 0xE1, 0x80, 0x03, 0xCC, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xDF, 0x00, 0x06, 0x3C, 0x00,
  0x30, 0x70, 0x01, 0x81, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01,
  0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01,
  0x81, 0x80, 0x0C, 0x1D, 0xE0, 0x63, 0xCF, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x08, 0x03, 0xFC, 0x00, 0x06, 0x00, 0xE0, 0xC0, 0x00, 0x80,
  0x38, 0x0C, 0x00, 0x30, 0x06, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x06, 0x02, 0x00, 0x0C, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x18, 0x30, 0x00,
  0x30, 0x03, 0x06, 0x00, 0x06, 0x00, 0x61, 0x83, 0xF0, 0xC0, 0x0C, 0x31,
  0xE7, 0x0C, 0x03, 0x0C, 0x30, 0x31, 0x80, 0x61, 0x8C, 0x03, 0x38, 0x1C,
  0x61, 0x80, 0x63, 0x87, 0x08, 0x60, 0x0C, 0x3F, 0xC3, 0x0C, 0x00, 0xC1,
  0xE0, 0xC1, 0x80, 0x18, 0x00, 0x18, 0x30, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x60, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x30, 0x18, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x60, 0x06, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0,
  0x18, 0x00, 0x60, 0x18, 0x03, 0x00, 0x0E, 0x06, 0x00, 0xC0, 0x00, 0xE3,
  0x80, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xD8,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x02, 0x1C, 0x06, 0x00, 0x0C, 0x38, 0x03,
  0x00, 0x0C, 0x30, 0x01, 0x80, 0x0C, 0x60, 0x00, 0xC0, 0x18, 0x60, 0x00,
  0x60, 0x18, 0xC0, 0x00, 0x30, 0x38, 0xC0, 0x00, 0x18, 0x30, 0xC0, 0x00,
  0x0C, 0x60, 0xC0, 0x00, 0x06, 0x60, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x06, 0x60, 0x38, 0x00,
  0x1C, 0x30, 0x1C, 0x00, 0x38, 0x18, 0x0F, 0x87, 0xF0, 0x0C, 0x03, 0xFF,
  0x80, 0x07, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFA, 0x80, 0x01, 0xC0,
  0xC0, 0x70, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x60,
  0x30, 0x30, 0x38, 0x18, 0x18, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x20, 0x0C, 0x01, 0xF0, 0x30, 0x3F, 0xF8, 0xC7, 0xE0, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0x20, 0x00, 0x0C, 0xC0,
  0x00, 0x61, 0x80, 0x03, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x18, 0x03,
  0x80, 0x70, 0x0C, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x18, 0xCE, 0x63, 0x18, 0xCC, 0x63, 0x11, 0x8C, 0x00, 0xFF,
  0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1C, 0x07, 0x80, 0x60, 0x03, 0x01,
  0x80, 0x03, 0x07, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x38,
  0x00, 0xE0, 0x38, 0x03, 0x80, 0x3E, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x70, 0x1F, 0x03, 0xB0, 0x73, 0x1C, 0x33, 0x83, 0x70,
  0x3C, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x01, 0xFC, 0x00, 0x3F,
  0xFC, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0x38, 0x60, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x78, 0x03, 0xC3, 0xC0,
  0x01, 0x86, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1D, 0x00, 0x00, 0x73, 0x80, 0x01, 0xC3, 0xF8, 0x3F, 0x01, 0xFF, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x38, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0xF0,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x3F, 0x80, 0x1F, 0xFF, 0xC0, 0x70, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x80, 0x00, 0xE3, 0x00, 0x07, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0x80,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x7F,
  0xE0, 0x43, 0xC1, 0xE1, 0x9C, 0x00, 0x63, 0x70, 0x00, 0x66, 0xC0, 0x00,
  0x6F, 0x00, 0x00, 0xDC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x18,
  0x00, 0x1C, 0x18, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x1E, 0x0F, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x03, 0x80, 0xE0, 0x03,
  0x83, 0x80, 0x03, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3,
  0x80, 0x03, 0x83, 0x00, 0x0E, 0x03, 0x80, 0x38, 0x03, 0xC1, 0xC0, 0x01,
  0xEF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3C, 0x1E, 0x00, 0xE0,
  0x0E, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x1C,
  0x60, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x7C, 0x1F, 0x00, 0x3F, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x38, 0x0F, 0x00,
  0xC0, 0x07, 0x03, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x3D, 0xC0, 0x00, 0xD9, 0xC0, 0x03,
  0x31, 0xC0, 0x1C, 0x61, 0xFF, 0xF1, 0x80, 0xFF, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x01, 0x81, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0xEF, 0xE4, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xE0, 0x38, 0xF3, 0x86, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63,
  0x8E, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x30, 0xC3, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0xFE, 0x38, 0x07, 0x90, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0xFF, 0x00, 0x31, 0x80,
  0x0F, 0xFF, 0x80, 0x66, 0x00, 0x38, 0x03, 0x00, 0x6C, 0x00, 0xC0, 0x06,
  0x00, 0xD0, 0x03, 0x00, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0x18, 0x03, 0xC0,
  0x18, 0x00, 0x20, 0x07, 0x80, 0x30, 0x00, 0x40, 0x0F, 0x00, 0xC0, 0x00,
  0x80, 0x1E, 0x01, 0x80, 0x01, 0x00, 0x3C, 0x03, 0x00, 0x06, 0x00, 0x78,
  0x06, 0x00, 0x0C, 0x00, 0xF0, 0x0C, 0x00, 0x18, 0x01, 0xE0, 0x18, 0x00,
  0x30, 0x03, 0xC0, 0x30, 0x00, 0x60, 0x0D, 0x80, 0x30, 0x01, 0xC0, 0x1B,
  0x00, 0x60, 0x06, 0xC0, 0x66, 0x00, 0x60, 0x1D, 0x80, 0xC4, 0x00, 0x70,
  0x71, 0x87, 0x0C, 0x00, 0x7F, 0x81, 0xFC, 0x18, 0x00, 0x10, 0x00, 0x40,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x03,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0x80, 0xC0,
  0x1F, 0xE0, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0xE0, 0x00, 0x20, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x01, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x18, 0x07, 0xFC, 0x03,
  0x00, 0x03, 0xE0, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x3E, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xEC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0C, 0x0E,
  0x00, 0x00, 0x30, 0x1E, 0x00, 0x01, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFF, 0x86, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x1F, 0xDF, 0xF0, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x81,
  0xCF, 0xF8, 0x7E, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x03,
  0x80, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x38,
  0x00, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC1, 0x80,
  0x00, 0xC3, 0x80, 0x00, 0xC7, 0xC0, 0x00, 0xCC, 0xE0, 0x00, 0xD8, 0x60,
  0x00, 0xF0, 0x30, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0x00,
  0x00, 0x00, 0xFD, 0x80, 0x00, 0x00, 0xDE, 0x60, 0x00, 0x00, 0x6F, 0x30,
  0x00, 0x00, 0x67, 0x98, 0x00, 0x00, 0x33, 0xC6, 0x00, 0x00, 0x19, 0xE3,
  0x00, 0x00, 0x18, 0xF0, 0xC0, 0x00, 0x0C, 0x78, 0x60, 0x00, 0x0C, 0x3C,
  0x30, 0x00, 0x06, 0x1E, 0x0C, 0x00, 0x03, 0x0F, 0x06, 0x00, 0x03, 0x07,
  0x81, 0x80, 0x01, 0x83, 0xC0, 0xC0, 0x01, 0x81, 0xE0, 0x60, 0x00, 0xC0,
  0xF0, 0x18, 0x00, 0x60, 0x78, 0x0C, 0x00, 0x60, 0x3C, 0x03, 0x00, 0x30,
  0x1E, 0x01, 0x80, 0x30, 0x0F, 0x00, 0xE0, 0x18, 0x07, 0x80, 0x30, 0x1C,
  0x03, 0xC0, 0x18, 0x0C, 0x01, 0xE0, 0x06, 0x06, 0x00, 0xF0, 0x03, 0x06,
  0x00, 0x78, 0x01, 0xC3, 0x00, 0x3C, 0x00, 0x63, 0x00, 0x1E, 0x00, 0x31,
  0x80, 0x0F, 0x00, 0x0C, 0xC0, 0x07, 0x80, 0x06, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x18, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xD8, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x0F, 0x18, 0x00, 0x03, 0xC3, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x3C,
  0x18, 0x00, 0x0F, 0x03, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x18, 0x00,
  0x3C, 0x03, 0x00, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x18, 0x00, 0xF0, 0x03,
  0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x00, 0xF0,
  0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x03, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x0F, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x1C, 0xF0, 0x00, 0x03, 0x3C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x0E, 0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFF, 0x03, 0x00, 0xFF, 0x0C, 0x00, 0x1E, 0x30, 0x00, 0x1C,
  0xC0, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x73,
  0x00, 0x03, 0x8C, 0x00, 0x7C, 0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0xFF, 0xFF, 0x00, 0xC0, 0x3F, 0xC0, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x07, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x07, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC1, 0xF0, 0x07, 0x8E, 0x00,
  0x02, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xCC,
  0x00, 0x0E, 0x3F, 0x83, 0xF0, 0x7F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x03, 0xC0, 0x1F, 0x87, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x18, 0x00, 0x0D, 0x00, 0x00, 0xE3, 0x00, 0x01,
  0xB0, 0x00, 0x18, 0x60, 0x00, 0x36, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0xC0,
  0x00, 0x60, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0x18, 0x00, 0x31, 0x80, 0x03,
  0x03, 0x00, 0x06, 0x30, 0x00, 0x60, 0x60, 0x01, 0x86, 0x00, 0x1C, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x18, 0x00,
  0x81, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x18, 0x03, 0x80, 0x30, 0x06, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00,
  0x30, 0x18, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x30, 0x70, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00,
  0x18, 0x30, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00,
  0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00, 0x02, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x03, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x0C, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xF0, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x86, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x06, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xF8, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x03, 0xFF, 0x01, 0xFC, 0x7C, 0x1C, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0xFF,
  0xF0, 0x7F, 0x03, 0x1E, 0x00, 0x33, 0x80, 0x03, 0x70, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x07, 0x60,
  0x00, 0xF6, 0x00, 0x09, 0x30, 0x03, 0x93, 0xE0, 0xE1, 0x0F, 0xFC, 0x10,
  0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x40,
  0x0C, 0x1F, 0xF8, 0x18, 0x78, 0x7C, 0x33, 0x80, 0x1C, 0x66, 0x00, 0x1C,
  0xD8, 0x00, 0x19, 0xA0, 0x00, 0x1B, 0xC0, 0x00, 0x37, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x06, 0xE0, 0x00,
  0x0D, 0xE0, 0x00, 0x33, 0x40, 0x00, 0x66, 0xC0, 0x01, 0x8C, 0xE0, 0x0E,
  0x18, 0xF0, 0x78, 0x30, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x0F, 0xFF, 0x03, 0xE1, 0xE0, 0xF0, 0x01, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x01, 0x07, 0xE3, 0xE0, 0x1F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x80, 0x30, 0x3F, 0xF0, 0x60,
  0xF0, 0x78, 0xC3, 0x80, 0x39, 0x8C, 0x00, 0x1B, 0x38, 0x00, 0x16, 0x60,
  0x00, 0x3D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xE0, 0x00, 0x3C,
  0xC0, 0x00, 0x59, 0xC0, 0x01, 0xB1, 0xC0, 0x06, 0x61, 0xF0, 0x78, 0xC0,
  0xFF, 0xC1, 0x80, 0x08, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x78,
  0x3C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xC3, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x60, 0x7C, 0x1F, 0x80, 0x7F, 0xF8, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x07, 0xFF, 0x0C, 0x1F, 0x0F, 0x18, 0x70, 0x03, 0x31,
  0x80, 0x03, 0x66, 0x00, 0x03, 0xCC, 0x00, 0x07, 0xB0, 0x00, 0x07, 0x60,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x76, 0x00, 0x00,
  0xEC, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x98, 0x00, 0x0B, 0x38, 0x00, 0x36,
  0x38, 0x01, 0xCC, 0x3E, 0x0F, 0x18, 0x1F, 0xF8, 0x30, 0x01, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x07, 0x00,
  0x1E, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC3, 0xFF, 0x0C, 0xF8, 0x7C, 0xDC, 0x00, 0xEB, 0x00, 0x06, 0xB0,
  0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xFF, 0xA0, 0x00,
  0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x01,
  0xC0, 0x70, 0x1C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x3B, 0xFC, 0xFE,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x1D, 0x00, 0x07, 0x20, 0x01,
  0xC4, 0x00, 0x70, 0x80, 0x0C, 0x10, 0x03, 0x02, 0x00, 0xC0, 0x40, 0x30,
  0x08, 0x0C, 0x01, 0x03, 0x00, 0x20, 0xE0, 0x04, 0x38, 0x00, 0x8F, 0x00,
  0x13, 0xB0, 0x02, 0x67, 0x00, 0x58, 0x60, 0x0E, 0x06, 0x01, 0x80, 0x60,
  0x20, 0x0E, 0x04, 0x00, 0xC0, 0x80, 0x0C, 0x10, 0x00, 0xC2, 0x00, 0x1C,
  0x40, 0x01, 0x88, 0x00, 0x19, 0x00, 0x01, 0xA0, 0x00, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x10,
  0x10, 0xFF, 0x80, 0x7F, 0xC2, 0x3C, 0x3C, 0x3E, 0x3E, 0x4C, 0x01, 0xCE,
  0x00, 0xEB, 0x00, 0x19, 0x80, 0x0D, 0x40, 0x01, 0xE0, 0x01, 0xF8, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x18, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x18, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x1E, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x18,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x08, 0x3F, 0xF0, 0x8F, 0x87, 0xC9, 0xC0, 0x0E, 0x90, 0x00, 0x6B,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x10, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xC3, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x07, 0xC3, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0x00, 0x10, 0x02, 0x0F, 0xFC, 0x08, 0x78, 0x7C, 0x23, 0x00, 0x38, 0x98,
  0x00, 0x72, 0xC0, 0x00, 0xCA, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1B, 0x80, 0x00,
  0x6E, 0x00, 0x03, 0xAC, 0x00, 0x0C, 0xF8, 0x00, 0x63, 0x70, 0x07, 0x8C,
  0xF8, 0xF8, 0x30, 0xFF, 0xC0, 0xC0, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFC, 0x10, 0x78, 0x3C, 0x43, 0x80,
  0x39, 0x18, 0x00, 0x34, 0xC0, 0x00, 0xD7, 0x00, 0x01, 0xD8, 0x00, 0x07,
  0x60, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x76, 0x00, 0x01, 0x4C, 0x00, 0x0D, 0x38, 0x00, 0x6C, 0x70,
  0x03, 0xB0, 0xF0, 0x78, 0xC0, 0xFF, 0xC3, 0x00, 0x20, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x83, 0xFE, 0x3E, 0x69, 0xC0, 0x2C, 0x00, 0xA0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xF0, 0x7C, 0x1F, 0x9C,
  0x00, 0x27, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xD8, 0x00, 0x3B, 0xF0, 0x3E, 0x1F, 0xFF, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x84, 0x0F,
  0xF0, 0x02, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xB0, 0x00,
  0x1D, 0x80, 0x01, 0xEE, 0x00, 0x1B, 0x38, 0x01, 0x98, 0xF8, 0x78, 0xC1,
  0xFF, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x33, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x06, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01,
  0x80, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0D,
  0x80, 0x06, 0x80, 0x06, 0x60, 0x01, 0xB0, 0x01, 0x98, 0x00, 0x4C, 0x00,
  0x63, 0x00, 0x33, 0x00, 0x38, 0xC0, 0x0C, 0x60, 0x0C, 0x30, 0x03, 0x18,
  0x03, 0x0E, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x18,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x01,
  0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x06, 0x60,
  0x03, 0x30, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x30,
  0xE0, 0x00, 0xC0, 0xE0, 0x03, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x18, 0x01,
  0xC0, 0x60, 0x01, 0x81, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x76, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x18,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x38,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC3,
  0x00, 0x01, 0x86, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x70, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x19, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E,
  0x01, 0xF0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xF0, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xF0, 0x07, 0xC0, 0x38, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x0F,
  0xC0, 0x3C, 0x00, 0x3F, 0xE0, 0x03, 0xE1, 0xF0, 0x0F, 0x00, 0x7C, 0x7C,
  0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_ExtraLight51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 36, 12, 4, -36 },
  { 19, 10, 13, 17, 4, -36 },
  { 36, 31, 36, 33, 1, -36 },
  { 176, 21, 42, 29, 3, -39 },
  { 287, 35, 38, 41, 3, -37 },
  { 454, 32, 38, 36, 3, -37 },
  { 606, 2, 13, 9, 4, -36 },
  { 610, 10, 44, 13, 2, -36 },
  { 665, 9, 44, 13, 2, -36 },
  { 715, 22, 21, 28, 3, -39 },
  { 773, 23, 24, 29, 3, -30 },
  { 842, 5, 13, 10, 2, -6 },
  { 851, 12, 2, 16, 2, -15 },
  { 854, 4, 3, 12, 4, -3 },
  { 856, 15, 36, 17, 1, -36 },
  { 924, 23, 38, 29, 3, -37 },
  { 1034, 12, 36, 29, 5, -36 },
  { 1088, 22, 37, 29, 3, -37 },
  { 1190, 23, 38, 29, 2, -37 },
  { 1300, 27, 37, 29, 1, -37 },
  { 1425, 22, 37, 29, 4, -36 },
  { 1527, 23, 38, 29, 3, -37 },
  { 1637, 23, 36, 29, 3, -36 },
  { 1741, 23, 38, 29, 3, -37 },
  { 1851, 23, 38, 29, 3, -37 },
  { 1961, 4, 27, 12, 4, -27 },
  { 1975, 6, 34, 12, 2, -27 },
  { 2001, 23, 23, 29, 3, -30 },
  { 2068, 23, 12, 29, 3, -24 },
  { 2103, 23, 23, 29, 3, -30 },
  { 2170, 17, 37, 21, 2, -37 },
  { 2249, 39, 41, 45, 3, -36 },
  { 2449, 30, 37, 30, 0, -37 },
  { 2588, 24, 36, 32, 5, -36 },
  { 2696, 27, 38, 32, 3, -37 },
  { 2825, 27, 36, 36, 5, -36 },
  { 2947, 20, 36, 28, 5, -36 },
  { 3037, 20, 36, 25, 5, -36 },
  { 3127, 30, 38, 37, 3, -37 },
  { 3270, 26, 36, 36, 5, -36 },
  { 3387, 9, 36, 15, 3, -36 },
  { 3428, 12, 45, 12, -5, -36 },
  { 3496, 24, 36, 29, 5, -36 },
  { 3604, 20, 36, 26, 5, -36 },
  { 3694, 33, 36, 43, 5, -36 },
  { 3843, 26, 36, 36, 5, -36 },
  { 3960, 33, 38, 39, 3, -37 },
  { 4117, 22, 36, 30, 5, -36 },
  { 4216, 33, 46, 39, 3, -37 },
  { 4406, 24, 36, 30, 5, -36 },
  { 4514, 22, 38, 28, 3, -37 },
  { 4619, 26, 36, 26, 0, -36 },
  { 4736, 27, 37, 37, 5, -36 },
  { 4861, 29, 36, 29, 0, -36 },
  { 4992, 43, 36, 45, 1, -36 },
  { 5186, 27, 36, 27, 0, -36 },
  { 5308, 26, 36, 26, 0, -36 },
  { 5425, 25, 36, 29, 2, -36 },
  { 5538, 11, 44, 16, 4, -36 },
  { 5599, 15, 36, 17, 1, -36 },
  { 5667, 11, 44, 16, 1, -36 },
  { 5728, 25, 23, 29, 2, -37 },
  { 5800, 21, 1, 21, 0, 5 },
  { 5803, 9, 8, 13, 2, -39 },
  { 5812, 20, 28, 27, 2, -27 },
  { 5882, 23, 40, 30, 4, -39 },
  { 5997, 20, 29, 24, 3, -28 },
  { 6070, 23, 40, 30, 3, -39 },
  { 6185, 22, 29, 28, 3, -28 },
  { 6265, 17, 39, 15, 1, -39 },
  { 6348, 23, 40, 30, 3, -28 },
  { 6463, 20, 39, 30, 5, -39 },
  { 6561, 3, 37, 11, 4, -37 },
  { 6575, 10, 49, 11, -3, -37 },
  { 6637, 19, 39, 24, 5, -39 },
  { 6730, 2, 39, 11, 5, -39 },
  { 6740, 35, 28, 44, 5, -28 },
  { 6863, 20, 28, 30, 5, -28 },
  { 6933, 24, 29, 30, 3, -28 },
  { 7020, 22, 40, 30, 5, -28 },
  { 7130, 22, 40, 30, 3, -28 },
  { 7240, 14, 27, 20, 5, -27 },
  { 7288, 19, 29, 24, 2, -28 },
  { 7357, 14, 35, 17, 1, -34 },
  { 7419, 21, 28, 30, 4, -27 },
  { 7493, 23, 27, 23, 0, -27 },
  { 7571, 34, 27, 36, 1, -27 },
  { 7686, 23, 27, 25, 1, -27 },
  { 7764, 23, 39, 23, 0, -27 },
  { 7877, 19, 27, 23, 2, -27 },
  { 7942, 15, 44, 18, 1, -36 },
  { 8025, 2, 52, 27, 13, -39 },
  { 8038, 14, 44, 18, 2, -36 },
  { 8115, 23, 4, 29, 3, -20 },
};

const GFXfont NotoSans_ExtraLight51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRALIGHT51PT7B_H_
