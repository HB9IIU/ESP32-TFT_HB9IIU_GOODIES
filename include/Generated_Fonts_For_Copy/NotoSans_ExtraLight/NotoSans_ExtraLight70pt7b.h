#ifndef _NOTOSANS_EXTRALIGHT70PT7B_H_
#define _NOTOSANS_EXTRALIGHT70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight70pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x76, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x06,
  0xFF, 0xFF, 0x60, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x06, 0xE0, 0x1B, 0x80, 0x6E, 0x01, 0xB8, 0x06,
  0xE0, 0x1B, 0x80, 0x6E, 0x01, 0xB8, 0x06, 0xC0, 0x19, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x03, 0xE0, 0xC0, 0xF8, 0x1E, 0x03,
  0x00, 0x60, 0xF0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x70, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x78, 0x03, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x07, 0xC3,
  0x00, 0x00, 0x0F, 0xEC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x31, 0xF0,
  0x00, 0x00, 0xC1, 0xF0, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x0C, 0x03, 0xC0,
  0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x03, 0x80, 0x00, 0xC0,
  0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x30, 0x0E,
  0x18, 0x00, 0xC0, 0xF8, 0x7E, 0x03, 0x0F, 0x81, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x38, 0x03, 0x80, 0x00, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x60, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x60, 0x30, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x70,
  0x3F, 0xE0, 0x60, 0x00, 0xE0, 0x60, 0x7F, 0xF0, 0x60, 0x00, 0xE0, 0xE0,
  0xE0, 0x38, 0x70, 0x00, 0xC0, 0xC1, 0xC0, 0x1C, 0x70, 0x01, 0xC1, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0xC3, 0x83, 0x80, 0x0E, 0x38, 0x03, 0x83, 0x83,
  0x00, 0x0E, 0x1E, 0x07, 0x07, 0x07, 0x00, 0x06, 0x0F, 0xFE, 0x06, 0x07,
  0x00, 0x07, 0x07, 0xFC, 0x0E, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x0C, 0x06,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x06,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xCF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xDC, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x01, 0xC0, 0x00, 0x18, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x03, 0x80, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xE0, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38,
  0x0E, 0x0E, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0xE0, 0x00, 0x00, 0x0E, 0x3C,
  0x0E, 0x00, 0x00, 0x00, 0x73, 0x80, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x38, 0x00, 0x00, 0x07, 0xB8, 0x03, 0xC0, 0x00,
  0x00, 0xF1, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x70, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0x3C, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC8, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xF0,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x30, 0x01, 0xFF, 0x80, 0xC0, 0x3F, 0x7F, 0x83, 0x07, 0xF8, 0x1F,
  0xCC, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xC0, 0x00, 0xE0, 0x01, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1E,
  0x3C, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0C, 0x38,
  0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0xF6, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xF7,
  0x03, 0xC7, 0x07, 0x87, 0x1F, 0x07, 0x3C, 0x07, 0x78, 0x07, 0xF0, 0x07,
  0x40, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x00, 0x38, 0x20, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xF0,
  0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x06, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x80,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x7F, 0x00, 0x1C, 0x0F, 0xFF, 0xC0, 0x38, 0x7F, 0xFF,
  0xE0, 0x61, 0xF0, 0x01, 0xE0, 0xC7, 0x00, 0x00, 0xE1, 0x9C, 0x00, 0x00,
  0xE3, 0x70, 0x00, 0x00, 0xE6, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0x36, 0x70, 0x00, 0x00, 0xEC, 0x70, 0x00, 0x03, 0xB8, 0xF0, 0x00, 0x1E,
  0x70, 0xF8, 0x00, 0xF8, 0xE0, 0x7F, 0xBF, 0xC1, 0xC0, 0x7F, 0xFE, 0x03,
  0x80, 0x0F, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x2F, 0xFF,
  0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0xFF, 0xFF, 0x60, 0x08, 0x3C, 0x78, 0xF1, 0xE1, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8E, 0x1C, 0x38,
  0x71, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0x83, 0x0E, 0x18, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x1F, 0x80, 0x1F,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0C, 0x38, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x38, 0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE7, 0x00, 0x03, 0xC0,
  0x00, 0xC0, 0x01, 0x9C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x07, 0x60, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x1D, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7E,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x07, 0xE0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x01, 0x80, 0x01,
  0xF0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x06, 0xC0, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x1B, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xEC, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x03, 0xB8, 0x00, 0x70, 0x00, 0x1B, 0x00, 0x0C, 0xE0, 0x01,
  0xC0, 0x00, 0x6C, 0x00, 0x73, 0x80, 0x03, 0x80, 0x03, 0x30, 0x03, 0x86,
  0x00, 0x0F, 0x00, 0x1C, 0xE0, 0x0E, 0x18, 0x00, 0x1E, 0x01, 0xE1, 0xC0,
  0xF0, 0x70, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0xC0, 0x00, 0x3F, 0xF0,
  0x07, 0xF8, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x98, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1C, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x00, 0x0F, 0x87, 0x00, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x03, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x07, 0xF0,
  0x38, 0x00, 0x00, 0x3E, 0x1C, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x0F, 0xC1, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x03, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x02, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00,
  0x01, 0xF0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x00, 0x7C, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x10,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFB, 0x00, 0x00,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x9C, 0x0F, 0x8F, 0xFF,
  0x87, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0x87, 0xE0,
  0x00, 0x01, 0xC7, 0x78, 0x00, 0x00, 0xE7, 0x1C, 0x00, 0x00, 0x77, 0x07,
  0x00, 0x00, 0x3F, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1D, 0xF7,
  0x00, 0x00, 0x00, 0x00, 0xEF, 0xB8, 0x00, 0x00, 0x00, 0x06, 0x7C, 0xC0,
  0x00, 0x00, 0x00, 0x73, 0xE7, 0x00, 0x00, 0x00, 0x03, 0x9F, 0x38, 0x00,
  0x00, 0x00, 0x38, 0xF8, 0xE0, 0x00, 0x00, 0x01, 0xC7, 0xC7, 0x00, 0x00,
  0x00, 0x0C, 0x3E, 0x18, 0x00, 0x00, 0x00, 0xE1, 0xF0, 0xE0, 0x00, 0x00,
  0x07, 0x0F, 0x87, 0x00, 0x00, 0x00, 0x70, 0x7C, 0x1C, 0x00, 0x00, 0x03,
  0x83, 0xE0, 0xE0, 0x00, 0x00, 0x18, 0x1F, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0xF8, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x3E,
  0x03, 0x80, 0x00, 0x07, 0x01, 0xF0, 0x1C, 0x00, 0x00, 0x30, 0x0F, 0x80,
  0x60, 0x00, 0x03, 0x80, 0x7C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xE0, 0x1C,
  0x00, 0x01, 0xC0, 0x1F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF8, 0x03, 0x80,
  0x00, 0x60, 0x07, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x70, 0x00,
  0x38, 0x01, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x7C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0x0E, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x70, 0x07, 0x00, 0x07,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x3E, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xF0,
  0x00, 0x30, 0x1C, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x7C, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1F, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x39,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x00,
  0x07, 0xE7, 0x00, 0x00, 0x00, 0x7E, 0x38, 0x00, 0x00, 0x07, 0xE3, 0xC0,
  0x00, 0x00, 0x7E, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x00, 0x7E,
  0x0F, 0x00, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x00, 0x7E, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x0E,
  0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x38, 0x00, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1E, 0x00,
  0x07, 0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0x01, 0xE0, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0x00, 0x70,
  0x07, 0xE0, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x00, 0x38, 0x07, 0xE0, 0x00,
  0x01, 0xC0, 0x7E, 0x00, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x7E,
  0x00, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x00, 0x03,
  0x87, 0xE0, 0x00, 0x00, 0x1C, 0x7E, 0x00, 0x00, 0x01, 0xE7, 0xE0, 0x00,
  0x00, 0x0E, 0x7E, 0x00, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x38, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x03, 0xE3, 0x80, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07,
  0xC3, 0x80, 0x00, 0x7E, 0x0E, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x0F, 0xC0, 0xE0, 0x00,
  0x03, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x01, 0xF8, 0x00, 0xFE, 0x0F, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x30, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x70, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x06, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x80, 0x06, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x06, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x03, 0x70, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0xC0, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x07, 0x01, 0x80, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x00, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xF8, 0x0E, 0x00, 0x03, 0xC0,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x3F, 0xE0, 0x07, 0x07, 0xC0, 0x00, 0x71, 0xF0, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x1F, 0x70, 0x00,
  0x03, 0x77, 0x80, 0x00, 0x67, 0x3C, 0x00, 0x1E, 0x71, 0xE0, 0x07, 0xC7,
  0x0F, 0xFF, 0xF0, 0x70, 0x7F, 0xFC, 0x03, 0x00, 0x7C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x03, 0xF8,
  0x00, 0xE0, 0x3F, 0xFE, 0x01, 0xC1, 0xFF, 0xFF, 0x03, 0x8F, 0x80, 0x1F,
  0x07, 0x3C, 0x00, 0x0F, 0x0E, 0x60, 0x00, 0x0F, 0x1D, 0xC0, 0x00, 0x0E,
  0x3F, 0x00, 0x00, 0x0E, 0x7C, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1B, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x03, 0x9F, 0x00, 0x00, 0x07, 0x3E, 0x00, 0x00,
  0x1C, 0x76, 0x00, 0x00, 0x78, 0xEE, 0x00, 0x01, 0xE1, 0xCE, 0x00, 0x07,
  0x83, 0x8F, 0x00, 0x3E, 0x06, 0x0F, 0xFF, 0xF8, 0x0C, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x70, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x81, 0xF8, 0x00, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x07, 0x00, 0x7F, 0xFC, 0x0E, 0x03,
  0xFF, 0xFE, 0x1C, 0x0F, 0x80, 0x1E, 0x38, 0x3C, 0x00, 0x0E, 0x70, 0xF0,
  0x00, 0x0E, 0x63, 0xC0, 0x00, 0x0E, 0xC7, 0x00, 0x00, 0x0D, 0x9C, 0x00,
  0x00, 0x1F, 0x38, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0D, 0x8E, 0x00, 0x00, 0x33, 0x0E,
  0x00, 0x00, 0xE6, 0x1F, 0x00, 0x03, 0x8C, 0x0F, 0x80, 0x1E, 0x18, 0x0F,
  0xFF, 0xF8, 0x30, 0x07, 0xFF, 0xC0, 0x60, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x80, 0xFC,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03,
  0xE0, 0x10, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x0C, 0x07, 0xFF,
  0xFC, 0x18, 0x1F, 0x00, 0x3C, 0x30, 0x78, 0x00, 0x1C, 0xE1, 0xE0, 0x00,
  0x0D, 0xC7, 0x80, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0x6E, 0x1C, 0x00,
  0x01, 0xDC, 0x1E, 0x00, 0x07, 0x38, 0x1F, 0x00, 0x3C, 0x70, 0x1F, 0xFF,
  0xF0, 0xE0, 0x0F, 0xFF, 0x81, 0xC0, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x40, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3E, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xF4, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x3F,
  0xFE, 0x07, 0x07, 0xFF, 0xF8, 0x38, 0xF8, 0x01, 0xF1, 0xCF, 0x00, 0x07,
  0x8E, 0xE0, 0x00, 0x0E, 0x76, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xDF,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0x80, 0x33, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x00, 0x18, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x38, 0x00,
  0x3C, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE1, 0xF0, 0x00, 0x1C,
  0x7E, 0x00, 0x03, 0x8E, 0xE0, 0x00, 0x73, 0x8E, 0x00, 0x0E, 0xE1, 0xE0,
  0x01, 0xF8, 0x1C, 0x00, 0x3E, 0x01, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x60, 0x3F, 0xF8,
  0x00, 0xFF, 0xF8, 0x38, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x1C, 0x78, 0x07,
  0xC1, 0xF0, 0x07, 0x8E, 0x70, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x70, 0x00,
  0x38, 0xC0, 0x00, 0x7B, 0xF0, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x06,
  0x01, 0xFF, 0xF0, 0x30, 0x3F, 0xFF, 0xC1, 0xC7, 0xC0, 0x0F, 0x8E, 0x78,
  0x00, 0x3C, 0x73, 0x00, 0x00, 0x73, 0xB0, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x0E, 0xF8, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xC0,
  0x7F, 0xFC, 0x03, 0x83, 0xFF, 0xFE, 0x07, 0x0F, 0x00, 0x3E, 0x0E, 0x38,
  0x00, 0x1E, 0x1C, 0xE0, 0x00, 0x1E, 0x3B, 0x80, 0x00, 0x1C, 0x76, 0x00,
  0x00, 0x1C, 0xF8, 0x00, 0x00, 0x39, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x00, 0x77, 0x80, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xDF,
  0x00, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x0E, 0x7E, 0x00, 0x00, 0x3C, 0xEE,
  0x00, 0x00, 0x71, 0xDE, 0x00, 0x01, 0xC3, 0x9E, 0x00, 0x0F, 0x07, 0x1F,
  0x00, 0x7C, 0x0E, 0x0F, 0xFF, 0xF0, 0x1C, 0x0F, 0xFF, 0x80, 0x38, 0x01,
  0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x0C, 0x07, 0xFF, 0xFC,
  0x18, 0x1F, 0x00, 0x3C, 0x30, 0x78, 0x00, 0x1C, 0xE1, 0xE0, 0x00, 0x1D,
  0xC7, 0x80, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x3E,
  0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0xCE, 0x00, 0x00,
  0x0F, 0x9C, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x6E, 0x3C, 0x00, 0x01,
  0x9C, 0x3C, 0x00, 0x0F, 0x38, 0x3E, 0x00, 0x7C, 0x70, 0x1F, 0xFF, 0xE0,
  0xE0, 0x1F, 0xFF, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x8E, 0x07, 0xFF,
  0xE1, 0xFF, 0xEE, 0x3C, 0x01, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xEC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xF3,
  0xF0, 0x00, 0xF8, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x01, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xB7,
  0x00, 0x00, 0x3B, 0x38, 0x00, 0x07, 0x33, 0xC0, 0x00, 0xE3, 0x1F, 0x00,
  0x3C, 0x30, 0xFF, 0xFF, 0x83, 0x03, 0xFF, 0xE0, 0x30, 0x07, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0C, 0x38,
  0x00, 0x0E, 0x30, 0x00, 0x38, 0x38, 0x00, 0x18, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x18, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x60, 0x38, 0x00, 0x60, 0x70,
  0x00, 0xE0, 0x60, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0x80,
  0x01, 0x83, 0x80, 0x03, 0x87, 0x00, 0x03, 0x86, 0x00, 0x03, 0x0E, 0x00,
  0x07, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x19, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x37, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x06, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x70,
  0x30, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x7E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0x3F, 0xFE, 0x00, 0x01, 0x7C, 0x1F, 0x80,
  0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraLight70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 51, 16, 6, -50 },
  { 27, 14, 18, 24, 5, -50 },
  { 59, 41, 50, 45, 2, -50 },
  { 316, 30, 57, 40, 4, -53 },
  { 530, 48, 52, 56, 4, -51 },
  { 842, 44, 52, 50, 4, -51 },
  { 1128, 3, 18, 13, 5, -50 },
  { 1135, 13, 61, 18, 3, -50 },
  { 1235, 14, 61, 18, 2, -50 },
  { 1342, 30, 29, 39, 4, -53 },
  { 1451, 32, 33, 40, 4, -41 },
  { 1583, 7, 17, 14, 3, -8 },
  { 1598, 17, 2, 23, 3, -20 },
  { 1603, 4, 6, 16, 6, -5 },
  { 1606, 21, 50, 23, 1, -50 },
  { 1738, 32, 52, 40, 4, -51 },
  { 1946, 16, 50, 40, 7, -50 },
  { 2046, 31, 51, 40, 4, -51 },
  { 2244, 32, 52, 40, 3, -51 },
  { 2452, 37, 50, 40, 2, -50 },
  { 2684, 30, 51, 40, 5, -50 },
  { 2876, 31, 52, 40, 5, -51 },
  { 3078, 32, 50, 40, 4, -50 },
  { 3278, 31, 52, 40, 4, -51 },
  { 3480, 31, 52, 40, 4, -51 },
  { 3682, 4, 39, 16, 6, -38 },
  { 3702, 7, 47, 16, 3, -38 },
  { 3744, 32, 32, 40, 4, -41 },
  { 3872, 32, 17, 40, 4, -33 },
  { 3940, 32, 32, 40, 4, -41 },
  { 4068, 25, 52, 29, 2, -51 },
  { 4231, 54, 57, 62, 4, -50 },
  { 4616, 41, 50, 41, 0, -50 },
  { 4873, 33, 50, 43, 7, -50 },
  { 5080, 37, 52, 43, 4, -51 },
  { 5321, 38, 50, 49, 7, -50 },
  { 5559, 27, 50, 39, 7, -50 },
  { 5728, 27, 50, 35, 7, -50 },
  { 5897, 41, 52, 51, 4, -51 },
  { 6164, 36, 50, 50, 7, -50 },
  { 6389, 13, 50, 21, 4, -50 },
  { 6471, 17, 62, 17, -7, -50 },
  { 6603, 33, 50, 40, 7, -50 },
  { 6810, 27, 50, 36, 7, -50 },
  { 6979, 45, 50, 60, 7, -50 },
  { 7261, 36, 50, 50, 7, -50 },
  { 7486, 45, 52, 53, 4, -51 },
  { 7779, 30, 50, 41, 7, -50 },
  { 7967, 45, 63, 53, 4, -51 },
  { 8322, 32, 50, 41, 7, -50 },
  { 8522, 30, 52, 38, 4, -51 },
  { 8717, 36, 50, 36, 0, -50 },
  { 8942, 37, 51, 50, 7, -50 },
  { 9178, 40, 50, 40, 0, -50 },
  { 9428, 58, 50, 62, 2, -50 },
  { 9791, 37, 50, 37, 0, -50 },
  { 10023, 36, 50, 36, 0, -50 },
  { 10248, 35, 50, 40, 3, -50 },
  { 10467, 14, 61, 22, 6, -50 },
  { 10574, 21, 50, 23, 1, -50 },
  { 10706, 14, 61, 22, 2, -50 },
  { 10813, 34, 31, 40, 3, -50 },
  { 10945, 28, 3, 28, 0, 6 },
  { 10956, 12, 12, 18, 3, -54 },
  { 10974, 28, 39, 36, 3, -38 },
  { 11111, 31, 54, 41, 6, -53 },
  { 11321, 27, 39, 33, 4, -38 },
  { 11453, 31, 54, 41, 4, -53 },
  { 11663, 30, 39, 38, 4, -38 },
  { 11810, 23, 54, 20, 1, -54 },
  { 11966, 31, 55, 41, 4, -38 },
  { 12180, 29, 53, 41, 6, -53 },
  { 12373, 5, 51, 15, 5, -51 },
  { 12405, 14, 68, 15, -4, -51 },
  { 12524, 27, 53, 33, 6, -53 },
  { 12703, 3, 53, 15, 6, -53 },
  { 12723, 49, 38, 61, 6, -38 },
  { 12956, 29, 38, 41, 6, -38 },
  { 13094, 33, 39, 41, 4, -38 },
  { 13255, 31, 54, 41, 6, -38 },
  { 13465, 31, 54, 41, 4, -38 },
  { 13675, 20, 38, 27, 6, -38 },
  { 13770, 26, 39, 32, 3, -38 },
  { 13897, 20, 47, 23, 1, -46 },
  { 14015, 28, 38, 41, 6, -37 },
  { 14148, 31, 37, 31, 0, -37 },
  { 14292, 47, 37, 49, 1, -37 },
  { 14510, 30, 37, 34, 2, -37 },
  { 14649, 31, 54, 31, 0, -37 },
  { 14859, 26, 37, 32, 3, -37 },
  { 14980, 20, 61, 24, 2, -50 },
  { 15133, 3, 70, 38, 17, -53 },
  { 15160, 20, 61, 24, 2, -50 },
  { 15313, 32, 7, 40, 4, -28 },
};

const GFXfont NotoSans_ExtraLight70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRALIGHT70PT7B_H_
