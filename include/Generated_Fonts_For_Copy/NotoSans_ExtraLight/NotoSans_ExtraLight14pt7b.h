#ifndef _NOTOSANS_EXTRALIGHT14PT7B_H_
#define _NOTOSANS_EXTRALIGHT14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x40, 0xB6, 0xD0, 0x12, 0x09, 0x04, 0x8F, 0xF1, 0x21, 0x23,
  0xFC, 0x48, 0x24, 0x12, 0x00, 0x21, 0xEA, 0x28, 0xA1, 0x83, 0x89, 0x24,
  0x9F, 0x88, 0xE1, 0x49, 0x25, 0x12, 0x89, 0xBF, 0x64, 0x52, 0x29, 0x24,
  0x91, 0xC0, 0x78, 0x22, 0x11, 0x09, 0x03, 0x02, 0x8A, 0x25, 0x0A, 0x82,
  0x3E, 0xC0, 0xF0, 0x6A, 0xAA, 0xA9, 0xC8, 0x92, 0x49, 0x25, 0x60, 0x20,
  0x8A, 0xDC, 0x31, 0x20, 0x20, 0x82, 0x3F, 0x20, 0x80, 0xF0, 0xE0, 0x80,
  0x11, 0x12, 0x22, 0x44, 0x48, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85,
  0xE0, 0x35, 0x91, 0x11, 0x11, 0x11, 0xF8, 0x10, 0x41, 0x08, 0x41, 0x08,
  0x43, 0xF0, 0xF8, 0x10, 0x41, 0x78, 0x20, 0x41, 0x07, 0xE0, 0x04, 0x0C,
  0x14, 0x14, 0x24, 0x44, 0x84, 0x7F, 0x04, 0x04, 0x7A, 0x08, 0x20, 0xF8,
  0x10, 0x41, 0x07, 0xE0, 0x3D, 0x08, 0x20, 0xFA, 0x18, 0x61, 0x85, 0xE0,
  0xFC, 0x10, 0x82, 0x08, 0x41, 0x08, 0x21, 0x00, 0x7A, 0x18, 0x72, 0x31,
  0x28, 0x61, 0x85, 0xE0, 0x7A, 0x18, 0x61, 0x85, 0xF0, 0x41, 0x0B, 0xC0,
  0xC1, 0xC3, 0xC0, 0x0C, 0xCC, 0x10, 0x30, 0x30, 0xFC, 0x00, 0x3F, 0xC0,
  0xC0, 0xC2, 0x33, 0x00, 0xF8, 0x42, 0x11, 0x10, 0x84, 0x01, 0x00, 0x1F,
  0x0C, 0x12, 0x01, 0x47, 0x99, 0x13, 0x42, 0x68, 0x8C, 0x9A, 0x8C, 0x88,
  0x00, 0xFC, 0x00, 0x08, 0x18, 0x14, 0x24, 0x24, 0x22, 0x5E, 0x42, 0x81,
  0x81, 0xFD, 0x06, 0x0C, 0x1F, 0xD0, 0xA0, 0xC1, 0x83, 0xF8, 0x3E, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x7C, 0xFC, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0xFC, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x83,
  0xF0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x00, 0x3F, 0x40, 0x80,
  0x80, 0x80, 0x8F, 0x81, 0x81, 0x41, 0x3F, 0x81, 0x81, 0x81, 0x81, 0xFF,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xD5, 0x55, 0x70, 0x24, 0x92, 0x49, 0x24,
  0xF0, 0x83, 0x0A, 0x24, 0x8A, 0x1A, 0x22, 0x44, 0x85, 0x04, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80, 0xE0, 0x70, 0x74, 0x3A, 0x1C,
  0x96, 0x4B, 0x29, 0x8C, 0xC4, 0x40, 0x81, 0xC1, 0xA1, 0xA1, 0x91, 0x89,
  0x89, 0x85, 0x83, 0x81, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x41, 0x1F, 0x00, 0xFA, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x00,
  0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x41, 0x1F, 0x01,
  0x00, 0x40, 0xF9, 0x0A, 0x0C, 0x28, 0x5F, 0x22, 0x42, 0x85, 0x04, 0x7E,
  0x08, 0x20, 0x60, 0x60, 0x41, 0x07, 0xE0, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x18, 0x18, 0x10,
  0x82, 0x14, 0x61, 0x46, 0x24, 0x52, 0x49, 0x22, 0x92, 0x29, 0x42, 0x8C,
  0x30, 0xC1, 0x08, 0x82, 0x88, 0x91, 0x41, 0x02, 0x0A, 0x22, 0x43, 0x04,
  0x82, 0x85, 0x11, 0x22, 0x82, 0x04, 0x08, 0x10, 0x20, 0x7E, 0x02, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFF, 0xF2, 0x49, 0x24, 0x92, 0x70,
  0x84, 0x44, 0x22, 0x21, 0x11, 0xE4, 0x92, 0x49, 0x24, 0xF0, 0x10, 0xC4,
  0x92, 0x86, 0x10, 0xFC, 0xA4, 0x74, 0x42, 0x17, 0xC6, 0x3F, 0x82, 0x08,
  0x2E, 0xC6, 0x18, 0x61, 0x86, 0x1F, 0x80, 0x3A, 0x21, 0x08, 0x42, 0x0F,
  0x04, 0x10, 0x4D, 0xCE, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x31, 0x28, 0x61,
  0xFA, 0x08, 0x1F, 0x19, 0x11, 0xE4, 0x21, 0x08, 0x42, 0x10, 0x33, 0x38,
  0x61, 0x86, 0x18, 0x5F, 0x04, 0x1F, 0x80, 0x82, 0x08, 0x2E, 0xC6, 0x18,
  0x61, 0x86, 0x18, 0x40, 0x9F, 0xC0, 0x20, 0x12, 0x49, 0x24, 0x9E, 0x82,
  0x08, 0x20, 0x8A, 0x4A, 0x38, 0x92, 0x28, 0xC0, 0xFF, 0xE0, 0x33, 0xB3,
  0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x3B, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x31, 0x38, 0x61, 0x86, 0x18, 0x5E, 0x3B, 0x18, 0x61, 0x86,
  0x18, 0x7E, 0x82, 0x08, 0x00, 0x33, 0x38, 0x61, 0x86, 0x18, 0x5F, 0x04,
  0x10, 0x40, 0x3C, 0x88, 0x88, 0x88, 0x74, 0x61, 0x83, 0x04, 0x3E, 0x4F,
  0x44, 0x44, 0x44, 0x30, 0x86, 0x18, 0x61, 0x86, 0x17, 0xC0, 0x85, 0x14,
  0x92, 0x28, 0xC1, 0x00, 0x8C, 0x53, 0x24, 0xC9, 0x4A, 0x52, 0x88, 0xC2,
  0x10, 0xC4, 0xA3, 0x04, 0x29, 0x1C, 0x40, 0x85, 0x14, 0x92, 0x28, 0xC1,
  0x08, 0x23, 0x80, 0xF8, 0x88, 0x44, 0x43, 0xE0, 0x12, 0x22, 0x24, 0xC2,
  0x22, 0x23, 0xFF, 0xFC, 0xC2, 0x22, 0x22, 0x12, 0x22, 0x2E, 0x66, 0x70,
};

const GFXglyph NotoSans_ExtraLight14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 3, 4, 5, 1, -10 },
  { 5, 9, 10, 9, 0, -10 },
  { 17, 6, 12, 8, 1, -11 },
  { 26, 9, 10, 11, 1, -10 },
  { 38, 9, 10, 10, 1, -10 },
  { 50, 1, 4, 3, 1, -10 },
  { 51, 2, 12, 4, 1, -10 },
  { 54, 3, 12, 4, 0, -10 },
  { 59, 6, 6, 8, 1, -11 },
  { 64, 6, 6, 8, 1, -8 },
  { 69, 1, 4, 3, 1, -2 },
  { 70, 3, 1, 5, 1, -4 },
  { 71, 1, 1, 3, 1, -1 },
  { 72, 4, 10, 5, 0, -10 },
  { 77, 6, 10, 8, 1, -10 },
  { 85, 4, 10, 8, 1, -10 },
  { 90, 6, 10, 8, 1, -10 },
  { 98, 6, 10, 8, 1, -10 },
  { 106, 8, 10, 8, 0, -10 },
  { 116, 6, 10, 8, 1, -10 },
  { 124, 6, 10, 8, 1, -10 },
  { 132, 6, 10, 8, 1, -10 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 6, 10, 8, 1, -10 },
  { 156, 1, 8, 3, 1, -8 },
  { 157, 1, 10, 3, 1, -8 },
  { 159, 6, 6, 8, 1, -8 },
  { 164, 6, 4, 8, 1, -7 },
  { 167, 6, 6, 8, 1, -8 },
  { 172, 5, 10, 6, 0, -10 },
  { 179, 11, 11, 12, 1, -10 },
  { 195, 8, 10, 8, 0, -10 },
  { 205, 7, 10, 9, 1, -10 },
  { 214, 7, 10, 9, 1, -10 },
  { 223, 8, 10, 10, 1, -10 },
  { 233, 6, 10, 8, 1, -10 },
  { 241, 6, 10, 7, 1, -10 },
  { 249, 8, 10, 10, 1, -10 },
  { 259, 8, 10, 10, 1, -10 },
  { 269, 2, 10, 4, 1, -10 },
  { 272, 3, 12, 3, -1, -10 },
  { 277, 7, 10, 8, 1, -10 },
  { 286, 6, 10, 7, 1, -10 },
  { 294, 9, 10, 12, 1, -10 },
  { 306, 8, 10, 10, 1, -10 },
  { 316, 9, 10, 11, 1, -10 },
  { 328, 6, 10, 8, 1, -10 },
  { 336, 9, 12, 11, 1, -10 },
  { 350, 7, 10, 8, 1, -10 },
  { 359, 6, 10, 8, 1, -10 },
  { 367, 7, 10, 7, 0, -10 },
  { 376, 8, 10, 10, 1, -10 },
  { 386, 8, 10, 8, 0, -10 },
  { 396, 12, 10, 12, 0, -10 },
  { 411, 7, 10, 7, 0, -10 },
  { 420, 7, 10, 7, 0, -10 },
  { 429, 8, 10, 8, 0, -10 },
  { 439, 3, 12, 4, 1, -10 },
  { 444, 4, 10, 5, 0, -10 },
  { 449, 3, 12, 4, 0, -10 },
  { 454, 6, 6, 8, 1, -10 },
  { 459, 6, 1, 6, 0, 1 },
  { 460, 2, 3, 4, 1, -11 },
  { 461, 5, 8, 7, 1, -8 },
  { 466, 6, 11, 8, 1, -11 },
  { 475, 5, 8, 7, 1, -8 },
  { 480, 6, 11, 8, 1, -11 },
  { 489, 6, 8, 8, 1, -8 },
  { 495, 5, 11, 4, 0, -11 },
  { 502, 6, 11, 8, 1, -8 },
  { 511, 6, 11, 8, 1, -11 },
  { 520, 1, 10, 3, 1, -10 },
  { 522, 3, 13, 3, -1, -10 },
  { 527, 6, 11, 7, 1, -11 },
  { 536, 1, 11, 3, 1, -11 },
  { 538, 10, 8, 12, 1, -8 },
  { 548, 6, 8, 8, 1, -8 },
  { 554, 6, 8, 8, 1, -8 },
  { 560, 6, 11, 8, 1, -8 },
  { 569, 6, 11, 8, 1, -8 },
  { 578, 4, 8, 5, 1, -8 },
  { 582, 5, 8, 6, 1, -8 },
  { 587, 4, 9, 5, 0, -9 },
  { 592, 6, 7, 8, 1, -7 },
  { 598, 6, 7, 6, 0, -7 },
  { 604, 10, 7, 10, 0, -7 },
  { 613, 6, 7, 7, 0, -7 },
  { 619, 6, 10, 6, 0, -7 },
  { 627, 5, 7, 6, 1, -7 },
  { 632, 4, 12, 5, 0, -10 },
  { 638, 1, 14, 8, 3, -11 },
  { 640, 4, 12, 5, 0, -10 },
  { 646, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_ExtraLight14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRALIGHT14PT7B_H_
