#ifndef _NOTOSANS_EXTRALIGHT20PT7B_H_
#define _NOTOSANS_EXTRALIGHT20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC4, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x22, 0x08, 0x4F,
  0xFE, 0x22, 0x04, 0x40, 0x88, 0x21, 0x1F, 0xFC, 0x88, 0x11, 0x02, 0x20,
  0x84, 0x00, 0x08, 0x1F, 0x92, 0x11, 0x08, 0x84, 0x41, 0xA0, 0x30, 0x0E,
  0x04, 0x82, 0x21, 0x10, 0x96, 0x58, 0xF0, 0x10, 0x78, 0x22, 0x11, 0x08,
  0x44, 0x21, 0x20, 0x84, 0x82, 0x14, 0xC8, 0x94, 0x92, 0xA1, 0x32, 0x84,
  0x12, 0x10, 0x88, 0x42, 0x21, 0x10, 0x44, 0x41, 0xE0, 0x0C, 0x01, 0x98,
  0x08, 0x40, 0x42, 0x02, 0x10, 0x11, 0x00, 0x50, 0x03, 0x00, 0x24, 0x12,
  0x10, 0xA0, 0x49, 0x01, 0x48, 0x04, 0x20, 0x50, 0xFC, 0x60, 0xF8, 0x34,
  0x44, 0x88, 0x88, 0x88, 0x88, 0x84, 0x42, 0x30, 0x89, 0x12, 0x49, 0x24,
  0x92, 0x52, 0x80, 0x08, 0x04, 0x02, 0x1F, 0xF0, 0x80, 0xA0, 0x88, 0x44,
  0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00,
  0x6A, 0x80, 0xF8, 0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x84,
  0x10, 0x42, 0x00, 0x0C, 0x19, 0x10, 0x48, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x14, 0x0A, 0x08, 0xF8, 0x1B, 0x62, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x7E, 0x40, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x07, 0xFC, 0x7E, 0x40, 0x80,
  0x20, 0x10, 0x10, 0x10, 0xF0, 0x06, 0x00, 0x80, 0x40, 0x20, 0x10, 0x17,
  0xF0, 0x01, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x88, 0x21, 0x04, 0x21, 0x04,
  0x40, 0x9F, 0xFC, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x7F, 0x20, 0x10,
  0x08, 0x04, 0x03, 0xE1, 0x0C, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x17,
  0xF0, 0x07, 0x0C, 0x08, 0x08, 0x04, 0x02, 0x02, 0x79, 0x42, 0xC0, 0xC0,
  0x60, 0x28, 0x14, 0x09, 0x08, 0x78, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80, 0x3F, 0x20,
  0x90, 0x28, 0x14, 0x11, 0x10, 0x70, 0x46, 0x40, 0xC0, 0x60, 0x30, 0x14,
  0x09, 0xF8, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x06, 0xC5, 0x1C,
  0x80, 0x40, 0x40, 0x20, 0x23, 0xE0, 0xC0, 0x20, 0x50, 0x00, 0x1A, 0xA0,
  0x00, 0x81, 0x83, 0x06, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x08, 0x38,
  0x60, 0xC0, 0x00, 0xFC, 0x08, 0x08, 0x10, 0x40, 0x86, 0x10, 0x20, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x07, 0xF0, 0x18, 0x08, 0x20, 0x04, 0x40, 0x02,
  0x43, 0xE2, 0x84, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x22,
  0x84, 0x62, 0x83, 0x9C, 0x40, 0x00, 0x20, 0x00, 0x10, 0x10, 0x07, 0xE0,
  0x06, 0x00, 0x60, 0x09, 0x00, 0x90, 0x09, 0x01, 0x08, 0x10, 0x82, 0x08,
  0x3F, 0xC2, 0x04, 0x40, 0x24, 0x02, 0x80, 0x28, 0x01, 0xFF, 0x40, 0x60,
  0x30, 0x18, 0x0C, 0x0B, 0xF9, 0x02, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x17,
  0xF0, 0x1F, 0xE4, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x80, 0xFF, 0x10, 0x12,
  0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0A, 0x01,
  0x40, 0x48, 0x11, 0xFC, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x03, 0x81, 0xC7,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x83, 0xF8, 0x01,
  0x80, 0x14, 0x01, 0x40, 0x13, 0x01, 0x0F, 0xE0, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x1F, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x17, 0x00, 0x81, 0xC1, 0xA0,
  0x90, 0x88, 0x84, 0x82, 0xC1, 0x90, 0x88, 0x42, 0x20, 0x90, 0x28, 0x14,
  0x04, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x40, 0x5A, 0x02, 0xC8,
  0x26, 0x41, 0x32, 0x09, 0x88, 0x8C, 0x44, 0x61, 0x43, 0x0A, 0x18, 0x50,
  0xC1, 0x04, 0x80, 0x70, 0x1A, 0x06, 0x81, 0x90, 0x62, 0x18, 0x86, 0x11,
  0x82, 0x60, 0x98, 0x16, 0x03, 0x80, 0xE0, 0x10, 0x07, 0x00, 0xC6, 0x08,
  0x08, 0x80, 0x24, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x80, 0x24, 0x01, 0x10, 0x10, 0x7F, 0x00, 0xFE, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x83, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x07,
  0x00, 0xC6, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x24, 0x01, 0x10, 0x10, 0x7F, 0x00,
  0x10, 0x00, 0x80, 0x03, 0x00, 0xFE, 0x40, 0xA0, 0x50, 0x18, 0x14, 0x0A,
  0x09, 0xF8, 0x84, 0x41, 0x20, 0x90, 0x28, 0x14, 0x04, 0x3F, 0x20, 0x20,
  0x10, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x40, 0x20, 0x10, 0x17,
  0xF0, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x8F,
  0xC0, 0x80, 0x28, 0x05, 0x01, 0x20, 0x22, 0x04, 0x41, 0x08, 0x20, 0x84,
  0x11, 0x01, 0x20, 0x28, 0x05, 0x00, 0x60, 0x08, 0x00, 0x81, 0x01, 0x81,
  0x81, 0x82, 0x82, 0x82, 0x82, 0x42, 0x42, 0x42, 0x42, 0x44, 0x44, 0x24,
  0x44, 0x24, 0x24, 0x24, 0x28, 0x28, 0x28, 0x18, 0x18, 0x18, 0x18, 0x10,
  0x10, 0xC0, 0x48, 0x10, 0x84, 0x08, 0x81, 0x20, 0x14, 0x01, 0x00, 0x60,
  0x12, 0x02, 0x20, 0x84, 0x10, 0x44, 0x05, 0x00, 0xC0, 0x80, 0x50, 0x24,
  0x08, 0x84, 0x11, 0x04, 0x80, 0xA0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x3F, 0xF0, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04,
  0x10, 0x20, 0x81, 0x04, 0x10, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0xF8, 0x0C, 0x05, 0x01, 0x20, 0x88, 0x21, 0x10, 0x44,
  0x0A, 0x03, 0xFF, 0x88, 0x80, 0x3C, 0x42, 0x01, 0x01, 0x01, 0x3F, 0x41,
  0x81, 0x81, 0x83, 0x7D, 0x80, 0x40, 0x20, 0x10, 0x0B, 0xC6, 0x12, 0x05,
  0x02, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x16, 0x0A, 0xF8, 0x1F, 0x20, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3F, 0x00, 0x80, 0x40, 0x20,
  0x11, 0xE9, 0x0D, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x0C,
  0xFA, 0x1E, 0x10, 0x90, 0x50, 0x18, 0x0F, 0xFE, 0x01, 0x00, 0x40, 0x20,
  0x0F, 0xC0, 0x1E, 0x40, 0x81, 0x0F, 0x84, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x00, 0x1E, 0xB0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xA0, 0xCF, 0xA0, 0x10, 0x08, 0x05, 0x04, 0x7C, 0x80, 0x80,
  0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x9F, 0xFC, 0x10, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12,
  0xC0, 0x81, 0x02, 0x04, 0x08, 0x30, 0xA2, 0x48, 0xA1, 0xC2, 0x44, 0x48,
  0x50, 0xA0, 0x80, 0xFF, 0xFE, 0xB8, 0x73, 0x1E, 0x28, 0x30, 0x60, 0x81,
  0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18, 0x20,
  0x40, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x1E, 0x10, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x40, 0xA0, 0x8F,
  0x80, 0xBC, 0x61, 0x20, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x60,
  0xAF, 0x90, 0x08, 0x04, 0x02, 0x01, 0x00, 0x1E, 0xB0, 0xD0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0xCF, 0xA0, 0x10, 0x08, 0x04, 0x02,
  0x01, 0xBE, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20, 0x3D, 0x86, 0x04, 0x04,
  0x07, 0x01, 0x81, 0x02, 0x07, 0xF0, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x1C, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x83, 0x7D, 0x80, 0xC0, 0x50, 0x48, 0x24, 0x21, 0x10, 0x88, 0x28,
  0x14, 0x0A, 0x02, 0x00, 0x81, 0x05, 0x0C, 0x14, 0x30, 0x90, 0xA2, 0x44,
  0x88, 0x92, 0x22, 0x45, 0x0A, 0x14, 0x28, 0x50, 0x60, 0x81, 0x02, 0x00,
  0x40, 0xA0, 0x88, 0x42, 0x40, 0xC0, 0x40, 0x30, 0x24, 0x22, 0x20, 0xB0,
  0x20, 0x80, 0xC0, 0x50, 0x48, 0x24, 0x21, 0x10, 0x88, 0x28, 0x14, 0x0A,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x81, 0x80, 0xFE, 0x04, 0x10, 0x20, 0x82,
  0x04, 0x10, 0x41, 0x03, 0xF8, 0x19, 0x08, 0x42, 0x10, 0x88, 0x82, 0x08,
  0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF, 0xF0, 0xC1, 0x08, 0x42, 0x10, 0x82,
  0x08, 0x88, 0x42, 0x10, 0x84, 0xC0, 0x78, 0xC3, 0xC0,
};

const GFXglyph NotoSans_ExtraLight20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 14, 5, 2, -14 },
  { 3, 4, 5, 7, 1, -14 },
  { 6, 11, 14, 13, 1, -14 },
  { 26, 9, 16, 11, 1, -15 },
  { 44, 14, 14, 16, 1, -14 },
  { 69, 13, 15, 14, 1, -15 },
  { 94, 1, 5, 4, 1, -14 },
  { 95, 4, 17, 5, 1, -14 },
  { 104, 3, 17, 5, 1, -14 },
  { 111, 9, 8, 11, 1, -15 },
  { 120, 9, 10, 11, 1, -12 },
  { 132, 2, 5, 4, 1, -2 },
  { 134, 5, 1, 6, 1, -6 },
  { 135, 1, 1, 5, 2, -1 },
  { 136, 6, 14, 7, 0, -14 },
  { 147, 9, 15, 11, 1, -15 },
  { 164, 5, 14, 11, 2, -14 },
  { 173, 9, 14, 11, 1, -14 },
  { 189, 9, 14, 11, 1, -14 },
  { 205, 11, 14, 11, 0, -14 },
  { 225, 9, 14, 11, 1, -14 },
  { 241, 9, 15, 11, 1, -15 },
  { 258, 9, 14, 11, 1, -14 },
  { 274, 9, 14, 11, 1, -14 },
  { 290, 9, 14, 11, 1, -14 },
  { 306, 1, 11, 5, 2, -11 },
  { 308, 2, 14, 5, 1, -11 },
  { 312, 9, 9, 11, 1, -12 },
  { 323, 9, 4, 11, 1, -9 },
  { 328, 9, 9, 11, 1, -12 },
  { 339, 7, 14, 8, 1, -14 },
  { 352, 16, 16, 18, 1, -14 },
  { 384, 12, 14, 12, 0, -14 },
  { 405, 9, 14, 12, 2, -14 },
  { 421, 11, 14, 12, 1, -14 },
  { 441, 11, 14, 14, 2, -14 },
  { 461, 8, 14, 11, 2, -14 },
  { 475, 8, 14, 10, 2, -14 },
  { 489, 12, 15, 14, 1, -15 },
  { 512, 10, 14, 14, 2, -14 },
  { 530, 4, 14, 6, 1, -14 },
  { 537, 5, 18, 5, -2, -14 },
  { 549, 9, 14, 11, 2, -14 },
  { 565, 8, 14, 10, 2, -14 },
  { 579, 13, 14, 17, 2, -14 },
  { 602, 10, 14, 14, 2, -14 },
  { 620, 13, 15, 15, 1, -15 },
  { 645, 8, 14, 12, 2, -14 },
  { 659, 13, 18, 15, 1, -15 },
  { 689, 9, 14, 12, 2, -14 },
  { 705, 9, 14, 11, 1, -14 },
  { 721, 10, 14, 10, 0, -14 },
  { 739, 10, 14, 14, 2, -14 },
  { 757, 11, 14, 11, 0, -14 },
  { 777, 16, 14, 18, 1, -14 },
  { 805, 11, 14, 11, 0, -14 },
  { 825, 10, 14, 10, 0, -14 },
  { 843, 10, 14, 12, 1, -14 },
  { 861, 4, 17, 6, 2, -14 },
  { 870, 6, 14, 7, 0, -14 },
  { 881, 5, 17, 6, 0, -14 },
  { 892, 10, 8, 11, 1, -14 },
  { 902, 8, 1, 8, 0, 2 },
  { 903, 3, 3, 5, 1, -15 },
  { 905, 8, 11, 10, 1, -11 },
  { 916, 9, 15, 12, 2, -15 },
  { 933, 8, 11, 9, 1, -11 },
  { 944, 9, 15, 12, 1, -15 },
  { 961, 9, 11, 11, 1, -11 },
  { 974, 7, 15, 6, 0, -15 },
  { 988, 9, 16, 12, 1, -11 },
  { 1006, 8, 15, 12, 2, -15 },
  { 1021, 1, 14, 4, 2, -14 },
  { 1023, 4, 19, 4, -1, -14 },
  { 1033, 7, 15, 9, 2, -15 },
  { 1047, 1, 15, 4, 2, -15 },
  { 1049, 14, 11, 17, 2, -11 },
  { 1069, 8, 11, 12, 2, -11 },
  { 1080, 9, 11, 12, 1, -11 },
  { 1093, 9, 16, 12, 2, -11 },
  { 1111, 9, 16, 12, 1, -11 },
  { 1129, 5, 11, 8, 2, -11 },
  { 1136, 7, 11, 9, 1, -11 },
  { 1146, 6, 13, 7, 0, -13 },
  { 1156, 8, 11, 12, 2, -11 },
  { 1167, 9, 11, 9, 0, -11 },
  { 1180, 14, 11, 14, 0, -11 },
  { 1200, 9, 11, 10, 0, -11 },
  { 1213, 9, 16, 9, 0, -11 },
  { 1231, 7, 11, 9, 1, -11 },
  { 1241, 5, 17, 7, 1, -14 },
  { 1252, 1, 20, 11, 5, -15 },
  { 1255, 5, 17, 7, 1, -14 },
  { 1266, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_ExtraLight20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRALIGHT20PT7B_H_
