#ifndef _NOTOSANS_EXTRALIGHT24PT7B_H_
#define _NOTOSANS_EXTRALIGHT24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight24pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x82, 0xC0, 0x99, 0x99, 0x99, 0x04, 0x20, 0x10,
  0x80, 0x42, 0x01, 0x08, 0x08, 0x21, 0xFF, 0xF0, 0x84, 0x02, 0x10, 0x08,
  0x40, 0x41, 0x01, 0x08, 0x3F, 0xFE, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08,
  0x20, 0x21, 0x00, 0x08, 0x0F, 0x84, 0x9A, 0x20, 0x88, 0x22, 0x08, 0x83,
  0x20, 0x78, 0x03, 0x00, 0xB0, 0x22, 0x08, 0x82, 0x10, 0x88, 0x22, 0xCB,
  0x0F, 0x00, 0x80, 0x3C, 0x04, 0x22, 0x04, 0x10, 0x84, 0x10, 0x42, 0x08,
  0x22, 0x04, 0x11, 0x02, 0x09, 0x10, 0x84, 0xB6, 0x44, 0x91, 0x1E, 0x50,
  0x40, 0x48, 0x20, 0x44, 0x10, 0x22, 0x08, 0x21, 0x04, 0x10, 0x82, 0x10,
  0x22, 0x18, 0x0E, 0x00, 0x1F, 0x80, 0x20, 0x80, 0x81, 0x01, 0x02, 0x02,
  0x04, 0x02, 0x10, 0x02, 0x40, 0x03, 0x00, 0x1A, 0x00, 0x42, 0x05, 0x02,
  0x12, 0x02, 0x28, 0x02, 0x90, 0x03, 0x10, 0x06, 0x30, 0x32, 0x1F, 0x82,
  0xFC, 0x19, 0x08, 0x84, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x42,
  0x08, 0x21, 0x80, 0x84, 0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22,
  0x44, 0x80, 0x04, 0x00, 0x80, 0x10, 0x62, 0x33, 0xF8, 0x08, 0x02, 0x80,
  0x88, 0x11, 0x84, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF,
  0xC1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x55, 0xA0, 0xFC, 0xB0,
  0x03, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x40, 0x40, 0x80, 0x1F, 0x84, 0x09, 0x01, 0x20, 0x14, 0x02,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x14, 0x02, 0x80,
  0x48, 0x11, 0x06, 0x1F, 0x00, 0x0C, 0x56, 0x71, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x3F, 0x08, 0x10, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0xE0, 0x3F, 0x98, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x18, 0x1F, 0x80, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x14, 0x06, 0x7F, 0x00, 0x00, 0x80, 0x18, 0x02, 0x80, 0x28,
  0x04, 0x80, 0x88, 0x10, 0x81, 0x08, 0x20, 0x84, 0x08, 0x40, 0x88, 0x08,
  0x7F, 0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0x90, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x03, 0xFC, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x0E, 0x06, 0xFE, 0x00, 0x1F, 0x88, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0xE2, 0xC6, 0xC0, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14,
  0x05, 0x02, 0x3F, 0x00, 0xFF, 0xE0, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x00, 0x1F, 0x84, 0x09, 0x01, 0x20, 0x14, 0x04, 0xC0,
  0x8C, 0x20, 0x78, 0x1B, 0x04, 0x19, 0x01, 0xA0, 0x18, 0x03, 0x00, 0x50,
  0x0B, 0x02, 0x1F, 0x80, 0x3F, 0x0C, 0x19, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0A, 0x01, 0x40, 0x67, 0x74, 0x10, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x20, 0x0C, 0x7E, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x4C, 0x00, 0x00, 0x01,
  0x24, 0xA4, 0x00, 0x20, 0x18, 0x0C, 0x0E, 0x02, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x30, 0x38,
  0x18, 0x0C, 0x02, 0x00, 0x00, 0xFE, 0x03, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x00, 0x00, 0x20, 0x30, 0x01, 0xFC,
  0x00, 0xC0, 0x60, 0x60, 0x02, 0x10, 0x00, 0x62, 0x00, 0x04, 0x81, 0xF0,
  0x50, 0xC2, 0x0C, 0x10, 0x41, 0x84, 0x08, 0x30, 0x81, 0x06, 0x10, 0x20,
  0xC2, 0x04, 0x18, 0x21, 0x44, 0x86, 0x4D, 0x10, 0x30, 0x41, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x28, 0x01, 0x20, 0x04, 0x80, 0x21, 0x00, 0x84, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x81, 0xFF, 0x08, 0x04, 0x20, 0x11, 0x00, 0x24, 0x00, 0x90, 0x01,
  0x80, 0x04, 0xFF, 0x88, 0x04, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x48, 0x38, 0xFF, 0x88, 0x06, 0x80, 0x28, 0x01, 0x80, 0x18, 0x02, 0x80,
  0x28, 0x04, 0xFF, 0x80, 0x0F, 0xF3, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x03, 0x00, 0x0F, 0xF0, 0xFF, 0x84, 0x03, 0x20, 0x0D, 0x00,
  0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0A, 0x00, 0x90, 0x18, 0xFF, 0x00, 0xFF, 0xE0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFE, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x0F, 0xF9, 0x80, 0x58, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x81, 0xFC, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xA0, 0x05, 0x80, 0x26, 0x01, 0x0F, 0xF8, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF,
  0xFC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0xF8, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x1F, 0x00, 0x80, 0x38, 0x04, 0x80, 0x88, 0x10, 0x82, 0x08, 0x40,
  0x88, 0x09, 0x80, 0xAC, 0x0C, 0x40, 0x82, 0x08, 0x10, 0x81, 0x08, 0x08,
  0x80, 0x48, 0x06, 0x80, 0x30, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0xC0, 0xC0, 0x03, 0xA0, 0x03, 0xA0, 0x05, 0xA0, 0x05, 0x90,
  0x05, 0x90, 0x09, 0x88, 0x09, 0x88, 0x11, 0x88, 0x11, 0x84, 0x11, 0x84,
  0x21, 0x82, 0x21, 0x82, 0x41, 0x82, 0x41, 0x81, 0x41, 0x81, 0x81, 0x80,
  0x81, 0xC0, 0x0E, 0x00, 0x68, 0x03, 0x20, 0x19, 0x00, 0xC4, 0x06, 0x10,
  0x30, 0x81, 0x82, 0x0C, 0x08, 0x60, 0x63, 0x01, 0x18, 0x04, 0xC0, 0x36,
  0x00, 0xB0, 0x03, 0x80, 0x18, 0x1F, 0xE0, 0x40, 0x21, 0x00, 0x22, 0x00,
  0x28, 0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x28, 0x00, 0x48, 0x00, 0x90, 0x02, 0x18, 0x08, 0x0F,
  0xE0, 0xFF, 0x10, 0x1A, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x14, 0x02,
  0x81, 0x9F, 0xC2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x00, 0x1F, 0xE0, 0x40, 0x21, 0x00, 0x22, 0x00, 0x28, 0x00, 0x50, 0x00,
  0xA0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x28,
  0x00, 0x48, 0x00, 0x90, 0x02, 0x18, 0x08, 0x0F, 0xE0, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x80, 0xFF, 0x10, 0x1A, 0x01, 0x40, 0x38, 0x03,
  0x00, 0xA0, 0x14, 0x06, 0x83, 0x1F, 0xC2, 0x0C, 0x40, 0x88, 0x09, 0x01,
  0x20, 0x14, 0x03, 0x80, 0x20, 0x3F, 0xCC, 0x01, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x40, 0x10, 0x06, 0xFF, 0x00, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xA0, 0x05, 0x00, 0x44, 0x04, 0x1F, 0xC0, 0x80,
  0x0D, 0x00, 0x24, 0x00, 0x90, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x04,
  0x08, 0x10, 0x40, 0x21, 0x00, 0x84, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00,
  0x50, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x40, 0x38, 0x04, 0x02, 0x80, 0xA0,
  0x24, 0x0A, 0x02, 0x40, 0xA0, 0x44, 0x11, 0x04, 0x41, 0x10, 0x42, 0x11,
  0x08, 0x21, 0x10, 0x82, 0x20, 0x88, 0x12, 0x08, 0x81, 0x20, 0x90, 0x12,
  0x05, 0x01, 0x40, 0x50, 0x0C, 0x05, 0x00, 0xC0, 0x60, 0x08, 0x02, 0x00,
  0xC0, 0x11, 0x01, 0x08, 0x18, 0x20, 0x81, 0x88, 0x04, 0x40, 0x14, 0x00,
  0xC0, 0x06, 0x00, 0x28, 0x02, 0x40, 0x11, 0x01, 0x04, 0x10, 0x20, 0x80,
  0x88, 0x02, 0x80, 0x18, 0x80, 0x14, 0x03, 0x40, 0x22, 0x04, 0x10, 0x41,
  0x08, 0x08, 0x80, 0x90, 0x05, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0xF0, 0xFC, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80, 0xC0, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04,
  0x02, 0x02, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x1F, 0x80, 0x06, 0x00, 0x60, 0x09, 0x00, 0x90, 0x10,
  0x81, 0x08, 0x20, 0x42, 0x04, 0x40, 0x28, 0x03, 0xFF, 0xC0, 0xC4, 0x30,
  0x1F, 0x18, 0x60, 0x08, 0x02, 0x00, 0x40, 0x11, 0xFD, 0x81, 0x80, 0x60,
  0x38, 0x0D, 0x05, 0x7E, 0x40, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x3E, 0x28, 0x26, 0x02, 0xC0, 0x50, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x16, 0x02, 0xA0, 0x93, 0xE0, 0x0F, 0xCC, 0x02, 0x01, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x1F, 0xC0, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x1E, 0x4C, 0x2A, 0x03, 0x40, 0x28,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x0A, 0x03, 0x20, 0x63, 0xF4,
  0x0F, 0x06, 0x11, 0x81, 0x20, 0x24, 0x03, 0x00, 0x7F, 0xFC, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x10, 0x01, 0xFC, 0x0F, 0x10, 0x10, 0x10, 0x10, 0xFE,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x1F, 0x26, 0x15, 0x01, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x28, 0x05, 0x01, 0x90, 0x31, 0xFA, 0x00, 0x40, 0x08, 0x01, 0x00, 0x4C,
  0x18, 0x7C, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x27, 0xCA, 0x0B,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x8F, 0xFF, 0x80, 0x10, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x13, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x05, 0x04, 0x84, 0x44, 0x24, 0x16, 0x0C, 0x84, 0x22, 0x09, 0x04, 0x81,
  0x40, 0x40, 0xFF, 0xFF, 0xC0, 0x9E, 0x1E, 0x50, 0xB0, 0xB0, 0x30, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80,
  0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x9F, 0x28, 0x2C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x0F, 0x03, 0x0C, 0x40, 0x64, 0x02, 0x40, 0x2C, 0x02, 0x80,
  0x18, 0x01, 0x40, 0x24, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x9F, 0x14,
  0x13, 0x01, 0x60, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0B,
  0x01, 0x50, 0x49, 0xF1, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x00, 0x1F, 0x24, 0x15, 0x01, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x28, 0x05, 0x01, 0x90, 0x51, 0xF2, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x9F, 0x43, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x00, 0x3F, 0x20, 0x60, 0x10, 0x04, 0x03, 0x00, 0x70,
  0x06, 0x00, 0x80, 0x40, 0x30, 0x2F, 0xE0, 0x20, 0x40, 0x87, 0xF2, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x0F, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0D, 0x05,
  0x3E, 0x40, 0x80, 0x30, 0x09, 0x01, 0x20, 0x42, 0x08, 0x41, 0x08, 0x40,
  0x88, 0x11, 0x01, 0x40, 0x28, 0x06, 0x00, 0x40, 0x80, 0x80, 0xA0, 0x40,
  0x90, 0x50, 0x48, 0x28, 0x22, 0x14, 0x21, 0x11, 0x10, 0x88, 0x88, 0x44,
  0x44, 0x14, 0x14, 0x0A, 0x0A, 0x05, 0x05, 0x03, 0x01, 0x80, 0x80, 0x80,
  0x80, 0x50, 0x24, 0x10, 0x8C, 0x12, 0x03, 0x00, 0x80, 0x70, 0x12, 0x08,
  0xC4, 0x11, 0x02, 0x80, 0x40, 0x80, 0x30, 0x09, 0x01, 0x20, 0x42, 0x08,
  0x41, 0x08, 0x40, 0x88, 0x11, 0x01, 0x40, 0x28, 0x06, 0x00, 0x40, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x02, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x40, 0x40,
  0x40, 0x60, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x0F, 0xF8, 0x0C,
  0x42, 0x08, 0x20, 0x82, 0x08, 0x21, 0x8C, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x04, 0x04, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x10, 0x18, 0xC1, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x0C,
  0x00, 0x18, 0x18, 0xC6, 0x07, 0x00,
};

const GFXglyph NotoSans_ExtraLight24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 17, 6, 2, -17 },
  { 6, 4, 6, 8, 2, -17 },
  { 9, 14, 17, 16, 1, -17 },
  { 39, 10, 19, 14, 2, -18 },
  { 63, 17, 17, 19, 1, -17 },
  { 100, 15, 17, 17, 1, -17 },
  { 132, 1, 6, 4, 2, -17 },
  { 133, 5, 21, 6, 1, -17 },
  { 147, 4, 21, 6, 1, -17 },
  { 158, 11, 10, 13, 1, -18 },
  { 172, 11, 11, 14, 1, -14 },
  { 188, 2, 6, 5, 1, -3 },
  { 190, 6, 1, 8, 1, -7 },
  { 191, 2, 2, 6, 2, -2 },
  { 192, 8, 17, 8, 0, -17 },
  { 209, 11, 17, 14, 1, -17 },
  { 233, 6, 17, 14, 2, -17 },
  { 246, 11, 17, 14, 1, -17 },
  { 270, 11, 17, 14, 1, -17 },
  { 294, 12, 17, 14, 1, -17 },
  { 320, 10, 17, 14, 2, -17 },
  { 342, 10, 17, 14, 2, -17 },
  { 364, 11, 17, 14, 1, -17 },
  { 388, 11, 17, 14, 1, -17 },
  { 412, 11, 17, 14, 1, -17 },
  { 436, 2, 13, 6, 2, -13 },
  { 440, 3, 16, 6, 1, -13 },
  { 446, 11, 11, 14, 1, -14 },
  { 462, 11, 5, 14, 1, -11 },
  { 469, 11, 11, 14, 1, -14 },
  { 485, 8, 17, 10, 1, -17 },
  { 502, 19, 19, 21, 1, -17 },
  { 548, 14, 17, 14, 0, -17 },
  { 578, 12, 17, 15, 2, -17 },
  { 604, 12, 17, 15, 2, -17 },
  { 630, 13, 17, 17, 2, -17 },
  { 658, 10, 17, 13, 2, -17 },
  { 680, 10, 17, 12, 2, -17 },
  { 702, 13, 17, 17, 2, -17 },
  { 730, 13, 17, 17, 2, -17 },
  { 758, 5, 17, 7, 1, -17 },
  { 769, 5, 21, 6, -2, -17 },
  { 783, 12, 17, 14, 2, -17 },
  { 809, 10, 17, 12, 2, -17 },
  { 831, 16, 17, 20, 2, -17 },
  { 865, 13, 17, 17, 2, -17 },
  { 893, 15, 17, 18, 2, -17 },
  { 925, 11, 17, 14, 2, -17 },
  { 949, 15, 21, 18, 2, -17 },
  { 989, 11, 17, 14, 2, -17 },
  { 1013, 11, 17, 13, 1, -17 },
  { 1037, 12, 17, 12, 0, -17 },
  { 1063, 13, 17, 17, 2, -17 },
  { 1091, 14, 17, 14, 0, -17 },
  { 1121, 20, 17, 21, 1, -17 },
  { 1164, 13, 17, 13, 0, -17 },
  { 1192, 12, 17, 12, 0, -17 },
  { 1218, 12, 17, 14, 1, -17 },
  { 1244, 5, 21, 8, 2, -17 },
  { 1258, 8, 17, 8, 0, -17 },
  { 1275, 5, 21, 8, 1, -17 },
  { 1289, 12, 10, 14, 1, -17 },
  { 1304, 10, 1, 10, 0, 2 },
  { 1306, 4, 3, 6, 1, -18 },
  { 1308, 10, 13, 13, 1, -13 },
  { 1325, 11, 18, 14, 2, -18 },
  { 1350, 10, 13, 11, 1, -13 },
  { 1367, 11, 18, 14, 1, -18 },
  { 1392, 11, 13, 13, 1, -13 },
  { 1410, 8, 18, 7, 0, -18 },
  { 1428, 11, 19, 14, 1, -13 },
  { 1455, 10, 18, 14, 2, -18 },
  { 1478, 1, 17, 5, 2, -17 },
  { 1481, 4, 23, 5, -1, -17 },
  { 1493, 9, 18, 11, 2, -18 },
  { 1514, 1, 18, 5, 2, -18 },
  { 1517, 17, 13, 21, 2, -13 },
  { 1545, 10, 13, 14, 2, -13 },
  { 1562, 12, 13, 14, 1, -13 },
  { 1582, 11, 19, 14, 2, -13 },
  { 1609, 11, 19, 14, 1, -13 },
  { 1636, 7, 13, 9, 2, -13 },
  { 1648, 9, 13, 11, 1, -13 },
  { 1663, 7, 16, 8, 0, -16 },
  { 1677, 10, 13, 14, 2, -13 },
  { 1694, 11, 13, 11, 0, -13 },
  { 1712, 17, 13, 17, 0, -13 },
  { 1740, 10, 13, 12, 1, -13 },
  { 1757, 11, 19, 11, 0, -13 },
  { 1784, 9, 13, 11, 1, -13 },
  { 1799, 6, 21, 8, 1, -17 },
  { 1815, 1, 24, 13, 6, -18 },
  { 1818, 7, 21, 8, 1, -17 },
  { 1837, 11, 3, 14, 1, -10 },
};

const GFXfont NotoSans_ExtraLight24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRALIGHT24PT7B_H_
