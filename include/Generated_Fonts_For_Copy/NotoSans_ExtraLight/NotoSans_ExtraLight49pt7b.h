#ifndef _NOTOSANS_EXTRALIGHT49PT7B_H_
#define _NOTOSANS_EXTRALIGHT49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight49pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00,
  0x00, 0xFF, 0x80, 0x60, 0xD8, 0x34, 0x0D, 0x03, 0x40, 0xD0, 0x34, 0x0D,
  0x03, 0x40, 0xD0, 0x34, 0x0D, 0x03, 0x40, 0xC0, 0x00, 0x0C, 0x01, 0x00,
  0x00, 0x40, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x00,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x08, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x40, 0x08, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x08, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x60, 0x08, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0xE3, 0x86, 0x0E, 0x70, 0x60, 0x06, 0x06, 0x00, 0xC0,
  0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0E,
  0x06, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x3C, 0x60, 0x00, 0xF6, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x06, 0x78, 0x00, 0x61,
  0xC0, 0x06, 0x06, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x01, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x07, 0x00,
  0x60, 0xEE, 0x06, 0x1C, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x1C,
  0x70, 0x00, 0x20, 0x1C, 0x0C, 0x00, 0x30, 0x0C, 0x06, 0x00, 0x30, 0x04,
  0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x60, 0x04, 0x06, 0x00,
  0x30, 0x02, 0x02, 0x00, 0x18, 0x01, 0x03, 0x00, 0x0C, 0x00, 0x83, 0x00,
  0x06, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x61, 0x87, 0xF1, 0x80, 0x30, 0xC7,
  0x1C, 0x40, 0x18, 0xC7, 0x03, 0x30, 0x18, 0x63, 0x01, 0x9C, 0x0C, 0x61,
  0x00, 0x67, 0x1C, 0x21, 0x80, 0x31, 0xFC, 0x30, 0xC0, 0x18, 0x00, 0x30,
  0x60, 0x0C, 0x00, 0x18, 0x30, 0x02, 0x00, 0x18, 0x18, 0x01, 0x00, 0x0C,
  0x0C, 0x00, 0x80, 0x0C, 0x06, 0x00, 0x40, 0x06, 0x03, 0x00, 0x20, 0x06,
  0x01, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x10, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x01, 0x80, 0x07, 0x03, 0x00,
  0xC0, 0x01, 0xC7, 0x00, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x06,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x18, 0x70, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x18, 0xC0, 0x1C, 0x00, 0x66, 0x00, 0x38, 0x03, 0x18, 0x00,
  0x70, 0x0C, 0xC0, 0x00, 0xE0, 0x33, 0x00, 0x01, 0xC1, 0x8C, 0x00, 0x03,
  0x8E, 0x30, 0x00, 0x07, 0x30, 0xC0, 0x00, 0x0F, 0x83, 0x00, 0x00, 0x1E,
  0x0E, 0x00, 0x00, 0x78, 0x18, 0x00, 0x03, 0xF0, 0x30, 0x00, 0x1C, 0xE0,
  0xF0, 0x01, 0xC1, 0xC0, 0xF0, 0x7E, 0x03, 0x81, 0xFF, 0xE0, 0x07, 0x6D,
  0x24, 0x92, 0x49, 0x24, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60,
  0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x07, 0x01, 0x80, 0x60, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0,
  0x60, 0x60, 0x70, 0x30, 0x30, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x1C, 0x04, 0x07, 0xFC, 0x21, 0xF8, 0x7D, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0xE0, 0x00, 0x0D, 0x80, 0x00, 0xC4, 0x00, 0x06, 0x30, 0x00, 0x60, 0xC0,
  0x06, 0x07, 0x00, 0x70, 0x18, 0x07, 0x00, 0x60, 0x10, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x19, 0xCC, 0x63, 0x19, 0x8C, 0x62, 0x31, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0xFC, 0x00, 0x78, 0x78, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x04, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x26, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0E,
  0x00, 0x1C, 0x18, 0x00, 0x60, 0x38, 0x03, 0x00, 0x78, 0x78, 0x00, 0x7F,
  0x80, 0x00, 0x60, 0x3C, 0x0F, 0x83, 0xB1, 0xC6, 0x70, 0xDC, 0x1E, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x07, 0xFE, 0x00, 0xF8, 0x7C, 0x1E, 0x00, 0x70, 0xC0, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0x7E, 0x1F, 0x03, 0x80, 0x0E, 0x18, 0x00, 0x0C, 0x40, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0xE0, 0x00, 0xE3, 0xF8, 0x1F, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xBF, 0xE0, 0x0F, 0xFF, 0xE0, 0x60,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x90, 0x00, 0x18, 0xC0, 0x03, 0x87, 0xC0, 0xF8, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0x03, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x10, 0x7F, 0xE0, 0xC7, 0x81, 0xE3,
  0x30, 0x01, 0xCD, 0x80, 0x03, 0x3C, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x01, 0x86, 0x00, 0x06, 0x1C, 0x00, 0x30, 0x38, 0x01, 0x80, 0x78,
  0x3C, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3C, 0x1F, 0x01, 0xC0,
  0x0E, 0x0E, 0x00, 0x1C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x0C,
  0x00, 0x1C, 0x18, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x78, 0x70, 0x00, 0x7F,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0xF0, 0x38, 0x07, 0x00, 0x38,
  0x38, 0x00, 0x71, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x66, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x38, 0x00, 0xE0,
  0x3C, 0x1F, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3C, 0x1E, 0x01,
  0x80, 0x1C, 0x0C, 0x00, 0x38, 0x60, 0x00, 0x61, 0x80, 0x00, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x60, 0x00, 0x2D, 0xC0, 0x01, 0xB3, 0x80, 0x0C, 0xC7, 0x81,
  0xE2, 0x07, 0xFE, 0x18, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x80, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0xFF, 0xA0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x39, 0xCE, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9C, 0xC6, 0x31, 0x98,
  0xC6, 0x23, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x7E, 0x3E, 0x20, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x07, 0xF0, 0x01, 0x18, 0x00, 0x7F, 0xF8, 0x06,
  0x60, 0x07, 0x00, 0x40, 0x19, 0x80, 0x38, 0x01, 0x00, 0x6C, 0x01, 0xC0,
  0x04, 0x00, 0xB0, 0x06, 0x00, 0x10, 0x03, 0xC0, 0x30, 0x00, 0x40, 0x0F,
  0x00, 0xC0, 0x03, 0x00, 0x38, 0x03, 0x00, 0x0C, 0x00, 0xE0, 0x0C, 0x00,
  0x30, 0x03, 0x80, 0x20, 0x00, 0xC0, 0x0A, 0x00, 0x80, 0x03, 0x00, 0x28,
  0x03, 0x00, 0x0C, 0x01, 0xA0, 0x0C, 0x00, 0x30, 0x06, 0xC0, 0x30, 0x01,
  0xC0, 0x1B, 0x00, 0xC0, 0x05, 0x00, 0xCC, 0x01, 0x80, 0x36, 0x03, 0x30,
  0x03, 0x03, 0x9C, 0x38, 0x60, 0x07, 0xFC, 0x3F, 0xC1, 0x80, 0x07, 0x80,
  0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x10, 0x00, 0x03,
  0xC0, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0x00, 0x07, 0x86, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x98, 0x00,
  0x03, 0x30, 0x00, 0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x06,
  0x30, 0x00, 0x18, 0x60, 0x03, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83,
  0x00, 0x01, 0xC6, 0x00, 0x01, 0xCC, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x1E, 0x00, 0x08, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x80, 0x3E, 0x07, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x0C, 0x00, 0x1E, 0x03, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x1C, 0x30,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC3,
  0x00, 0x01, 0xC0, 0xC0, 0x03, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0xD8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7C, 0x07, 0xF0,
  0x1E, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x13,
  0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x1C, 0x00,
  0x00, 0x10, 0xE0, 0x00, 0x01, 0x07, 0x00, 0x00, 0x10, 0x3C, 0x00, 0x03,
  0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0xFF, 0x9F, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1F, 0x3F,
  0xE0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xE8, 0x1C, 0xFF, 0x83, 0xC0, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x33, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0x63, 0xC0, 0x00, 0xCD, 0x80, 0x01, 0xB1, 0x80, 0x03, 0xC3,
  0x80, 0x07, 0x03, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x07, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0E,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x1C,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x1B,
  0xCC, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x63,
  0xC6, 0x00, 0x00, 0x63, 0xC6, 0x00, 0x00, 0x43, 0xC3, 0x00, 0x00, 0xC3,
  0xC3, 0x00, 0x00, 0xC3, 0xC3, 0x00, 0x01, 0x83, 0xC1, 0x80, 0x01, 0x83,
  0xC1, 0x80, 0x01, 0x03, 0xC0, 0xC0, 0x03, 0x03, 0xC0, 0xC0, 0x03, 0x03,
  0xC0, 0xC0, 0x06, 0x03, 0xC0, 0x60, 0x06, 0x03, 0xC0, 0x60, 0x0C, 0x03,
  0xC0, 0x30, 0x0C, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0xC0, 0x30, 0x18, 0x03,
  0xC0, 0x18, 0x18, 0x03, 0xC0, 0x18, 0x30, 0x03, 0xC0, 0x0C, 0x30, 0x03,
  0xC0, 0x0C, 0x30, 0x03, 0xC0, 0x0C, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03,
  0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1E,
  0xE0, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xC7, 0x00, 0x01,
  0xE1, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x0C, 0x00,
  0x1E, 0x03, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0x60, 0x03, 0xC0, 0x18,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x00, 0xC0, 0x3C, 0x00,
  0x70, 0x1E, 0x00, 0x18, 0x0F, 0x00, 0x06, 0x07, 0x80, 0x03, 0x83, 0xC0,
  0x00, 0xC1, 0xE0, 0x00, 0x30, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x06, 0x3C,
  0x00, 0x01, 0x9E, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x37, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x30,
  0x00, 0xF1, 0x80, 0x01, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0C,
  0xC0, 0x00, 0xE6, 0x00, 0x1E, 0x30, 0x1F, 0xC1, 0xFF, 0xF8, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C, 0x01, 0xC0, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0x00,
  0x0F, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x66, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x06, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x70, 0xC0, 0x01, 0xC1, 0x80, 0x1F, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60,
  0x03, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x38, 0x03, 0xFF,
  0xC0, 0x7C, 0x3F, 0x8F, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x80, 0x01,
  0xC7, 0xF0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x1C,
  0x1E, 0x00, 0x3C, 0x03, 0xE0, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06,
  0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0x00, 0x01, 0x98,
  0x00, 0x07, 0x00, 0x00, 0xCC, 0x00, 0x02, 0x80, 0x00, 0x63, 0x00, 0x03,
  0x60, 0x00, 0x31, 0x80, 0x01, 0xB0, 0x00, 0x30, 0xC0, 0x00, 0xD8, 0x00,
  0x18, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x18, 0x00, 0x63, 0x00, 0x06, 0x0C,
  0x00, 0x31, 0x80, 0x06, 0x06, 0x00, 0x10, 0x40, 0x03, 0x01, 0x00, 0x18,
  0x30, 0x01, 0x80, 0xC0, 0x0C, 0x18, 0x01, 0x80, 0x60, 0x06, 0x0C, 0x00,
  0xC0, 0x30, 0x02, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x01, 0x80, 0xC0,
  0x18, 0x0C, 0x00, 0x60, 0x60, 0x0C, 0x0E, 0x00, 0x30, 0x30, 0x06, 0x06,
  0x00, 0x18, 0x10, 0x01, 0x83, 0x00, 0x04, 0x18, 0x00, 0xC1, 0x80, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00,
  0x0C, 0x60, 0x00, 0x33, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x01,
  0xE0, 0x00, 0x34, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x0C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xB0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x0E, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x43, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80,
  0x01, 0x81, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x03, 0xFF, 0x01, 0xF8, 0xF8, 0x18, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x01, 0xFF, 0x03,
  0xFF, 0xF0, 0xF0, 0x03, 0x3C, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x76,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF6, 0x00, 0x0B,
  0x60, 0x01, 0xB7, 0x00, 0x33, 0x3C, 0x1E, 0x30, 0xFF, 0x83, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x7F, 0xC0, 0xC7, 0x83, 0xC3, 0x30, 0x03,
  0x8D, 0x80, 0x07, 0x34, 0x00, 0x0C, 0xF0, 0x00, 0x1B, 0x80, 0x00, 0x6E,
  0x00, 0x01, 0xB8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8,
  0x00, 0x0E, 0xF0, 0x00, 0x33, 0x60, 0x01, 0x8C, 0xC0, 0x0E, 0x31, 0xC1,
  0xE0, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0xFC, 0x3C, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x01, 0x07, 0x81, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0xFF, 0xC3, 0x0F, 0x87, 0x8C, 0x70, 0x03, 0x33, 0x80, 0x06, 0xCC,
  0x00, 0x0B, 0x60, 0x00, 0x3D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x0F, 0x70, 0x00,
  0x2C, 0xE0, 0x01, 0xB1, 0xC0, 0x0C, 0xC3, 0xC1, 0xE3, 0x03, 0xFE, 0x0C,
  0x03, 0xFF, 0x00, 0x3C, 0x3C, 0x03, 0x00, 0x70, 0x30, 0x00, 0xC3, 0x00,
  0x06, 0x38, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x02, 0x07, 0x81, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x03,
  0xC3, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0xFF, 0x0C, 0x3E, 0x1E, 0x31, 0xC0, 0x0C, 0xCE, 0x00, 0x1B, 0x30, 0x00,
  0x3D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x3C, 0xC0, 0x00, 0xB3,
  0x80, 0x06, 0xC7, 0x00, 0x33, 0x0F, 0x07, 0x8C, 0x0F, 0xF8, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x06, 0x1F,
  0x00, 0x70, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x1F, 0xF0, 0xC7, 0x87, 0xCC, 0xC0, 0x0E, 0xD8, 0x00, 0x6D, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0x80, 0x00, 0x1B, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x83, 0x3F, 0x87, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xEC, 0x00,
  0x19, 0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x06,
  0x03, 0x01, 0x80, 0x60, 0x70, 0x0C, 0x1C, 0x01, 0x87, 0x00, 0x31, 0xC0,
  0x06, 0x3C, 0x00, 0xCD, 0xC0, 0x1B, 0x1C, 0x03, 0xC1, 0x80, 0x70, 0x18,
  0x0C, 0x03, 0x81, 0x80, 0x38, 0x30, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x07,
  0x18, 0x00, 0x73, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x0E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0xFE, 0x03, 0xFE,
  0x18, 0xE1, 0xE1, 0xE1, 0xE3, 0x30, 0x0E, 0x70, 0x0E, 0x6C, 0x00, 0xCC,
  0x00, 0xEF, 0x00, 0x0F, 0x00, 0x0D, 0xC0, 0x01, 0xC0, 0x01, 0xB8, 0x00,
  0x38, 0x00, 0x17, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x40, 0x00, 0x78,
  0x00, 0x08, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x01, 0xE0, 0x00, 0x20, 0x00,
  0x3C, 0x00, 0x04, 0x00, 0x07, 0x80, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x10,
  0x00, 0x1E, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x00, 0x40, 0x00, 0x78, 0x00,
  0x08, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x01, 0xE0, 0x00, 0x20, 0x00, 0x3C,
  0x00, 0x04, 0x00, 0x07, 0x80, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x10, 0x00,
  0x1E, 0x00, 0x02, 0x00, 0x03, 0xC0, 0x00, 0x40, 0x00, 0x78, 0x00, 0x08,
  0x00, 0x0C, 0xC1, 0xFF, 0x0C, 0x78, 0x7C, 0xCC, 0x00, 0xED, 0x80, 0x06,
  0xD0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x01, 0xFF, 0x00, 0x0F, 0x0F,
  0x80, 0x30, 0x03, 0x80, 0xC0, 0x03, 0x83, 0x00, 0x03, 0x8C, 0x00, 0x03,
  0x18, 0x00, 0x07, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x19, 0x80,
  0x00, 0x33, 0x00, 0x00, 0xE6, 0x00, 0x01, 0x86, 0x00, 0x07, 0x06, 0x00,
  0x1C, 0x0E, 0x00, 0x70, 0x07, 0x87, 0xC0, 0x07, 0xFE, 0x00, 0xC1, 0xFF,
  0x03, 0x1E, 0x0F, 0x0C, 0xE0, 0x0E, 0x36, 0x00, 0x1C, 0xD0, 0x00, 0x33,
  0xC0, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xB8, 0x00, 0x06, 0xF0, 0x00, 0x1B, 0x40, 0x00, 0xCD, 0x80,
  0x07, 0x33, 0x00, 0x38, 0xC7, 0x87, 0xC3, 0x0F, 0xFC, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x08, 0x7C, 0x3C, 0x47, 0x00, 0x32,
  0x70, 0x00, 0xD3, 0x00, 0x02, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x03, 0xB8,
  0x00, 0x14, 0xC0, 0x01, 0xA3, 0x80, 0x19, 0x0F, 0x07, 0x88, 0x3F, 0xF0,
  0x40, 0x08, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0xC3, 0xFF, 0x1E, 0x3C, 0xC0, 0x36,
  0x00, 0xD0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x07, 0xFF, 0x07, 0x83, 0xF3, 0x00, 0x09, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x0E, 0xF8, 0x0F,
  0x0F, 0xFF, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0xC0, 0xFF, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x76, 0x00, 0x0F, 0x60, 0x01, 0xB3, 0x80, 0x3B, 0x1E,
  0x0F, 0x30, 0xFF, 0xC1, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x60, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x20, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x03, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x23, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x05, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xB0, 0x00, 0x70, 0x00, 0xCC, 0x00, 0x2C, 0x00, 0x66, 0x00, 0x36, 0x00,
  0x33, 0x00, 0x1B, 0x00, 0x30, 0xC0, 0x08, 0xC0, 0x18, 0x60, 0x0C, 0x60,
  0x0C, 0x30, 0x06, 0x30, 0x06, 0x18, 0x02, 0x0C, 0x06, 0x06, 0x03, 0x06,
  0x03, 0x03, 0x01, 0x83, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0,
  0x60, 0xC0, 0x30, 0x60, 0x30, 0x60, 0x18, 0x30, 0x08, 0x30, 0x0C, 0x30,
  0x06, 0x10, 0x03, 0x18, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x8C, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x26, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1B, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x06,
  0x06, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0xC0, 0x01, 0x86, 0x00, 0x07, 0x30, 0x00, 0x0D, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x33, 0x00,
  0x01, 0x86, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x30, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0xC0, 0x70, 0x03, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x0C, 0x60, 0x00,
  0x3B, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x60, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x03, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x23, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3C, 0x03, 0xF0, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x7C,
  0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0x80, 0x1E, 0x0F, 0x80, 0xE0, 0x07, 0xFE, 0x80, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraLight49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 35, 11, 4, -35 },
  { 15, 10, 13, 17, 3, -35 },
  { 32, 29, 35, 32, 1, -35 },
  { 159, 20, 40, 28, 3, -37 },
  { 259, 33, 35, 39, 3, -35 },
  { 404, 30, 36, 35, 3, -36 },
  { 539, 3, 13, 9, 3, -35 },
  { 544, 9, 43, 13, 2, -35 },
  { 593, 9, 43, 13, 2, -35 },
  { 642, 21, 20, 27, 3, -37 },
  { 695, 22, 23, 28, 3, -29 },
  { 759, 5, 12, 10, 2, -6 },
  { 767, 12, 2, 16, 2, -14 },
  { 770, 3, 3, 11, 4, -3 },
  { 772, 15, 35, 16, 1, -35 },
  { 838, 22, 36, 28, 3, -36 },
  { 937, 11, 35, 28, 5, -35 },
  { 986, 21, 35, 28, 3, -35 },
  { 1078, 22, 35, 28, 2, -35 },
  { 1175, 26, 35, 28, 1, -35 },
  { 1289, 21, 35, 28, 4, -35 },
  { 1381, 22, 36, 28, 3, -36 },
  { 1480, 22, 35, 28, 3, -35 },
  { 1577, 22, 35, 28, 3, -35 },
  { 1674, 22, 36, 28, 3, -35 },
  { 1773, 3, 26, 11, 4, -26 },
  { 1783, 5, 32, 11, 2, -26 },
  { 1803, 22, 22, 28, 3, -29 },
  { 1864, 22, 11, 28, 3, -23 },
  { 1895, 22, 22, 28, 3, -29 },
  { 1956, 17, 35, 20, 2, -35 },
  { 2031, 38, 40, 43, 3, -35 },
  { 2221, 29, 35, 29, 0, -35 },
  { 2348, 23, 35, 30, 5, -35 },
  { 2449, 26, 35, 30, 3, -35 },
  { 2563, 26, 35, 34, 5, -35 },
  { 2677, 19, 35, 27, 5, -35 },
  { 2761, 19, 35, 24, 5, -35 },
  { 2845, 28, 36, 35, 3, -36 },
  { 2971, 25, 35, 35, 5, -35 },
  { 3081, 9, 35, 14, 3, -35 },
  { 3121, 12, 44, 12, -5, -35 },
  { 3187, 23, 35, 28, 5, -35 },
  { 3288, 19, 35, 25, 5, -35 },
  { 3372, 32, 35, 42, 5, -35 },
  { 3512, 25, 35, 35, 5, -35 },
  { 3622, 31, 36, 37, 3, -36 },
  { 3762, 21, 35, 28, 5, -35 },
  { 3854, 31, 44, 37, 3, -36 },
  { 4025, 23, 35, 29, 5, -35 },
  { 4126, 21, 35, 27, 3, -35 },
  { 4218, 25, 35, 25, 0, -35 },
  { 4328, 25, 35, 35, 5, -35 },
  { 4438, 28, 35, 28, 0, -35 },
  { 4561, 41, 35, 43, 1, -35 },
  { 4741, 26, 35, 26, 0, -35 },
  { 4855, 25, 35, 25, 0, -35 },
  { 4965, 24, 35, 28, 2, -35 },
  { 5070, 10, 43, 15, 4, -35 },
  { 5124, 15, 35, 16, 1, -35 },
  { 5190, 10, 43, 15, 1, -35 },
  { 5244, 24, 21, 28, 2, -35 },
  { 5307, 20, 2, 20, 0, 4 },
  { 5312, 9, 8, 13, 2, -38 },
  { 5321, 20, 26, 26, 2, -26 },
  { 5386, 22, 37, 29, 4, -37 },
  { 5488, 19, 26, 23, 3, -26 },
  { 5550, 22, 37, 29, 3, -37 },
  { 5652, 21, 26, 27, 3, -26 },
  { 5721, 16, 37, 14, 1, -37 },
  { 5795, 22, 38, 29, 3, -26 },
  { 5900, 20, 37, 29, 4, -37 },
  { 5993, 3, 35, 11, 4, -35 },
  { 6007, 10, 47, 11, -3, -35 },
  { 6066, 19, 37, 23, 4, -37 },
  { 6154, 2, 37, 11, 4, -37 },
  { 6164, 35, 26, 43, 4, -26 },
  { 6278, 20, 26, 29, 4, -26 },
  { 6343, 23, 26, 28, 3, -26 },
  { 6418, 22, 37, 29, 4, -26 },
  { 6520, 21, 37, 29, 3, -26 },
  { 6618, 14, 26, 19, 4, -26 },
  { 6664, 18, 26, 23, 2, -26 },
  { 6723, 14, 32, 16, 1, -32 },
  { 6779, 20, 26, 29, 4, -26 },
  { 6844, 22, 26, 22, 0, -26 },
  { 6916, 33, 26, 35, 1, -26 },
  { 7024, 22, 26, 24, 1, -26 },
  { 7096, 22, 38, 22, 0, -26 },
  { 7201, 18, 26, 22, 2, -26 },
  { 7260, 14, 43, 17, 1, -35 },
  { 7336, 2, 49, 26, 12, -37 },
  { 7349, 14, 43, 17, 2, -35 },
  { 7425, 22, 5, 28, 3, -20 },
};

const GFXfont NotoSans_ExtraLight49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRALIGHT49PT7B_H_
