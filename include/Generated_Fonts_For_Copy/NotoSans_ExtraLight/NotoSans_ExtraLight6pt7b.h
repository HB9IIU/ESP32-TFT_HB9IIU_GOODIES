#ifndef _NOTOSANS_EXTRALIGHT6PT7B_H_
#define _NOTOSANS_EXTRALIGHT6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x6F, 0xEA, 0x5F, 0x3E, 0xDB, 0x75, 0xE4, 0xBF, 0x80,
  0xF8, 0xF8, 0x55, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A, 0xF6, 0xF0,
  0xF0, 0xE5, 0x70, 0xEC, 0xF0, 0x2F, 0x90, 0xE8, 0xF0, 0xFA, 0xF0, 0xE5,
  0x20, 0xEA, 0xF0, 0xF5, 0xB0, 0xA0, 0xB0, 0x39, 0x80, 0xFC, 0x8F, 0x00,
  0xD8, 0x7F, 0xF7, 0x47, 0x00, 0x46, 0xA9, 0xFF, 0xF8, 0x86, 0xF6, 0xF0,
  0xFB, 0xFA, 0xFA, 0x97, 0xBE, 0xD0, 0xF0, 0x55, 0xC0, 0xEB, 0xAB, 0x9B,
  0xBD, 0xB7, 0xD0, 0xF9, 0x97, 0xFA, 0xF9, 0x97, 0x10, 0xFB, 0xF8, 0xF0,
  0xE9, 0x20, 0xB6, 0xF0, 0xB5, 0x20, 0xAD, 0x54, 0xA0, 0xA9, 0x50, 0xA9,
  0x20, 0xE9, 0x70, 0xF8, 0xA5, 0xF8, 0x54, 0xC0, 0x80, 0x7F, 0x80, 0xAF,
  0xC0, 0xF3, 0x80, 0x2E, 0xDE, 0xFB, 0x80, 0x7A, 0x80, 0xF6, 0xB0, 0xAF,
  0xC0, 0xF0, 0xF8, 0xBA, 0xC0, 0xF8, 0xFD, 0xD0, 0xFC, 0xF7, 0x80, 0xFE,
  0xF7, 0x90, 0xE0, 0xCB, 0x80, 0xEB, 0xB7, 0x80, 0xB9, 0x00, 0xF5, 0xA0,
  0xAA, 0x80, 0xB9, 0x60, 0xEB, 0x80, 0xEA, 0x40, 0xFE, 0xD5, 0xC0, 0xE0,
};

const GFXglyph NotoSans_ExtraLight6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 5, 0, -4 },
  { 9, 4, 4, 4, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 1, 5, 2, 0, -4 },
  { 13, 1, 5, 2, 0, -4 },
  { 14, 3, 3, 3, 0, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 4, 3, 1, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 1, 3, 1, 0, -3 },
  { 42, 1, 4, 1, 0, -3 },
  { 43, 3, 3, 3, 0, -4 },
  { 45, 3, 2, 3, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 2, 4, 3, 0, -4 },
  { 49, 5, 5, 5, 0, -4 },
  { 53, 4, 4, 4, 0, -4 },
  { 55, 2, 4, 4, 1, -4 },
  { 56, 4, 4, 4, 0, -4 },
  { 58, 3, 4, 4, 1, -4 },
  { 60, 2, 4, 3, 1, -4 },
  { 61, 2, 4, 3, 1, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 3, 4, 4, 1, -4 },
  { 66, 1, 4, 2, 0, -4 },
  { 67, 2, 5, 1, -1, -4 },
  { 69, 2, 4, 3, 1, -4 },
  { 70, 2, 4, 3, 1, -4 },
  { 71, 4, 4, 5, 1, -4 },
  { 73, 3, 4, 4, 1, -4 },
  { 75, 4, 4, 5, 0, -4 },
  { 77, 2, 4, 3, 1, -4 },
  { 78, 4, 5, 5, 0, -4 },
  { 81, 2, 4, 4, 1, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 4, 1, -4 },
  { 88, 3, 4, 3, 0, -4 },
  { 90, 5, 4, 5, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 1, 5, 2, 1, -4 },
  { 100, 2, 4, 2, 0, -4 },
  { 101, 1, 5, 2, 0, -4 },
  { 102, 3, 2, 3, 0, -4 },
  { 103, 2, 1, 2, 0, 0 },
  { 104, 1, 1, 2, 0, -5 },
  { 105, 3, 3, 3, 0, -3 },
  { 107, 2, 5, 4, 1, -5 },
  { 109, 3, 3, 3, 0, -3 },
  { 111, 3, 5, 4, 0, -5 },
  { 113, 3, 3, 3, 0, -3 },
  { 115, 2, 5, 2, 0, -5 },
  { 117, 3, 4, 4, 0, -3 },
  { 119, 2, 5, 3, 1, -5 },
  { 121, 1, 4, 1, 0, -4 },
  { 122, 1, 5, 1, 0, -4 },
  { 123, 2, 5, 3, 1, -5 },
  { 125, 1, 5, 1, 0, -5 },
  { 126, 4, 3, 5, 1, -3 },
  { 128, 2, 3, 3, 1, -3 },
  { 129, 3, 3, 3, 0, -3 },
  { 131, 2, 4, 4, 1, -3 },
  { 132, 3, 4, 4, 0, -3 },
  { 134, 1, 3, 2, 1, -3 },
  { 135, 3, 3, 3, 0, -3 },
  { 137, 2, 4, 2, 0, -4 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 3, 3, 3, 0, -3 },
  { 142, 4, 3, 4, 0, -3 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 3, 4, 3, 0, -3 },
  { 148, 3, 3, 3, 0, -3 },
  { 150, 2, 5, 2, 0, -4 },
  { 152, 1, 7, 3, 1, -5 },
  { 153, 2, 5, 2, 0, -4 },
  { 155, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraLight6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRALIGHT6PT7B_H_
