#ifndef _NOTOSANS_EXTRALIGHT68PT7B_H_
#define _NOTOSANS_EXTRALIGHT68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight68pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x6F,
  0xFF, 0xF4, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x03, 0x80, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x01, 0x80, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x01, 0xF8, 0xC1, 0xFC, 0x1E, 0x06, 0x01, 0xC1, 0xE0, 0x30,
  0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x30, 0x03, 0x00, 0x03, 0x80, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0xE0,
  0x06, 0x00, 0x07, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0xE0, 0x0C,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x01, 0xE0, 0xC0, 0x00, 0x07, 0xC6, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0x7F, 0x00, 0x00, 0x18, 0x7C, 0x00, 0x00, 0xC0, 0xF0, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0xC0, 0x07, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x00, 0xF3,
  0x00, 0x18, 0x0F, 0x1F, 0x80, 0xC1, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x03,
  0x80, 0x38, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x60, 0x00, 0x18, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x07, 0x00, 0x07, 0x03, 0x00, 0xF8, 0x0E, 0x00, 0x0C,
  0x0E, 0x07, 0xFC, 0x1C, 0x00, 0x18, 0x18, 0x3F, 0xFC, 0x18, 0x00, 0x70,
  0x70, 0xF0, 0x1C, 0x38, 0x00, 0xE0, 0xC1, 0xC0, 0x18, 0x70, 0x01, 0x83,
  0x87, 0x00, 0x38, 0x70, 0x07, 0x06, 0x0E, 0x00, 0x30, 0xE0, 0x1C, 0x1C,
  0x18, 0x00, 0x70, 0xF0, 0x70, 0x70, 0x70, 0x00, 0xE0, 0xFF, 0xC0, 0xC0,
  0xE0, 0x00, 0xC0, 0x7F, 0x03, 0x81, 0x80, 0x01, 0x80, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE1,
  0xF0, 0x00, 0x00, 0x00, 0x1D, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x1C,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0x00,
  0x61, 0xC0, 0x00, 0x1E, 0x00, 0x38, 0x70, 0x00, 0x03, 0xC0, 0x0E, 0x38,
  0x00, 0x00, 0x78, 0x07, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xC3, 0x80, 0x00,
  0x01, 0xE0, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x38, 0x38, 0x00, 0x00, 0x07,
  0x9C, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x60, 0x00, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x07, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x1C, 0x00, 0x00,
  0x7C, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0xFC, 0x00, 0x7E, 0x00,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDB, 0x6D, 0xB6, 0xD8,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x0F, 0xF8, 0x06, 0x03, 0xFF,
  0xF8, 0x20, 0x7F, 0x87, 0xF9, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x38, 0x18, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x61,
  0x8E, 0x30, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF, 0xF4,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xF0, 0x1E, 0x60, 0x78, 0xC1, 0xE1,
  0x8F, 0x03, 0x3C, 0x06, 0xF0, 0x0F, 0x80, 0x1A, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x07, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0xF8,
  0x00, 0x1E, 0x07, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x08, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x88, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0x3F, 0x80, 0x03,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x38, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x02, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC8, 0x00, 0x00,
  0x3C, 0x70, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x7F,
  0xC0, 0x06, 0x03, 0xFF, 0xF0, 0x0C, 0x1F, 0xC3, 0xF8, 0x18, 0xF0, 0x00,
  0x78, 0x33, 0xC0, 0x00, 0x78, 0x6E, 0x00, 0x00, 0x71, 0xD8, 0x00, 0x00,
  0x73, 0xE0, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00,
  0xDE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0B, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x01,
  0xF0, 0x1E, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1B, 0x38, 0x00,
  0x00, 0xCC, 0x70, 0x00, 0x07, 0x31, 0xE0, 0x00, 0x79, 0xC3, 0xF0, 0x07,
  0xC7, 0x03, 0xFF, 0xFC, 0x1C, 0x03, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x02, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0x40, 0x1E, 0x3C, 0x78, 0xF0, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x87, 0x0E, 0x38,
  0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x06, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0x03, 0xF0,
  0x70, 0x00, 0x78, 0x40, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xE3, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x06, 0x30, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x67,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x76, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x3E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x07,
  0xC0, 0x03, 0x00, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x06, 0xC0, 0x03, 0x00, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x0E, 0xC0, 0x03, 0x80, 0x00, 0xF8, 0x00, 0xCE, 0x00, 0x1C, 0x00,
  0x1D, 0x80, 0x1C, 0xE0, 0x00, 0xE0, 0x03, 0x98, 0x03, 0x86, 0x00, 0x0F,
  0x00, 0x71, 0xC0, 0x78, 0x60, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0x07, 0x00,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0x00, 0x7E, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x81, 0xC0, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x7C, 0x38, 0x00,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0,
  0x03, 0xF0, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0x20, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x02, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x01, 0xFC,
  0x00, 0xE0, 0x00, 0x03, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0xE0, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xB8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x78, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE1, 0xF0, 0x00,
  0x00, 0xE3, 0xF0, 0x00, 0x00, 0xE7, 0x38, 0x00, 0x00, 0xEE, 0x1C, 0x00,
  0x00, 0xFC, 0x1E, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xDC, 0x00, 0x00, 0x00, 0x03, 0xFD, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xCC, 0x00, 0x00, 0x00, 0x07, 0x7C, 0xE0, 0x00, 0x00, 0x00,
  0x77, 0xCE, 0x00, 0x00, 0x00, 0x06, 0x7C, 0x70, 0x00, 0x00, 0x00, 0xE7,
  0xC7, 0x00, 0x00, 0x00, 0x0E, 0x7C, 0x30, 0x00, 0x00, 0x01, 0xC7, 0xC3,
  0x80, 0x00, 0x00, 0x1C, 0x7C, 0x18, 0x00, 0x00, 0x01, 0x87, 0xC1, 0xC0,
  0x00, 0x00, 0x38, 0x7C, 0x1C, 0x00, 0x00, 0x03, 0x87, 0xC0, 0xC0, 0x00,
  0x00, 0x70, 0x7C, 0x0E, 0x00, 0x00, 0x07, 0x07, 0xC0, 0x60, 0x00, 0x00,
  0x60, 0x7C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0xC0, 0x70, 0x00, 0x00, 0xC0,
  0x7C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x7C,
  0x01, 0x80, 0x00, 0x18, 0x07, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x7C, 0x01,
  0xC0, 0x00, 0x30, 0x07, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x7C, 0x00, 0xE0,
  0x00, 0x70, 0x07, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x7C, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x7C, 0x00, 0x18, 0x01, 0x80, 0x07,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x7C, 0x00, 0x1C, 0x03, 0x00, 0x07, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x7C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x7C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0x9C, 0x00, 0x07, 0xC0, 0x00, 0x39, 0xC0,
  0x00, 0x7C, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x0F, 0x07, 0x00,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x07, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0xFE, 0x0E,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x78,
  0xE0, 0x00, 0x0F, 0x87, 0x00, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0x40, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0x00,
  0x01, 0xFC, 0x0E, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3E, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x01, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x05, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0x1C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x38, 0x0C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x60,
  0x07, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x07, 0x00, 0x06, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x06,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x07, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0x70, 0xF8, 0x00, 0x0E, 0x3C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xD8, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x37, 0x70,
  0x00, 0x0E, 0xE7, 0x00, 0x03, 0x8C, 0x78, 0x01, 0xE1, 0x87, 0xFF, 0xF8,
  0x30, 0x7F, 0xFC, 0x06, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x00, 0xE0, 0x7F, 0xFC, 0x03,
  0x87, 0xFF, 0xFC, 0x0E, 0x3C, 0x00, 0xF8, 0x39, 0xC0, 0x00, 0xF0, 0xEE,
  0x00, 0x01, 0xE3, 0xB0, 0x00, 0x03, 0x8D, 0x80, 0x00, 0x07, 0x36, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0x73, 0xE0, 0x00, 0x03,
  0xCD, 0xC0, 0x00, 0x0E, 0x33, 0x80, 0x00, 0x70, 0xC7, 0x00, 0x07, 0x83,
  0x0F, 0x00, 0x7C, 0x0C, 0x1F, 0xFF, 0xE0, 0x30, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xC0, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x10, 0x3E, 0x00, 0x1C, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x07, 0x00, 0x7F, 0xF8, 0x1C, 0x07,
  0xFF, 0xF8, 0x70, 0x3E, 0x00, 0xF0, 0xC1, 0xE0, 0x00, 0xE3, 0x0E, 0x00,
  0x01, 0xCC, 0x70, 0x00, 0x03, 0xB3, 0xC0, 0x00, 0x06, 0xCE, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xB1,
  0xC0, 0x00, 0x0E, 0xC7, 0x80, 0x00, 0x33, 0x0F, 0x00, 0x03, 0x8C, 0x1F,
  0x00, 0x3C, 0x30, 0x3F, 0xFF, 0xE0, 0xC0, 0x3F, 0xFE, 0x03, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0x38, 0x07, 0x80, 0x00, 0xE0,
  0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xFC, 0x01, 0xF8, 0x70, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x30, 0x1F, 0xFF,
  0xE0, 0xC0, 0xF8, 0x01, 0xE3, 0x07, 0x80, 0x01, 0xCC, 0x38, 0x00, 0x03,
  0x31, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1F, 0x38, 0x00, 0x00, 0x3C,
  0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0xC7, 0x00,
  0x00, 0x3F, 0x1E, 0x00, 0x01, 0xDC, 0x3C, 0x00, 0x0E, 0x70, 0x7C, 0x00,
  0xF1, 0xC0, 0x7F, 0xFF, 0x87, 0x00, 0xFF, 0xF8, 0x1C, 0x00, 0x1F, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x20, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x7F, 0xFC, 0x0E, 0x1F, 0xFF, 0xE0,
  0xE3, 0xC0, 0x0F, 0x8E, 0x70, 0x00, 0x3C, 0xEE, 0x00, 0x01, 0xCF, 0xC0,
  0x00, 0x0E, 0xF8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x06, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x77,
  0xBE, 0xE6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x00, 0x70, 0x07, 0x80, 0x3E, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xF2, 0x0F,
  0x1F, 0xF0, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xB8,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xE1, 0xE0, 0x00, 0x38, 0xFC, 0x00, 0x0E, 0x73, 0x80, 0x03, 0xB8, 0x70,
  0x00, 0xFC, 0x1C, 0x00, 0x3E, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0xC7, 0x80, 0x3C, 0x1F, 0x00,
  0xF8, 0xCE, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xCC, 0x00, 0x0F, 0x30, 0x00,
  0x1C, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x0C, 0x07,
  0xFF, 0xC0, 0xC1, 0xFF, 0xFF, 0x0C, 0x3C, 0x00, 0xF8, 0xC7, 0x00, 0x03,
  0xCC, 0xE0, 0x00, 0x1C, 0xCC, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x6F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x03, 0x01, 0xFF, 0xF0, 0x0C, 0x0F, 0xFF, 0xF0,
  0x30, 0xF0, 0x03, 0xE0, 0xC7, 0x80, 0x03, 0xC3, 0x18, 0x00, 0x07, 0x8C,
  0xC0, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0x1C, 0xF8, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x3B, 0xE0, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x07, 0x3F, 0x00, 0x00,
  0x38, 0xEE, 0x00, 0x01, 0xC3, 0x9C, 0x00, 0x0F, 0x0E, 0x3C, 0x00, 0xF8,
  0x38, 0x7F, 0xFF, 0x80, 0xE0, 0x7F, 0xF8, 0x03, 0x80, 0x1F, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x30, 0x1F, 0xFF, 0xE0, 0xC0, 0xF0, 0x03, 0xC3, 0x07,
  0x00, 0x03, 0x8C, 0x38, 0x00, 0x07, 0x71, 0xC0, 0x00, 0x0F, 0xCE, 0x00,
  0x00, 0x1F, 0x38, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x01,
  0xF3, 0x80, 0x00, 0x07, 0xC7, 0x00, 0x00, 0x37, 0x1E, 0x00, 0x01, 0xDC,
  0x3C, 0x00, 0x0E, 0x70, 0x7C, 0x00, 0xF1, 0xC0, 0xFF, 0xFF, 0x87, 0x00,
  0xFF, 0xF8, 0x1C, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0x18, 0x0F, 0xFF, 0x07, 0xFF, 0xF1, 0xE0,
  0x1E, 0x70, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xE0, 0x01, 0xE3, 0xC0, 0x00, 0x11, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x3E, 0x00, 0x0F, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xDC, 0x00, 0x00, 0xDB, 0xC0, 0x00, 0x33, 0x3C, 0x00, 0x1E, 0x63,
  0xE0, 0x0F, 0x8C, 0x3F, 0xFF, 0xC1, 0x81, 0xFF, 0xE0, 0x30, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x60,
  0x00, 0x30, 0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x77, 0x00, 0x00, 0x78, 0x00, 0x01, 0x9C, 0x00, 0x01,
  0xF0, 0x00, 0x0E, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x3B,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0xEE, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x18,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x70, 0x60, 0x00, 0x71, 0xC0,
  0x01, 0x81, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x0C, 0x00,
  0x38, 0x0C, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0xE0, 0x03,
  0x00, 0xE0, 0x07, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x30, 0x03, 0x80, 0xE0, 0x03,
  0x81, 0xC0, 0x06, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x38,
  0x18, 0x00, 0x70, 0x70, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0xC3,
  0x80, 0x03, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xE6, 0x00,
  0x01, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00,
  0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0, 0x0C,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0x30, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x0F, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x02, 0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x81, 0xE8, 0x00, 0x0F, 0xFF, 0x90, 0x00, 0x07, 0xFC,
  0x00,
};

const GFXglyph NotoSans_ExtraLight68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 50, 16, 6, -49 },
  { 26, 13, 18, 23, 5, -49 },
  { 56, 40, 49, 44, 2, -49 },
  { 301, 29, 56, 39, 4, -52 },
  { 504, 47, 50, 54, 4, -49 },
  { 798, 42, 50, 48, 4, -49 },
  { 1061, 3, 18, 12, 5, -49 },
  { 1068, 13, 60, 18, 3, -49 },
  { 1166, 13, 60, 18, 2, -49 },
  { 1264, 29, 28, 37, 4, -52 },
  { 1366, 31, 32, 39, 4, -40 },
  { 1490, 6, 17, 14, 3, -8 },
  { 1503, 16, 3, 22, 3, -20 },
  { 1509, 4, 6, 16, 6, -5 },
  { 1512, 21, 49, 23, 1, -49 },
  { 1641, 31, 50, 39, 4, -49 },
  { 1835, 15, 49, 39, 7, -49 },
  { 1927, 30, 49, 39, 4, -49 },
  { 2111, 31, 50, 39, 3, -49 },
  { 2305, 36, 49, 39, 2, -49 },
  { 2526, 29, 50, 39, 5, -49 },
  { 2708, 31, 50, 39, 4, -49 },
  { 2902, 31, 49, 39, 4, -49 },
  { 3092, 30, 50, 39, 4, -49 },
  { 3280, 30, 50, 39, 4, -49 },
  { 3468, 4, 37, 16, 6, -36 },
  { 3487, 7, 45, 16, 3, -36 },
  { 3527, 31, 31, 39, 4, -40 },
  { 3648, 31, 16, 39, 4, -32 },
  { 3710, 31, 31, 39, 4, -40 },
  { 3831, 24, 50, 28, 2, -49 },
  { 3981, 52, 55, 60, 4, -48 },
  { 4339, 40, 49, 40, 0, -49 },
  { 4584, 31, 49, 42, 7, -49 },
  { 4774, 36, 50, 42, 4, -49 },
  { 4999, 36, 49, 48, 7, -49 },
  { 5220, 26, 49, 37, 7, -49 },
  { 5380, 26, 49, 34, 7, -49 },
  { 5540, 40, 50, 49, 4, -49 },
  { 5790, 35, 49, 48, 7, -49 },
  { 6005, 12, 49, 20, 4, -49 },
  { 6079, 16, 61, 16, -6, -49 },
  { 6201, 32, 49, 39, 7, -49 },
  { 6397, 26, 49, 35, 7, -49 },
  { 6557, 44, 49, 58, 7, -49 },
  { 6827, 34, 49, 48, 7, -49 },
  { 7036, 43, 50, 52, 4, -49 },
  { 7305, 29, 49, 39, 7, -49 },
  { 7483, 43, 61, 52, 4, -49 },
  { 7811, 31, 49, 40, 7, -49 },
  { 8001, 29, 50, 37, 4, -49 },
  { 8183, 35, 49, 35, 0, -49 },
  { 8398, 36, 50, 49, 6, -49 },
  { 8623, 39, 49, 39, 0, -49 },
  { 8862, 56, 49, 60, 2, -49 },
  { 9205, 36, 49, 36, 0, -49 },
  { 9426, 35, 49, 35, 0, -49 },
  { 9641, 35, 49, 39, 2, -49 },
  { 9856, 14, 60, 21, 6, -49 },
  { 9961, 21, 49, 23, 1, -49 },
  { 10090, 14, 60, 21, 2, -49 },
  { 10195, 33, 30, 39, 3, -49 },
  { 10319, 27, 2, 27, 0, 6 },
  { 10326, 12, 11, 17, 3, -52 },
  { 10343, 27, 38, 35, 3, -37 },
  { 10472, 30, 53, 40, 6, -52 },
  { 10671, 26, 38, 32, 4, -37 },
  { 10795, 30, 53, 40, 4, -52 },
  { 10994, 29, 38, 37, 4, -37 },
  { 11132, 23, 52, 20, 1, -52 },
  { 11282, 30, 53, 40, 4, -37 },
  { 11481, 28, 52, 40, 6, -52 },
  { 11663, 5, 49, 15, 5, -49 },
  { 11694, 13, 65, 15, -3, -49 },
  { 11800, 26, 52, 32, 6, -52 },
  { 11969, 3, 52, 15, 6, -52 },
  { 11989, 48, 37, 59, 6, -37 },
  { 12211, 28, 37, 40, 6, -37 },
  { 12341, 32, 38, 40, 4, -37 },
  { 12493, 30, 53, 40, 6, -37 },
  { 12692, 30, 53, 40, 4, -37 },
  { 12891, 19, 37, 26, 6, -37 },
  { 12979, 25, 38, 31, 3, -37 },
  { 13098, 19, 46, 22, 1, -45 },
  { 13208, 27, 37, 40, 6, -36 },
  { 13333, 30, 36, 30, 0, -36 },
  { 13468, 46, 36, 48, 1, -36 },
  { 13675, 29, 36, 33, 2, -36 },
  { 13806, 30, 52, 30, 0, -36 },
  { 14001, 25, 36, 31, 3, -36 },
  { 14114, 19, 60, 24, 2, -49 },
  { 14257, 2, 69, 37, 17, -52 },
  { 14275, 20, 60, 24, 2, -49 },
  { 14425, 31, 6, 39, 4, -27 },
};

const GFXfont NotoSans_ExtraLight68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRALIGHT68PT7B_H_
