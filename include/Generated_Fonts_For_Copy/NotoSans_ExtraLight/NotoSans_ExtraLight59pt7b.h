#ifndef _NOTOSANS_EXTRALIGHT59PT7B_H_
#define _NOTOSANS_EXTRALIGHT59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight59pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0x40, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x3C, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x20, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x1F, 0x18, 0x7E, 0x38, 0x18, 0x0C, 0x70, 0x18, 0x00,
  0x60, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xE0, 0x18, 0x00,
  0xE0, 0x18, 0x00, 0x70, 0x18, 0x00, 0x38, 0x18, 0x00, 0x1E, 0x18, 0x00,
  0x0F, 0x98, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1B, 0xE0, 0x00, 0x18, 0xF8, 0x00, 0x18, 0x3C, 0x00, 0x18, 0x0E,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x07, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x18, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x1E, 0xC0, 0x18, 0x3C,
  0xFE, 0x19, 0xF0, 0x7F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x07, 0x8F, 0x00, 0x00, 0xE0,
  0x03, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x60, 0x00, 0x60, 0x01, 0x80,
  0x38, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01, 0xC0, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x01, 0xC0, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x81, 0x80, 0x00,
  0x30, 0x01, 0xC1, 0x81, 0xF0, 0x18, 0x00, 0xC1, 0xC3, 0xFE, 0x0C, 0x00,
  0x60, 0xC3, 0xC3, 0x86, 0x00, 0x30, 0xE1, 0x80, 0xE1, 0x80, 0x38, 0x61,
  0x80, 0x30, 0xC0, 0x18, 0x60, 0xC0, 0x1C, 0x30, 0x1C, 0x30, 0xC0, 0x06,
  0x1E, 0x3C, 0x30, 0x60, 0x03, 0x07, 0xFC, 0x18, 0x30, 0x01, 0xC0, 0x70,
  0x18, 0x18, 0x00, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x0E,
  0x00, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x06,
  0x00, 0x06, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x18,
  0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x60,
  0x00, 0x18, 0x0E, 0x00, 0x30, 0x00, 0x0F, 0x9E, 0x00, 0x30, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x1C, 0x01, 0xC0, 0x00, 0xC3,
  0x80, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0x70, 0x01, 0xC6, 0x00, 0x03, 0x80,
  0x18, 0xE0, 0x00, 0x1C, 0x01, 0x8C, 0x00, 0x00, 0xE0, 0x38, 0xC0, 0x00,
  0x07, 0x03, 0x0C, 0x00, 0x00, 0x38, 0x70, 0xC0, 0x00, 0x01, 0xCE, 0x0C,
  0x00, 0x00, 0x0E, 0xC0, 0xC0, 0x00, 0x00, 0x7C, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x7C, 0x06, 0x00, 0x00, 0x0E, 0xE0, 0x70, 0x00,
  0x03, 0xC7, 0x03, 0x80, 0x00, 0x78, 0x38, 0x1E, 0x00, 0x1E, 0x01, 0xC0,
  0xFF, 0xFF, 0xC0, 0x0E, 0x03, 0xFF, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0xD9, 0x24, 0x90, 0x00, 0x70, 0x0C, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xF0,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x40, 0x0C, 0x00, 0x5C, 0x03, 0x00, 0xFF, 0xE0, 0xC1, 0xFC, 0x3F,
  0x33, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x33, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x0C,
  0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x71, 0xC7, 0x18,
  0x63, 0x8E, 0x30, 0xC7, 0x18, 0x61, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xEF, 0xFF, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xC3, 0xE0,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x18, 0x00, 0x06, 0x03, 0x80,
  0x01, 0xC0, 0x38, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0x3F, 0x7F, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E,
  0x07, 0xB0, 0x79, 0x87, 0x0C, 0xF0, 0x6F, 0x03, 0xE0, 0x1A, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFE,
  0x1F, 0x00, 0x78, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x1F, 0x80, 0xF8, 0x00,
  0x70, 0xF0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x72, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x3C, 0x3F, 0xFB, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x38, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0xE0, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0D, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x01, 0xC3, 0xC0, 0x01, 0xE0, 0x7F, 0xDF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xE0, 0x70, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x0F, 0xF0, 0x0C, 0x1F, 0xFF, 0x83, 0x0F, 0x00, 0xF0,
  0xCF, 0x00, 0x0E, 0x33, 0x00, 0x01, 0xCD, 0x80, 0x00, 0x3B, 0xC0, 0x00,
  0x06, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x07, 0x80, 0x1C, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7C,
  0x1F, 0x80, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x0C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x01,
  0xC0, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E, 0xE0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x1E, 0x00, 0x3C, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xB8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x0C, 0x0C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x3E, 0x70, 0x00, 0x0F, 0xC6, 0x00, 0x03, 0xB8, 0xF0, 0x00, 0xE7,
  0x07, 0x80, 0xF8, 0xC0, 0x7F, 0xFC, 0x18, 0x01, 0xFC, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xC7, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x6F, 0xFF, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF,
  0x40, 0x0C, 0x3C, 0x78, 0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x30, 0x60,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0x1F, 0x8E,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x07, 0xFC, 0x00, 0x30, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x63, 0x00, 0x07, 0x80, 0x38, 0x01, 0x8C, 0x00, 0x38, 0x00,
  0xC0, 0x06, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x1D, 0x80, 0x0E, 0x00, 0x0C,
  0x00, 0x36, 0x00, 0x30, 0x00, 0x30, 0x00, 0xD8, 0x01, 0xC0, 0x00, 0xC0,
  0x03, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xF0, 0x03, 0x00, 0x00, 0xC0, 0x03,
  0xC0, 0x0C, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x7C,
  0x00, 0xC0, 0x00, 0x30, 0x01, 0xB0, 0x03, 0x80, 0x01, 0xC0, 0x06, 0xC0,
  0x06, 0x00, 0x07, 0x00, 0x1B, 0x80, 0x18, 0x00, 0x1C, 0x00, 0xE6, 0x00,
  0x70, 0x00, 0xF0, 0x03, 0x18, 0x00, 0xC0, 0x06, 0x60, 0x1C, 0x60, 0x03,
  0x80, 0x39, 0x80, 0xE1, 0x80, 0x07, 0x83, 0xC3, 0x8F, 0x03, 0x00, 0x0F,
  0xFC, 0x07, 0xF8, 0x0C, 0x00, 0x07, 0x80, 0x07, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x01, 0x83, 0x80, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x1C, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0x00, 0x01, 0xF8, 0x60, 0x00, 0x07, 0x8C,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x30, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x01, 0xC3, 0x00,
  0x03, 0xF0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0x80, 0x00, 0x7C,
  0x30, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x01, 0xD8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x30, 0x00, 0x03, 0xC6, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x07, 0xC0, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x40, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x01, 0xE0, 0xC0,
  0x00, 0x00, 0xF0, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x1F, 0x00, 0xC0,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xD8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFC,
  0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x0C, 0x07,
  0x80, 0x00, 0x03, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xEF,
  0xF8, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x3A, 0x01, 0xCF,
  0xFE, 0x3F, 0xF0, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1C, 0xC0, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00,
  0x1C, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x0C, 0x7E, 0x00,
  0x00, 0xCE, 0x70, 0x00, 0x0D, 0xC3, 0x80, 0x00, 0xF8, 0x38, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF6, 0x00, 0x00,
  0x00, 0x1F, 0xD8, 0x00, 0x00, 0x00, 0x6F, 0x70, 0x00, 0x00, 0x03, 0xBC,
  0xC0, 0x00, 0x00, 0x0C, 0xF3, 0x80, 0x00, 0x00, 0x33, 0xC6, 0x00, 0x00,
  0x01, 0xCF, 0x18, 0x00, 0x00, 0x06, 0x3C, 0x70, 0x00, 0x00, 0x38, 0xF0,
  0xC0, 0x00, 0x00, 0xC3, 0xC3, 0x80, 0x00, 0x03, 0x0F, 0x06, 0x00, 0x00,
  0x1C, 0x3C, 0x18, 0x00, 0x00, 0x60, 0xF0, 0x70, 0x00, 0x03, 0x83, 0xC0,
  0xC0, 0x00, 0x0C, 0x0F, 0x03, 0x80, 0x00, 0x30, 0x3C, 0x06, 0x00, 0x01,
  0x80, 0xF0, 0x18, 0x00, 0x06, 0x03, 0xC0, 0x70, 0x00, 0x38, 0x0F, 0x00,
  0xC0, 0x00, 0xC0, 0x3C, 0x03, 0x80, 0x03, 0x00, 0xF0, 0x06, 0x00, 0x18,
  0x03, 0xC0, 0x18, 0x00, 0x60, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x80, 0x30, 0x03, 0xC0, 0x06, 0x01, 0x80,
  0x0F, 0x00, 0x18, 0x06, 0x00, 0x3C, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x00,
  0xC0, 0xC0, 0x03, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x00, 0x06, 0x18, 0x00,
  0x3C, 0x00, 0x1C, 0x60, 0x00, 0xF0, 0x00, 0x33, 0x80, 0x03, 0xC0, 0x00,
  0xCC, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x0F, 0x01, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0xF0, 0x01, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0xE0,
  0x0F, 0x00, 0x01, 0x80, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x18, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x30,
  0x00, 0x7E, 0x18, 0x00, 0x07, 0x8C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x03, 0xB0, 0x00, 0x03, 0x98, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xC6, 0x00,
  0x0F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x38,
  0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0x00, 0x07, 0xE0, 0x60, 0x00, 0x1E,
  0x0C, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x1C, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x30, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x38, 0x60, 0x00, 0x1E, 0x0C, 0x00, 0x0F, 0x81, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x18,
  0x00, 0x30, 0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x9F, 0xF8, 0x3C, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x8E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x72, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x02, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x70,
  0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x07, 0xC0,
  0x00, 0x06, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x0E, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x1C, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x1C,
  0x00, 0x70, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x06, 0x00, 0x30, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x06,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x03,
  0x01, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x01, 0x81, 0xC0, 0x03,
  0x81, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x01,
  0x83, 0x80, 0x00, 0xC3, 0x80, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x80, 0x01,
  0xC3, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x63, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x76, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x70, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x70, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x60, 0x0E,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x38, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x7F,
  0x07, 0xC0, 0xE0, 0x01, 0xC1, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0x07, 0xF0, 0x06, 0x3C, 0x00, 0x0C, 0xE0, 0x00, 0x1B,
  0x80, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x5F, 0x00,
  0x01, 0xB7, 0x00, 0x06, 0x6F, 0x00, 0x38, 0xCF, 0xE7, 0xE1, 0x87, 0xFF,
  0x03, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x0F,
  0xE0, 0x0C, 0x0F, 0xFF, 0x03, 0x0F, 0x83, 0xE0, 0xC7, 0x00, 0x1C, 0x33,
  0x00, 0x03, 0x8D, 0x80, 0x00, 0x73, 0x60, 0x00, 0x0C, 0xF0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x60,
  0x00, 0x1C, 0xD8, 0x00, 0x06, 0x33, 0x00, 0x07, 0x8C, 0x70, 0x03, 0xC3,
  0x0F, 0xDF, 0xC0, 0xC1, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xF0, 0xF8, 0x1E, 0x00, 0x10, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x01, 0xC0, 0x3F, 0xFC, 0x38,
  0x1F, 0x03, 0xC7, 0x07, 0x00, 0x1C, 0xE1, 0xC0, 0x00, 0xDC, 0x70, 0x00,
  0x0F, 0x8C, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1E, 0x60, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x03, 0xCC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1F,
  0x1C, 0x00, 0x06, 0x61, 0xC0, 0x01, 0xCC, 0x1E, 0x00, 0x71, 0x81, 0xFD,
  0xFC, 0x30, 0x0F, 0xFE, 0x06, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x81, 0xE0, 0x00, 0xC0, 0x1F,
  0xDF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xE0, 0x20, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x0C, 0x0F, 0xC1, 0xE3,
  0x83, 0x80, 0x06, 0x70, 0xE0, 0x00, 0x6E, 0x38, 0x00, 0x07, 0xC6, 0x00,
  0x00, 0xF9, 0xC0, 0x00, 0x0F, 0x30, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x30,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x8E, 0x00, 0x03,
  0x70, 0xE0, 0x00, 0xEE, 0x0F, 0x00, 0x39, 0xC0, 0xFE, 0xFE, 0x38, 0x07,
  0xFF, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x3C, 0x1F, 0x80, 0x1F, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3F, 0x80, 0xE0, 0xFF, 0xF0, 0xE3,
  0xE0, 0xF8, 0xE7, 0x00, 0x1C, 0xCC, 0x00, 0x0E, 0xD8, 0x00, 0x06, 0xD0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xDF, 0xF4, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03,
  0xA0, 0xE7, 0xF8, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xB8, 0x00, 0x0E,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x06, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x1E,
  0x00, 0x0C, 0x3E, 0x00, 0x18, 0xCC, 0x00, 0x33, 0x1C, 0x00, 0x6C, 0x1C,
  0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x18, 0x03, 0x80, 0x38, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x38, 0x00, 0x70, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0x61, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x60, 0xFF, 0xE0, 0x1F, 0xFC, 0x31, 0xF0, 0xF8, 0x3E, 0x0F, 0x99,
  0xC0, 0x0E, 0x38, 0x01, 0xCC, 0xC0, 0x03, 0xB8, 0x00, 0x76, 0xC0, 0x01,
  0xD8, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00,
  0x07, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0x80, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x07, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x3F, 0x80, 0xC0, 0xFF, 0xF0, 0xC3, 0xE0,
  0xF8, 0xC7, 0x00, 0x1C, 0xCC, 0x00, 0x0E, 0xD8, 0x00, 0x06, 0xD0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x38, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x01,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x30, 0x3F, 0xFC, 0x0C, 0x3E, 0x0F, 0x83, 0x1C, 0x00,
  0x78, 0xCE, 0x00, 0x0E, 0x33, 0x00, 0x01, 0xCD, 0x80, 0x00, 0x3B, 0x40,
  0x00, 0x06, 0xF0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0xF0, 0x00, 0x01, 0xBC, 0x00, 0x00,
  0xED, 0x80, 0x00, 0x73, 0xF0, 0x00, 0x1C, 0xEE, 0x00, 0x0E, 0x39, 0xC0,
  0x0F, 0x0E, 0x3F, 0xFF, 0x83, 0x83, 0xFF, 0x80, 0xE0, 0x0C, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC,
  0x30, 0x3E, 0x07, 0x8C, 0x1C, 0x00, 0x73, 0x0E, 0x00, 0x06, 0xC7, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x3C, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x60,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0x70, 0x00,
  0x1B, 0x0E, 0x00, 0x0C, 0xC3, 0xC0, 0x0F, 0x30, 0x3F, 0x3F, 0x0C, 0x07,
  0xFF, 0x83, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x3E, 0x60, 0xFF, 0xF0, 0xF8, 0xD9, 0xC0, 0x0C, 0xC0, 0x06, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x3E, 0x03, 0xF0, 0xE0, 0x00, 0x43, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE8, 0x00, 0x03, 0x9E, 0x00, 0x0E, 0x3F, 0xE7,
  0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1F, 0xBC, 0x07, 0xFE, 0x00, 0x30, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x60,
  0x00, 0x0B, 0x70, 0x00, 0x1B, 0x38, 0x00, 0x33, 0x3C, 0x00, 0xE3, 0x1F,
  0xDF, 0xC3, 0x07, 0xFF, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03,
  0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x18, 0x1C, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x06,
  0x00, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xC0,
  0x03, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x03,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x36,
  0x00, 0x0E, 0x30, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x00, 0x66, 0x00, 0x0C,
  0x30, 0x00, 0x63, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0x00, 0x18, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0x18, 0x00, 0xC3, 0x80, 0x18, 0x1C, 0x01, 0xC1, 0x80,
  0x38, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x0C, 0x01, 0x81, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0xC0, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x06, 0x03, 0x00,
  0xE0, 0x60, 0x06, 0x07, 0x00, 0x60, 0x60, 0x07, 0x06, 0x00, 0x60, 0xE0,
  0x03, 0x06, 0x00, 0x70, 0xC0, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0x39, 0xC0, 0x01, 0x9C, 0x00, 0x19,
  0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x30, 0x00,
  0x38, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x06,
  0x01, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x06, 0x1C, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x18, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x18, 0x00,
  0x38, 0x07, 0x00, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x70, 0x06, 0x00, 0x18, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x03, 0x80, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x38, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x05, 0xE1, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0xF8, 0x00, 0x3F, 0xFD, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_ExtraLight59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 43, 14, 5, -42 },
  { 23, 12, 15, 20, 4, -42 },
  { 46, 34, 42, 38, 2, -42 },
  { 225, 24, 48, 34, 4, -45 },
  { 369, 41, 44, 47, 3, -43 },
  { 595, 36, 44, 42, 4, -43 },
  { 793, 3, 15, 11, 4, -42 },
  { 799, 12, 51, 16, 2, -42 },
  { 876, 11, 51, 16, 2, -42 },
  { 947, 26, 25, 33, 3, -45 },
  { 1029, 27, 28, 34, 3, -35 },
  { 1124, 6, 15, 12, 2, -7 },
  { 1136, 15, 2, 19, 2, -17 },
  { 1140, 4, 5, 14, 5, -4 },
  { 1143, 18, 42, 20, 1, -42 },
  { 1238, 27, 44, 34, 3, -43 },
  { 1387, 13, 42, 34, 6, -42 },
  { 1456, 26, 43, 34, 3, -43 },
  { 1596, 26, 44, 34, 3, -43 },
  { 1739, 32, 42, 34, 1, -42 },
  { 1907, 26, 43, 34, 4, -42 },
  { 2047, 26, 44, 34, 4, -43 },
  { 2190, 27, 42, 34, 3, -42 },
  { 2332, 26, 44, 34, 4, -43 },
  { 2475, 27, 44, 34, 3, -43 },
  { 2624, 4, 33, 14, 5, -32 },
  { 2641, 7, 40, 14, 2, -32 },
  { 2676, 27, 27, 34, 3, -35 },
  { 2768, 27, 14, 34, 3, -28 },
  { 2816, 27, 27, 34, 3, -35 },
  { 2908, 20, 44, 25, 2, -43 },
  { 3018, 46, 48, 52, 3, -42 },
  { 3294, 35, 42, 35, 0, -42 },
  { 3478, 27, 42, 37, 6, -42 },
  { 3620, 31, 44, 36, 4, -43 },
  { 3791, 32, 42, 41, 6, -42 },
  { 3959, 23, 42, 33, 6, -42 },
  { 4080, 23, 42, 29, 6, -42 },
  { 4201, 34, 44, 43, 4, -43 },
  { 4388, 30, 42, 42, 6, -42 },
  { 4546, 11, 42, 17, 3, -42 },
  { 4604, 14, 52, 14, -6, -42 },
  { 4695, 28, 42, 34, 6, -42 },
  { 4842, 23, 42, 30, 6, -42 },
  { 4963, 38, 42, 50, 6, -42 },
  { 5163, 30, 42, 42, 6, -42 },
  { 5321, 37, 44, 45, 4, -43 },
  { 5525, 25, 42, 34, 6, -42 },
  { 5657, 37, 53, 45, 4, -43 },
  { 5903, 27, 42, 35, 6, -42 },
  { 6045, 26, 44, 32, 3, -43 },
  { 6188, 30, 42, 30, 0, -42 },
  { 6346, 31, 43, 42, 6, -42 },
  { 6513, 34, 42, 34, 0, -42 },
  { 6692, 48, 42, 52, 2, -42 },
  { 6944, 31, 42, 31, 0, -42 },
  { 7107, 31, 42, 31, 0, -42 },
  { 7270, 30, 42, 34, 2, -42 },
  { 7428, 12, 51, 19, 5, -42 },
  { 7505, 18, 42, 20, 1, -42 },
  { 7600, 13, 51, 19, 1, -42 },
  { 7683, 28, 26, 34, 3, -42 },
  { 7774, 24, 2, 24, 0, 5 },
  { 7780, 11, 9, 15, 2, -45 },
  { 7793, 23, 33, 31, 3, -32 },
  { 7888, 26, 46, 35, 5, -45 },
  { 8038, 23, 33, 28, 3, -32 },
  { 8133, 27, 46, 35, 3, -45 },
  { 8289, 26, 33, 32, 3, -32 },
  { 8397, 20, 45, 17, 1, -45 },
  { 8510, 27, 46, 35, 3, -32 },
  { 8666, 24, 45, 34, 5, -45 },
  { 8801, 3, 43, 13, 5, -43 },
  { 8818, 11, 57, 13, -3, -43 },
  { 8897, 23, 45, 28, 5, -45 },
  { 9027, 3, 45, 13, 5, -45 },
  { 9044, 41, 32, 51, 5, -32 },
  { 9208, 24, 32, 34, 5, -32 },
  { 9304, 28, 33, 34, 3, -32 },
  { 9420, 26, 46, 35, 5, -32 },
  { 9570, 26, 46, 35, 3, -32 },
  { 9720, 17, 32, 23, 5, -32 },
  { 9788, 23, 33, 27, 2, -32 },
  { 9883, 17, 40, 19, 1, -39 },
  { 9968, 24, 32, 34, 5, -31 },
  { 10064, 26, 31, 26, 0, -31 },
  { 10165, 40, 31, 42, 1, -31 },
  { 10320, 26, 31, 29, 1, -31 },
  { 10421, 26, 45, 26, 0, -31 },
  { 10568, 23, 31, 27, 2, -31 },
  { 10658, 16, 51, 20, 2, -42 },
  { 10760, 2, 60, 32, 15, -45 },
  { 10775, 17, 51, 20, 2, -42 },
  { 10884, 27, 6, 34, 3, -24 },
};

const GFXfont NotoSans_ExtraLight59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRALIGHT59PT7B_H_
