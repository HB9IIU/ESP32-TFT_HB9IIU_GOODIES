#ifndef _NOTOSANS_EXTRALIGHT19PT7B_H_
#define _NOTOSANS_EXTRALIGHT19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE4, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x42, 0x08, 0x81,
  0x11, 0xFF, 0xC4, 0x41, 0x08, 0x22, 0x1F, 0xF8, 0x88, 0x11, 0x02, 0x20,
  0x84, 0x00, 0x08, 0x7F, 0x88, 0x88, 0x88, 0x48, 0x38, 0x0C, 0x0A, 0x09,
  0x09, 0x09, 0x8A, 0x7C, 0x08, 0x30, 0x22, 0x42, 0x22, 0x11, 0x11, 0x08,
  0x48, 0x44, 0x92, 0x25, 0x49, 0x51, 0x34, 0x88, 0x24, 0x42, 0x22, 0x11,
  0x11, 0x08, 0x98, 0x38, 0x1C, 0x02, 0x20, 0x41, 0x04, 0x10, 0x22, 0x01,
  0x40, 0x18, 0x02, 0x40, 0x42, 0x28, 0x12, 0x81, 0x48, 0x0C, 0x41, 0xC3,
  0xE3, 0xF8, 0x25, 0x29, 0x24, 0x92, 0x49, 0x12, 0x20, 0x91, 0x22, 0x49,
  0x24, 0x92, 0x52, 0x80, 0x08, 0x08, 0xC9, 0x3E, 0x18, 0x24, 0x62, 0x08,
  0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00, 0x6A, 0xF0,
  0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x84, 0x10, 0x42, 0x00,
  0x1C, 0x11, 0x10, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x28, 0x24, 0x11, 0xF0, 0x13, 0x59, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3C,
  0xC2, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xFF, 0x3C, 0xC2, 0x01, 0x01, 0x01, 0x02, 0x3C, 0x06, 0x01, 0x01, 0x01,
  0x01, 0x01, 0xFE, 0x01, 0x00, 0x20, 0x0C, 0x02, 0x80, 0x90, 0x12, 0x04,
  0x41, 0x08, 0x41, 0x08, 0x22, 0xFF, 0x80, 0x80, 0x10, 0x02, 0x00, 0x7F,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xF8, 0x02, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x17, 0xF0, 0x0F, 0x18, 0x10, 0x08, 0x04, 0x04, 0x62, 0xC9, 0x82,
  0x80, 0xC0, 0x60, 0x28, 0x14, 0x11, 0xF0, 0xFF, 0x80, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x3C,
  0x21, 0x90, 0x50, 0x24, 0x13, 0x10, 0x70, 0x4C, 0x41, 0x40, 0x60, 0x30,
  0x14, 0x11, 0xF0, 0x3C, 0x21, 0x20, 0x50, 0x28, 0x0C, 0x06, 0x06, 0x85,
  0x3C, 0x80, 0x80, 0x40, 0x20, 0x23, 0xE0, 0x80, 0x40, 0x40, 0x00, 0x6A,
  0x01, 0x83, 0x06, 0x0C, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x30, 0xE1, 0x80,
  0x72, 0x30, 0x41, 0x04, 0x10, 0x84, 0x20, 0x82, 0x00, 0x01, 0x80, 0x0F,
  0xF0, 0x60, 0x11, 0x00, 0x12, 0x1E, 0x28, 0x42, 0x31, 0x04, 0x62, 0x10,
  0xC4, 0x21, 0x88, 0x43, 0x10, 0x8A, 0x1E, 0xE2, 0x00, 0x04, 0x00, 0x06,
  0x04, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x80, 0x28, 0x05, 0x00, 0x90, 0x22,
  0x04, 0x41, 0x04, 0x3F, 0x84, 0x09, 0x01, 0x20, 0x28, 0x03, 0x00, 0x40,
  0xFC, 0x41, 0xA0, 0x50, 0x28, 0x14, 0x0B, 0xF9, 0x04, 0x81, 0x40, 0x60,
  0x30, 0x18, 0x17, 0xF0, 0x0F, 0x84, 0x12, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x07, 0xF0, 0xF8, 0x21,
  0xC8, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x02, 0x81, 0x3F, 0x80, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81,
  0x02, 0x04, 0x08, 0x1F, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x0F, 0xC2, 0x04, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x04, 0x1F, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x12, 0x02,
  0x3F, 0xC0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0xFE, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0xF4, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x4F, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0xF0, 0x80, 0xC0, 0xA0, 0x90, 0x88, 0x84, 0x82, 0x81, 0xA0, 0x88,
  0x42, 0x21, 0x10, 0x48, 0x14, 0x04, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0x80, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xA0, 0x5A, 0x05, 0x90, 0x59, 0x09, 0x90, 0x98, 0x91, 0x89, 0x18,
  0x61, 0x86, 0x18, 0x21, 0x80, 0x60, 0x1C, 0x06, 0x81, 0xA0, 0x64, 0x18,
  0x86, 0x21, 0x84, 0x60, 0x98, 0x26, 0x05, 0x80, 0xE0, 0x10, 0x0F, 0x83,
  0x04, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x40, 0x14, 0x02, 0x20, 0x41, 0xF8, 0xF8, 0x86, 0x81, 0x81, 0x81,
  0x81, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x83, 0x04,
  0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x40, 0x14, 0x02, 0x20, 0x61, 0xF8, 0x01, 0x00, 0x08, 0x00, 0x60, 0xF8,
  0x43, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x09, 0xF8, 0x88, 0x42, 0x20, 0x90,
  0x48, 0x14, 0x0C, 0x3E, 0x41, 0x80, 0x80, 0x80, 0x40, 0x30, 0x0C, 0x03,
  0x01, 0x01, 0x01, 0x01, 0xFE, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x40, 0x8F, 0xC0, 0x80, 0x30, 0x05, 0x01, 0x20, 0x24, 0x08,
  0x41, 0x08, 0x20, 0x88, 0x11, 0x02, 0x20, 0x28, 0x05, 0x00, 0xC0, 0x08,
  0x00, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x0C, 0x14, 0x14, 0x28, 0x48, 0x90,
  0x91, 0x11, 0x22, 0x24, 0x24, 0x48, 0x50, 0x90, 0xA0, 0xA1, 0x41, 0x81,
  0x03, 0x02, 0x02, 0x00, 0x80, 0x50, 0x22, 0x10, 0x84, 0x12, 0x02, 0x80,
  0xC0, 0x30, 0x12, 0x04, 0x82, 0x11, 0x04, 0x40, 0xA0, 0x10, 0x80, 0x60,
  0x24, 0x08, 0x84, 0x21, 0x04, 0x81, 0x20, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20,
  0x10, 0x10, 0x10, 0x08, 0x08, 0x08, 0x07, 0xFC, 0xF8, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0xF0, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10,
  0x20, 0x82, 0x04, 0x10, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0xF0, 0x08, 0x0C, 0x05, 0x04, 0x82, 0x22, 0x11, 0x05, 0x02, 0x80, 0x80,
  0xFF, 0x91, 0x80, 0x7C, 0x04, 0x08, 0x13, 0xE8, 0x60, 0xC1, 0x82, 0xFC,
  0x80, 0x80, 0x80, 0x80, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0xFC, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x7C, 0x00,
  0x80, 0x40, 0x20, 0x13, 0xEA, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x34, 0x19, 0xF4, 0x3E, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x40,
  0x3F, 0x0E, 0x20, 0x81, 0x02, 0x1F, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x00, 0x3E, 0xA0, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x41, 0x9F, 0x40, 0x20, 0x10, 0x12, 0x10, 0xF0, 0x81, 0x02, 0x04, 0x0F,
  0xD0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xD0, 0x55, 0x55,
  0x50, 0x31, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0xC0, 0x81,
  0x02, 0x04, 0x08, 0x71, 0x24, 0x50, 0xA1, 0xA2, 0x44, 0x48, 0x50, 0x40,
  0xFF, 0xFC, 0xFD, 0xF4, 0x30, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06,
  0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x40, 0xFD, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x04, 0x3E, 0x20, 0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x41, 0x1F, 0x00, 0xBE, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x3F, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x3F, 0x01, 0x01, 0x01, 0x01, 0xFC, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x00, 0x7F, 0x02, 0x04, 0x07, 0x01, 0x80, 0x81, 0x03, 0xF8,
  0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xFC, 0x81, 0x81, 0x41, 0x42, 0x22,
  0x24, 0x24, 0x14, 0x18, 0x08, 0x82, 0x0A, 0x18, 0x51, 0x42, 0x8A, 0x24,
  0x49, 0x12, 0x48, 0xA2, 0x85, 0x0C, 0x10, 0x60, 0x81, 0x00, 0x41, 0x91,
  0x08, 0x82, 0x80, 0x80, 0x60, 0x50, 0x44, 0x41, 0x60, 0xC0, 0x81, 0x81,
  0x41, 0x42, 0x22, 0x24, 0x24, 0x14, 0x18, 0x08, 0x08, 0x10, 0x10, 0x20,
  0xC0, 0xFE, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81, 0xFC, 0x0C, 0x41,
  0x04, 0x10, 0x42, 0x08, 0xC0, 0x82, 0x04, 0x10, 0x41, 0x04, 0x0C, 0xFF,
  0xFF, 0xE0, 0x82, 0x08, 0x42, 0x10, 0x84, 0x19, 0x08, 0x42, 0x10, 0x84,
  0xC0, 0x70, 0x47, 0xC0,
};

const GFXglyph NotoSans_ExtraLight19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 14, 4, 2, -14 },
  { 3, 4, 5, 6, 1, -14 },
  { 6, 11, 14, 12, 1, -14 },
  { 26, 8, 15, 11, 1, -14 },
  { 41, 13, 14, 15, 1, -14 },
  { 64, 12, 14, 13, 1, -14 },
  { 85, 1, 5, 3, 1, -14 },
  { 86, 3, 17, 5, 1, -14 },
  { 93, 3, 17, 5, 1, -14 },
  { 100, 8, 7, 10, 1, -14 },
  { 107, 9, 9, 11, 1, -11 },
  { 118, 2, 4, 4, 1, -2 },
  { 119, 4, 1, 6, 1, -6 },
  { 120, 1, 1, 4, 2, -1 },
  { 121, 6, 14, 6, 0, -14 },
  { 132, 9, 14, 11, 1, -14 },
  { 148, 4, 14, 11, 2, -14 },
  { 155, 8, 14, 11, 1, -14 },
  { 169, 8, 14, 11, 1, -14 },
  { 183, 11, 14, 11, 0, -14 },
  { 203, 9, 14, 11, 1, -14 },
  { 219, 9, 14, 11, 1, -14 },
  { 235, 9, 14, 11, 1, -14 },
  { 251, 9, 14, 11, 1, -14 },
  { 267, 9, 14, 11, 1, -14 },
  { 283, 1, 10, 4, 2, -10 },
  { 285, 2, 12, 4, 1, -10 },
  { 288, 9, 8, 11, 1, -11 },
  { 297, 9, 5, 11, 1, -9 },
  { 303, 9, 8, 11, 1, -11 },
  { 312, 6, 14, 8, 1, -14 },
  { 323, 15, 15, 17, 1, -13 },
  { 352, 11, 14, 11, 0, -14 },
  { 372, 9, 14, 12, 2, -14 },
  { 388, 10, 14, 12, 1, -14 },
  { 406, 10, 14, 13, 2, -14 },
  { 424, 7, 14, 10, 2, -14 },
  { 437, 7, 14, 9, 2, -14 },
  { 450, 11, 14, 14, 1, -14 },
  { 470, 10, 14, 14, 2, -14 },
  { 488, 4, 14, 6, 1, -14 },
  { 495, 5, 17, 5, -2, -14 },
  { 506, 9, 14, 11, 2, -14 },
  { 522, 7, 14, 10, 2, -14 },
  { 535, 12, 14, 16, 2, -14 },
  { 556, 10, 14, 14, 2, -14 },
  { 574, 12, 14, 14, 1, -14 },
  { 595, 8, 14, 11, 2, -14 },
  { 609, 12, 17, 14, 1, -14 },
  { 635, 9, 14, 11, 2, -14 },
  { 651, 8, 14, 10, 1, -14 },
  { 665, 10, 14, 10, 0, -14 },
  { 683, 10, 14, 14, 2, -14 },
  { 701, 11, 14, 11, 0, -14 },
  { 721, 15, 14, 17, 1, -14 },
  { 748, 10, 14, 10, 0, -14 },
  { 766, 10, 14, 10, 0, -14 },
  { 784, 9, 14, 11, 1, -14 },
  { 800, 4, 17, 6, 2, -14 },
  { 809, 6, 14, 6, 0, -14 },
  { 820, 4, 17, 6, 0, -14 },
  { 829, 9, 9, 11, 1, -14 },
  { 840, 8, 1, 8, 0, 2 },
  { 841, 3, 3, 5, 1, -15 },
  { 843, 7, 10, 10, 1, -10 },
  { 852, 8, 14, 11, 2, -14 },
  { 866, 7, 10, 9, 1, -10 },
  { 875, 9, 14, 11, 1, -14 },
  { 891, 8, 10, 10, 1, -10 },
  { 901, 7, 15, 5, 0, -15 },
  { 915, 9, 15, 11, 1, -10 },
  { 932, 7, 14, 11, 2, -14 },
  { 945, 2, 14, 4, 1, -14 },
  { 949, 4, 19, 4, -1, -14 },
  { 959, 7, 14, 9, 2, -14 },
  { 972, 1, 14, 4, 2, -14 },
  { 974, 13, 10, 17, 2, -10 },
  { 991, 7, 10, 11, 2, -10 },
  { 1000, 9, 10, 11, 1, -10 },
  { 1012, 8, 14, 11, 2, -10 },
  { 1026, 8, 14, 11, 1, -10 },
  { 1040, 5, 10, 7, 2, -10 },
  { 1047, 7, 10, 9, 1, -10 },
  { 1056, 6, 13, 6, 0, -13 },
  { 1066, 7, 10, 11, 2, -10 },
  { 1075, 8, 10, 8, 0, -10 },
  { 1085, 13, 10, 13, 0, -10 },
  { 1102, 9, 10, 9, 0, -10 },
  { 1114, 8, 15, 8, 0, -10 },
  { 1129, 7, 10, 9, 1, -10 },
  { 1138, 6, 17, 7, 0, -14 },
  { 1151, 1, 19, 10, 5, -14 },
  { 1154, 5, 17, 7, 1, -14 },
  { 1165, 9, 2, 11, 1, -8 },
};

const GFXfont NotoSans_ExtraLight19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRALIGHT19PT7B_H_
