#ifndef _NOTOSANS_EXTRALIGHT39PT7B_H_
#define _NOTOSANS_EXTRALIGHT39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraLight.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraLight39pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x00, 0x0B, 0xF0,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x00, 0x60, 0x20,
  0x00, 0x80, 0x40, 0x01, 0x01, 0x80, 0x02, 0x03, 0x00, 0x0C, 0x04, 0x00,
  0x18, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x60, 0x00, 0x80, 0xC0, 0x7F,
  0xFF, 0xFC, 0x06, 0x02, 0x00, 0x08, 0x04, 0x00, 0x10, 0x18, 0x00, 0x20,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x02, 0x01, 0x00, 0x04, 0x02,
  0x03, 0xFF, 0xFF, 0xF0, 0x10, 0x18, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x40,
  0x01, 0x00, 0x80, 0x02, 0x03, 0x00, 0x04, 0x06, 0x00, 0x18, 0x08, 0x00,
  0x30, 0x10, 0x00, 0x40, 0x20, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0xFF, 0x81, 0xC8, 0xF1, 0x84, 0x11, 0x82, 0x00, 0x81, 0x00, 0x40,
  0x80, 0x60, 0x40, 0x10, 0x20, 0x0C, 0x10, 0x06, 0x08, 0x01, 0xC4, 0x00,
  0x7A, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x4E, 0x00, 0x21, 0x80, 0x10,
  0x60, 0x08, 0x10, 0x04, 0x0C, 0x02, 0x06, 0x01, 0x03, 0x00, 0x81, 0x00,
  0x41, 0x80, 0x21, 0x8E, 0x13, 0x83, 0xFF, 0x80, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x1F, 0x00, 0x0C, 0x06, 0x30, 0x01, 0x01, 0x83, 0x00, 0x60,
  0x20, 0x20, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x30, 0x08,
  0x18, 0x06, 0x01, 0x02, 0x00, 0xC0, 0x20, 0x80, 0x18, 0x04, 0x30, 0x03,
  0x01, 0x84, 0x00, 0x60, 0x31, 0x8F, 0x84, 0x06, 0x23, 0x18, 0x80, 0x8C,
  0xC1, 0x98, 0x31, 0x10, 0x11, 0x8C, 0x62, 0x03, 0x1F, 0x08, 0xC0, 0x60,
  0x03, 0x18, 0x0C, 0x00, 0xC3, 0x00, 0x80, 0x10, 0x60, 0x10, 0x06, 0x0C,
  0x02, 0x00, 0x81, 0x80, 0xC0, 0x30, 0x30, 0x18, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x40, 0x40, 0x20, 0x0C, 0x18, 0x0C, 0x00, 0xC6, 0x03, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0x03, 0x87, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00,
  0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x0C, 0x00, 0x10,
  0x06, 0x00, 0x0C, 0x02, 0x00, 0x02, 0x03, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x30, 0x60, 0x06, 0x30, 0x18, 0x02, 0x30, 0x06, 0x03, 0x10, 0x01, 0x81,
  0x18, 0x00, 0x61, 0x8C, 0x00, 0x18, 0x86, 0x00, 0x06, 0xC3, 0x00, 0x01,
  0xC0, 0x80, 0x00, 0xE0, 0x60, 0x00, 0xD8, 0x18, 0x00, 0xC6, 0x07, 0x01,
  0xC1, 0x81, 0xFF, 0x80, 0x70, 0xFF, 0xC0, 0x06, 0x18, 0x20, 0xC3, 0x06,
  0x08, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x02, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x06,
  0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02,
  0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x20, 0xE0, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x03,
  0x82, 0x06, 0xF9, 0x1E, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x50, 0x00, 0x64,
  0x00, 0x63, 0x00, 0x20, 0xC0, 0x30, 0x30, 0x30, 0x18, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x2D, 0xB6, 0xB6, 0x90, 0xFF, 0x80, 0x5F, 0x80, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0x07, 0xF8, 0x03, 0x83, 0x01, 0x80, 0x60, 0xC0,
  0x0C, 0x20, 0x01, 0x18, 0x00, 0x66, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00,
  0x90, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x0D, 0x00,
  0x02, 0x40, 0x00, 0x98, 0x00, 0x26, 0x00, 0x18, 0x80, 0x04, 0x30, 0x03,
  0x06, 0x01, 0x80, 0xC0, 0xC0, 0x1F, 0xE0, 0x01, 0x81, 0xC3, 0xE3, 0x33,
  0x1F, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x07, 0xF0, 0x1E, 0x0E, 0x1C, 0x01, 0x88, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x1F, 0xFF, 0xF0, 0x0F, 0xF8, 0x1E, 0x0E, 0x38, 0x01, 0x90, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x03, 0x80, 0x7F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x40, 0x03, 0xB8, 0x07,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x16, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x60,
  0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x40, 0xC0, 0x04, 0x06, 0x00, 0x60,
  0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x03, 0x03,
  0x00, 0x18, 0x10, 0x00, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x08, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x40, 0x07,
  0x38, 0x0E, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0x81, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x10, 0xFF, 0x09, 0xC1, 0xC5, 0x80, 0x33, 0x80,
  0x0D, 0x80, 0x02, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0D, 0x00, 0x06, 0xC0, 0x02, 0x20, 0x03, 0x18, 0x03,
  0x07, 0x03, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xF8, 0x07, 0x03,
  0x83, 0x00, 0x30, 0xC0, 0x04, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x06, 0x20, 0x01, 0x0C, 0x00, 0xC1, 0x80, 0x60, 0x38, 0x70, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0xE1, 0xC0, 0x60, 0x18, 0x30, 0x03, 0x18, 0x00,
  0x64, 0x00, 0x09, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D,
  0x00, 0x02, 0x60, 0x01, 0x8C, 0x00, 0xC1, 0xC0, 0xE0, 0x3F, 0xE0, 0x07,
  0xF0, 0x07, 0x07, 0x03, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x40, 0x01, 0xD8, 0x00, 0xF3, 0x00, 0x6C, 0x60, 0x32, 0x0F,
  0xF0, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x07, 0x00, 0x07, 0x00,
  0xFF, 0x80, 0x5F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x7E, 0x11, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0x8C, 0x62, 0x11,
  0x8C, 0x46, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xC3,
  0xC1, 0xC8, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x06, 0x20, 0x03, 0xF0, 0x09, 0x80, 0x3D, 0xF0,
  0x36, 0x03, 0x80, 0x80, 0xD0, 0x08, 0x02, 0x01, 0xC0, 0x60, 0x08, 0x07,
  0x01, 0x00, 0x20, 0x1C, 0x0C, 0x00, 0x80, 0x70, 0x30, 0x02, 0x01, 0x80,
  0xC0, 0x08, 0x06, 0x03, 0x00, 0x20, 0x1C, 0x0C, 0x01, 0x80, 0xF0, 0x30,
  0x06, 0x03, 0xC0, 0x40, 0x38, 0x09, 0x01, 0x80, 0xB0, 0x44, 0x03, 0xFC,
  0x7F, 0x18, 0x03, 0xC0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x60, 0x00, 0x06,
  0x40, 0x00, 0x08, 0x80, 0x00, 0x31, 0x80, 0x00, 0x61, 0x00, 0x00, 0x83,
  0x00, 0x03, 0x06, 0x00, 0x04, 0x04, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x40, 0x10, 0x01, 0x80, 0x30, 0x02, 0x00, 0x20, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x20, 0x00, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x02,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x04, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x00, 0x00, 0x16, 0x00, 0x00, 0x30, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0C, 0x00, 0x73, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0B,
  0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x13, 0x00, 0x18, 0xC0,
  0x3C, 0x3F, 0xFC, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x07, 0xE3, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x0F, 0x03, 0xC1, 0xC0, 0x02, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x0C, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x30, 0x01, 0xC1, 0x80, 0x03, 0x0C,
  0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x00, 0x98, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x00, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xB0, 0x00, 0x05, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x13, 0x00,
  0x01, 0x98, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x38, 0x30, 0x3F, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xB0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x03, 0xC0, 0x7C, 0x0C, 0x00, 0x10, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x40,
  0x00, 0x02, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x0C, 0x00,
  0x02, 0x0E, 0x00, 0x04, 0x0F, 0x00, 0x78, 0x07, 0xFF, 0xC0, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFE, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x67, 0xF0, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x03, 0x3F, 0xCF, 0xC0, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x33,
  0x00, 0x18, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x36, 0xC0,
  0x0F, 0x30, 0x03, 0x86, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0,
  0x03, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0xFF,
  0xF0, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE8, 0x00, 0x00, 0xB6, 0x00,
  0x00, 0x5B, 0x00, 0x00, 0x6C, 0x80, 0x00, 0x26, 0x60, 0x00, 0x33, 0x10,
  0x00, 0x11, 0x8C, 0x00, 0x08, 0xC6, 0x00, 0x0C, 0x61, 0x00, 0x04, 0x30,
  0xC0, 0x06, 0x18, 0x20, 0x02, 0x0C, 0x18, 0x03, 0x06, 0x04, 0x01, 0x83,
  0x03, 0x00, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x30, 0x60,
  0x30, 0x08, 0x30, 0x18, 0x06, 0x10, 0x0C, 0x03, 0x18, 0x06, 0x00, 0x88,
  0x03, 0x00, 0x6C, 0x01, 0x80, 0x16, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x01, 0x00, 0x10, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x3B, 0x00, 0x03, 0xB0, 0x00, 0x39, 0x80, 0x03, 0x8C, 0x00, 0x38, 0xC0,
  0x03, 0x86, 0x00, 0x38, 0x30, 0x03, 0x83, 0x00, 0x38, 0x18, 0x03, 0x80,
  0xC0, 0x38, 0x04, 0x03, 0x80, 0x60, 0x38, 0x03, 0x03, 0x80, 0x10, 0x38,
  0x01, 0x83, 0x80, 0x0C, 0x38, 0x00, 0x43, 0x80, 0x06, 0x38, 0x00, 0x33,
  0x80, 0x01, 0x38, 0x00, 0x1B, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x00, 0xFF, 0xC0, 0x01, 0xE0, 0x78, 0x01, 0x80, 0x0E,
  0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C,
  0x00, 0xE0, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x0E, 0xC0,
  0x38, 0xFF, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xE0, 0x78, 0x01, 0x80, 0x0E,
  0x01, 0x80, 0x01, 0x81, 0x80, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x11, 0x80, 0x00, 0x18,
  0xC0, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C,
  0x00, 0xE0, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0C, 0x00, 0xE3,
  0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x04, 0xC0,
  0x01, 0x30, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x07,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x03, 0x03,
  0x00, 0x60, 0xC0, 0x08, 0x30, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x03, 0x30, 0x00, 0x4C, 0x00, 0x1B, 0x00, 0x03, 0x07, 0xFC, 0x0F, 0x03,
  0x8C, 0x00, 0x4C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0xB8, 0x07, 0x8F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x34, 0x00, 0x06, 0x60, 0x00, 0x63, 0x00, 0x0C, 0x1E,
  0x07, 0x80, 0x7F, 0xE0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x98, 0x00, 0x06, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x04,
  0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x80, 0x80, 0x04, 0x03, 0x00,
  0x30, 0x04, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x60, 0x18, 0x00, 0x80, 0x60,
  0x03, 0x01, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x61, 0x80, 0x00,
  0x86, 0x00, 0x03, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x68,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x40, 0x01, 0xC0, 0x03, 0x60, 0x03, 0xC0,
  0x02, 0x60, 0x03, 0x40, 0x02, 0x20, 0x02, 0x40, 0x06, 0x20, 0x02, 0x60,
  0x06, 0x30, 0x06, 0x60, 0x04, 0x30, 0x04, 0x20, 0x0C, 0x10, 0x04, 0x30,
  0x0C, 0x10, 0x0C, 0x30, 0x0C, 0x18, 0x0C, 0x10, 0x08, 0x18, 0x08, 0x10,
  0x18, 0x08, 0x08, 0x18, 0x18, 0x0C, 0x18, 0x18, 0x10, 0x0C, 0x18, 0x08,
  0x30, 0x04, 0x10, 0x08, 0x30, 0x04, 0x10, 0x0C, 0x30, 0x06, 0x30, 0x04,
  0x20, 0x06, 0x20, 0x04, 0x60, 0x02, 0x20, 0x06, 0x60, 0x02, 0x60, 0x06,
  0x40, 0x03, 0x60, 0x02, 0x40, 0x03, 0x40, 0x02, 0xC0, 0x01, 0x40, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x31, 0x00, 0x03, 0x0C, 0x00, 0x10, 0x30, 0x01, 0x80,
  0x80, 0x18, 0x06, 0x00, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x04,
  0x00, 0x08, 0x60, 0x00, 0x62, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x08, 0x60,
  0x00, 0xC1, 0x00, 0x0C, 0x0C, 0x00, 0x40, 0x30, 0x06, 0x00, 0x80, 0x60,
  0x06, 0x03, 0x00, 0x18, 0x30, 0x00, 0x41, 0x00, 0x03, 0x18, 0x00, 0x0D,
  0x80, 0x00, 0x70, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00, 0x63, 0x00,
  0x04, 0x30, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x80, 0xC0, 0x10, 0x04,
  0x03, 0x00, 0x60, 0x60, 0x02, 0x06, 0x00, 0x30, 0xC0, 0x01, 0x08, 0x00,
  0x19, 0x80, 0x00, 0x90, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x01, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0xFF, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x06, 0x80, 0x00, 0x98, 0x00, 0x31,
  0x00, 0x04, 0x30, 0x01, 0x82, 0x00, 0x20, 0x60, 0x0C, 0x04, 0x01, 0x00,
  0xC0, 0x60, 0x08, 0x08, 0x01, 0x83, 0x00, 0x10, 0x40, 0x03, 0x18, 0x00,
  0x22, 0x00, 0x06, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xC3, 0x06, 0x0C, 0x18,
  0x30, 0x07, 0xF0, 0x7C, 0xF0, 0x80, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x01, 0xFC, 0x3F, 0x89, 0xC0, 0x16,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x17, 0x00,
  0x6B, 0x81, 0x93, 0xFC, 0x20, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0xFE, 0x0C, 0xF1, 0xC3, 0x60, 0x18, 0xF0, 0x03, 0x38, 0x00,
  0x6E, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0xE0,
  0x01, 0xB8, 0x00, 0x6E, 0x00, 0x33, 0x40, 0x18, 0xCC, 0x0C, 0x31, 0xFE,
  0x00, 0x01, 0xFC, 0x0F, 0x1C, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x70, 0x10, 0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0xFC, 0x30, 0xE1, 0xCC, 0x60, 0x1B, 0x30, 0x03, 0xD8, 0x00,
  0x76, 0x00, 0x1D, 0x00, 0x03, 0x40, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03, 0x40,
  0x01, 0xD8, 0x00, 0x72, 0x00, 0x1C, 0xC0, 0x0B, 0x1C, 0x0C, 0xC1, 0xFE,
  0x30, 0x03, 0xF0, 0x07, 0x8E, 0x06, 0x01, 0x86, 0x00, 0x62, 0x00, 0x33,
  0x00, 0x09, 0x00, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x60, 0x7F, 0xE0, 0x00, 0xFC,
  0x0F, 0xE0, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0xFF, 0x8F, 0xFE, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x03, 0xF0, 0xC3, 0xC7, 0x31, 0x80, 0x6C, 0xC0, 0x0F,
  0x20, 0x01, 0xD8, 0x00, 0x74, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00,
  0x0D, 0x00, 0x07, 0x60, 0x01, 0xCC, 0x00, 0xF3, 0x00, 0x2C, 0x70, 0x33,
  0x07, 0xF8, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x19, 0x00, 0x0C, 0x78, 0x0E, 0x07, 0xFE, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xF8, 0xCE, 0x3C, 0xD8, 0x06, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xF4,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x08, 0x00, 0x00, 0x00,
  0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x6F, 0x80, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x0F, 0x00, 0x36,
  0x00, 0xCC, 0x03, 0x18, 0x0C, 0x30, 0x30, 0x60, 0xC0, 0xC3, 0x01, 0x8C,
  0x03, 0x18, 0x06, 0x58, 0x0D, 0x30, 0x1C, 0x30, 0x38, 0x30, 0x60, 0x30,
  0xC0, 0x61, 0x80, 0x63, 0x00, 0x66, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC7, 0xE0, 0x3F, 0x0C, 0xE3, 0x8F, 0x3C, 0xD8,
  0x0D, 0x80, 0x6E, 0x00, 0xD0, 0x06, 0xE0, 0x07, 0x00, 0x2C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x30, 0xC3, 0xF8, 0xCE, 0x3C, 0xD8, 0x06,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x03, 0xF8, 0x03, 0xC7, 0x81, 0x80, 0x30, 0xC0, 0x06, 0x20, 0x01, 0x98,
  0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x14, 0x00, 0x0D, 0x80, 0x03,
  0x60, 0x00, 0x8C, 0x00, 0x61, 0x80, 0x30, 0x30, 0x38, 0x07, 0xF8, 0x00,
  0x87, 0xF0, 0x4F, 0x1C, 0x2C, 0x03, 0x14, 0x00, 0xCC, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x05, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x05, 0x80, 0x06, 0xC0, 0x03,
  0x70, 0x03, 0x2C, 0x03, 0x93, 0x03, 0x88, 0xFF, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x87, 0x0E, 0x46, 0x01, 0xA6, 0x00,
  0x76, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x03, 0x60, 0x01, 0x90, 0x01, 0xCC, 0x01, 0xA3, 0x81, 0x90, 0xFF,
  0x88, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x87, 0xE7, 0x3B, 0x03,
  0x80, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x0F,
  0xF0, 0xE1, 0xF6, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x38, 0x00, 0xB0, 0x0E, 0x7F, 0xE0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x03, 0xFF, 0xFF, 0xF0, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0,
  0x0E, 0x00, 0x7F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x40, 0x05, 0x60, 0x0D, 0x38, 0x19, 0x1F, 0xE1, 0xC0, 0x00, 0xE0,
  0x00, 0xD0, 0x00, 0x6C, 0x00, 0x22, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x18,
  0x20, 0x0C, 0x18, 0x04, 0x04, 0x06, 0x02, 0x02, 0x01, 0x81, 0x00, 0x41,
  0x80, 0x30, 0x80, 0x18, 0xC0, 0x04, 0x60, 0x03, 0x20, 0x00, 0xB0, 0x00,
  0x50, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0xF0, 0x03, 0x00,
  0x3C, 0x00, 0xC0, 0x0B, 0x00, 0x78, 0x02, 0x40, 0x12, 0x01, 0x98, 0x04,
  0x80, 0x66, 0x03, 0x30, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x03, 0x0C,
  0x18, 0x60, 0xC3, 0x04, 0x18, 0x20, 0x41, 0x02, 0x18, 0x18, 0xC0, 0xC6,
  0x06, 0x20, 0x31, 0x00, 0x88, 0x04, 0x40, 0x26, 0x01, 0xB0, 0x0D, 0x80,
  0x6C, 0x03, 0x40, 0x0A, 0x00, 0x70, 0x02, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x01, 0xB0, 0x01, 0x8C, 0x01, 0x82, 0x00, 0x81,
  0x80, 0xC0, 0x60, 0xC0, 0x10, 0xC0, 0x0C, 0x40, 0x03, 0x60, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x36, 0x00, 0x31, 0x80, 0x10, 0x40, 0x18,
  0x30, 0x18, 0x0C, 0x18, 0x03, 0x08, 0x01, 0x8C, 0x00, 0x6C, 0x00, 0x18,
  0xC0, 0x00, 0xE0, 0x00, 0xD0, 0x00, 0x6C, 0x00, 0x22, 0x00, 0x31, 0x80,
  0x10, 0xC0, 0x18, 0x20, 0x0C, 0x18, 0x04, 0x04, 0x06, 0x02, 0x03, 0x01,
  0x81, 0x00, 0x41, 0x80, 0x30, 0x80, 0x18, 0xC0, 0x04, 0x60, 0x03, 0x20,
  0x00, 0xB0, 0x00, 0x50, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x07, 0xC0, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x80, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x7C, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0xF0, 0x1E, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0xE0, 0x1C, 0x0E, 0x01,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x0C, 0x01, 0x80, 0x20, 0x3C, 0x1E, 0x00, 0x1C, 0x00, 0x1F, 0xE0,
  0x1C, 0x0F, 0x1E, 0x00, 0xFC,
};

const GFXglyph NotoSans_ExtraLight39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 28, 9, 3, -28 },
  { 12, 7, 10, 13, 3, -28 },
  { 21, 23, 28, 25, 1, -28 },
  { 102, 17, 32, 22, 2, -30 },
  { 170, 27, 28, 31, 2, -28 },
  { 265, 25, 28, 28, 2, -28 },
  { 353, 1, 10, 7, 3, -28 },
  { 355, 7, 34, 10, 2, -28 },
  { 385, 8, 34, 10, 1, -28 },
  { 419, 17, 16, 21, 2, -30 },
  { 453, 18, 18, 22, 2, -23 },
  { 494, 3, 10, 8, 2, -5 },
  { 498, 9, 1, 13, 2, -11 },
  { 500, 3, 3, 9, 3, -3 },
  { 502, 12, 28, 13, 0, -28 },
  { 544, 18, 28, 22, 2, -28 },
  { 607, 9, 28, 22, 4, -28 },
  { 639, 17, 28, 22, 2, -28 },
  { 699, 17, 28, 22, 2, -28 },
  { 759, 21, 28, 22, 1, -28 },
  { 833, 17, 28, 22, 3, -28 },
  { 893, 17, 28, 22, 3, -28 },
  { 953, 18, 28, 22, 2, -28 },
  { 1016, 18, 28, 22, 2, -28 },
  { 1079, 18, 28, 22, 2, -28 },
  { 1142, 3, 21, 9, 3, -21 },
  { 1150, 5, 26, 9, 1, -21 },
  { 1167, 18, 18, 22, 2, -23 },
  { 1208, 18, 9, 22, 2, -18 },
  { 1229, 18, 18, 22, 2, -23 },
  { 1270, 14, 28, 16, 1, -28 },
  { 1319, 30, 32, 34, 2, -28 },
  { 1439, 23, 28, 23, 0, -28 },
  { 1520, 18, 28, 24, 4, -28 },
  { 1583, 21, 28, 24, 2, -28 },
  { 1657, 21, 28, 27, 4, -28 },
  { 1731, 15, 28, 21, 4, -28 },
  { 1784, 15, 28, 19, 4, -28 },
  { 1837, 23, 28, 28, 2, -28 },
  { 1918, 20, 28, 28, 4, -28 },
  { 1988, 7, 28, 11, 2, -28 },
  { 2013, 10, 35, 9, -4, -28 },
  { 2057, 18, 28, 22, 4, -28 },
  { 2120, 15, 28, 20, 4, -28 },
  { 2173, 25, 28, 33, 4, -28 },
  { 2261, 20, 28, 28, 4, -28 },
  { 2331, 25, 28, 30, 2, -28 },
  { 2419, 16, 28, 23, 4, -28 },
  { 2475, 25, 35, 30, 2, -28 },
  { 2585, 18, 28, 23, 4, -28 },
  { 2648, 17, 28, 21, 2, -28 },
  { 2708, 20, 28, 20, 0, -28 },
  { 2778, 20, 28, 28, 4, -28 },
  { 2848, 22, 28, 22, 0, -28 },
  { 2925, 32, 28, 34, 1, -28 },
  { 3037, 21, 28, 20, 0, -28 },
  { 3111, 20, 28, 20, 0, -28 },
  { 3181, 20, 28, 23, 1, -28 },
  { 3251, 8, 34, 12, 3, -28 },
  { 3285, 12, 28, 13, 0, -28 },
  { 3327, 8, 34, 12, 1, -28 },
  { 3361, 19, 17, 22, 2, -28 },
  { 3402, 16, 1, 16, 0, 4 },
  { 3404, 6, 6, 10, 2, -30 },
  { 3409, 15, 21, 20, 2, -21 },
  { 3449, 18, 30, 23, 3, -30 },
  { 3517, 15, 21, 18, 2, -21 },
  { 3557, 18, 30, 23, 2, -30 },
  { 3625, 17, 21, 21, 2, -21 },
  { 3670, 14, 30, 11, 0, -30 },
  { 3723, 18, 30, 23, 2, -21 },
  { 3791, 16, 30, 23, 3, -30 },
  { 3851, 2, 28, 8, 3, -28 },
  { 3858, 7, 37, 8, -2, -28 },
  { 3891, 15, 30, 18, 3, -30 },
  { 3948, 1, 30, 8, 4, -30 },
  { 3952, 28, 21, 34, 3, -21 },
  { 4026, 16, 21, 23, 3, -21 },
  { 4068, 18, 21, 23, 2, -21 },
  { 4116, 17, 30, 23, 4, -21 },
  { 4180, 17, 30, 23, 2, -21 },
  { 4244, 10, 21, 15, 4, -21 },
  { 4271, 14, 21, 18, 2, -21 },
  { 4308, 12, 26, 13, 0, -26 },
  { 4347, 16, 21, 23, 3, -21 },
  { 4389, 17, 21, 17, 0, -21 },
  { 4434, 26, 21, 28, 1, -21 },
  { 4503, 17, 21, 19, 1, -21 },
  { 4548, 17, 30, 17, 0, -21 },
  { 4612, 14, 21, 18, 2, -21 },
  { 4649, 11, 34, 14, 1, -28 },
  { 4696, 1, 40, 21, 10, -30 },
  { 4701, 11, 34, 14, 1, -28 },
  { 4748, 18, 4, 22, 2, -16 },
};

const GFXfont NotoSans_ExtraLight39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraLight39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraLight39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRALIGHT39PT7B_H_
