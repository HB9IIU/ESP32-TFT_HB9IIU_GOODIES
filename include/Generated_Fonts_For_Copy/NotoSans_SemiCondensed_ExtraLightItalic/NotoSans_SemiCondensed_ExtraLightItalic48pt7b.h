#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x30, 0x66, 0x08, 0xC3,
  0x10, 0x66, 0x0C, 0xC1, 0x18, 0x22, 0x0C, 0x41, 0x88, 0x33, 0x04, 0x60,
  0x80, 0x00, 0x0C, 0x06, 0x00, 0x04, 0x02, 0x00, 0x02, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x80, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x20, 0x10, 0x00, 0x30, 0x18, 0x07, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0x04, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x00, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x40, 0x20,
  0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x08, 0x03, 0xFF, 0xFF,
  0xF0, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x02, 0x01, 0x00, 0x03, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x40, 0x60, 0x00, 0x60,
  0x30, 0x00, 0x30, 0x10, 0x00, 0x10, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x07,
  0xFF, 0x00, 0xF3, 0x7C, 0x0E, 0x10, 0x20, 0x60, 0x80, 0x06, 0x04, 0x00,
  0x30, 0x60, 0x01, 0x03, 0x00, 0x18, 0x10, 0x00, 0x40, 0x80, 0x03, 0x04,
  0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x03, 0x90, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x70, 0x00, 0x11, 0xC0, 0x00, 0x86,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x10, 0x30, 0x00,
  0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x02, 0x0C, 0x1C, 0x11, 0xC0,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x0C, 0x0E, 0x30, 0x01, 0x80, 0xC1, 0x80, 0x30, 0x18, 0x18, 0x03,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x18, 0x06, 0x01, 0x81, 0x00, 0x60, 0x18, 0x30, 0x06, 0x01, 0x06,
  0x00, 0x40, 0x30, 0x40, 0x0C, 0x03, 0x0C, 0x00, 0xC0, 0x31, 0x87, 0x8C,
  0x02, 0x18, 0xFE, 0xC0, 0x63, 0x18, 0x6C, 0x04, 0x63, 0x02, 0x60, 0xC6,
  0x60, 0x36, 0x18, 0xC6, 0x03, 0x3F, 0x18, 0x40, 0x31, 0xC1, 0x8C, 0x03,
  0x00, 0x30, 0xC0, 0x20, 0x06, 0x08, 0x02, 0x00, 0x61, 0x80, 0x60, 0x0C,
  0x18, 0x06, 0x00, 0x81, 0x80, 0x60, 0x18, 0x18, 0x04, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x80, 0x80, 0xC0, 0x18, 0x18, 0x08,
  0x01, 0x83, 0x01, 0x80, 0x0C, 0x60, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x70, 0x60, 0x00, 0xE0,
  0x30, 0x00, 0xC0, 0x30, 0x00, 0x80, 0x30, 0x01, 0x80, 0x30, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80,
  0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x18,
  0x00, 0x1C, 0x0C, 0x03, 0x38, 0x0C, 0x02, 0x30, 0x06, 0x06, 0x60, 0x06,
  0x04, 0x60, 0x03, 0x0C, 0xC0, 0x01, 0x98, 0xC0, 0x01, 0x98, 0xC0, 0x00,
  0xF0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xE0, 0x60, 0x03,
  0x30, 0x70, 0x06, 0x30, 0x3C, 0x3C, 0x18, 0x1F, 0xF0, 0x0C, 0x33, 0x32,
  0x66, 0x64, 0x44, 0xCC, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x0C,
  0x0C, 0x07, 0x84, 0x00, 0xE2, 0x00, 0x1D, 0x0F, 0x03, 0xFF, 0x81, 0xC0,
  0x01, 0xB0, 0x01, 0x88, 0x01, 0x86, 0x01, 0x83, 0x01, 0x80, 0xC0, 0x80,
  0x60, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x0E, 0x18, 0x30, 0xC1, 0x83, 0x0C, 0x10, 0x60, 0x83, 0x00, 0x7F,
  0xFF, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xF8, 0x00, 0xE0, 0xC0, 0x18, 0x06, 0x03, 0x00, 0x30, 0x70,
  0x03, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x32,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x64, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03, 0xC7, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xE0, 0x38, 0x1F, 0x07, 0x63, 0x8C, 0xE1, 0xB0, 0x24,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x60, 0x06,
  0x01, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x1E, 0x03, 0x80, 0xE0,
  0x06, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x80, 0x07, 0x03, 0xE0, 0x78, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1A, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x19, 0x80, 0x00,
  0xC4, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C,
  0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x30, 0x18, 0x01,
  0x80, 0x40, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00,
  0xC0, 0x60, 0x02, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83,
  0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x20, 0x03, 0x80, 0xF0, 0x7C, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x0E, 0x02, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC3, 0xF8, 0x06, 0x7F, 0xE0, 0x36, 0x01, 0x83, 0x60,
  0x06, 0x1E, 0x00, 0x30, 0xE0, 0x01, 0x86, 0x00, 0x04, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x88, 0x00, 0x08, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x30, 0x80, 0x01, 0x84, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0E,
  0x00, 0xC0, 0x30, 0x0E, 0x00, 0xE1, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFF,
  0xF4, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x60, 0x0E, 0x03, 0x00,
  0x18, 0x0C, 0x00, 0x20, 0x20, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x08,
  0x18, 0x00, 0x60, 0x20, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x06,
  0x03, 0x80, 0x1C, 0x1C, 0x00, 0x39, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x3C, 0xE0, 0x01, 0xC1, 0xC0, 0x1C, 0x01, 0x80, 0xE0, 0x07, 0x03,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0x78, 0x78, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x38, 0x38, 0x03, 0x00, 0xE0, 0x30,
  0x03, 0x03, 0x00, 0x08, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00,
  0x0C, 0x60, 0x00, 0xE3, 0x00, 0x06, 0x18, 0x00, 0x70, 0xE0, 0x07, 0x83,
  0x00, 0x6C, 0x0C, 0x06, 0x60, 0x3F, 0xE2, 0x00, 0x78, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x06, 0x0F, 0x00, 0x3F, 0xE0, 0x00, 0x02, 0x07, 0x07, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x00, 0x40,
  0x1C, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0xF0, 0xE0, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE7, 0xC0,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x02, 0x18, 0x01, 0xFF, 0x02,
  0x18, 0x07, 0x06, 0x03, 0x30, 0x0C, 0x06, 0x03, 0x30, 0x18, 0x06, 0x03,
  0x20, 0x18, 0x06, 0x03, 0x60, 0x30, 0x04, 0x02, 0x60, 0x20, 0x0C, 0x02,
  0x60, 0x60, 0x0C, 0x06, 0x40, 0x60, 0x0C, 0x06, 0xC0, 0xC0, 0x18, 0x06,
  0xC0, 0xC0, 0x18, 0x04, 0xC0, 0xC0, 0x18, 0x0C, 0xC0, 0xC0, 0x38, 0x0C,
  0xC0, 0xC0, 0x30, 0x18, 0xC0, 0xC0, 0x70, 0x18, 0xC0, 0xC0, 0xD8, 0x30,
  0xC0, 0x61, 0x98, 0x60, 0xC0, 0x7F, 0x0F, 0xC0, 0x40, 0x1C, 0x07, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x08, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80,
  0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01,
  0x81, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x18, 0x04, 0x00, 0x60,
  0x08, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x1F, 0xFF,
  0xC0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x10, 0x60, 0x00, 0x21, 0x80, 0x00, 0x63,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00, 0x07, 0xC0,
  0x00, 0x0C, 0x01, 0xFF, 0xE0, 0x06, 0x03, 0xE0, 0x0C, 0x00, 0x60, 0x18,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x00, 0x81, 0x80, 0x01, 0x83, 0x00,
  0x02, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00,
  0xC0, 0xC0, 0x01, 0x81, 0x80, 0x0E, 0x03, 0x00, 0x78, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x30, 0x03, 0x80, 0x60, 0x03, 0x80, 0x80, 0x03, 0x03,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x20,
  0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x03, 0x06, 0x00,
  0x0E, 0x18, 0x00, 0x18, 0x30, 0x00, 0xE0, 0x60, 0x03, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3C,
  0x06, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0xFC, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0xC0, 0x18, 0x00, 0x70, 0x08, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x10, 0x60, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x61, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00, 0x07, 0x01, 0x80,
  0x0F, 0x00, 0xC0, 0x1E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0x80, 0x7C, 0x03, 0x80, 0x02, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0C, 0x00, 0x3F, 0xE3, 0x00, 0x0F, 0xF8, 0xC0, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x40,
  0x1C, 0x00, 0x30, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x02, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0x30, 0x18, 0x00, 0x02, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x01, 0xFF, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x43, 0x80, 0x1F, 0xE0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x47, 0x00,
  0x00, 0x33, 0xC0, 0x00, 0x0D, 0xB0, 0x00, 0x03, 0xC6, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x00, 0xC0,
  0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x1B, 0x01, 0x60, 0x00, 0x06, 0x80, 0x58, 0x00, 0x03,
  0x60, 0x32, 0x00, 0x00, 0xD8, 0x0C, 0x80, 0x00, 0x66, 0x03, 0x20, 0x00,
  0x19, 0x80, 0x8C, 0x00, 0x0C, 0x40, 0x63, 0x00, 0x03, 0x30, 0x18, 0xC0,
  0x01, 0x8C, 0x06, 0x30, 0x00, 0x63, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x41,
  0x00, 0x18, 0x60, 0x30, 0x40, 0x06, 0x18, 0x0C, 0x10, 0x03, 0x06, 0x03,
  0x06, 0x00, 0xC1, 0x80, 0xC1, 0x80, 0x60, 0x40, 0x20, 0x60, 0x18, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x81, 0x80,
  0xC0, 0x60, 0x20, 0x40, 0x20, 0x30, 0x08, 0x30, 0x18, 0x0C, 0x03, 0x18,
  0x06, 0x03, 0x00, 0xC6, 0x01, 0x80, 0xC0, 0x33, 0x00, 0x60, 0x20, 0x0C,
  0xC0, 0x10, 0x18, 0x03, 0x60, 0x0C, 0x06, 0x00, 0xD8, 0x03, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x60, 0x07, 0x00, 0x30, 0x30, 0x01, 0x80, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x30, 0x1E,
  0x00, 0x02, 0x01, 0x60, 0x00, 0x60, 0x13, 0x00, 0x06, 0x03, 0x30, 0x00,
  0x60, 0x33, 0x00, 0x06, 0x03, 0x18, 0x00, 0xC0, 0x21, 0x80, 0x0C, 0x06,
  0x18, 0x00, 0xC0, 0x60, 0xC0, 0x0C, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0xC0,
  0x18, 0x04, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x20, 0x10, 0x0C, 0x03, 0x03, 0x00, 0x80, 0x30, 0x30, 0x18, 0x01,
  0x03, 0x01, 0x80, 0x18, 0x30, 0x18, 0x01, 0x82, 0x01, 0x80, 0x08, 0x60,
  0x30, 0x00, 0xC6, 0x03, 0x00, 0x0C, 0x60, 0x30, 0x00, 0x46, 0x03, 0x00,
  0x06, 0x40, 0x20, 0x00, 0x6C, 0x06, 0x00, 0x02, 0xC0, 0x60, 0x00, 0x3C,
  0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x86, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0xC0, 0x01, 0xC0,
  0x60, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x87, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0x07, 0xE0, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xE0, 0x18, 0x00, 0xC0, 0x20, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0xE0, 0x18, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1C, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x0E, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0D, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x18, 0x00, 0x01, 0x86, 0x00, 0x01, 0x83, 0x00, 0x01,
  0x81, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x87,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0x07, 0xE0,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x20, 0x01, 0x80,
  0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80,
  0x0E, 0x06, 0x00, 0x38, 0x0C, 0x01, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x40, 0x60, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x0C, 0x01, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xE0, 0x0F, 0x01, 0xC0, 0x70, 0x01, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x80, 0x07, 0x03, 0xE0, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x08, 0x18, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x08, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x04, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x04, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06,
  0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0xC0, 0x80, 0x06, 0x04, 0x00, 0x60, 0x20,
  0x03, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x21, 0x80, 0x01, 0x0C, 0x00, 0x08, 0xC0, 0x00,
  0x66, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1B, 0x00, 0x05, 0x00, 0x06,
  0xC0, 0x03, 0x40, 0x03, 0x30, 0x00, 0xD0, 0x00, 0xCC, 0x00, 0x64, 0x00,
  0x23, 0x00, 0x19, 0x00, 0x18, 0xC0, 0x04, 0x60, 0x06, 0x30, 0x03, 0x18,
  0x03, 0x0C, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x18,
  0x60, 0x18, 0x10, 0x0C, 0x18, 0x0C, 0x04, 0x03, 0x06, 0x03, 0x01, 0x01,
  0x81, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x60, 0x10, 0x10, 0x18, 0x18, 0x04,
  0x0C, 0x06, 0x0C, 0x01, 0x02, 0x01, 0x83, 0x00, 0x41, 0x80, 0x61, 0x80,
  0x10, 0x60, 0x18, 0x60, 0x04, 0x30, 0x06, 0x18, 0x01, 0x0C, 0x01, 0x8C,
  0x00, 0x66, 0x00, 0x63, 0x00, 0x19, 0x80, 0x19, 0x80, 0x06, 0xC0, 0x06,
  0x60, 0x01, 0xB0, 0x01, 0xB0, 0x00, 0x68, 0x00, 0x6C, 0x00, 0x1E, 0x00,
  0x1A, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0x10, 0x01, 0xC0, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x21, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x1C,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x3B, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x01, 0x86, 0x00, 0x18, 0x10, 0x00, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0xE0,
  0x30, 0x06, 0x00, 0x80, 0x60, 0x06, 0x03, 0x00, 0x30, 0x30, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x21, 0x80, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0x6C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xC1, 0x83, 0x06, 0x04, 0x08,
  0x18, 0x30, 0x60, 0xC0, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x60,
  0xC1, 0x83, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x81, 0x83, 0x06,
  0x0C, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00, 0x66,
  0x00, 0x0C, 0x20, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x03, 0x01, 0x80, 0x30,
  0x18, 0x06, 0x00, 0x80, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x04, 0x18,
  0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0xFF, 0xFF, 0xC3, 0x06, 0x18, 0x30, 0x41, 0x83, 0x00, 0x7C, 0x00, 0x1F,
  0xF1, 0x03, 0x83, 0x30, 0x60, 0x1B, 0x0C, 0x00, 0xB1, 0xC0, 0x0E, 0x18,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x62, 0x00, 0x06, 0x60, 0x00, 0xC6,
  0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07,
  0x0C, 0x00, 0xF0, 0x60, 0x1B, 0x06, 0x03, 0x30, 0x38, 0xE2, 0x01, 0xFC,
  0x20, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x83, 0xE0, 0x0C, 0x7F, 0x80, 0x66, 0x06, 0x03,
  0x60, 0x18, 0x16, 0x00, 0xC1, 0xE0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00,
  0xC3, 0x00, 0x06, 0x38, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60,
  0x00, 0x62, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x38, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00,
  0x30, 0x58, 0x03, 0x82, 0x40, 0x38, 0x33, 0x87, 0x81, 0x8F, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0xFF, 0xC0, 0xE0, 0x20, 0xE0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x18, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x01, 0xF0, 0x60, 0x0F, 0xF8, 0xC0, 0x38, 0x19, 0x80, 0xC0, 0x1A,
  0x03, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x70, 0x60, 0x00, 0xC0,
  0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x10, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00,
  0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x01,
  0xE0, 0x60, 0x06, 0xC0, 0x60, 0x1D, 0x00, 0xC0, 0x72, 0x00, 0xE1, 0xCC,
  0x00, 0xFE, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x38, 0x38, 0x1C,
  0x06, 0x0E, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0x30, 0x01,
  0x88, 0x00, 0xC6, 0x00, 0x61, 0x80, 0xF0, 0x7F, 0xF0, 0x1F, 0xE0, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x1C, 0x1C,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x10, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x8C,
  0x03, 0x81, 0x98, 0x0C, 0x01, 0x20, 0x30, 0x01, 0xC0, 0xE0, 0x03, 0x81,
  0x80, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC0, 0xC0, 0x03,
  0x81, 0x80, 0x07, 0x03, 0x00, 0x1E, 0x06, 0x00, 0x6C, 0x06, 0x01, 0xD0,
  0x0C, 0x07, 0x60, 0x0E, 0x1C, 0xC0, 0x0F, 0xE1, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x30, 0x07, 0x83,
  0xC0, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x0F, 0x80,
  0x63, 0xFE, 0x06, 0x60, 0x60, 0x6C, 0x03, 0x05, 0x80, 0x30, 0xF0, 0x03,
  0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00,
  0x21, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x04, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x20, 0x00, 0xC6, 0x00, 0x0C, 0x60,
  0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0xC0, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x08, 0xE0, 0x07, 0xE0, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x10, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30, 0x01, 0x86, 0x00,
  0x18, 0xE0, 0x01, 0x9C, 0x00, 0x1B, 0xC0, 0x01, 0x26, 0x00, 0x34, 0x60,
  0x03, 0x86, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x04, 0x00, 0xC0, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x06, 0x3F, 0xC1, 0xFE, 0x06, 0xE0, 0xC7,
  0x07, 0x04, 0x80, 0x6C, 0x03, 0x05, 0x00, 0x68, 0x03, 0x0F, 0x00, 0x78,
  0x03, 0x0E, 0x00, 0x70, 0x03, 0x0C, 0x00, 0x60, 0x03, 0x0C, 0x00, 0x60,
  0x03, 0x0C, 0x00, 0x60, 0x03, 0x18, 0x00, 0x40, 0x03, 0x18, 0x00, 0xC0,
  0x02, 0x18, 0x00, 0xC0, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x30, 0x00, 0xC0,
  0x06, 0x30, 0x01, 0x80, 0x06, 0x30, 0x01, 0x80, 0x0C, 0x30, 0x01, 0x80,
  0x0C, 0x20, 0x01, 0x80, 0x0C, 0x60, 0x01, 0x00, 0x0C, 0x60, 0x03, 0x00,
  0x08, 0x60, 0x03, 0x00, 0x18, 0x60, 0x03, 0x00, 0x18, 0x40, 0x03, 0x00,
  0x18, 0xC0, 0x02, 0x00, 0x18, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x0F, 0x80,
  0x63, 0xFE, 0x06, 0x60, 0x60, 0x4C, 0x03, 0x05, 0x80, 0x30, 0xF0, 0x03,
  0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00,
  0x21, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x63, 0x00,
  0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x20, 0x00, 0xC6, 0x00, 0x0C, 0x60,
  0x01, 0x86, 0x00, 0x18, 0x60, 0x01, 0x84, 0x00, 0x18, 0xC0, 0x01, 0x0C,
  0x00, 0x30, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0x81, 0xC0, 0x60, 0x0C,
  0x0C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x63, 0x00, 0x02, 0x30, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x30, 0x60, 0x06, 0x03,
  0x00, 0xE0, 0x3C, 0x38, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x03, 0x1F,
  0xF0, 0x06, 0x60, 0x60, 0x09, 0x80, 0x60, 0x16, 0x00, 0xC0, 0x78, 0x00,
  0xC0, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0x83,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x30,
  0x00, 0x60, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x80, 0x0C, 0x07, 0x80,
  0x38, 0x09, 0x00, 0xE0, 0x33, 0x87, 0x80, 0x63, 0xFC, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0xC0,
  0xE0, 0x66, 0x0C, 0x01, 0xA0, 0xC0, 0x0F, 0x0E, 0x00, 0x38, 0x60, 0x01,
  0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x18,
  0xC0, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00,
  0x78, 0x60, 0x06, 0xC1, 0x80, 0x34, 0x0C, 0x07, 0x60, 0x38, 0x73, 0x00,
  0xFE, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0x06, 0x3F,
  0x06, 0x60, 0x04, 0xC0, 0x05, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0xC1, 0xC0, 0x61, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x31, 0x00, 0x30, 0xF0, 0x70, 0x3F, 0xF0, 0x00, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x07, 0xFF, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE2, 0x07, 0xE0, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x08, 0x00, 0x31, 0x80, 0x02, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC2,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x18,
  0x40, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x0F,
  0x0C, 0x01, 0xB0, 0x60, 0x32, 0x07, 0x0E, 0x20, 0x3F, 0xC6, 0x00, 0xC0,
  0x00, 0xD0, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x31,
  0x80, 0x0C, 0x60, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x16, 0x00, 0x05, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0x60, 0x0F, 0x00, 0x6C, 0x03, 0x60,
  0x19, 0x80, 0x6C, 0x03, 0x30, 0x09, 0x80, 0xC6, 0x03, 0x30, 0x18, 0xC0,
  0x46, 0x02, 0x18, 0x18, 0xC0, 0xC3, 0x02, 0x18, 0x18, 0x60, 0xC3, 0x06,
  0x0C, 0x10, 0x20, 0xC1, 0x86, 0x04, 0x30, 0x30, 0x80, 0x86, 0x06, 0x30,
  0x10, 0x80, 0xC6, 0x02, 0x30, 0x19, 0x80, 0x44, 0x03, 0x30, 0x0D, 0x80,
  0x6C, 0x01, 0xB0, 0x0D, 0x80, 0x3C, 0x01, 0xA0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x03, 0x00, 0x1C,
  0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x0C, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x00, 0x98,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0C, 0x80, 0x00, 0x33, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0x60, 0x03, 0x81, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x10,
  0x1C, 0x00, 0x60, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x01, 0x80, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x04, 0x00, 0x06, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x86, 0x00, 0x00, 0x21,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x08, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x7C, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x3E,
  0x03, 0xC0, 0x7C, 0xF8, 0x01, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 34, 10, 1, -34 },
  { 44, 11, 12, 15, 5, -34 },
  { 61, 25, 34, 25, 1, -34 },
  { 168, 21, 39, 23, 1, -36 },
  { 271, 28, 36, 33, 3, -35 },
  { 397, 24, 35, 27, 1, -35 },
  { 502, 4, 12, 8, 5, -34 },
  { 508, 14, 42, 12, 1, -34 },
  { 582, 13, 42, 12, -3, -34 },
  { 651, 17, 18, 22, 6, -36 },
  { 690, 20, 22, 24, 3, -28 },
  { 745, 7, 11, 9, -2, -5 },
  { 755, 12, 2, 14, 1, -14 },
  { 758, 3, 3, 10, 1, -3 },
  { 760, 21, 34, 15, -2, -34 },
  { 850, 20, 35, 23, 2, -35 },
  { 938, 11, 34, 23, 7, -34 },
  { 985, 22, 35, 23, 0, -35 },
  { 1082, 22, 35, 23, 0, -35 },
  { 1179, 22, 35, 23, 0, -35 },
  { 1276, 22, 34, 23, 1, -34 },
  { 1370, 21, 35, 23, 2, -35 },
  { 1462, 20, 34, 23, 4, -34 },
  { 1547, 22, 35, 23, 1, -35 },
  { 1644, 21, 35, 23, 1, -35 },
  { 1736, 8, 26, 10, 1, -26 },
  { 1762, 11, 32, 10, -2, -26 },
  { 1806, 20, 21, 24, 3, -28 },
  { 1859, 20, 12, 24, 3, -23 },
  { 1889, 20, 21, 24, 3, -28 },
  { 1942, 15, 35, 17, 3, -35 },
  { 2008, 32, 38, 35, 2, -34 },
  { 2160, 23, 34, 23, -3, -34 },
  { 2258, 23, 34, 25, 2, -34 },
  { 2356, 24, 35, 24, 3, -35 },
  { 2461, 25, 34, 28, 1, -34 },
  { 2568, 23, 34, 22, 1, -34 },
  { 2666, 23, 34, 20, 1, -34 },
  { 2764, 26, 35, 29, 3, -35 },
  { 2878, 28, 34, 29, 1, -34 },
  { 2997, 16, 34, 12, -1, -34 },
  { 3065, 19, 43, 10, -8, -34 },
  { 3168, 26, 34, 23, 1, -34 },
  { 3279, 16, 34, 20, 1, -34 },
  { 3347, 34, 34, 35, 1, -34 },
  { 3492, 28, 34, 29, 1, -34 },
  { 3611, 25, 35, 30, 3, -35 },
  { 3721, 23, 34, 23, 1, -34 },
  { 3819, 25, 43, 30, 3, -35 },
  { 3954, 23, 34, 24, 1, -34 },
  { 4052, 22, 35, 21, 0, -35 },
  { 4149, 20, 34, 20, 4, -34 },
  { 4234, 26, 34, 29, 3, -34 },
  { 4345, 21, 34, 23, 5, -34 },
  { 4435, 34, 34, 36, 5, -34 },
  { 4580, 27, 34, 21, -3, -34 },
  { 4695, 21, 34, 20, 4, -34 },
  { 4785, 25, 34, 22, -1, -34 },
  { 4892, 18, 42, 14, -1, -34 },
  { 4987, 7, 34, 15, 5, -34 },
  { 5017, 18, 42, 14, -3, -34 },
  { 5112, 20, 19, 24, 2, -34 },
  { 5160, 16, 1, 16, -4, 5 },
  { 5162, 6, 8, 11, 7, -37 },
  { 5168, 20, 26, 24, 2, -26 },
  { 5233, 21, 36, 24, 1, -36 },
  { 5328, 17, 26, 19, 2, -26 },
  { 5384, 23, 36, 24, 2, -36 },
  { 5488, 18, 26, 21, 2, -26 },
  { 5547, 24, 49, 12, -6, -37 },
  { 5694, 23, 38, 24, 0, -26 },
  { 5804, 20, 36, 23, 1, -36 },
  { 5894, 9, 35, 9, 1, -35 },
  { 5934, 17, 47, 10, -7, -35 },
  { 6034, 20, 36, 19, 1, -36 },
  { 6124, 10, 36, 9, 1, -36 },
  { 6169, 32, 26, 36, 1, -26 },
  { 6273, 20, 26, 23, 1, -26 },
  { 6338, 20, 26, 24, 2, -26 },
  { 6403, 23, 37, 24, -1, -26 },
  { 6510, 21, 37, 24, 2, -26 },
  { 6608, 16, 26, 16, 1, -26 },
  { 6660, 17, 26, 18, 0, -26 },
  { 6716, 12, 32, 13, 2, -32 },
  { 6764, 20, 25, 23, 2, -25 },
  { 6827, 18, 25, 18, 2, -25 },
  { 6884, 27, 25, 29, 3, -25 },
  { 6969, 22, 25, 19, -2, -25 },
  { 7038, 26, 37, 18, -5, -25 },
  { 7159, 19, 25, 18, -1, -25 },
  { 7219, 17, 42, 16, 1, -34 },
  { 7309, 2, 49, 22, 11, -37 },
  { 7322, 17, 42, 16, -3, -34 },
  { 7412, 20, 4, 24, 3, -19 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC48PT7B_H_
