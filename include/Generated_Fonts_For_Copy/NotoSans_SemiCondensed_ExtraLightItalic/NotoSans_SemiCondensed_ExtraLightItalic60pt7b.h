#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x00, 0x1C,
  0x1C, 0x60, 0x71, 0x81, 0x86, 0x06, 0x38, 0x18, 0xC0, 0xE3, 0x03, 0x0C,
  0x0C, 0x30, 0x31, 0x80, 0xC6, 0x06, 0x18, 0x18, 0x60, 0x61, 0x01, 0x8C,
  0x04, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0xF0, 0x83,
  0x80, 0x70, 0x60, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x01,
  0x80, 0x01, 0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x20, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x79, 0x80, 0x00, 0x0F, 0x60, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xDE, 0x00, 0x00,
  0x23, 0xC0, 0x00, 0x18, 0x78, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x70, 0x00, 0x10, 0x1C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x0E, 0x00, 0x06,
  0x07, 0x02, 0x01, 0x83, 0x80, 0xE0, 0x63, 0xC0, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x70, 0x60, 0x00, 0x60,
  0x38, 0x1C, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x1C, 0x06, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x30, 0x03, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x30, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x00, 0x30, 0x1C, 0x01, 0x80, 0x1C,
  0x06, 0x00, 0x60, 0x06, 0x03, 0x00, 0x18, 0x01, 0x81, 0xC0, 0x06, 0x00,
  0x60, 0x60, 0x03, 0x80, 0x18, 0x30, 0x00, 0xC0, 0x0E, 0x1C, 0x00, 0x30,
  0x03, 0x06, 0x0F, 0xCC, 0x00, 0xC3, 0x0F, 0xFB, 0x00, 0x60, 0xC7, 0x06,
  0xC0, 0x18, 0x61, 0x80, 0xF8, 0x0C, 0x38, 0xC0, 0x36, 0x07, 0x0C, 0x30,
  0x0D, 0xC1, 0x86, 0x18, 0x03, 0x3F, 0xC3, 0x86, 0x00, 0xC7, 0xE0, 0xC3,
  0x00, 0x30, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x38, 0x30, 0x03, 0x00, 0x0C,
  0x1C, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x03, 0x81, 0x80, 0x1C, 0x00,
  0xC0, 0x60, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x38, 0x06, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x38, 0x03,
  0x00, 0xC0, 0x0E, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x18, 0x00, 0x60,
  0x30, 0x0C, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x03, 0x9E, 0x03, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x70, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x30, 0x38, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0x67, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xF1, 0x80, 0x00, 0x03, 0x83, 0x80, 0x02, 0x0E, 0x03, 0x00, 0x18, 0x38,
  0x07, 0x00, 0x30, 0xE0, 0x06, 0x00, 0xC3, 0x80, 0x0E, 0x01, 0x86, 0x00,
  0x0E, 0x06, 0x1C, 0x00, 0x0C, 0x0C, 0x30, 0x00, 0x1C, 0x30, 0x60, 0x00,
  0x18, 0xE0, 0xC0, 0x00, 0x39, 0x83, 0x80, 0x00, 0x36, 0x07, 0x00, 0x00,
  0x7C, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x01, 0xE0, 0x18, 0x00, 0x07,
  0xE0, 0x38, 0x00, 0x1C, 0xC0, 0x38, 0x00, 0xF1, 0xC0, 0x78, 0x03, 0x81,
  0x80, 0x7F, 0xFE, 0x03, 0x80, 0x3F, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x0C,
  0x30, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80, 0x60, 0x0F,
  0x01, 0x00, 0x0F, 0x0C, 0x00, 0x0F, 0x30, 0x00, 0x0E, 0xC3, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x60, 0x00, 0x71, 0x80,
  0x03, 0x83, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x60, 0x08,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x0C, 0x06, 0x06, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x77,
  0xF7, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x07, 0x00,
  0x03, 0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x38,
  0x00, 0x03, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x06, 0x70, 0x00, 0x03, 0x38, 0x00, 0x01, 0x98, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x0E, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x07, 0x01, 0x80, 0x07, 0x00, 0xC0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x3E, 0x07,
  0xF0, 0x73, 0x0F, 0x18, 0xF0, 0xCE, 0x0E, 0xE0, 0x74, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xF0, 0x0E, 0x00, 0x78, 0x00, 0xE0, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x08, 0x00,
  0x07, 0x80, 0xE0, 0x01, 0xE0, 0x0F, 0xF9, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x07, 0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18, 0x38,
  0x00, 0x06, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x1C,
  0x03, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03, 0x00,
  0x0E, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x70, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0,
  0xF8, 0x00, 0x20, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x07, 0x00, 0xE0, 0x03, 0xC0,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x87, 0xFC,
  0x00, 0xC7, 0xFF, 0xC0, 0x33, 0x80, 0x78, 0x0D, 0xC0, 0x0E, 0x07, 0xC0,
  0x01, 0xC1, 0xE0, 0x00, 0x30, 0x78, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x86,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x07, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x38, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xF0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0x80,
  0x01, 0xC0, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x0C, 0x03, 0x80, 0x03, 0x80, 0x30, 0x00, 0x60, 0x07, 0x00, 0x18, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x1E,
  0x03, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x30,
  0x1C, 0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x18, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1C,
  0x00, 0x30, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x06,
  0x00, 0x01, 0x87, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x31,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0xF1, 0xC0, 0x00, 0xF0, 0x60, 0x00, 0xF8, 0x38, 0x00, 0xEC, 0x0E, 0x00,
  0xE6, 0x03, 0xFF, 0xC6, 0x00, 0xFF, 0xC3, 0x00, 0x04, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x80, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x0E, 0x03, 0xC0,
  0x80, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x61, 0x80, 0x07, 0xFF, 0x00,
  0xC7, 0x00, 0x1E, 0x1E, 0x01, 0x8C, 0x00, 0xE0, 0x18, 0x03, 0x38, 0x03,
  0x80, 0x30, 0x06, 0x60, 0x06, 0x00, 0x60, 0x0C, 0xC0, 0x18, 0x00, 0xC0,
  0x1B, 0x80, 0x70, 0x03, 0x00, 0x36, 0x00, 0xC0, 0x06, 0x00, 0x6C, 0x03,
  0x80, 0x0C, 0x01, 0xD8, 0x06, 0x00, 0x18, 0x03, 0x70, 0x1C, 0x00, 0x60,
  0x06, 0xC0, 0x30, 0x00, 0xC0, 0x0D, 0x80, 0x60, 0x01, 0x80, 0x3B, 0x00,
  0xC0, 0x07, 0x00, 0x66, 0x01, 0x80, 0x0C, 0x00, 0xCC, 0x03, 0x00, 0x18,
  0x03, 0x18, 0x06, 0x00, 0x70, 0x06, 0x30, 0x0C, 0x01, 0xE0, 0x18, 0x60,
  0x18, 0x03, 0xC0, 0x70, 0xC0, 0x30, 0x0D, 0x80, 0xC1, 0x80, 0x70, 0x33,
  0x87, 0x03, 0x00, 0x7B, 0xC3, 0xFC, 0x06, 0x00, 0x7F, 0x03, 0xF0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xC0,
  0x01, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x70,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x00, 0x63, 0x80, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x38, 0x03, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x60, 0x38, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01, 0x80,
  0x03, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x38, 0x00, 0x78, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x30, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x70, 0x0C, 0x00, 0x0F, 0x00, 0xE0, 0x03, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0x10, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x7E, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x70, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0xC0,
  0x18, 0x00, 0x1E, 0x00, 0x30, 0x00, 0xF8, 0x00, 0xE0, 0x0F, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x7F, 0xF8, 0xC0, 0x00, 0x7F, 0xF0, 0xC0, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x1E, 0x00,
  0x01, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x1E,
  0x00, 0x01, 0x80, 0x3C, 0x00, 0x01, 0x80, 0x78, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x03, 0x01, 0xE0, 0x00, 0x03, 0x03, 0xC0, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x06, 0x3C, 0x00, 0x00, 0x06, 0x7C, 0x00, 0x00, 0x0E, 0xCE, 0x00,
  0x00, 0x0F, 0x86, 0x00, 0x00, 0x0F, 0x06, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x60, 0x00, 0x18, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x03, 0x60, 0x00, 0x00, 0x1F, 0x00, 0xD8, 0x00, 0x00, 0x0F, 0x80, 0x36,
  0x00, 0x00, 0x03, 0x60, 0x0D, 0x80, 0x00, 0x01, 0xD8, 0x07, 0x60, 0x00,
  0x00, 0x6E, 0x01, 0x98, 0x00, 0x00, 0x3B, 0x80, 0x66, 0x00, 0x00, 0x0C,
  0xC0, 0x19, 0xC0, 0x00, 0x06, 0x30, 0x06, 0x70, 0x00, 0x03, 0x8C, 0x03,
  0x8C, 0x00, 0x00, 0xC7, 0x00, 0xC3, 0x00, 0x00, 0x71, 0x80, 0x30, 0xC0,
  0x00, 0x18, 0x60, 0x0C, 0x30, 0x00, 0x0E, 0x18, 0x07, 0x0C, 0x00, 0x03,
  0x06, 0x01, 0xC3, 0x00, 0x01, 0xC3, 0x80, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x18, 0x38, 0x00, 0x38, 0x30, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x03, 0x81,
  0x80, 0x06, 0x07, 0x00, 0xC0, 0x60, 0x03, 0x81, 0xC0, 0x30, 0x18, 0x00,
  0xC0, 0x60, 0x0C, 0x06, 0x00, 0x70, 0x18, 0x03, 0x01, 0x80, 0x18, 0x06,
  0x01, 0xC0, 0x60, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x80, 0x30,
  0x38, 0x03, 0x00, 0xE0, 0x0C, 0x0C, 0x01, 0xC0, 0x30, 0x03, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC3, 0x80, 0x18, 0x03, 0x00, 0x30, 0xC0, 0x06, 0x01,
  0xC0, 0x0E, 0x70, 0x01, 0x80, 0x70, 0x01, 0x98, 0x00, 0xE0, 0x18, 0x00,
  0x6E, 0x00, 0x30, 0x06, 0x00, 0x1B, 0x00, 0x0C, 0x01, 0x80, 0x07, 0xC0,
  0x03, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x1C,
  0x00, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0xF8, 0x00, 0x01, 0xC0, 0x36, 0x00, 0x00, 0x60, 0x0D, 0x80, 0x00, 0x18,
  0x07, 0x70, 0x00, 0x06, 0x01, 0x8C, 0x00, 0x03, 0x80, 0x63, 0x00, 0x00,
  0xE0, 0x18, 0xE0, 0x00, 0x30, 0x06, 0x18, 0x00, 0x0C, 0x03, 0x86, 0x00,
  0x03, 0x00, 0xC1, 0xC0, 0x01, 0xC0, 0x30, 0x30, 0x00, 0x60, 0x0C, 0x0C,
  0x00, 0x18, 0x07, 0x03, 0x80, 0x06, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x60,
  0x18, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x03,
  0x80, 0x30, 0x03, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x70,
  0x0C, 0x00, 0x60, 0x18, 0x03, 0x00, 0x1C, 0x06, 0x01, 0xC0, 0x03, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0xE0, 0x18, 0x00, 0x38, 0x30, 0x06, 0x00, 0x06,
  0x0C, 0x03, 0x80, 0x01, 0x83, 0x00, 0xE0, 0x00, 0x70, 0xC0, 0x30, 0x00,
  0x0C, 0x70, 0x0C, 0x00, 0x03, 0x18, 0x03, 0x00, 0x00, 0xE6, 0x01, 0xC0,
  0x00, 0x19, 0x80, 0x70, 0x00, 0x06, 0x60, 0x18, 0x00, 0x01, 0xF8, 0x06,
  0x00, 0x00, 0x3C, 0x01, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x30, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03,
  0x83, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70,
  0x0C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xE0, 0x1F, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xE0, 0x3F, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xC0, 0x01, 0xC0, 0x0C,
  0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x70, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x30, 0x00, 0x60,
  0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x02, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x08, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x38, 0x18, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x39, 0x80, 0x00, 0x06, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x03,
  0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x07,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x0C,
  0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x07, 0x18, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xC0, 0x00, 0x1D, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xE0,
  0x00, 0x18, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x18, 0x00, 0x0D, 0x80, 0x00,
  0xE3, 0x00, 0x01, 0xB0, 0x00, 0x18, 0x60, 0x00, 0x66, 0x00, 0x07, 0x0C,
  0x00, 0x0C, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x18, 0x00, 0x38, 0x30, 0x00,
  0x63, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0xE1, 0x80, 0x06, 0x03, 0x00, 0x18, 0x38, 0x01,
  0xC0, 0x60, 0x07, 0x07, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0xE0, 0x0E, 0x01,
  0x80, 0x18, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00,
  0xC0, 0x70, 0x03, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x03,
  0x80, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x00,
  0x30, 0x30, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x80, 0x06, 0x18, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00,
  0x18, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x67,
  0x00, 0x01, 0x9C, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x38, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x30,
  0x00, 0x0C, 0x0E, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x07,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0C,
  0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC1,
  0x83, 0x83, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0x00, 0x3F, 0xC1, 0x80, 0x7F,
  0xF0, 0xC0, 0x78, 0x1C, 0x60, 0x70, 0x03, 0x60, 0x70, 0x01, 0xB0, 0x70,
  0x00, 0x58, 0x30, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x18, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x0C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x86, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0xF0, 0x60, 0x00, 0x58, 0x30, 0x00, 0x7C, 0x1C, 0x00, 0x6C, 0x06, 0x00,
  0x66, 0x03, 0x80, 0xE3, 0x00, 0xFB, 0xE1, 0x80, 0x3F, 0xE0, 0x80, 0x01,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x3F, 0xC0, 0x06, 0x1F, 0xF8, 0x01, 0x9E, 0x07, 0x00, 0xEE,
  0x00, 0xE0, 0x33, 0x00, 0x1C, 0x0D, 0x80, 0x07, 0x03, 0xC0, 0x00, 0xC1,
  0xE0, 0x00, 0x30, 0x78, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x18,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x30, 0x6C, 0x00, 0x1C, 0x1B, 0x00, 0x0E, 0x06, 0x60, 0x07, 0x01, 0x9C,
  0x03, 0x80, 0x63, 0xEF, 0xC0, 0x30, 0x7F, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x78, 0x02, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x7E, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x07, 0x00, 0x1F, 0xFE,
  0x30, 0x01, 0xE0, 0x39, 0x80, 0x1C, 0x00, 0xCC, 0x01, 0xC0, 0x03, 0x60,
  0x1C, 0x00, 0x1F, 0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x30, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x70, 0x0C, 0x00, 0x07, 0x80, 0x60, 0x00, 0x3C, 0x03, 0x00, 0x03, 0xE0,
  0x18, 0x00, 0x1E, 0x00, 0xC0, 0x01, 0xB0, 0x07, 0x00, 0x19, 0x80, 0x18,
  0x01, 0xCC, 0x00, 0xE0, 0x3C, 0xC0, 0x03, 0xEF, 0x86, 0x00, 0x0F, 0xF8,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0,
  0x1E, 0x07, 0x80, 0xF0, 0x0E, 0x07, 0x00, 0x18, 0x18, 0x00, 0x70, 0xE0,
  0x01, 0xC7, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x00, 0x03,
  0x1C, 0x00, 0x1C, 0x60, 0x00, 0xE1, 0x80, 0x0F, 0x06, 0x03, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xF0, 0x06, 0x01, 0xF9, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1C,
  0x10, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x30, 0x03, 0xFF,
  0xC6, 0x00, 0x78, 0x0E, 0x60, 0x0E, 0x00, 0x66, 0x01, 0xC0, 0x03, 0x60,
  0x38, 0x00, 0x36, 0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x38, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x1E, 0x03, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x3E, 0x03, 0x00, 0x03,
  0xC0, 0x30, 0x00, 0x6C, 0x03, 0x80, 0x0C, 0xC0, 0x18, 0x01, 0xDC, 0x01,
  0xC0, 0x79, 0x80, 0x0F, 0xBE, 0x18, 0x00, 0x7F, 0xC1, 0x80, 0x00, 0x40,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x80, 0x03, 0x80,
  0x0E, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x0F, 0xF0, 0x03, 0x0F,
  0xFE, 0x01, 0x9E, 0x07, 0x01, 0xDC, 0x01, 0xC0, 0xDC, 0x00, 0x60, 0x6C,
  0x00, 0x30, 0x3C, 0x00, 0x18, 0x3C, 0x00, 0x0C, 0x1E, 0x00, 0x06, 0x0E,
  0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x18, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x0E,
  0x01, 0x80, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x0E,
  0x00, 0x30, 0x06, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01, 0x87,
  0x00, 0x00, 0xC7, 0x80, 0x00, 0x66, 0xC0, 0x00, 0x36, 0x70, 0x00, 0x36,
  0x18, 0x00, 0x1E, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x01, 0x80, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x70, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x83, 0xF8, 0x03, 0xFC,
  0x00, 0xC7, 0xFE, 0x07, 0xFF, 0x00, 0x47, 0x03, 0x87, 0x03, 0xC0, 0x66,
  0x00, 0xC7, 0x00, 0xE0, 0x36, 0x00, 0x77, 0x00, 0x30, 0x1A, 0x00, 0x1B,
  0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x83, 0x80, 0x01, 0x80, 0x01, 0x81, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x70, 0x00, 0x30, 0x00, 0x38, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x06, 0x00, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x81, 0x80, 0x01, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x60, 0x00, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x06, 0x00, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x80, 0x01, 0x81, 0x80, 0x01, 0x80, 0x00, 0xC1, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x01, 0x83, 0xFC, 0x00, 0xC3, 0xFF, 0x80, 0xE7, 0x81,
  0xC0, 0x67, 0x00, 0x70, 0x37, 0x00, 0x18, 0x1B, 0x00, 0x0C, 0x0F, 0x00,
  0x06, 0x0F, 0x00, 0x03, 0x07, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC1, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86,
  0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF0, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0x60, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x7F, 0x80, 0x01, 0x87, 0xFF, 0x00, 0x0C, 0xF0, 0x38, 0x00, 0xCE, 0x00,
  0xE0, 0x06, 0x60, 0x03, 0x80, 0x36, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x60,
  0x0F, 0x00, 0x03, 0x00, 0xF0, 0x00, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x18, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0xE0, 0x00, 0xE0,
  0x1B, 0x00, 0x0E, 0x00, 0xCC, 0x00, 0xE0, 0x06, 0x70, 0x0E, 0x00, 0x31,
  0xF7, 0xE0, 0x03, 0x87, 0xFC, 0x00, 0x1C, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0xC0, 0x3F, 0xFC, 0x60, 0x1E, 0x03, 0x98, 0x0E, 0x00, 0x66, 0x07, 0x00,
  0x0D, 0x83, 0x80, 0x03, 0x60, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x18,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x83,
  0x00, 0x01, 0xE0, 0xC0, 0x00, 0xF8, 0x30, 0x00, 0x3C, 0x0C, 0x00, 0x1B,
  0x03, 0x80, 0x0C, 0xC0, 0x60, 0x07, 0x70, 0x1C, 0x03, 0x98, 0x03, 0xEF,
  0x86, 0x00, 0x7F, 0xC1, 0x80, 0x01, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x83, 0xF8, 0x0C, 0x7F, 0x80, 0x47, 0x80, 0x06,
  0x70, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3C, 0x03, 0x81,
  0xC0, 0x02, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x80, 0x03, 0x83, 0x80,
  0x1C, 0x0F, 0xE7, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x1F, 0xFF, 0x7F, 0xFE, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x7D, 0xC0, 0x3F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x38, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x86,
  0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0xF0,
  0x60, 0x00, 0xF0, 0x30, 0x00, 0x78, 0x18, 0x00, 0x6C, 0x0E, 0x00, 0x66,
  0x07, 0x80, 0xE3, 0x01, 0xFF, 0xE3, 0x00, 0x7F, 0xC1, 0x80, 0x02, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00,
  0x0E, 0x60, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x30,
  0x60, 0x01, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x38, 0x18, 0x00, 0xC0, 0x70,
  0x07, 0x01, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x00, 0x30, 0x1C,
  0x00, 0xC0, 0x60, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x70, 0x00,
  0xC1, 0x80, 0x03, 0x0E, 0x00, 0x0E, 0x30, 0x00, 0x39, 0xC0, 0x00, 0x66,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x6C, 0x00,
  0x1C, 0x00, 0x19, 0x80, 0x03, 0x80, 0x03, 0x30, 0x00, 0xF0, 0x00, 0xE6,
  0x00, 0x1E, 0x00, 0x18, 0xC0, 0x06, 0xC0, 0x07, 0x18, 0x00, 0xD8, 0x00,
  0xC3, 0x00, 0x33, 0x00, 0x38, 0x60, 0x06, 0x60, 0x06, 0x0C, 0x01, 0xCC,
  0x00, 0xC1, 0x80, 0x31, 0x80, 0x30, 0x30, 0x0E, 0x38, 0x06, 0x06, 0x01,
  0x87, 0x01, 0xC0, 0xC0, 0x70, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0E, 0x03,
  0x03, 0x81, 0x81, 0x80, 0x60, 0x60, 0x30, 0x70, 0x0C, 0x0C, 0x06, 0x0C,
  0x01, 0x83, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x18, 0x60, 0x06, 0x18, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x03, 0x18,
  0x01, 0x9C, 0x00, 0x66, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x60, 0x01,
  0xB8, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x18, 0x03, 0x00, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x0C, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x07, 0x06, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0x18,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x60, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x38, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xBF, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x03, 0xFB, 0xE8, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 13, 43, 13, 1, -43 },
  { 71, 14, 16, 18, 6, -43 },
  { 99, 32, 43, 32, 1, -43 },
  { 271, 26, 49, 29, 2, -46 },
  { 431, 34, 44, 41, 4, -43 },
  { 618, 31, 45, 33, 1, -44 },
  { 793, 6, 16, 10, 6, -43 },
  { 805, 17, 52, 15, 2, -43 },
  { 916, 17, 52, 15, -4, -43 },
  { 1027, 22, 22, 27, 7, -45 },
  { 1088, 26, 28, 31, 3, -35 },
  { 1179, 9, 14, 11, -3, -6 },
  { 1195, 14, 2, 18, 2, -17 },
  { 1199, 4, 4, 12, 1, -4 },
  { 1201, 26, 43, 19, -3, -43 },
  { 1341, 25, 45, 29, 3, -44 },
  { 1482, 13, 43, 29, 9, -43 },
  { 1552, 27, 43, 29, 0, -43 },
  { 1698, 28, 44, 29, 0, -43 },
  { 1852, 27, 43, 29, 0, -43 },
  { 1998, 27, 44, 29, 1, -43 },
  { 2147, 26, 45, 29, 3, -44 },
  { 2294, 25, 43, 29, 5, -43 },
  { 2429, 27, 44, 29, 1, -43 },
  { 2578, 25, 44, 29, 2, -43 },
  { 2716, 10, 32, 12, 1, -32 },
  { 2756, 14, 40, 12, -3, -32 },
  { 2826, 25, 27, 31, 4, -35 },
  { 2911, 25, 14, 31, 4, -28 },
  { 2955, 25, 27, 31, 4, -35 },
  { 3040, 20, 43, 21, 3, -43 },
  { 3148, 39, 48, 43, 3, -43 },
  { 3382, 28, 43, 28, -3, -43 },
  { 3533, 29, 43, 31, 2, -43 },
  { 3689, 29, 44, 30, 4, -43 },
  { 3849, 31, 43, 35, 2, -43 },
  { 4016, 28, 43, 28, 2, -43 },
  { 4167, 28, 43, 25, 2, -43 },
  { 4318, 32, 44, 36, 4, -43 },
  { 4494, 34, 43, 36, 2, -43 },
  { 4677, 19, 43, 15, -1, -43 },
  { 4780, 22, 54, 13, -9, -43 },
  { 4929, 32, 43, 29, 2, -43 },
  { 5101, 19, 43, 25, 2, -43 },
  { 5204, 42, 43, 44, 2, -43 },
  { 5430, 34, 43, 36, 2, -43 },
  { 5613, 31, 45, 37, 4, -44 },
  { 5788, 28, 43, 29, 2, -43 },
  { 5939, 31, 54, 37, 4, -44 },
  { 6149, 28, 43, 30, 2, -43 },
  { 6300, 28, 44, 27, 0, -43 },
  { 6454, 25, 43, 25, 5, -43 },
  { 6589, 32, 44, 36, 4, -43 },
  { 6765, 27, 43, 28, 6, -43 },
  { 6911, 43, 43, 45, 6, -43 },
  { 7143, 33, 43, 26, -3, -43 },
  { 7321, 26, 43, 25, 5, -43 },
  { 7461, 31, 43, 27, -1, -43 },
  { 7628, 22, 52, 17, -1, -43 },
  { 7771, 9, 43, 19, 6, -43 },
  { 7820, 22, 52, 17, -4, -43 },
  { 7963, 26, 25, 30, 2, -43 },
  { 8045, 20, 2, 20, -5, 6 },
  { 8050, 7, 10, 14, 9, -46 },
  { 8059, 25, 33, 29, 3, -32 },
  { 8163, 26, 47, 30, 1, -46 },
  { 8316, 21, 33, 23, 3, -32 },
  { 8403, 29, 47, 30, 3, -46 },
  { 8574, 22, 33, 26, 3, -32 },
  { 8665, 31, 60, 15, -8, -46 },
  { 8898, 28, 46, 30, 1, -32 },
  { 9059, 25, 46, 29, 1, -46 },
  { 9203, 12, 43, 12, 1, -43 },
  { 9268, 21, 57, 12, -8, -43 },
  { 9418, 25, 46, 24, 1, -46 },
  { 9562, 12, 46, 12, 1, -46 },
  { 9631, 41, 32, 45, 1, -32 },
  { 9795, 25, 32, 29, 1, -32 },
  { 9895, 24, 33, 30, 3, -32 },
  { 9994, 29, 46, 30, -2, -32 },
  { 10161, 26, 46, 30, 3, -32 },
  { 10311, 21, 32, 20, 1, -32 },
  { 10395, 22, 33, 22, 0, -32 },
  { 10486, 16, 40, 16, 2, -39 },
  { 10566, 25, 33, 29, 3, -32 },
  { 10670, 22, 32, 22, 3, -32 },
  { 10758, 35, 32, 36, 3, -32 },
  { 10898, 27, 32, 24, -2, -32 },
  { 11006, 33, 47, 23, -7, -32 },
  { 11200, 24, 32, 22, -1, -32 },
  { 11296, 21, 52, 20, 2, -43 },
  { 11433, 2, 61, 28, 14, -46 },
  { 11449, 21, 53, 19, -3, -43 },
  { 11589, 25, 6, 31, 4, -24 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC60PT7B_H_
