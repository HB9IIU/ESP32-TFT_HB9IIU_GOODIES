#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0x70, 0x00, 0x18, 0x18, 0xC1, 0xCE, 0x0E, 0x60, 0x63, 0x03, 0x18,
  0x18, 0xC1, 0xCC, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0x80, 0x8C, 0x0C,
  0x60, 0x63, 0x03, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xE3, 0x0F, 0x01, 0xC1, 0x81, 0x01,
  0xC0, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x03, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x80, 0x00, 0x1E, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x06, 0x04, 0x03, 0x07, 0x03, 0x81, 0x0F, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x01, 0xC3, 0x80, 0x03, 0x01, 0xC0,
  0xC0, 0x03, 0x00, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x30, 0x01, 0x80, 0x60,
  0x18, 0x01, 0x80, 0x60, 0x0C, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x03, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x60, 0x06,
  0x00, 0x60, 0x60, 0x03, 0x00, 0x30, 0x30, 0x03, 0x80, 0x30, 0x30, 0x01,
  0x80, 0x18, 0x30, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x60, 0x06, 0x18, 0x3F,
  0x30, 0x06, 0x1C, 0x7F, 0xD8, 0x03, 0x0C, 0x70, 0x6C, 0x03, 0x0C, 0x30,
  0x3E, 0x01, 0x8E, 0x30, 0x0D, 0x81, 0x86, 0x18, 0x06, 0xE1, 0x86, 0x18,
  0x03, 0x3F, 0x87, 0x0C, 0x01, 0x8F, 0x83, 0x0C, 0x00, 0xC0, 0x03, 0x06,
  0x00, 0x60, 0x03, 0x83, 0x00, 0x30, 0x01, 0x83, 0x80, 0x38, 0x01, 0x81,
  0x80, 0x18, 0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x06, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x38,
  0x00, 0xC0, 0x60, 0x18, 0x00, 0x70, 0x60, 0x18, 0x00, 0x1C, 0xF0, 0x1C,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x18, 0x01, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0xDE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x03, 0x0E,
  0x03, 0x80, 0x18, 0xE0, 0x0C, 0x01, 0xC6, 0x00, 0x30, 0x0C, 0x60, 0x01,
  0xC0, 0xE7, 0x00, 0x06, 0x06, 0x30, 0x00, 0x38, 0x71, 0x80, 0x00, 0xC3,
  0x0C, 0x00, 0x07, 0x30, 0xE0, 0x00, 0x1B, 0x87, 0x00, 0x00, 0xF8, 0x38,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xF0, 0x30, 0x00,
  0x39, 0x81, 0xC0, 0x03, 0x8E, 0x07, 0x00, 0x78, 0x30, 0x1F, 0xBF, 0x81,
  0xC0, 0x7F, 0xF0, 0x07, 0x00, 0x30, 0x00, 0x00, 0x18, 0xCE, 0x63, 0x18,
  0xCC, 0x63, 0x18, 0x8C, 0x63, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x20, 0x18,
  0x03, 0x80, 0xC0, 0x0F, 0x04, 0x00, 0x1E, 0x20, 0x00, 0x39, 0x03, 0xC0,
  0x7F, 0xFE, 0x00, 0xF8, 0x00, 0x1A, 0x00, 0x01, 0x98, 0x00, 0x18, 0x40,
  0x01, 0x83, 0x00, 0x18, 0x08, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0x40,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x81, 0x81, 0xC0,
  0xC0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x77, 0xF7, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x0E, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x07, 0x06, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0x60, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x1F, 0x80, 0xE6, 0x0F,
  0x30, 0x70, 0xC3, 0x83, 0x3C, 0x0C, 0x40, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x40, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x01, 0xC0, 0x0C,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x20, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x00,
  0xFF, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x71, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x60,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x07, 0x00,
  0xE0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0x60, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x20, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x03, 0xFD,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xC0, 0x20, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x04, 0x00, 0x18, 0x3F, 0xE0, 0x0C, 0x7E, 0xF8, 0x06, 0x60, 0x0E, 0x06,
  0x60, 0x03, 0x83, 0x60, 0x00, 0xC1, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x38, 0x00, 0x03, 0x18, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x1C, 0x00,
  0x0E, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x0F, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xC0,
  0xF0, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x30, 0x00, 0x70, 0x1C,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00,
  0xE0, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x06, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0x60, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x71, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x01, 0xC3, 0x00,
  0x01, 0xE1, 0xC0, 0x01, 0xF0, 0x60, 0x01, 0xF0, 0x38, 0x01, 0xD8, 0x0F,
  0x03, 0xCC, 0x03, 0xFF, 0x8C, 0x00, 0x7F, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x0E, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x78, 0x1E, 0x04,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x01, 0x80, 0x06, 0x0C, 0x00, 0x7F, 0xF0, 0x18, 0x60, 0x03,
  0xC3, 0xC0, 0x71, 0x80, 0x1C, 0x06, 0x01, 0xCC, 0x00, 0xC0, 0x18, 0x07,
  0x30, 0x06, 0x00, 0x60, 0x1D, 0xC0, 0x38, 0x01, 0x80, 0x66, 0x00, 0xC0,
  0x0C, 0x01, 0x98, 0x06, 0x00, 0x30, 0x06, 0x60, 0x18, 0x00, 0xC0, 0x1B,
  0x00, 0xC0, 0x03, 0x00, 0x6C, 0x03, 0x00, 0x18, 0x01, 0xB0, 0x0C, 0x00,
  0x60, 0x0C, 0xC0, 0x70, 0x01, 0x80, 0x33, 0x01, 0x80, 0x0E, 0x00, 0xCC,
  0x06, 0x00, 0x30, 0x06, 0x30, 0x18, 0x01, 0xC0, 0x18, 0xC0, 0x60, 0x07,
  0x00, 0xC3, 0x01, 0x80, 0x3C, 0x03, 0x0C, 0x07, 0x00, 0xB0, 0x18, 0x30,
  0x0C, 0x06, 0x40, 0xC0, 0xC0, 0x38, 0x71, 0x8F, 0x03, 0x00, 0x7F, 0x87,
  0xF0, 0x0C, 0x00, 0x30, 0x02, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x18, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x70,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x01, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x07, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0x60, 0x01, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0C, 0x01, 0xF8, 0x00, 0xC0,
  0x01, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x03,
  0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x02, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x01, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0C, 0x00, 0x78, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x07,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x06,
  0x00, 0x00, 0xE0, 0x18, 0x00, 0x0F, 0x00, 0x60, 0x00, 0x78, 0x01, 0x80,
  0x07, 0x80, 0x0E, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3E, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x1F, 0xFE, 0x30, 0x00, 0x3F, 0xF8, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x86, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x1C, 0x03,
  0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x18,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xE0,
  0x0C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x01, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0x67, 0x80, 0x00, 0x03, 0xBB, 0x00, 0x00, 0x0D, 0xCC, 0x00, 0x00, 0x3E,
  0x38, 0x00, 0x00, 0xF0, 0x60, 0x00, 0x07, 0x81, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80,
  0x00, 0xE0, 0x0E, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x01,
  0xB0, 0x0D, 0x80, 0x00, 0x01, 0xB8, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x03,
  0x30, 0x00, 0x00, 0xCC, 0x01, 0x98, 0x00, 0x00, 0xE6, 0x01, 0xCC, 0x00,
  0x00, 0x63, 0x00, 0xC6, 0x00, 0x00, 0x73, 0x80, 0x63, 0x00, 0x00, 0x31,
  0x80, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x18, 0xC0, 0x00, 0x18, 0x60, 0x1C,
  0x30, 0x00, 0x1C, 0x70, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x06, 0x0C, 0x00,
  0x0C, 0x18, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x06, 0x06,
  0x01, 0xC1, 0x80, 0x07, 0x07, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x60,
  0x60, 0x03, 0x81, 0x80, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x38, 0x0C, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x38,
  0x03, 0x00, 0x60, 0x06, 0x18, 0x01, 0x80, 0x30, 0x03, 0x1C, 0x00, 0xC0,
  0x38, 0x01, 0x8C, 0x00, 0xE0, 0x18, 0x00, 0xCE, 0x00, 0x60, 0x0C, 0x00,
  0x66, 0x00, 0x30, 0x06, 0x00, 0x36, 0x00, 0x18, 0x03, 0x00, 0x1B, 0x00,
  0x0C, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x00, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x60, 0x0F,
  0x00, 0x00, 0x30, 0x0C, 0xC0, 0x00, 0x18, 0x06, 0x60, 0x00, 0x0C, 0x03,
  0x30, 0x00, 0x0E, 0x01, 0x8C, 0x00, 0x06, 0x01, 0xC6, 0x00, 0x03, 0x00,
  0xC3, 0x00, 0x01, 0x80, 0x60, 0xC0, 0x00, 0xC0, 0x30, 0x60, 0x00, 0xE0,
  0x18, 0x30, 0x00, 0x60, 0x1C, 0x0C, 0x00, 0x30, 0x0C, 0x06, 0x00, 0x18,
  0x06, 0x03, 0x00, 0x1C, 0x03, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x60, 0x06,
  0x01, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x60, 0x06, 0x01,
  0xC0, 0x30, 0x03, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x60, 0x1C, 0x00, 0x60,
  0x30, 0x0C, 0x00, 0x30, 0x18, 0x06, 0x00, 0x1C, 0x1C, 0x03, 0x00, 0x06,
  0x0C, 0x03, 0x80, 0x03, 0x06, 0x01, 0x80, 0x01, 0xC3, 0x00, 0xC0, 0x00,
  0x61, 0x80, 0x60, 0x00, 0x31, 0xC0, 0x30, 0x00, 0x1C, 0xC0, 0x38, 0x00,
  0x06, 0x60, 0x18, 0x00, 0x03, 0x30, 0x0C, 0x00, 0x01, 0xD8, 0x06, 0x00,
  0x00, 0x78, 0x03, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0x80,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x00, 0x3C,
  0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x03,
  0xC0, 0x18, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0xE0, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x38, 0x18, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x00, 0x3C, 0x00, 0x60,
  0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0xE0, 0x18, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x00, 0xC0, 0x1F, 0x80, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x20, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x20, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x03, 0x03, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0x70, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0C,
  0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x03,
  0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x07, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C,
  0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x18, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x38,
  0x00, 0x1B, 0x00, 0x01, 0x8E, 0x00, 0x06, 0xC0, 0x00, 0xE3, 0x80, 0x03,
  0xB0, 0x00, 0x30, 0xE0, 0x00, 0xCC, 0x00, 0x1C, 0x38, 0x00, 0x73, 0x00,
  0x06, 0x06, 0x00, 0x18, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x30, 0x00, 0xC0,
  0x60, 0x03, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC3, 0x80, 0x1C, 0x06, 0x00,
  0x60, 0xE0, 0x06, 0x01, 0x80, 0x18, 0x18, 0x03, 0x80, 0x60, 0x0E, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x60, 0x18,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x60, 0x18, 0x06, 0x03, 0x80, 0x18,
  0x0C, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80,
  0x18, 0x18, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x18, 0x38, 0x01, 0x83,
  0x00, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x01, 0x87, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x80, 0x06, 0x18, 0x00, 0x18, 0x60, 0x01, 0x8E, 0x00, 0x06, 0x30,
  0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x07, 0x06,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0xC0, 0x18,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x70, 0x00, 0x06, 0x00, 0x60, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x8C, 0x00, 0x01, 0x87, 0x00, 0x01, 0x81, 0x80, 0x01, 0xC0,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x38,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x01, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x38, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x07,
  0x00, 0x1C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x06, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x31, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x0D, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x86, 0x1C, 0x30, 0xE1,
  0x83, 0x04, 0x00, 0x1F, 0xC1, 0x80, 0x3F, 0xF0, 0xC0, 0x38, 0x0C, 0x60,
  0x38, 0x03, 0x20, 0x38, 0x00, 0xB0, 0x38, 0x00, 0x78, 0x38, 0x00, 0x3C,
  0x18, 0x00, 0x1E, 0x1C, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x61, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x18, 0x00,
  0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80,
  0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0xF0, 0x30, 0x00, 0xD8, 0x1C,
  0x00, 0xCC, 0x06, 0x00, 0xEC, 0x03, 0x80, 0xE6, 0x00, 0xF3, 0xE3, 0x00,
  0x3F, 0xC1, 0x80, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0xFE, 0x00, 0x38, 0xFF, 0xE0, 0x0C, 0x70, 0x3C, 0x03, 0x38,
  0x07, 0x00, 0xD8, 0x00, 0xE0, 0x3C, 0x00, 0x18, 0x1B, 0x00, 0x06, 0x07,
  0x80, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x1C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x38, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x06, 0x80, 0x03,
  0x81, 0xB0, 0x00, 0xC0, 0x6C, 0x00, 0x70, 0x19, 0x80, 0x78, 0x04, 0x3E,
  0xFC, 0x03, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x01, 0xE0, 0x10, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x02, 0x01, 0xF3, 0xE0,
  0x0F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0xE0, 0x01, 0xFF, 0xC6, 0x00,
  0x1C, 0x07, 0x30, 0x01, 0xC0, 0x19, 0x80, 0x1C, 0x00, 0x6C, 0x01, 0xC0,
  0x01, 0x60, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x06, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0xF0, 0x06, 0x00, 0x07, 0x80, 0x30, 0x00, 0x6C, 0x01, 0x80,
  0x07, 0xC0, 0x0E, 0x00, 0x36, 0x00, 0x30, 0x07, 0x30, 0x01, 0xC0, 0x71,
  0x80, 0x07, 0x9F, 0x0C, 0x00, 0x1F, 0xE0, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x78, 0x1C, 0x07, 0x00, 0x60,
  0x70, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x00, 0x07, 0x38, 0x00,
  0x31, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0xC0, 0x01, 0xC6, 0x00, 0x3C, 0x30,
  0x07, 0xC3, 0x9F, 0xF8, 0x1F, 0xFE, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x10, 0x0F, 0x8F, 0x80, 0x3F, 0xF8, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x60,
  0x07, 0xFF, 0x08, 0x01, 0xE0, 0x73, 0x00, 0x70, 0x06, 0x60, 0x1C, 0x00,
  0x6C, 0x07, 0x00, 0x05, 0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x0F, 0x01, 0x80, 0x01, 0xE0, 0x30, 0x00, 0x6C, 0x06, 0x00, 0x1F, 0x00,
  0xE0, 0x07, 0x60, 0x0C, 0x01, 0xCC, 0x01, 0xC0, 0x71, 0x80, 0x1E, 0x7C,
  0x70, 0x01, 0xFE, 0x0C, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x10, 0x00, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x1F, 0xC0,
  0x06, 0x3F, 0xF8, 0x06, 0x38, 0x1E, 0x03, 0x30, 0x07, 0x01, 0xB0, 0x01,
  0x80, 0xF0, 0x00, 0xC0, 0xD0, 0x00, 0x70, 0x78, 0x00, 0x30, 0x38, 0x00,
  0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0,
  0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x1C,
  0x00, 0x06, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x43, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x07, 0x03, 0x80,
  0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x07, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x06, 0x03, 0x80, 0x06, 0x07,
  0x00, 0x06, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x70,
  0x00, 0x0C, 0xF8, 0x00, 0x1D, 0xD8, 0x00, 0x1B, 0x98, 0x00, 0x1F, 0x1C,
  0x00, 0x1E, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x03,
  0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0xC0, 0x60, 0x00,
  0xC0, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x01, 0x87,
  0xF0, 0x07, 0xF0, 0x06, 0x1F, 0xF8, 0x3F, 0xF8, 0x0C, 0x60, 0x70, 0xE0,
  0x70, 0x19, 0x80, 0x73, 0x80, 0x70, 0x36, 0x00, 0x6E, 0x00, 0x60, 0x78,
  0x00, 0xD8, 0x00, 0xC1, 0xA0, 0x01, 0xE0, 0x01, 0x83, 0xC0, 0x03, 0x80,
  0x03, 0x07, 0x00, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x70, 0x00, 0x70, 0x00, 0x70, 0xC0, 0x00, 0xC0,
  0x00, 0xC1, 0x80, 0x01, 0x80, 0x01, 0x83, 0x00, 0x03, 0x00, 0x03, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0xC3,
  0x80, 0x03, 0x80, 0x03, 0x86, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x00, 0x30,
  0xE0, 0x00, 0xE0, 0x00, 0xE1, 0x80, 0x01, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0x83, 0xF8, 0x01, 0x87, 0xFF,
  0x00, 0xC7, 0x03, 0xC0, 0x66, 0x00, 0xE0, 0x36, 0x00, 0x30, 0x1E, 0x00,
  0x1C, 0x1A, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x70, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0C,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC1,
  0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x38, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x00, 0xC0, 0x70, 0x01, 0xC1, 0xC0, 0x01,
  0x87, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0D,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x0E, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x61, 0xC0, 0x01, 0xC1, 0x80, 0x07,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x70, 0x03, 0xEF, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x01, 0x0F, 0xFE, 0x00, 0x18,
  0xE0, 0x78, 0x00, 0xCE, 0x01, 0xC0, 0x06, 0xC0, 0x07, 0x00, 0x3E, 0x00,
  0x18, 0x03, 0x60, 0x00, 0xC0, 0x1E, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x18,
  0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x38, 0x03, 0x60, 0x01, 0x80, 0x1B, 0x00, 0x1C, 0x00, 0xCC, 0x03, 0xC0,
  0x06, 0x3C, 0xF8, 0x00, 0x70, 0xFF, 0x80, 0x03, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xC0, 0x1F,
  0xFC, 0x20, 0x0E, 0x03, 0x98, 0x07, 0x00, 0x66, 0x03, 0x80, 0x0D, 0x81,
  0xC0, 0x01, 0x60, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x38, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x81, 0x80, 0x01,
  0xE0, 0x60, 0x00, 0xD8, 0x18, 0x00, 0x7C, 0x07, 0x00, 0x1B, 0x00, 0xC0,
  0x0C, 0xC0, 0x38, 0x0E, 0x30, 0x07, 0x9F, 0x1C, 0x00, 0xFF, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x83,
  0xF0, 0x10, 0xFF, 0x03, 0x1C, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0xE0, 0x0E,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE1, 0x00, 0x06, 0x0C, 0x00, 0xF0, 0x7E, 0x3F, 0x00, 0xFF,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x0F, 0xFF, 0x7F, 0xFE, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x98, 0x07, 0xF0, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x07,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06,
  0x18, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x70, 0x00, 0x18, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30,
  0x60, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x60,
  0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xE0, 0xC0, 0x03, 0x60,
  0xC0, 0x06, 0xC0, 0xC0, 0x0E, 0xC0, 0xE0, 0x1C, 0xC0, 0x7D, 0xF0, 0xC0,
  0x3F, 0xE0, 0x80, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0D, 0xC0, 0x00, 0xEE, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x03,
  0x0C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0xC0,
  0x0E, 0x06, 0x00, 0x60, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x00,
  0x30, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x0E,
  0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x33, 0x80, 0x01,
  0xD8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x70, 0x00,
  0x6E, 0x00, 0x1C, 0x00, 0x3B, 0x80, 0x07, 0x00, 0x0C, 0xE0, 0x03, 0x40,
  0x03, 0x18, 0x00, 0xD0, 0x01, 0x86, 0x00, 0x66, 0x00, 0x61, 0x80, 0x19,
  0x80, 0x38, 0x60, 0x0C, 0x60, 0x0C, 0x18, 0x03, 0x18, 0x07, 0x06, 0x01,
  0x86, 0x01, 0x81, 0x80, 0x61, 0x80, 0x60, 0x60, 0x30, 0x60, 0x30, 0x18,
  0x0C, 0x18, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x01, 0x81, 0x81, 0x81, 0x80,
  0x60, 0xE0, 0x60, 0xE0, 0x18, 0x30, 0x18, 0x30, 0x06, 0x1C, 0x06, 0x1C,
  0x01, 0x86, 0x01, 0x86, 0x00, 0x61, 0x80, 0x61, 0x80, 0x18, 0xC0, 0x18,
  0xC0, 0x06, 0x30, 0x06, 0x30, 0x01, 0x98, 0x01, 0x98, 0x00, 0x66, 0x00,
  0x66, 0x00, 0x1B, 0x00, 0x0B, 0x80, 0x06, 0xC0, 0x02, 0xC0, 0x01, 0xE0,
  0x00, 0xB0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x03,
  0x00, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x18, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x0C, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x70, 0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x03, 0x80, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x60, 0x07, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0x1C, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x9F, 0xFC, 0x00, 0xFC, 0x0F, 0x80,
  0xF8, 0x01, 0xFF, 0xE8, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 41, 13, 1, -41 },
  { 63, 13, 15, 18, 6, -41 },
  { 88, 31, 41, 31, 1, -41 },
  { 247, 25, 47, 28, 2, -44 },
  { 394, 33, 43, 40, 4, -42 },
  { 572, 29, 43, 32, 1, -42 },
  { 728, 5, 15, 10, 6, -41 },
  { 738, 16, 50, 14, 2, -41 },
  { 838, 17, 50, 14, -4, -41 },
  { 945, 21, 22, 27, 7, -44 },
  { 1003, 25, 27, 30, 3, -34 },
  { 1088, 9, 13, 11, -3, -6 },
  { 1103, 13, 2, 17, 2, -17 },
  { 1107, 4, 4, 12, 1, -4 },
  { 1109, 26, 41, 18, -3, -41 },
  { 1243, 24, 43, 28, 3, -42 },
  { 1372, 14, 41, 28, 8, -41 },
  { 1444, 26, 42, 28, 0, -42 },
  { 1581, 27, 43, 28, 0, -42 },
  { 1727, 26, 42, 28, 0, -42 },
  { 1864, 26, 42, 28, 1, -41 },
  { 2001, 25, 43, 28, 3, -42 },
  { 2136, 24, 41, 28, 5, -41 },
  { 2259, 26, 43, 28, 1, -42 },
  { 2399, 25, 43, 28, 2, -42 },
  { 2534, 10, 31, 12, 1, -31 },
  { 2573, 14, 38, 12, -3, -31 },
  { 2640, 25, 26, 30, 3, -34 },
  { 2722, 25, 14, 30, 3, -27 },
  { 2766, 25, 26, 30, 3, -34 },
  { 2848, 19, 42, 20, 3, -42 },
  { 2948, 38, 46, 42, 3, -41 },
  { 3167, 27, 42, 27, -3, -42 },
  { 3309, 28, 41, 30, 2, -41 },
  { 3453, 28, 43, 29, 4, -42 },
  { 3604, 30, 41, 34, 2, -41 },
  { 3758, 27, 41, 27, 2, -41 },
  { 3897, 27, 41, 25, 2, -41 },
  { 4036, 31, 43, 35, 4, -42 },
  { 4203, 33, 41, 35, 2, -41 },
  { 4373, 19, 41, 15, -1, -41 },
  { 4471, 22, 51, 12, -9, -41 },
  { 4612, 30, 41, 28, 2, -41 },
  { 4766, 18, 41, 25, 2, -41 },
  { 4859, 41, 41, 43, 2, -41 },
  { 5070, 33, 41, 35, 2, -41 },
  { 5240, 30, 43, 36, 4, -42 },
  { 5402, 27, 41, 28, 2, -41 },
  { 5541, 30, 52, 36, 4, -42 },
  { 5736, 27, 41, 29, 2, -41 },
  { 5875, 27, 43, 26, 0, -42 },
  { 6021, 24, 41, 24, 5, -41 },
  { 6144, 31, 42, 35, 4, -41 },
  { 6307, 26, 41, 27, 6, -41 },
  { 6441, 42, 41, 44, 6, -41 },
  { 6657, 32, 41, 25, -3, -41 },
  { 6821, 25, 41, 24, 5, -41 },
  { 6950, 30, 41, 26, -1, -41 },
  { 7104, 22, 50, 17, -1, -41 },
  { 7242, 9, 41, 19, 6, -41 },
  { 7289, 22, 50, 17, -4, -41 },
  { 7427, 25, 24, 29, 2, -42 },
  { 7502, 20, 2, 20, -5, 6 },
  { 7507, 6, 9, 13, 9, -44 },
  { 7514, 25, 32, 28, 2, -31 },
  { 7614, 26, 45, 29, 1, -44 },
  { 7761, 20, 32, 23, 3, -31 },
  { 7841, 29, 45, 29, 2, -44 },
  { 8005, 21, 32, 25, 3, -31 },
  { 8089, 29, 58, 14, -7, -44 },
  { 8300, 27, 45, 29, 1, -31 },
  { 8452, 25, 44, 28, 1, -44 },
  { 8590, 12, 42, 11, 1, -42 },
  { 8653, 21, 56, 12, -8, -42 },
  { 8800, 24, 44, 23, 1, -44 },
  { 8932, 12, 44, 11, 1, -44 },
  { 8998, 39, 31, 43, 1, -31 },
  { 9150, 25, 31, 28, 1, -31 },
  { 9247, 23, 32, 29, 3, -31 },
  { 9339, 29, 44, 29, -2, -31 },
  { 9499, 26, 45, 29, 2, -31 },
  { 9646, 20, 31, 19, 1, -31 },
  { 9724, 21, 32, 22, 0, -31 },
  { 9808, 15, 39, 16, 2, -38 },
  { 9882, 24, 32, 28, 3, -31 },
  { 9978, 21, 31, 22, 3, -31 },
  { 10060, 34, 31, 35, 3, -31 },
  { 10192, 27, 31, 23, -2, -31 },
  { 10297, 31, 45, 22, -6, -31 },
  { 10472, 23, 31, 21, -1, -31 },
  { 10562, 20, 50, 19, 2, -41 },
  { 10687, 2, 58, 27, 13, -44 },
  { 10702, 20, 50, 19, -3, -41 },
  { 10827, 25, 5, 30, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC58PT7B_H_
