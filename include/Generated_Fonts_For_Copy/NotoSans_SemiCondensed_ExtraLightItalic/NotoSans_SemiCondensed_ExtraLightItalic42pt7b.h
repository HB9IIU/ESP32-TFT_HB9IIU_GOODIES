#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xC0, 0x30, 0xCC, 0x33, 0x08, 0x86,
  0x21, 0x98, 0x66, 0x11, 0x04, 0x41, 0x10, 0xCC, 0x20, 0x00, 0x10, 0x30,
  0x00, 0xC0, 0x80, 0x02, 0x02, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x81, 0x00, 0x04, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC0, 0x60, 0x40, 0x01, 0x01, 0x00, 0x04, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0x80, 0x02, 0x02, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x40, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x30, 0x30, 0x00, 0x80, 0x80,
  0x02, 0x02, 0x00, 0x18, 0x18, 0x00, 0x60, 0x40, 0x01, 0x01, 0x00, 0x04,
  0x0C, 0x00, 0x30, 0x20, 0x00, 0x80, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0xFF, 0x80, 0xE6, 0x70, 0x61, 0x00,
  0x30, 0x40, 0x0C, 0x10, 0x02, 0x04, 0x00, 0x83, 0x00, 0x20, 0x80, 0x0C,
  0x20, 0x03, 0x08, 0x00, 0x66, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x05, 0xC0, 0x03, 0x38, 0x00, 0xC6, 0x00, 0x20, 0x80, 0x08, 0x30,
  0x02, 0x0C, 0x01, 0x82, 0x00, 0x41, 0x80, 0x10, 0x62, 0x04, 0x70, 0xF9,
  0xF8, 0x0F, 0xF8, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0xC0, 0x04, 0x1C, 0x40, 0x0C, 0x10, 0x60, 0x18, 0x30, 0x60,
  0x10, 0x20, 0x20, 0x30, 0x60, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x60,
  0xC0, 0xC0, 0x61, 0x80, 0xC0, 0x41, 0x00, 0xC0, 0x43, 0x00, 0xC0, 0xC6,
  0x00, 0x80, 0xC4, 0x7C, 0x80, 0x8C, 0xC6, 0xC1, 0x98, 0x83, 0xC1, 0x11,
  0x83, 0x42, 0x33, 0x03, 0x7C, 0x63, 0x03, 0x00, 0x42, 0x03, 0x00, 0xC6,
  0x03, 0x00, 0x86, 0x02, 0x01, 0x86, 0x02, 0x03, 0x04, 0x06, 0x02, 0x04,
  0x06, 0x06, 0x04, 0x04, 0x0C, 0x04, 0x0C, 0x08, 0x04, 0x0C, 0x18, 0x04,
  0x18, 0x30, 0x06, 0x30, 0x60, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x7F,
  0x00, 0x06, 0x1C, 0x00, 0x60, 0x60, 0x02, 0x01, 0x00, 0x30, 0x08, 0x01,
  0x80, 0x40, 0x0C, 0x02, 0x00, 0x60, 0x30, 0x03, 0x01, 0x00, 0x18, 0x18,
  0x00, 0x41, 0x80, 0x03, 0x38, 0x00, 0x1B, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xCC, 0x00, 0x0C, 0x30, 0x18, 0xC1, 0x80, 0xCC, 0x06, 0x04,
  0xC0, 0x30, 0x64, 0x00, 0xC2, 0x60, 0x02, 0x33, 0x00, 0x1B, 0x18, 0x00,
  0x70, 0xC0, 0x03, 0x86, 0x00, 0x18, 0x30, 0x01, 0xE0, 0xC0, 0x39, 0x87,
  0x07, 0x0C, 0x0F, 0xF0, 0x30, 0x33, 0x32, 0x26, 0x64, 0x44, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x0C, 0x18,
  0x0E, 0x20, 0x06, 0x40, 0x03, 0xBF, 0x03, 0xC0, 0x0E, 0x00, 0x32, 0x00,
  0xC4, 0x03, 0x04, 0x0C, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x0C, 0x30, 0x86, 0x18, 0xC3, 0x08,
  0x63, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0xC3, 0x80, 0xC0, 0x40, 0xC0, 0x30, 0xC0,
  0x08, 0x60, 0x04, 0x60, 0x02, 0x30, 0x01, 0x30, 0x00, 0x98, 0x00, 0x48,
  0x00, 0x2C, 0x00, 0x16, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03,
  0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x26, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0C, 0x10, 0x04, 0x0C,
  0x06, 0x03, 0x0E, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0xE0, 0x68, 0x76, 0x31,
  0xB8, 0x48, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x00, 0x00, 0x7F, 0x00, 0x38,
  0x38, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x78,
  0x38, 0x1C, 0x01, 0x81, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x40, 0x06, 0x0E, 0x03, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xA0, 0x00, 0x64, 0x00, 0x09, 0x80, 0x03,
  0x30, 0x00, 0xC4, 0x00, 0x30, 0x80, 0x0C, 0x30, 0x01, 0x06, 0x00, 0x60,
  0xC0, 0x18, 0x10, 0x06, 0x02, 0x00, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03,
  0x03, 0x00, 0x40, 0xC0, 0x08, 0x10, 0x03, 0x06, 0x00, 0x61, 0xFF, 0xFF,
  0xC0, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0xFF, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x40, 0x0C, 0x0E, 0x07, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x1C,
  0x10, 0x1C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x23,
  0xF8, 0x1B, 0x83, 0x07, 0x80, 0x61, 0x40, 0x0C, 0x60, 0x03, 0x38, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x23,
  0x00, 0x18, 0xC0, 0x06, 0x10, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x60, 0x38,
  0x70, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x38, 0x30, 0x0C, 0x03, 0x03, 0x00, 0x20, 0x60, 0x06,
  0x08, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x03, 0x04, 0x00, 0xC0, 0xC0, 0x18,
  0x18, 0x06, 0x01, 0x81, 0x80, 0x18, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x3D, 0xC0, 0x0E, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x08, 0x30, 0x01, 0x84,
  0x00, 0x31, 0x80, 0x02, 0x30, 0x00, 0x46, 0x00, 0x08, 0xC0, 0x03, 0x18,
  0x00, 0x61, 0x00, 0x18, 0x30, 0x06, 0x03, 0x83, 0x80, 0x3F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x60, 0xC0, 0x30, 0x18, 0x18, 0x03, 0x0C, 0x00, 0xC2,
  0x00, 0x31, 0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x44, 0x00, 0x13, 0x00,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0xC4, 0x00, 0x71, 0x80, 0x38, 0x60, 0x1A,
  0x0C, 0x0D, 0x81, 0xFE, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x81, 0xC0, 0x3F, 0xC0, 0x00, 0x0E, 0x18, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x0C, 0x18, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x10,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xE0, 0xE0, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x81, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x18, 0x00, 0x00, 0x22, 0x00,
  0xFE, 0x04, 0xC0, 0x60, 0x40, 0x90, 0x18, 0x18, 0x16, 0x06, 0x03, 0x02,
  0xC0, 0x80, 0x40, 0x50, 0x30, 0x08, 0x0A, 0x04, 0x03, 0x03, 0xC1, 0x80,
  0x60, 0x78, 0x30, 0x08, 0x0B, 0x04, 0x03, 0x01, 0x40, 0x80, 0x60, 0x68,
  0x10, 0x0C, 0x09, 0x02, 0x03, 0x83, 0x20, 0x60, 0xF0, 0xC4, 0x0C, 0x32,
  0x30, 0xC0, 0xFC, 0x7C, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x02, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x04, 0x80,
  0x00, 0xC8, 0x00, 0x08, 0x80, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x03, 0x0C,
  0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0xC0, 0x0C, 0x0C, 0x00, 0x80,
  0x40, 0x18, 0x04, 0x01, 0x00, 0x40, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x60,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x30,
  0x00, 0x63, 0x00, 0x02, 0x60, 0x00, 0x26, 0x00, 0x02, 0xC0, 0x00, 0x2C,
  0x00, 0x03, 0x01, 0xFF, 0x80, 0x30, 0x7E, 0x03, 0x00, 0x60, 0x30, 0x03,
  0x02, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00,
  0x30, 0x40, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x01, 0xC0, 0x81,
  0xF0, 0x0F, 0xFC, 0x01, 0x80, 0x70, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x10,
  0x00, 0xC1, 0x00, 0x04, 0x30, 0x00, 0x43, 0x00, 0x04, 0x30, 0x00, 0xC2,
  0x00, 0x0C, 0x60, 0x00, 0x86, 0x00, 0x18, 0x60, 0x03, 0x04, 0x00, 0xE0,
  0x40, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0x03, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0C,
  0x3F, 0x00, 0x30, 0x0E, 0x00, 0xC0, 0x0C, 0x02, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x30,
  0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x20, 0x00, 0x30, 0x80,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x08, 0x60, 0x00, 0x61, 0x00, 0x01,
  0x84, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x08,
  0x00, 0x30, 0x60, 0x01, 0xC1, 0x80, 0x0E, 0x06, 0x00, 0x70, 0x10, 0x07,
  0x00, 0x43, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x01,
  0xFF, 0xF0, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xC0, 0xF0, 0x18, 0x00, 0x40, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xFC, 0xC0, 0x0F, 0xF2,
  0x00, 0x00, 0x88, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00, 0x62, 0x00,
  0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x10, 0xC0, 0x00, 0xC1, 0x80, 0x03,
  0x06, 0x00, 0x0C, 0x0E, 0x00, 0x20, 0x1C, 0x07, 0x80, 0x1F, 0xF8, 0x00,
  0x01, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x02,
  0x02, 0x00, 0x02, 0x02, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x04, 0x00, 0x04, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x10, 0x10, 0x00, 0x10, 0x10, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x20, 0x20, 0x00, 0x20,
  0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0x40, 0x00, 0x40,
  0x40, 0x00, 0x40, 0xC0, 0x00, 0xC0, 0x03, 0xFC, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x87, 0x00, 0xFE,
  0x00, 0x01, 0x00, 0x0E, 0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x20, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x00,
  0x04, 0x0C, 0x00, 0x08, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0x38, 0x00, 0x02, 0xD8, 0x00, 0x0F, 0x30, 0x00, 0x1C,
  0x20, 0x00, 0x30, 0x60, 0x00, 0x40, 0xC0, 0x00, 0x80, 0x80, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x10, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x02, 0x00, 0x18, 0x04, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xA0, 0x00, 0x0A,
  0x02, 0xC0, 0x00, 0x78, 0x1B, 0x00, 0x03, 0x60, 0x6C, 0x00, 0x0D, 0x81,
  0xB0, 0x00, 0x64, 0x04, 0x40, 0x01, 0x90, 0x11, 0x00, 0x0C, 0xC0, 0xC4,
  0x00, 0x23, 0x03, 0x10, 0x01, 0x8C, 0x0C, 0x60, 0x04, 0x20, 0x21, 0x80,
  0x30, 0x80, 0x86, 0x00, 0x86, 0x06, 0x18, 0x06, 0x18, 0x18, 0x20, 0x30,
  0x60, 0x60, 0x80, 0xC1, 0x01, 0x02, 0x06, 0x0C, 0x04, 0x08, 0x18, 0x30,
  0x30, 0x20, 0xC0, 0xC0, 0xC0, 0xC2, 0x02, 0x02, 0x03, 0x18, 0x08, 0x08,
  0x0C, 0x40, 0x60, 0x60, 0x13, 0x01, 0x81, 0x80, 0x48, 0x06, 0x06, 0x01,
  0x60, 0x10, 0x10, 0x07, 0x00, 0x40, 0x40, 0x1C, 0x03, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x01, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x80, 0xE0, 0x00, 0xC0,
  0x50, 0x00, 0x60, 0x2C, 0x00, 0x30, 0x36, 0x00, 0x10, 0x19, 0x00, 0x08,
  0x0C, 0xC0, 0x0C, 0x04, 0x60, 0x06, 0x02, 0x10, 0x03, 0x03, 0x0C, 0x01,
  0x01, 0x86, 0x01, 0x80, 0xC1, 0x00, 0xC0, 0x40, 0xC0, 0x60, 0x20, 0x60,
  0x20, 0x30, 0x10, 0x10, 0x18, 0x0C, 0x18, 0x0C, 0x06, 0x0C, 0x04, 0x01,
  0x06, 0x02, 0x00, 0xC2, 0x03, 0x00, 0x61, 0x01, 0x80, 0x11, 0x80, 0xC0,
  0x0C, 0xC0, 0x40, 0x06, 0x60, 0x60, 0x01, 0x20, 0x30, 0x00, 0xD0, 0x18,
  0x00, 0x78, 0x08, 0x00, 0x1C, 0x04, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0x03, 0x80, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x0C,
  0x00, 0x18, 0x20, 0x00, 0x61, 0x80, 0x00, 0x8C, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x40, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1A, 0x00,
  0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x0C, 0x80, 0x00, 0x32, 0x00, 0x00,
  0xCC, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80, 0x06, 0x06,
  0x00, 0x38, 0x0C, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x30, 0xF8, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x02, 0x00, 0x20,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x02,
  0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00, 0x40, 0x80, 0x0C, 0x08, 0x01,
  0x81, 0x80, 0xF0, 0x1F, 0xFC, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0x03, 0x80, 0x30, 0x03, 0x01, 0x80,
  0x0C, 0x0C, 0x00, 0x18, 0x20, 0x00, 0x61, 0x80, 0x00, 0x8C, 0x00, 0x03,
  0x30, 0x00, 0x0C, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x40,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1A, 0x00, 0x00, 0x68, 0x00, 0x01, 0xA0, 0x00, 0x0C, 0x80, 0x00, 0x32,
  0x00, 0x00, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC1, 0x80,
  0x06, 0x06, 0x00, 0x38, 0x0C, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0x3F, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFE, 0x00, 0x30,
  0xF8, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x02, 0x00, 0x20, 0x60, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0xC0, 0x80, 0x18, 0x08, 0x03, 0x01, 0xFF, 0xE0,
  0x1F, 0xF0, 0x01, 0x81, 0x00, 0x10, 0x18, 0x01, 0x01, 0x80, 0x30, 0x08,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00, 0x40, 0x60, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x06, 0x04, 0x00, 0x20, 0x40, 0x03, 0x0C, 0x00, 0x30, 0x00,
  0x7F, 0xC0, 0x38, 0x1C, 0x0C, 0x00, 0x83, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x40, 0x06, 0x0E, 0x03, 0x80, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC2,
  0x00, 0x03, 0x18, 0x00, 0x08, 0x60, 0x00, 0x21, 0x80, 0x01, 0x84, 0x00,
  0x06, 0x10, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x20, 0x00, 0x30, 0x80, 0x00, 0xC6, 0x00, 0x02, 0x18, 0x00, 0x18, 0x60,
  0x00, 0x61, 0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x10, 0xC0, 0x00,
  0xC3, 0x00, 0x03, 0x08, 0x00, 0x08, 0x20, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x0C, 0x0C, 0x00, 0x60, 0x18, 0x03, 0x80, 0x38, 0x3C, 0x00, 0x7F,
  0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0x4C,
  0x00, 0x19, 0x80, 0x02, 0x10, 0x00, 0xC2, 0x00, 0x10, 0x40, 0x06, 0x08,
  0x00, 0x81, 0x00, 0x30, 0x20, 0x04, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18,
  0x0C, 0x03, 0x01, 0x00, 0x60, 0x60, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x10,
  0x40, 0x02, 0x18, 0x00, 0x42, 0x00, 0x08, 0xC0, 0x01, 0x10, 0x00, 0x26,
  0x00, 0x06, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x05, 0x00, 0x1C, 0x00, 0x68, 0x00, 0xA0, 0x03, 0x40, 0x0D, 0x80, 0x32,
  0x00, 0x4C, 0x01, 0x90, 0x06, 0x60, 0x08, 0x80, 0x33, 0x00, 0xC4, 0x01,
  0x18, 0x04, 0x20, 0x18, 0xC0, 0x61, 0x00, 0x86, 0x02, 0x08, 0x0C, 0x30,
  0x30, 0x40, 0x41, 0x81, 0x82, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0xC0,
  0x83, 0x03, 0x04, 0x04, 0x18, 0x18, 0x60, 0x31, 0x80, 0xC2, 0x01, 0x8C,
  0x06, 0x30, 0x0C, 0x40, 0x31, 0x80, 0x66, 0x01, 0x88, 0x03, 0x20, 0x0C,
  0xC0, 0x1B, 0x00, 0x24, 0x00, 0xD0, 0x01, 0x60, 0x07, 0x80, 0x0A, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x02, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x18, 0x00,
  0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0x42, 0x00, 0x00, 0x8C, 0x00, 0x01,
  0xB0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x68, 0x00, 0x00, 0x98, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x80, 0x06, 0x01, 0x00,
  0x08, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x04, 0x03, 0x00, 0x0C, 0x04,
  0x00, 0x18, 0x18, 0x00, 0x10, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xC8, 0x00, 0xC4, 0x00, 0x63, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30, 0x20,
  0x30, 0x18, 0x10, 0x0C, 0x18, 0x06, 0x18, 0x01, 0x08, 0x00, 0x8C, 0x00,
  0x6C, 0x00, 0x34, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xC1,
  0x81, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x81, 0x83, 0x06, 0x04,
  0x08, 0x10, 0x30, 0x60, 0xC0, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x20,
  0x40, 0xC0, 0x00, 0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x05, 0x00, 0x03,
  0x60, 0x01, 0x88, 0x00, 0x42, 0x00, 0x30, 0xC0, 0x18, 0x10, 0x06, 0x06,
  0x03, 0x01, 0x80, 0x80, 0x20, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x46,
  0x00, 0x19, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3,
  0x18, 0x61, 0x0C, 0x20, 0x00, 0x60, 0x00, 0xFE, 0x30, 0x60, 0xC8, 0x30,
  0x1A, 0x18, 0x03, 0x84, 0x00, 0xE3, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x03,
  0x10, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x01, 0x88,
  0x00, 0x62, 0x00, 0x18, 0x80, 0x0C, 0x20, 0x03, 0x0C, 0x01, 0xC3, 0x00,
  0xF0, 0x40, 0x68, 0x1C, 0x32, 0x03, 0xF0, 0x80, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x07, 0x00, 0xC7, 0xF0, 0x33, 0x06, 0x0D,
  0x00, 0x82, 0x80, 0x30, 0xE0, 0x0C, 0x70, 0x01, 0x18, 0x00, 0x46, 0x00,
  0x11, 0x80, 0x0C, 0x40, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x08,
  0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x46, 0x00, 0x31, 0x80, 0x18, 0x50,
  0x06, 0x34, 0x03, 0x0C, 0xC3, 0x82, 0x1F, 0x80, 0x00, 0x78, 0x07, 0xFC,
  0x1C, 0x08, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x07,
  0x04, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x07, 0x04, 0x03, 0xFC, 0xC0, 0x60, 0x6C, 0x0C, 0x02,
  0x81, 0x80, 0x28, 0x30, 0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00,
  0x10, 0x40, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0,
  0x02, 0x08, 0x00, 0x60, 0x80, 0x06, 0x08, 0x00, 0xE0, 0x80, 0x0E, 0x0C,
  0x01, 0xC0, 0xC0, 0x34, 0x04, 0x06, 0xC0, 0x70, 0xCC, 0x03, 0xF8, 0x80,
  0x00, 0x60, 0x07, 0xF8, 0x1C, 0x18, 0x60, 0x31, 0x80, 0x62, 0x00, 0x4C,
  0x01, 0x90, 0x03, 0x60, 0x0C, 0x80, 0x31, 0x03, 0xC7, 0xFE, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x07, 0x06, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1C, 0x40, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x98, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x0F, 0xF1, 0x01, 0xC1, 0xB0, 0x30, 0x0B, 0x06, 0x00, 0xE0,
  0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x41, 0x00, 0x04,
  0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x08, 0x20, 0x01,
  0x82, 0x00, 0x18, 0x20, 0x03, 0x82, 0x00, 0x38, 0x30, 0x07, 0x03, 0x00,
  0xD0, 0x10, 0x1B, 0x01, 0xC3, 0x30, 0x0F, 0xE2, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x80, 0x30, 0x0F, 0x1E, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x0E, 0x03, 0x1F, 0xC1, 0xB8, 0x30,
  0xF0, 0x08, 0x50, 0x04, 0x30, 0x02, 0x38, 0x01, 0x18, 0x00, 0x8C, 0x00,
  0xC4, 0x00, 0x62, 0x00, 0x33, 0x00, 0x11, 0x80, 0x08, 0xC0, 0x0C, 0x40,
  0x06, 0x60, 0x03, 0x30, 0x01, 0x18, 0x00, 0x88, 0x00, 0xC4, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x11, 0x80, 0x18, 0x03, 0x03, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x27,
  0x00, 0x7C, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x60, 0x40, 0x60, 0x20, 0x60, 0x30,
  0x60, 0x18, 0x60, 0x0C, 0x60, 0x04, 0x60, 0x02, 0x70, 0x03, 0x78, 0x01,
  0xE4, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x60, 0x60, 0x30, 0x30, 0x18, 0x08,
  0x08, 0x06, 0x04, 0x03, 0x06, 0x00, 0x83, 0x00, 0x61, 0x80, 0x30, 0x01,
  0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x00, 0x18, 0x03, 0x00, 0xCF,
  0xE0, 0xFE, 0x0D, 0x83, 0x18, 0x70, 0xB0, 0x12, 0x03, 0x0A, 0x01, 0x40,
  0x30, 0xC0, 0x1C, 0x01, 0x1C, 0x01, 0x80, 0x31, 0x80, 0x18, 0x03, 0x18,
  0x01, 0x00, 0x31, 0x00, 0x30, 0x02, 0x10, 0x03, 0x00, 0x23, 0x00, 0x30,
  0x06, 0x30, 0x02, 0x00, 0x63, 0x00, 0x60, 0x06, 0x20, 0x06, 0x00, 0x46,
  0x00, 0x60, 0x04, 0x60, 0x04, 0x00, 0xC6, 0x00, 0x40, 0x0C, 0x40, 0x0C,
  0x00, 0xC4, 0x00, 0xC0, 0x08, 0xC0, 0x0C, 0x00, 0x8C, 0x00, 0x80, 0x18,
  0xC0, 0x18, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x1F, 0xC0, 0xDC, 0x18, 0x2C,
  0x02, 0x0A, 0x00, 0x83, 0x00, 0x31, 0xC0, 0x08, 0x60, 0x02, 0x18, 0x01,
  0x86, 0x00, 0x61, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x01, 0x0C, 0x00, 0xC2,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x02, 0x18, 0x00, 0x84, 0x00, 0x61, 0x00,
  0x18, 0xC0, 0x06, 0x30, 0x01, 0x0C, 0x00, 0xC0, 0x00, 0x70, 0x01, 0xFE,
  0x01, 0xC1, 0x81, 0x80, 0x61, 0x80, 0x11, 0x80, 0x0C, 0xC0, 0x06, 0xC0,
  0x03, 0x60, 0x01, 0xA0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x16,
  0x00, 0x1B, 0x00, 0x0D, 0x00, 0x06, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x03,
  0x18, 0x01, 0x86, 0x01, 0x81, 0x83, 0x80, 0x7F, 0x00, 0x00, 0x07, 0x00,
  0x31, 0xFC, 0x03, 0x30, 0x60, 0x24, 0x02, 0x02, 0x80, 0x30, 0x38, 0x03,
  0x07, 0x00, 0x10, 0x70, 0x01, 0x06, 0x00, 0x10, 0x60, 0x03, 0x04, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x02, 0x08, 0x00, 0x61, 0x80,
  0x06, 0x18, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x40, 0x18, 0x34,
  0x03, 0x03, 0x30, 0xE0, 0x31, 0xF8, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0x10, 0x70, 0x6C, 0x30, 0x0B, 0x18, 0x03, 0x84, 0x00, 0x63, 0x00, 0x18,
  0x80, 0x06, 0x60, 0x01, 0x10, 0x00, 0x4C, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0x88, 0x00, 0x62, 0x00, 0x18, 0x80, 0x0E, 0x20, 0x03,
  0x8C, 0x01, 0xC3, 0x00, 0xD0, 0x40, 0x6C, 0x1C, 0x33, 0x03, 0xF8, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x31, 0xF0, 0xDC, 0x02, 0xC0, 0x0A, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0xFC, 0x38, 0x18, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x88, 0x03, 0x18, 0x1C, 0x1F, 0xF0, 0x00,
  0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x0F, 0xFC, 0x60, 0x10, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0xF0, 0x18,
  0x00, 0x8C, 0x00, 0xC4, 0x00, 0x62, 0x00, 0x33, 0x00, 0x11, 0x80, 0x08,
  0xC0, 0x0C, 0x40, 0x06, 0x20, 0x03, 0x30, 0x01, 0x18, 0x00, 0x88, 0x00,
  0xC4, 0x00, 0x66, 0x00, 0x33, 0x00, 0x31, 0x80, 0x18, 0x80, 0x1C, 0x40,
  0x0E, 0x30, 0x0A, 0x18, 0x0D, 0x06, 0x1C, 0x81, 0xF8, 0xC0, 0xC0, 0x03,
  0xC0, 0x06, 0xC0, 0x04, 0x40, 0x0C, 0x40, 0x18, 0x40, 0x18, 0x40, 0x30,
  0x40, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x60, 0xC0, 0x61, 0x80,
  0x21, 0x00, 0x23, 0x00, 0x22, 0x00, 0x26, 0x00, 0x24, 0x00, 0x2C, 0x00,
  0x28, 0x00, 0x38, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x01, 0xE0, 0x0C, 0x01,
  0x90, 0x0E, 0x00, 0x88, 0x07, 0x80, 0xC4, 0x02, 0xC0, 0x62, 0x03, 0x60,
  0x61, 0x01, 0x30, 0x30, 0x81, 0x98, 0x10, 0x40, 0x8C, 0x18, 0x20, 0xC6,
  0x08, 0x10, 0x43, 0x0C, 0x08, 0x60, 0x84, 0x04, 0x20, 0x46, 0x02, 0x30,
  0x23, 0x01, 0x10, 0x13, 0x00, 0x98, 0x09, 0x80, 0x48, 0x04, 0x80, 0x2C,
  0x02, 0xC0, 0x14, 0x01, 0x40, 0x0A, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x70, 0x30, 0x04, 0x03, 0x00, 0xC0, 0x10,
  0x18, 0x01, 0x83, 0x00, 0x08, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00,
  0x58, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x19, 0x00, 0x03, 0x18, 0x00, 0x61, 0x80, 0x06, 0x08, 0x00, 0xC0, 0xC0,
  0x18, 0x04, 0x03, 0x00, 0x60, 0x20, 0x06, 0x0E, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x01, 0x00, 0x18, 0x02, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40,
  0x00, 0x81, 0x80, 0x01, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x10, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x80, 0x00, 0x33, 0x00, 0x00, 0x64, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x23, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x78, 0x01, 0x80, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xF8,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x03,
  0xE0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x74, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x70, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x5F, 0xF0, 0x1C,
  0x0F, 0x1E, 0x00, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 30, 9, 1, -30 },
  { 31, 10, 11, 13, 4, -30 },
  { 45, 22, 30, 22, 1, -30 },
  { 128, 18, 34, 20, 1, -32 },
  { 205, 24, 31, 29, 3, -30 },
  { 298, 21, 30, 23, 1, -30 },
  { 377, 4, 11, 7, 4, -30 },
  { 383, 12, 37, 10, 1, -30 },
  { 439, 12, 37, 10, -3, -30 },
  { 495, 15, 16, 19, 5, -32 },
  { 525, 18, 20, 21, 2, -25 },
  { 570, 6, 10, 8, -2, -5 },
  { 578, 10, 1, 12, 1, -12 },
  { 580, 3, 3, 8, 1, -3 },
  { 582, 18, 30, 13, -2, -30 },
  { 650, 17, 30, 20, 2, -30 },
  { 714, 10, 30, 20, 6, -30 },
  { 752, 19, 30, 20, 0, -30 },
  { 824, 19, 30, 20, 0, -30 },
  { 896, 19, 30, 20, 0, -30 },
  { 968, 19, 30, 20, 1, -30 },
  { 1040, 18, 30, 20, 2, -30 },
  { 1108, 18, 30, 20, 3, -30 },
  { 1176, 19, 30, 20, 1, -30 },
  { 1248, 18, 30, 20, 1, -30 },
  { 1316, 7, 22, 8, 1, -22 },
  { 1336, 10, 27, 8, -2, -22 },
  { 1370, 18, 18, 21, 2, -24 },
  { 1411, 18, 10, 21, 2, -20 },
  { 1434, 18, 18, 21, 2, -24 },
  { 1475, 14, 30, 15, 2, -30 },
  { 1528, 27, 34, 30, 2, -30 },
  { 1643, 20, 30, 20, -2, -30 },
  { 1718, 20, 30, 22, 1, -30 },
  { 1793, 20, 30, 21, 3, -30 },
  { 1868, 22, 30, 24, 1, -30 },
  { 1951, 20, 30, 19, 1, -30 },
  { 2026, 20, 30, 18, 1, -30 },
  { 2101, 22, 30, 25, 3, -30 },
  { 2184, 24, 30, 25, 1, -30 },
  { 2274, 14, 30, 11, -1, -30 },
  { 2327, 16, 37, 9, -7, -30 },
  { 2401, 23, 30, 20, 1, -30 },
  { 2488, 14, 30, 18, 1, -30 },
  { 2541, 30, 30, 31, 1, -30 },
  { 2654, 25, 30, 25, 1, -30 },
  { 2748, 22, 30, 26, 3, -30 },
  { 2831, 20, 30, 21, 1, -30 },
  { 2906, 22, 37, 26, 3, -30 },
  { 3008, 20, 30, 21, 1, -30 },
  { 3083, 19, 30, 19, 0, -30 },
  { 3155, 17, 30, 18, 4, -30 },
  { 3219, 22, 30, 25, 3, -30 },
  { 3302, 19, 30, 20, 4, -30 },
  { 3374, 29, 30, 32, 5, -30 },
  { 3483, 23, 30, 18, -2, -30 },
  { 3570, 17, 30, 18, 4, -30 },
  { 3634, 22, 30, 19, -1, -30 },
  { 3717, 16, 37, 12, -1, -30 },
  { 3791, 7, 30, 13, 4, -30 },
  { 3818, 16, 37, 12, -3, -30 },
  { 3892, 18, 17, 21, 2, -30 },
  { 3931, 14, 2, 14, -3, 4 },
  { 3935, 5, 7, 10, 6, -32 },
  { 3940, 18, 23, 21, 2, -23 },
  { 3992, 18, 32, 21, 1, -32 },
  { 4064, 15, 23, 16, 2, -23 },
  { 4108, 20, 32, 21, 2, -32 },
  { 4188, 15, 23, 18, 2, -23 },
  { 4232, 21, 42, 10, -5, -32 },
  { 4343, 20, 33, 21, 0, -23 },
  { 4426, 17, 32, 21, 1, -32 },
  { 4494, 8, 30, 8, 1, -30 },
  { 4524, 15, 40, 8, -6, -30 },
  { 4599, 17, 32, 17, 1, -32 },
  { 4667, 8, 32, 8, 1, -32 },
  { 4699, 28, 23, 31, 1, -23 },
  { 4780, 18, 23, 21, 1, -23 },
  { 4832, 17, 23, 21, 2, -23 },
  { 4881, 20, 33, 21, -1, -23 },
  { 4964, 18, 33, 21, 2, -23 },
  { 5039, 14, 23, 14, 1, -23 },
  { 5080, 15, 23, 16, 0, -23 },
  { 5124, 10, 28, 11, 2, -28 },
  { 5159, 17, 22, 21, 2, -22 },
  { 5206, 16, 22, 16, 2, -22 },
  { 5250, 25, 22, 25, 2, -22 },
  { 5319, 20, 22, 17, -2, -22 },
  { 5374, 23, 32, 16, -5, -22 },
  { 5466, 17, 22, 15, -1, -22 },
  { 5513, 15, 37, 14, 1, -30 },
  { 5583, 1, 42, 20, 10, -32 },
  { 5589, 15, 37, 14, -2, -30 },
  { 5659, 18, 4, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC42PT7B_H_
