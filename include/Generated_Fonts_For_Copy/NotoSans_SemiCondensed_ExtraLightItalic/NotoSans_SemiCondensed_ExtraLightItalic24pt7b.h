#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x11, 0x22, 0x22, 0x24, 0x44, 0x40, 0x08, 0x80, 0x4C, 0x65,
  0x29, 0x48, 0x04, 0x20, 0x42, 0x04, 0x40, 0x44, 0x08, 0x47, 0xFF, 0x08,
  0x81, 0x08, 0x11, 0x01, 0x10, 0x21, 0x2F, 0xFC, 0x22, 0x02, 0x20, 0x42,
  0x04, 0x40, 0x44, 0x00, 0x02, 0x00, 0x80, 0xFC, 0xC8, 0x22, 0x09, 0x02,
  0x40, 0x90, 0x1C, 0x03, 0x00, 0xB0, 0x24, 0x08, 0x82, 0x41, 0x12, 0x48,
  0xFC, 0x04, 0x01, 0x00, 0x3C, 0x1A, 0x20, 0x91, 0x09, 0x08, 0x88, 0x44,
  0x42, 0x42, 0x24, 0x51, 0x2D, 0x8A, 0x8F, 0xA4, 0x41, 0x42, 0x12, 0x11,
  0x10, 0x88, 0x84, 0x84, 0x48, 0x22, 0xC0, 0xE0, 0x0F, 0x80, 0x88, 0x10,
  0x41, 0x08, 0x10, 0x81, 0x10, 0x0A, 0x00, 0xC0, 0x14, 0x06, 0x41, 0x42,
  0x28, 0x22, 0x81, 0x48, 0x18, 0x81, 0x88, 0x24, 0x7C, 0x40, 0x6A, 0xA0,
  0x06, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x00, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x20, 0x83,
  0x0C, 0x00, 0x08, 0x08, 0x88, 0x69, 0x1E, 0x28, 0x48, 0x84, 0x04, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x3F, 0xF0, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x24, 0xA5, 0x00, 0xF8, 0xC0, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x00, 0x0F, 0x84, 0x11, 0x04, 0x81, 0x20, 0x50, 0x14,
  0x05, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80, 0xA0, 0x48, 0x11, 0x08,
  0x3C, 0x00, 0x0C, 0x56, 0xA2, 0x08, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20,
  0x82, 0x08, 0x40, 0x0F, 0xC2, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0x80, 0x0F, 0xC2, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x10, 0x1C, 0x0F, 0x00, 0x10, 0x03, 0x00, 0x20, 0x04, 0x01, 0x00, 0x24,
  0x08, 0xFE, 0x00, 0x00, 0x60, 0x14, 0x03, 0x00, 0xA0, 0x24, 0x08, 0x82,
  0x10, 0x44, 0x10, 0x84, 0x11, 0x02, 0x20, 0x8F, 0xFE, 0x02, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x0F, 0xE1, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0xF8, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x24,
  0x08, 0x7E, 0x00, 0x07, 0xE1, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x11,
  0x82, 0xC8, 0x60, 0x98, 0x12, 0x02, 0x40, 0x48, 0x09, 0x01, 0x20, 0x42,
  0x18, 0x3C, 0x00, 0x7F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x00, 0x0F, 0x84, 0x12, 0x04, 0x81, 0x20, 0x48, 0x31, 0x18, 0x38, 0x1E,
  0x18, 0x4C, 0x12, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x04, 0x7E, 0x00, 0x0F,
  0x84, 0x22, 0x05, 0x01, 0x40, 0x50, 0x14, 0x05, 0x03, 0x41, 0x4D, 0xA0,
  0x88, 0x02, 0x01, 0x00, 0x40, 0x20, 0x10, 0xF8, 0x00, 0x11, 0x00, 0x00,
  0x00, 0x00, 0x04, 0xC0, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x08, 0x42,
  0x21, 0x10, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x00, 0x80, 0x10, 0x18, 0x18, 0x18, 0x18, 0x08,
  0x00, 0x3E, 0x01, 0x01, 0x01, 0x01, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x20,
  0x40, 0x40, 0x00, 0x00, 0x40, 0xC0, 0x01, 0xF8, 0x06, 0x04, 0x08, 0x02,
  0x10, 0x02, 0x20, 0x01, 0x21, 0xF1, 0x42, 0x11, 0x44, 0x21, 0x84, 0x21,
  0x88, 0x22, 0x88, 0x42, 0x88, 0x42, 0x88, 0xC4, 0x85, 0x38, 0x82, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x18, 0x05,
  0x00, 0xA0, 0x24, 0x04, 0x81, 0x10, 0x42, 0x08, 0x42, 0x08, 0x7F, 0x10,
  0x12, 0x02, 0x80, 0x50, 0x0C, 0x01, 0x80, 0x20, 0x1F, 0xC2, 0x04, 0x40,
  0x88, 0x12, 0x02, 0x40, 0x48, 0x11, 0x0C, 0x3F, 0x88, 0x11, 0x01, 0x20,
  0x24, 0x05, 0x00, 0xA0, 0x24, 0x08, 0xFE, 0x00, 0x07, 0xE3, 0x00, 0xC0,
  0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x00, 0x1F, 0x81, 0x06, 0x10,
  0x21, 0x01, 0x20, 0x12, 0x01, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40,
  0x34, 0x02, 0x40, 0x68, 0x04, 0x80, 0x88, 0x30, 0xFC, 0x00, 0x1F, 0xE2,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0xFC, 0x20, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFE, 0x00, 0x1F, 0xE2,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0x88, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x07, 0xF1,
  0x80, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x83, 0xE8,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x44, 0x04, 0x3F, 0x80,
  0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x12, 0x01, 0x10, 0x08, 0x80, 0x44,
  0x02, 0x3F, 0xF2, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x40, 0x12, 0x01,
  0x10, 0x08, 0x80, 0x40, 0x1E, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x04, 0x08, 0x20, 0xF0, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x01, 0x0F, 0x00, 0x10, 0x11, 0x02, 0x10, 0x41,
  0x08, 0x21, 0x02, 0x20, 0x24, 0x02, 0x80, 0x34, 0x06, 0x40, 0x44, 0x04,
  0x20, 0x42, 0x08, 0x10, 0x81, 0x08, 0x10, 0x80, 0x80, 0x10, 0x20, 0x40,
  0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0xFE,
  0x18, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xA2, 0x80, 0x51, 0x40,
  0x48, 0x90, 0x28, 0x48, 0x24, 0x44, 0x12, 0x22, 0x11, 0x11, 0x10, 0x88,
  0x88, 0x84, 0x48, 0x44, 0x24, 0x22, 0x0C, 0x11, 0x06, 0x10, 0x82, 0x08,
  0x00, 0x18, 0x0C, 0x60, 0x21, 0x80, 0x85, 0x02, 0x24, 0x08, 0x90, 0x42,
  0x21, 0x08, 0x84, 0x22, 0x11, 0x04, 0x44, 0x12, 0x10, 0x48, 0x40, 0xA2,
  0x02, 0x88, 0x0A, 0x20, 0x10, 0x80, 0x40, 0x0F, 0xC1, 0x02, 0x20, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x04, 0x80, 0xC4, 0x18, 0x3E, 0x00, 0x1F, 0x82, 0x08,
  0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x11, 0x02, 0x21, 0x8F, 0x81, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0x02,
  0x20, 0x14, 0x01, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80, 0xC4, 0x18, 0x3E, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x1F, 0x82, 0x08, 0x40, 0x88, 0x12, 0x02,
  0x40, 0x48, 0x11, 0x06, 0x23, 0x0B, 0xC1, 0x08, 0x21, 0x04, 0x21, 0x02,
  0x20, 0x44, 0x08, 0x80, 0x80, 0x0F, 0xE2, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x08, 0xFE, 0x00, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x00, 0x20, 0x19, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04,
  0x40, 0x42, 0x02, 0x10, 0x20, 0x7E, 0x00, 0x80, 0x30, 0x0A, 0x01, 0x20,
  0x44, 0x08, 0x82, 0x10, 0x42, 0x10, 0x42, 0x08, 0x81, 0x10, 0x24, 0x04,
  0x80, 0xA0, 0x14, 0x01, 0x00, 0x20, 0x00, 0x81, 0x81, 0xC0, 0xC0, 0xA0,
  0xA0, 0x50, 0x50, 0x48, 0x28, 0x24, 0x24, 0x22, 0x12, 0x11, 0x11, 0x10,
  0x88, 0x88, 0x48, 0x44, 0x24, 0x24, 0x14, 0x12, 0x0A, 0x0A, 0x05, 0x05,
  0x03, 0x03, 0x01, 0x81, 0x80, 0x80, 0x80, 0x00, 0x08, 0x08, 0x40, 0x81,
  0x08, 0x08, 0xC0, 0x44, 0x02, 0x40, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x28,
  0x02, 0x40, 0x12, 0x01, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x80, 0x40,
  0x80, 0x50, 0x24, 0x09, 0x04, 0x42, 0x10, 0x82, 0x40, 0xA0, 0x28, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x00, 0x0F, 0xF8,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x08, 0x00,
  0xFF, 0xC0, 0x0F, 0x84, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10,
  0x0F, 0x00, 0x84, 0x44, 0x44, 0x42, 0x22, 0x22, 0x21, 0x11, 0x10, 0x07,
  0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x0F, 0x80, 0x02,
  0x01, 0x80, 0x90, 0x24, 0x11, 0x08, 0x22, 0x09, 0x02, 0x40, 0x60, 0x10,
  0xFF, 0xA4, 0x0E, 0x44, 0x52, 0x0D, 0x03, 0x40, 0x90, 0x28, 0x0A, 0x02,
  0x81, 0xA0, 0x48, 0x33, 0x14, 0x79, 0x00, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x01, 0x00, 0x27, 0x05, 0x10, 0xC1, 0x10, 0x26, 0x04, 0x80, 0x90, 0x12,
  0x02, 0x80, 0x90, 0x13, 0x04, 0x61, 0x93, 0xC0, 0x0F, 0x88, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x03, 0xE0, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xF4, 0x10, 0xC2, 0x0C, 0x40,
  0x44, 0x04, 0x80, 0x88, 0x08, 0x80, 0x88, 0x08, 0x81, 0x88, 0x30, 0xC7,
  0x07, 0x90, 0x0F, 0x08, 0x48, 0x28, 0x14, 0x12, 0x13, 0xF1, 0x00, 0x80,
  0x40, 0x20, 0x08, 0x03, 0xE0, 0x00, 0xF0, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0xFC, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x0C, 0x00, 0x07, 0xA1, 0x0C, 0x41, 0x90, 0x12, 0x02,
  0x80, 0x90, 0x12, 0x02, 0x40, 0xC8, 0x19, 0x06, 0x21, 0xC3, 0xC8, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x10, 0xC0, 0xE0, 0x00, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x20, 0x09, 0xC2, 0x88, 0xC1, 0x20, 0x50, 0x24, 0x09, 0x02, 0x40,
  0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0x40, 0x08, 0x00, 0x01, 0x08, 0x44,
  0x21, 0x08, 0x44, 0x21, 0x08, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x02, 0x02,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10,
  0x10, 0x10, 0x10, 0x20, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x11, 0x08, 0x44, 0x22, 0x09, 0x02, 0xC0, 0xD0, 0x24, 0x11, 0x04, 0x21,
  0x08, 0x41, 0x30, 0x40, 0x08, 0x42, 0x11, 0x08, 0x42, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x46, 0x00, 0x13, 0x8F, 0x0E, 0x28, 0x84, 0x18, 0x22, 0x08,
  0x12, 0x04, 0x11, 0x02, 0x08, 0x82, 0x04, 0x41, 0x02, 0x40, 0x81, 0x20,
  0x41, 0x10, 0x20, 0x88, 0x20, 0x4C, 0x10, 0x20, 0x13, 0x82, 0x88, 0x60,
  0x98, 0x12, 0x04, 0x40, 0x88, 0x11, 0x02, 0x40, 0x48, 0x11, 0x02, 0x20,
  0x4C, 0x08, 0x0F, 0x04, 0x22, 0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x02,
  0x80, 0xA0, 0x28, 0x11, 0x08, 0x7C, 0x00, 0x09, 0xC0, 0xA2, 0x0C, 0x10,
  0x81, 0x18, 0x11, 0x01, 0x10, 0x11, 0x01, 0x20, 0x22, 0x02, 0x30, 0x43,
  0x0C, 0x2F, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00,
  0x0F, 0x44, 0x32, 0x0D, 0x01, 0x40, 0x50, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x68, 0x33, 0x1C, 0x79, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x27, 0x28, 0x30, 0x20, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x1F, 0x10, 0x48, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x00, 0x80, 0x4F, 0xC0, 0x10, 0x42, 0x3F, 0x20, 0x84, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x08, 0x3C, 0x20, 0x48, 0x12, 0x05, 0x02, 0x40, 0x90, 0x24,
  0x0A, 0x02, 0x81, 0x20, 0x48, 0x32, 0x14, 0x79, 0x00, 0x80, 0xC0, 0xA0,
  0x50, 0x44, 0x22, 0x21, 0x10, 0x90, 0x48, 0x28, 0x14, 0x0C, 0x06, 0x00,
  0x81, 0x06, 0x0C, 0x18, 0x30, 0xA1, 0x42, 0x85, 0x12, 0x24, 0x44, 0x92,
  0x14, 0x48, 0x51, 0x21, 0x85, 0x06, 0x14, 0x10, 0x20, 0x40, 0x80, 0x10,
  0x22, 0x08, 0x22, 0x04, 0x40, 0x90, 0x0C, 0x01, 0x00, 0x50, 0x0A, 0x02,
  0x40, 0x84, 0x20, 0x8C, 0x08, 0x08, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20,
  0x42, 0x02, 0x10, 0x11, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x38, 0x00,
  0x1F, 0xC0, 0x30, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04,
  0x02, 0x01, 0x00, 0xFF, 0x00, 0x07, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0xC0, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x30, 0xFF, 0xFF, 0xFF, 0x0E, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04,
  0x04, 0x04, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x20, 0xC0, 0x30, 0x33, 0x98, 0x18,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 17, 5, 1, -17 },
  { 10, 5, 6, 7, 3, -17 },
  { 14, 12, 17, 13, 1, -17 },
  { 40, 10, 19, 11, 1, -18 },
  { 64, 13, 17, 16, 2, -17 },
  { 92, 12, 17, 13, 1, -17 },
  { 118, 2, 6, 4, 3, -17 },
  { 120, 7, 21, 6, 1, -17 },
  { 139, 7, 21, 6, -2, -17 },
  { 158, 8, 9, 11, 3, -18 },
  { 167, 10, 11, 12, 1, -14 },
  { 181, 3, 6, 4, -1, -3 },
  { 184, 5, 1, 7, 1, -7 },
  { 185, 1, 2, 5, 1, -2 },
  { 186, 10, 17, 7, -1, -17 },
  { 208, 10, 17, 11, 1, -17 },
  { 230, 6, 17, 11, 3, -17 },
  { 243, 11, 17, 11, 0, -17 },
  { 267, 11, 17, 11, 0, -17 },
  { 291, 11, 17, 11, 0, -17 },
  { 315, 11, 17, 11, 0, -17 },
  { 339, 11, 17, 11, 1, -17 },
  { 363, 10, 17, 11, 2, -17 },
  { 385, 10, 17, 11, 1, -17 },
  { 407, 10, 17, 11, 1, -17 },
  { 429, 4, 13, 5, 0, -13 },
  { 436, 5, 16, 5, -1, -13 },
  { 446, 10, 11, 12, 1, -14 },
  { 460, 10, 5, 12, 1, -11 },
  { 467, 10, 11, 12, 1, -14 },
  { 481, 8, 17, 8, 1, -17 },
  { 498, 16, 19, 17, 1, -17 },
  { 536, 11, 17, 11, -1, -17 },
  { 560, 11, 17, 12, 1, -17 },
  { 584, 11, 17, 12, 2, -17 },
  { 608, 12, 17, 14, 1, -17 },
  { 634, 11, 17, 11, 1, -17 },
  { 658, 11, 17, 10, 1, -17 },
  { 682, 12, 17, 15, 2, -17 },
  { 708, 13, 17, 14, 1, -17 },
  { 736, 7, 17, 6, 0, -17 },
  { 751, 9, 21, 5, -4, -17 },
  { 775, 12, 17, 11, 1, -17 },
  { 801, 7, 17, 10, 1, -17 },
  { 816, 17, 17, 18, 1, -17 },
  { 853, 14, 17, 15, 1, -17 },
  { 883, 12, 17, 15, 2, -17 },
  { 909, 11, 17, 12, 1, -17 },
  { 933, 12, 21, 15, 2, -17 },
  { 965, 11, 17, 12, 1, -17 },
  { 989, 11, 17, 11, 0, -17 },
  { 1013, 10, 17, 10, 2, -17 },
  { 1035, 13, 17, 14, 2, -17 },
  { 1063, 11, 17, 11, 2, -17 },
  { 1087, 17, 17, 18, 3, -17 },
  { 1124, 13, 17, 10, -1, -17 },
  { 1152, 10, 17, 10, 2, -17 },
  { 1174, 13, 17, 11, -1, -17 },
  { 1202, 9, 21, 7, 0, -17 },
  { 1226, 4, 17, 8, 2, -17 },
  { 1235, 9, 21, 7, -2, -17 },
  { 1259, 10, 10, 12, 1, -17 },
  { 1272, 8, 1, 8, -2, 2 },
  { 1273, 2, 3, 5, 4, -18 },
  { 1274, 10, 13, 12, 1, -13 },
  { 1291, 11, 18, 12, 0, -18 },
  { 1316, 9, 13, 9, 1, -13 },
  { 1331, 12, 18, 12, 1, -18 },
  { 1358, 9, 13, 10, 1, -13 },
  { 1373, 12, 24, 6, -3, -18 },
  { 1409, 11, 19, 12, 0, -13 },
  { 1436, 10, 18, 12, 1, -18 },
  { 1459, 5, 17, 5, 0, -17 },
  { 1470, 8, 23, 5, -3, -17 },
  { 1493, 10, 18, 10, 0, -18 },
  { 1516, 5, 18, 5, 0, -18 },
  { 1528, 17, 13, 18, 0, -13 },
  { 1556, 11, 13, 12, 0, -13 },
  { 1574, 10, 13, 12, 1, -13 },
  { 1591, 12, 19, 12, -1, -13 },
  { 1620, 10, 19, 12, 1, -13 },
  { 1644, 8, 13, 8, 1, -13 },
  { 1657, 9, 13, 9, 0, -13 },
  { 1672, 6, 16, 6, 1, -16 },
  { 1684, 10, 13, 12, 1, -13 },
  { 1701, 9, 13, 9, 1, -13 },
  { 1716, 14, 13, 14, 1, -13 },
  { 1739, 11, 13, 10, -1, -13 },
  { 1757, 13, 19, 9, -3, -13 },
  { 1788, 10, 13, 9, -1, -13 },
  { 1805, 8, 21, 8, 1, -17 },
  { 1826, 1, 24, 11, 5, -18 },
  { 1829, 8, 21, 8, -1, -17 },
  { 1850, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC24PT7B_H_
