#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1,
  0x02, 0x04, 0x18, 0x30, 0x40, 0x80, 0x00, 0x00, 0x00, 0x20, 0xC1, 0x80,
  0x63, 0x63, 0x43, 0x42, 0x42, 0x42, 0xC6, 0x84, 0x84, 0x00, 0x60, 0x80,
  0x08, 0x10, 0x03, 0x06, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x06, 0x00,
  0x60, 0x80, 0x08, 0x10, 0x3F, 0xFF, 0xE0, 0x60, 0x80, 0x08, 0x10, 0x01,
  0x02, 0x00, 0x60, 0xC0, 0x08, 0x10, 0x01, 0x02, 0x00, 0x20, 0xC0, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF0, 0x20, 0x40, 0x0C, 0x18, 0x01, 0x02, 0x00, 0x20,
  0x40, 0x0C, 0x18, 0x01, 0x02, 0x00, 0x20, 0x40, 0x0C, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0xFC, 0x03, 0xAF, 0x0C, 0x20, 0x08,
  0x20, 0x18, 0x40, 0x18, 0x40, 0x18, 0x40, 0x18, 0x40, 0x08, 0xC0, 0x0C,
  0x80, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xB0, 0x01, 0x18, 0x01,
  0x08, 0x01, 0x0C, 0x01, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x02, 0x10, 0xC2,
  0x60, 0x7F, 0xC0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0xFC, 0x03, 0x0C, 0x20, 0x10, 0x41, 0x01, 0x86, 0x08, 0x18,
  0x20, 0x40, 0x83, 0x02, 0x0C, 0x18, 0x10, 0x40, 0x80, 0x84, 0x04, 0x0C,
  0x60, 0x20, 0x42, 0x01, 0x02, 0x23, 0xC8, 0x33, 0x33, 0x41, 0x13, 0x0A,
  0x19, 0x10, 0x7F, 0x99, 0x83, 0x38, 0x88, 0x18, 0x08, 0x40, 0x80, 0xC6,
  0x04, 0x04, 0x20, 0x20, 0x41, 0x01, 0x06, 0x08, 0x18, 0x20, 0x40, 0x83,
  0x02, 0x0C, 0x30, 0x10, 0x41, 0x00, 0xC6, 0x18, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x77, 0x00, 0x30, 0x60, 0x08, 0x08, 0x02, 0x02, 0x01, 0x80, 0x80,
  0x60, 0x20, 0x18, 0x18, 0x06, 0x0C, 0x00, 0x86, 0x00, 0x23, 0x00, 0x0D,
  0x80, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xCC, 0x00, 0x61, 0x01, 0x30, 0x60,
  0xD8, 0x08, 0x24, 0x03, 0x1B, 0x00, 0x44, 0x80, 0x1B, 0x20, 0x03, 0x88,
  0x00, 0xC3, 0x00, 0x78, 0xC0, 0x32, 0x18, 0x18, 0xC3, 0xF8, 0x18, 0x6D,
  0x24, 0xB4, 0x80, 0x00, 0xE0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08,
  0x04, 0x02, 0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x10, 0x40, 0xE1, 0x00,
  0x64, 0x00, 0x6F, 0xC0, 0xC0, 0x0D, 0x00, 0x66, 0x03, 0x08, 0x18, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC0, 0xFF,
  0xFF, 0x80, 0x7C, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0xF0, 0x18,
  0x30, 0x60, 0x30, 0x80, 0x63, 0x00, 0x44, 0x00, 0x98, 0x01, 0x20, 0x02,
  0xC0, 0x05, 0x80, 0x0A, 0x00, 0x34, 0x00, 0x78, 0x00, 0xF0, 0x01, 0x60,
  0x02, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x24, 0x00, 0xC8, 0x01, 0x90, 0x02,
  0x20, 0x0C, 0x60, 0x30, 0x40, 0x40, 0xC3, 0x00, 0xFC, 0x00, 0x03, 0x83,
  0x86, 0x46, 0x6E, 0x32, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x01, 0xC0, 0xC0, 0x80,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x01, 0x80, 0xC0, 0x80, 0x30, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x60, 0x38, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x90, 0x00,
  0xD8, 0x00, 0xCC, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x41, 0x00, 0x61, 0x80,
  0x60, 0x80, 0x20, 0x40, 0x20, 0x20, 0x30, 0x30, 0x30, 0x18, 0x30, 0x08,
  0x10, 0x04, 0x10, 0x02, 0x1F, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x03, 0xFF,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x17, 0xC0, 0x1E, 0xF0, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0xC0, 0xE0,
  0xFF, 0x80, 0x00, 0x3E, 0x00, 0xF7, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x67, 0xE0, 0x4C, 0x38, 0x50, 0x08, 0xE0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x0C, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0xC0, 0x18,
  0xC0, 0x30, 0x40, 0x60, 0x60, 0xC0, 0x3F, 0x80, 0x7F, 0xFE, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x00, 0x00, 0x78, 0x03,
  0xDE, 0x06, 0x03, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08,
  0x01, 0x0C, 0x03, 0x0C, 0x06, 0x06, 0x0C, 0x03, 0x18, 0x01, 0xE0, 0x03,
  0xC0, 0x0E, 0x70, 0x18, 0x18, 0x30, 0x08, 0x60, 0x0C, 0xC0, 0x04, 0xC0,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0xC0, 0x08, 0x60, 0x18, 0x70,
  0x70, 0x1F, 0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x06, 0x06, 0x0C, 0x02, 0x08,
  0x03, 0x18, 0x03, 0x10, 0x01, 0x30, 0x01, 0x30, 0x03, 0x30, 0x03, 0x20,
  0x03, 0x20, 0x03, 0x30, 0x06, 0x30, 0x0E, 0x18, 0x1A, 0x0E, 0x76, 0x07,
  0xC4, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x81, 0x80, 0xFE, 0x00, 0x08, 0x71, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0C, 0x30,
  0x01, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x01, 0x80, 0x80, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x07, 0x83, 0xFC, 0x20, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xE0, 0x38, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x08,
  0x00, 0x02, 0x18, 0x00, 0x03, 0x30, 0x0F, 0x83, 0x20, 0x31, 0xC1, 0x60,
  0x60, 0x81, 0x40, 0xC0, 0x81, 0x41, 0x81, 0x83, 0xC1, 0x01, 0x83, 0xC3,
  0x01, 0x02, 0x83, 0x01, 0x02, 0x82, 0x03, 0x02, 0x82, 0x03, 0x06, 0x82,
  0x02, 0x04, 0x82, 0x06, 0x0C, 0x82, 0x0A, 0x18, 0x83, 0x1B, 0x30, 0x81,
  0xE1, 0xE0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x02, 0x80, 0x03, 0x40, 0x01, 0x30, 0x01, 0x98,
  0x00, 0x8C, 0x00, 0xC6, 0x00, 0x41, 0x00, 0x60, 0x80, 0x20, 0x40, 0x30,
  0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x04, 0x0F, 0xFF, 0x04, 0x01, 0x86,
  0x00, 0xC2, 0x00, 0x63, 0x00, 0x31, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02,
  0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x40, 0x03, 0xFF, 0x01, 0x80, 0xE0,
  0x60, 0x08, 0x10, 0x03, 0x04, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30,
  0x02, 0x08, 0x00, 0x82, 0x00, 0x41, 0x80, 0x70, 0x7F, 0xF0, 0x1F, 0xF8,
  0x04, 0x03, 0x01, 0x00, 0x20, 0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC2,
  0x00, 0x30, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x01, 0x84, 0x00, 0x61, 0x00,
  0x70, 0xC0, 0x70, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x06,
  0x01, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x81, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0xC0, 0x70, 0x18, 0x07, 0x02, 0x00, 0x60, 0x40, 0x06, 0x18,
  0x00, 0xC3, 0x00, 0x08, 0x60, 0x01, 0x08, 0x00, 0x21, 0x00, 0x04, 0x60,
  0x00, 0x8C, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0xC4, 0x00, 0x19, 0x80,
  0x02, 0x30, 0x00, 0xC4, 0x00, 0x18, 0x80, 0x06, 0x10, 0x00, 0xC6, 0x00,
  0x30, 0xC0, 0x0C, 0x10, 0x03, 0x02, 0x01, 0xC0, 0xC1, 0xE0, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x83, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x83,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xE0, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x01, 0x80,
  0x30, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x1F, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x08, 0x40, 0x01, 0x84, 0x00, 0x18,
  0x60, 0x01, 0x02, 0x00, 0x10, 0x30, 0x01, 0x01, 0xC0, 0x70, 0x07, 0xFC,
  0x00, 0x02, 0x00, 0x08, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x08, 0x00, 0x20,
  0x40, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x08, 0x00,
  0x20, 0x40, 0x01, 0x06, 0x00, 0x18, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x08,
  0x00, 0x20, 0x40, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x00, 0x04,
  0x08, 0x00, 0x20, 0x40, 0x01, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x00,
  0x04, 0x08, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x03, 0xF0,
  0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x0F,
  0xE0, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x3F, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x70, 0x60, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x30, 0x04, 0x06, 0x00,
  0xC0, 0xC0, 0x0C, 0x18, 0x00, 0x83, 0x00, 0x08, 0x60, 0x00, 0x8C, 0x00,
  0x19, 0x80, 0x01, 0xB8, 0x00, 0x16, 0x80, 0x01, 0xCC, 0x00, 0x18, 0xC0,
  0x03, 0x04, 0x00, 0x30, 0x60, 0x02, 0x02, 0x00, 0x20, 0x30, 0x02, 0x03,
  0x00, 0x60, 0x10, 0x06, 0x01, 0x80, 0x40, 0x08, 0x04, 0x00, 0x80, 0xC0,
  0x0C, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0x03, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x70, 0x50, 0x00, 0x3C, 0x14, 0x00, 0x0B, 0x05, 0x00, 0x06, 0x83,
  0x60, 0x01, 0x20, 0xD8, 0x00, 0xD8, 0x26, 0x00, 0x26, 0x08, 0x80, 0x19,
  0x02, 0x20, 0x04, 0x41, 0x88, 0x03, 0x10, 0x62, 0x00, 0x8C, 0x10, 0x80,
  0x63, 0x04, 0x20, 0x30, 0x81, 0x0C, 0x08, 0x20, 0xC3, 0x06, 0x08, 0x30,
  0x41, 0x06, 0x08, 0x10, 0xC1, 0x82, 0x04, 0x20, 0x40, 0x81, 0x18, 0x10,
  0x60, 0x44, 0x0C, 0x18, 0x13, 0x03, 0x04, 0x06, 0x80, 0x81, 0x01, 0xC0,
  0x20, 0xC0, 0x30, 0x08, 0x30, 0x08, 0x06, 0x00, 0x02, 0x00, 0x0C, 0x1C,
  0x00, 0x20, 0x50, 0x01, 0x81, 0x40, 0x06, 0x05, 0x80, 0x10, 0x32, 0x00,
  0x40, 0xC8, 0x01, 0x02, 0x30, 0x0C, 0x08, 0x40, 0x30, 0x21, 0x00, 0x81,
  0x86, 0x02, 0x06, 0x08, 0x08, 0x10, 0x20, 0x60, 0x40, 0xC1, 0x81, 0x01,
  0x04, 0x0C, 0x04, 0x10, 0x30, 0x18, 0xC0, 0x80, 0x23, 0x02, 0x00, 0x8C,
  0x08, 0x03, 0x20, 0x60, 0x04, 0x81, 0x80, 0x16, 0x04, 0x00, 0x78, 0x10,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xF8, 0x03, 0x80, 0xC0, 0x60, 0x06, 0x0C, 0x00, 0x60, 0x80, 0x02, 0x18,
  0x00, 0x31, 0x00, 0x03, 0x30, 0x00, 0x32, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x02,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C, 0x00, 0x0C, 0x40, 0x00,
  0x84, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x30, 0x06, 0x01, 0x81,
  0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0x03, 0x81, 0x80, 0x60, 0x80,
  0x30, 0x40, 0x08, 0x60, 0x04, 0x30, 0x02, 0x18, 0x01, 0x08, 0x01, 0x84,
  0x00, 0xC6, 0x00, 0x43, 0x00, 0x61, 0x00, 0xE0, 0x83, 0xC0, 0x7F, 0x80,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0x80, 0xC0, 0x60, 0x06, 0x0C, 0x00,
  0x60, 0x80, 0x02, 0x18, 0x00, 0x31, 0x00, 0x03, 0x30, 0x00, 0x32, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x34, 0x00, 0x02, 0x40,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x4C,
  0x00, 0x0C, 0x40, 0x00, 0x84, 0x00, 0x18, 0x60, 0x01, 0x06, 0x00, 0x30,
  0x30, 0x06, 0x01, 0x81, 0xC0, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x03,
  0xFE, 0x03, 0x03, 0x81, 0x80, 0x60, 0x80, 0x30, 0x40, 0x08, 0x60, 0x04,
  0x30, 0x02, 0x18, 0x01, 0x08, 0x01, 0x84, 0x00, 0x86, 0x00, 0xC3, 0x00,
  0xC1, 0x00, 0xC0, 0xFF, 0x80, 0x41, 0x80, 0x60, 0x40, 0x30, 0x20, 0x10,
  0x18, 0x08, 0x0C, 0x04, 0x02, 0x06, 0x01, 0x03, 0x00, 0xC1, 0x00, 0x20,
  0x80, 0x10, 0xC0, 0x0C, 0x60, 0x06, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xC0,
  0xC0, 0x20, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x60, 0x38, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x10,
  0xC0, 0x01, 0x08, 0x00, 0x30, 0x80, 0x03, 0x18, 0x00, 0x21, 0x80, 0x02,
  0x10, 0x00, 0x61, 0x00, 0x06, 0x10, 0x00, 0x43, 0x00, 0x04, 0x30, 0x00,
  0x42, 0x00, 0x0C, 0x20, 0x00, 0xC2, 0x00, 0x08, 0x60, 0x00, 0x86, 0x00,
  0x18, 0x40, 0x01, 0x84, 0x00, 0x18, 0x40, 0x01, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x04, 0x00, 0x20, 0x40, 0x06, 0x06, 0x00, 0xC0, 0x38, 0x38, 0x01,
  0xFE, 0x00, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C,
  0x80, 0x08, 0x80, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x60,
  0xC0, 0x40, 0x40, 0xC0, 0x40, 0x80, 0x41, 0x80, 0x41, 0x00, 0x43, 0x00,
  0x42, 0x00, 0x46, 0x00, 0x44, 0x00, 0x6C, 0x00, 0x68, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x20, 0x00, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0A, 0x00, 0x50, 0x06, 0x80, 0x34, 0x01, 0x20, 0x09,
  0x00, 0xCC, 0x06, 0x40, 0x23, 0x01, 0x10, 0x18, 0xC0, 0x44, 0x06, 0x30,
  0x31, 0x01, 0x0C, 0x08, 0x40, 0xC3, 0x06, 0x10, 0x20, 0xC1, 0x04, 0x18,
  0x30, 0xC1, 0x04, 0x0C, 0x20, 0x43, 0x03, 0x18, 0x10, 0x80, 0xC4, 0x04,
  0x20, 0x31, 0x01, 0x18, 0x0C, 0xC0, 0x44, 0x03, 0x20, 0x13, 0x00, 0xD8,
  0x04, 0x80, 0x14, 0x01, 0x60, 0x07, 0x00, 0x50, 0x01, 0x80, 0x14, 0x00,
  0x60, 0x07, 0x00, 0x10, 0x01, 0x80, 0x00, 0x03, 0x00, 0x38, 0x08, 0x01,
  0x00, 0x60, 0x18, 0x03, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0x80, 0x03,
  0x0C, 0x00, 0x08, 0xC0, 0x00, 0x44, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00, 0x32,
  0x00, 0x01, 0x18, 0x00, 0x18, 0x40, 0x01, 0x82, 0x00, 0x08, 0x18, 0x00,
  0x80, 0xC0, 0x0C, 0x02, 0x00, 0xC0, 0x18, 0x04, 0x00, 0xC0, 0x60, 0x02,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x40, 0x06, 0x40, 0x0C, 0x60, 0x08,
  0x60, 0x18, 0x20, 0x10, 0x20, 0x20, 0x30, 0x60, 0x30, 0x40, 0x10, 0xC0,
  0x11, 0x80, 0x11, 0x00, 0x1B, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x08,
  0x1F, 0x80, 0x84, 0x31, 0x84, 0x21, 0x08, 0x43, 0x08, 0x42, 0x10, 0x86,
  0x30, 0x84, 0x21, 0x0C, 0x61, 0x08, 0x40, 0x01, 0xFC, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x90, 0x01,
  0x90, 0x01, 0x18, 0x03, 0x08, 0x06, 0x08, 0x04, 0x0C, 0x0C, 0x04, 0x08,
  0x04, 0x10, 0x06, 0x30, 0x02, 0x20, 0x02, 0x60, 0x03, 0xC0, 0x01, 0xFF,
  0xF8, 0xC3, 0x08, 0x61, 0x04, 0x03, 0xE2, 0x0E, 0xE4, 0x70, 0x68, 0x80,
  0x73, 0x00, 0xCC, 0x01, 0x98, 0x03, 0x20, 0x06, 0xC0, 0x0D, 0x80, 0x12,
  0x00, 0x24, 0x00, 0x48, 0x01, 0x90, 0x03, 0x20, 0x0C, 0x40, 0x18, 0x80,
  0x51, 0x81, 0x61, 0x86, 0xC1, 0xF1, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08,
  0x78, 0x09, 0x8C, 0x1B, 0x06, 0x1E, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x03, 0x20, 0x03, 0x20, 0x02, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x18, 0xF0, 0x10, 0x98,
  0x60, 0x8F, 0xC0, 0x01, 0xF0, 0x38, 0xC7, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x10, 0x7F, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x03, 0xE3, 0x03, 0x99, 0x06, 0x02, 0x82,
  0x01, 0x43, 0x00, 0x63, 0x00, 0x31, 0x80, 0x10, 0x80, 0x08, 0xC0, 0x04,
  0x60, 0x06, 0x20, 0x03, 0x10, 0x01, 0x08, 0x01, 0x84, 0x00, 0xC2, 0x00,
  0xE1, 0x00, 0x70, 0x80, 0x70, 0x60, 0x68, 0x18, 0x64, 0x07, 0xC6, 0x00,
  0x01, 0xE0, 0x39, 0x83, 0x06, 0x20, 0x13, 0x00, 0x90, 0x0D, 0x80, 0x68,
  0x06, 0xC0, 0xE7, 0xFC, 0x3E, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x10, 0x7F, 0x80, 0x00, 0x07, 0xE0,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x4C, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0xC0, 0x73, 0x20, 0x70, 0x28, 0x10, 0x0A, 0x0C, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x10, 0x40, 0x04, 0x30, 0x01, 0x0C, 0x00, 0xC2,
  0x00, 0x30, 0x80, 0x08, 0x20, 0x06, 0x08, 0x01, 0x82, 0x00, 0xE0, 0x80,
  0x30, 0x20, 0x1C, 0x0C, 0x0D, 0x01, 0x86, 0xC0, 0x3E, 0x30, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x08,
  0x06, 0x03, 0xCF, 0x00, 0x3F, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x78,
  0x13, 0x98, 0x28, 0x18, 0xE0, 0x11, 0xC0, 0x23, 0x00, 0x44, 0x00, 0x98,
  0x03, 0x30, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x26, 0x00, 0xCC, 0x01,
  0x90, 0x02, 0x20, 0x04, 0x40, 0x09, 0x80, 0x33, 0x00, 0x64, 0x00, 0x80,
  0x02, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x02,
  0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x2E, 0x01, 0xE0, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x06, 0x10, 0x18, 0x60, 0x60, 0xC0, 0x81, 0x02, 0x02,
  0x08, 0x04, 0x20, 0x18, 0x80, 0x32, 0x00, 0x4E, 0x00, 0xA4, 0x01, 0x88,
  0x06, 0x18, 0x0C, 0x10, 0x10, 0x30, 0x20, 0x60, 0x40, 0x41, 0x80, 0xC3,
  0x00, 0x84, 0x01, 0x80, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08,
  0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x10,
  0x20, 0x41, 0x83, 0x04, 0x00, 0x08, 0xF8, 0x3E, 0x04, 0xCE, 0x33, 0x86,
  0x81, 0x20, 0x43, 0x80, 0xA0, 0x31, 0x80, 0x60, 0x18, 0xC0, 0x30, 0x0C,
  0x40, 0x10, 0x04, 0x60, 0x08, 0x02, 0x30, 0x0C, 0x01, 0x10, 0x06, 0x01,
  0x88, 0x02, 0x00, 0xC4, 0x01, 0x00, 0x46, 0x00, 0x80, 0x23, 0x00, 0xC0,
  0x11, 0x00, 0x60, 0x18, 0x80, 0x20, 0x0C, 0x40, 0x10, 0x04, 0x60, 0x08,
  0x02, 0x30, 0x0C, 0x03, 0x10, 0x04, 0x01, 0x80, 0x08, 0x78, 0x13, 0x9C,
  0x68, 0x18, 0xE0, 0x11, 0xC0, 0x23, 0x00, 0x44, 0x00, 0x98, 0x03, 0x30,
  0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x26, 0x00, 0xCC, 0x01, 0x90, 0x02,
  0x20, 0x04, 0x40, 0x09, 0x80, 0x33, 0x00, 0x64, 0x00, 0x80, 0x03, 0xE0,
  0x0E, 0x70, 0x70, 0x30, 0x80, 0x63, 0x00, 0x4C, 0x00, 0xD8, 0x01, 0xA0,
  0x03, 0xC0, 0x07, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0xD0, 0x01,
  0x20, 0x06, 0x40, 0x0C, 0xC0, 0x31, 0x80, 0xC1, 0x83, 0x01, 0xFC, 0x00,
  0x02, 0x1E, 0x00, 0x98, 0xC0, 0x6C, 0x18, 0x1E, 0x03, 0x05, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x30, 0x80,
  0x0C, 0x20, 0x02, 0x18, 0x00, 0x86, 0x00, 0x61, 0x80, 0x10, 0x60, 0x0C,
  0x18, 0x06, 0x0F, 0x01, 0x03, 0x61, 0x80, 0x8F, 0xC0, 0x20, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xE3, 0x07, 0x32, 0x18, 0x0A,
  0x10, 0x0A, 0x30, 0x06, 0x60, 0x06, 0x60, 0x04, 0x40, 0x04, 0xC0, 0x04,
  0xC0, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x38,
  0x80, 0x30, 0x80, 0x70, 0xC0, 0xD0, 0x61, 0xB0, 0x3F, 0x30, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x08, 0xF0, 0x9D, 0x0A, 0x01, 0xC0, 0x1C, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x03, 0xF0,
  0x71, 0xC6, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x30, 0x30, 0xFF, 0x00, 0x04, 0x01, 0x00, 0xC0, 0x20,
  0x1F, 0xDF, 0xF1, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0xF0, 0x10, 0x02, 0x60, 0x0C, 0xC0, 0x19, 0x00, 0x22, 0x00, 0x44, 0x00,
  0x98, 0x03, 0x30, 0x06, 0x40, 0x08, 0x80, 0x11, 0x00, 0x26, 0x00, 0xCC,
  0x01, 0x90, 0x02, 0x20, 0x0C, 0x40, 0x18, 0x80, 0x71, 0x01, 0x63, 0x06,
  0x83, 0xF1, 0x00, 0x80, 0x0E, 0x00, 0x6C, 0x01, 0x30, 0x0C, 0xC0, 0x23,
  0x01, 0x84, 0x04, 0x10, 0x30, 0x40, 0x81, 0x06, 0x04, 0x10, 0x10, 0xC0,
  0x42, 0x01, 0x98, 0x06, 0x40, 0x1B, 0x00, 0x68, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0,
  0x2C, 0x0F, 0x03, 0x60, 0x58, 0x13, 0x06, 0x41, 0x98, 0x22, 0x08, 0xC3,
  0x10, 0xC6, 0x10, 0x84, 0x31, 0x84, 0x20, 0x88, 0x23, 0x04, 0xC1, 0x10,
  0x24, 0x09, 0x81, 0x60, 0x48, 0x0A, 0x02, 0xC0, 0x50, 0x14, 0x03, 0x00,
  0xA0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x01, 0x86, 0x01, 0x81,
  0x01, 0x80, 0xC0, 0x80, 0x20, 0x80, 0x10, 0xC0, 0x0C, 0xC0, 0x02, 0x40,
  0x01, 0x40, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x64, 0x00, 0x22,
  0x00, 0x31, 0x80, 0x30, 0x40, 0x30, 0x30, 0x10, 0x18, 0x10, 0x04, 0x18,
  0x03, 0x00, 0x03, 0x00, 0x30, 0x30, 0x02, 0x03, 0x00, 0x60, 0x10, 0x04,
  0x01, 0x00, 0xC0, 0x10, 0x08, 0x01, 0x01, 0x80, 0x10, 0x10, 0x01, 0x03,
  0x00, 0x18, 0x20, 0x01, 0x86, 0x00, 0x18, 0x40, 0x00, 0x8C, 0x00, 0x08,
  0x80, 0x00, 0x98, 0x00, 0x09, 0x00, 0x00, 0xB0, 0x00, 0x0A, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x09, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x07, 0x00, 0x70, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x01, 0x77, 0x81, 0x80, 0xFE,
  0x80, 0x18,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 8, 9, 11, 4, -26 },
  { 33, 19, 26, 20, 1, -26 },
  { 95, 16, 30, 18, 1, -28 },
  { 155, 21, 27, 25, 3, -27 },
  { 226, 18, 27, 21, 1, -27 },
  { 287, 3, 9, 6, 4, -26 },
  { 291, 11, 32, 9, 1, -26 },
  { 335, 10, 32, 9, -2, -26 },
  { 375, 14, 14, 17, 4, -28 },
  { 400, 16, 18, 19, 2, -22 },
  { 436, 6, 9, 7, -2, -4 },
  { 443, 9, 2, 11, 1, -11 },
  { 446, 2, 3, 7, 1, -3 },
  { 447, 16, 26, 11, -2, -26 },
  { 499, 15, 27, 18, 2, -27 },
  { 550, 9, 26, 18, 5, -26 },
  { 580, 17, 27, 18, 0, -27 },
  { 638, 17, 27, 18, 0, -27 },
  { 696, 17, 27, 18, 0, -27 },
  { 754, 16, 26, 18, 1, -26 },
  { 806, 16, 27, 18, 2, -27 },
  { 860, 15, 26, 18, 3, -26 },
  { 909, 16, 27, 18, 1, -27 },
  { 963, 16, 27, 18, 1, -27 },
  { 1017, 6, 20, 7, 1, -20 },
  { 1032, 9, 25, 7, -2, -20 },
  { 1061, 16, 16, 19, 2, -21 },
  { 1093, 16, 9, 19, 2, -18 },
  { 1111, 16, 16, 19, 2, -21 },
  { 1143, 12, 27, 13, 2, -27 },
  { 1184, 24, 29, 27, 2, -26 },
  { 1271, 17, 26, 18, -2, -26 },
  { 1327, 18, 26, 19, 1, -26 },
  { 1386, 19, 27, 19, 2, -27 },
  { 1451, 19, 26, 22, 1, -26 },
  { 1513, 17, 26, 17, 1, -26 },
  { 1569, 17, 26, 16, 1, -26 },
  { 1625, 20, 27, 22, 2, -27 },
  { 1693, 21, 26, 22, 1, -26 },
  { 1762, 12, 26, 9, -1, -26 },
  { 1801, 14, 33, 8, -6, -26 },
  { 1859, 20, 26, 18, 1, -26 },
  { 1924, 12, 26, 16, 1, -26 },
  { 1963, 26, 26, 27, 1, -26 },
  { 2048, 22, 26, 22, 1, -26 },
  { 2120, 20, 27, 23, 2, -27 },
  { 2188, 17, 26, 18, 1, -26 },
  { 2244, 20, 33, 23, 2, -27 },
  { 2327, 17, 26, 18, 1, -26 },
  { 2383, 17, 27, 16, 0, -27 },
  { 2441, 16, 26, 16, 3, -26 },
  { 2493, 20, 26, 22, 2, -26 },
  { 2558, 16, 26, 17, 4, -26 },
  { 2610, 26, 26, 28, 4, -26 },
  { 2695, 21, 26, 16, -2, -26 },
  { 2764, 16, 26, 16, 3, -26 },
  { 2816, 19, 26, 17, -1, -26 },
  { 2878, 13, 32, 11, 0, -26 },
  { 2930, 5, 26, 12, 4, -26 },
  { 2947, 14, 32, 11, -3, -26 },
  { 3003, 16, 16, 18, 1, -27 },
  { 3035, 13, 1, 12, -3, 4 },
  { 3037, 5, 6, 8, 5, -28 },
  { 3041, 15, 20, 18, 2, -20 },
  { 3079, 16, 28, 19, 1, -28 },
  { 3135, 13, 20, 14, 2, -20 },
  { 3168, 17, 28, 19, 2, -28 },
  { 3228, 13, 20, 16, 2, -20 },
  { 3261, 19, 37, 9, -5, -28 },
  { 3349, 18, 29, 19, 0, -20 },
  { 3415, 15, 28, 18, 1, -28 },
  { 3468, 7, 27, 7, 1, -27 },
  { 3492, 13, 36, 7, -5, -27 },
  { 3551, 15, 28, 15, 1, -28 },
  { 3604, 7, 28, 7, 1, -28 },
  { 3629, 25, 20, 27, 1, -20 },
  { 3692, 15, 20, 18, 1, -20 },
  { 3730, 15, 20, 18, 2, -20 },
  { 3768, 18, 29, 19, -1, -20 },
  { 3834, 16, 29, 19, 2, -20 },
  { 3892, 12, 20, 12, 1, -20 },
  { 3922, 13, 20, 14, 0, -20 },
  { 3955, 10, 24, 10, 1, -24 },
  { 3985, 15, 20, 18, 2, -20 },
  { 4023, 14, 20, 14, 2, -20 },
  { 4058, 21, 20, 22, 2, -20 },
  { 4111, 17, 20, 15, -1, -20 },
  { 4154, 20, 29, 14, -4, -20 },
  { 4227, 15, 20, 14, -1, -20 },
  { 4265, 13, 32, 12, 1, -26 },
  { 4317, 1, 37, 17, 9, -28 },
  { 4322, 13, 32, 12, -2, -26 },
  { 4374, 16, 4, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC37PT7B_H_
