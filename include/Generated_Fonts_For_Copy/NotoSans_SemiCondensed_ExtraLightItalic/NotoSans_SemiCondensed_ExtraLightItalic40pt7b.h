#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x40, 0xE0, 0xC0, 0x30, 0x98, 0xC8, 0x64, 0x36, 0x13,
  0x09, 0x0C, 0x86, 0x42, 0x61, 0x20, 0x80, 0x00, 0x20, 0x60, 0x01, 0x03,
  0x00, 0x18, 0x10, 0x00, 0xC0, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x40, 0x03,
  0x02, 0x00, 0x10, 0x30, 0x00, 0x81, 0x00, 0xFF, 0xFF, 0xC8, 0x60, 0xC0,
  0x02, 0x06, 0x00, 0x10, 0x20, 0x01, 0x81, 0x00, 0x08, 0x18, 0x00, 0x40,
  0x80, 0x06, 0x04, 0x00, 0x20, 0x60, 0x01, 0x03, 0x01, 0xFF, 0xFF, 0x80,
  0xC0, 0x80, 0x04, 0x0C, 0x00, 0x20, 0x40, 0x03, 0x02, 0x00, 0x10, 0x30,
  0x00, 0x81, 0x00, 0x0C, 0x08, 0x00, 0x60, 0xC0, 0x02, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0xF8, 0x03, 0xD7, 0xC1,
  0x84, 0x20, 0xC3, 0x00, 0x20, 0x80, 0x08, 0x20, 0x02, 0x08, 0x00, 0x82,
  0x00, 0x21, 0x80, 0x0C, 0x40, 0x01, 0x90, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x26, 0x00, 0x08, 0xC0, 0x02, 0x18, 0x01, 0x86, 0x00,
  0x41, 0x80, 0x10, 0x60, 0x04, 0x10, 0x01, 0x0C, 0x20, 0xC6, 0x0F, 0x27,
  0x01, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x07, 0x80, 0x08, 0x3B, 0x80, 0x30, 0x43, 0x00, 0xC1, 0x82, 0x01, 0x02,
  0x04, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x20, 0xC0, 0xC0,
  0x43, 0x01, 0x81, 0x84, 0x02, 0x03, 0x18, 0x04, 0x04, 0x20, 0x08, 0x08,
  0x8F, 0x90, 0x33, 0x31, 0xA0, 0x44, 0xC1, 0x61, 0x11, 0x02, 0x6E, 0x66,
  0x06, 0x70, 0x8C, 0x08, 0x03, 0x10, 0x10, 0x0C, 0x20, 0x20, 0x10, 0xC0,
  0x40, 0x61, 0x81, 0x81, 0x82, 0x03, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x18,
  0x30, 0x10, 0x20, 0x40, 0x30, 0xC1, 0x80, 0x63, 0x06, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x0E, 0x60, 0x01, 0x83, 0x00, 0x30, 0x10, 0x03, 0x01,
  0x80, 0x20, 0x18, 0x02, 0x01, 0x00, 0x20, 0x30, 0x02, 0x03, 0x00, 0x30,
  0x60, 0x03, 0x0C, 0x00, 0x11, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0xE6, 0x00, 0x18, 0x60, 0x33, 0x03, 0x02, 0x60, 0x10, 0x64,
  0x01, 0x86, 0xC0, 0x08, 0xCC, 0x00, 0xC8, 0xC0, 0x05, 0x8C, 0x00, 0x70,
  0xC0, 0x07, 0x0C, 0x00, 0xF0, 0x60, 0x19, 0x87, 0x07, 0x08, 0x3F, 0xC0,
  0xC0, 0x33, 0x22, 0x66, 0x44, 0x4C, 0x80, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x10, 0x03, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x20, 0x40,
  0xE1, 0x00, 0xC4, 0x00, 0xE7, 0xC0, 0xF0, 0x05, 0x00, 0x24, 0x03, 0x08,
  0x18, 0x20, 0x40, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x0C,
  0x21, 0x86, 0x30, 0xC2, 0x10, 0xC0, 0xFF, 0xFF, 0xC0, 0x5F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xEF, 0x00, 0xC0, 0x80,
  0xC0, 0x60, 0xC0, 0x10, 0x40, 0x08, 0x60, 0x06, 0x20, 0x03, 0x30, 0x01,
  0x90, 0x00, 0xC8, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x12, 0x00, 0x19, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0x30, 0x01, 0x98, 0x00, 0xC8,
  0x00, 0x44, 0x00, 0x62, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x18,
  0x18, 0x18, 0x06, 0x18, 0x01, 0xF8, 0x00, 0x01, 0x81, 0xC3, 0xC3, 0x23,
  0x37, 0x1A, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18,
  0x08, 0x04, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x30, 0x18, 0x08,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x08, 0xFF, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x3E, 0xF0, 0x1C, 0x03, 0x02, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC2,
  0x00, 0x30, 0x70, 0x1C, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0B, 0x00, 0x06, 0x80, 0x03, 0x20, 0x01, 0x98, 0x00,
  0x46, 0x00, 0x21, 0x00, 0x18, 0x40, 0x0C, 0x10, 0x06, 0x0C, 0x01, 0x03,
  0x00, 0xC0, 0x80, 0x60, 0x20, 0x30, 0x18, 0x08, 0x06, 0x04, 0x01, 0x83,
  0x00, 0x41, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x1F, 0xF0, 0x07, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x08,
  0x03, 0x83, 0x03, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x3C, 0xC0,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x18, 0x06, 0x7F, 0x83, 0x60,
  0x61, 0x40, 0x10, 0xC0, 0x0C, 0xE0, 0x06, 0x60, 0x01, 0x30, 0x00, 0x98,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x11, 0x80, 0x18, 0xC0, 0x0C,
  0x20, 0x0C, 0x18, 0x0C, 0x06, 0x0C, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0x9F,
  0xFF, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x7B, 0xC0, 0x30, 0x18, 0x18, 0x02, 0x04, 0x00, 0xC3, 0x00,
  0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x81, 0x00, 0x60, 0x60, 0x30,
  0x0C, 0x18, 0x01, 0x9C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x18, 0xE0, 0x1C,
  0x0C, 0x0C, 0x03, 0x06, 0x00, 0x61, 0x00, 0x08, 0xC0, 0x02, 0x30, 0x00,
  0x8C, 0x00, 0x23, 0x00, 0x08, 0xC0, 0x06, 0x30, 0x01, 0x06, 0x00, 0xC0,
  0xE0, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xC0, 0xC0,
  0xC0, 0x30, 0xC0, 0x18, 0x40, 0x04, 0x60, 0x02, 0x20, 0x01, 0x10, 0x00,
  0x98, 0x00, 0x4C, 0x00, 0x26, 0x00, 0x33, 0x00, 0x19, 0x80, 0x1C, 0x40,
  0x1E, 0x30, 0x1A, 0x0E, 0x39, 0x03, 0xF1, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x18, 0x10, 0x30, 0x0F, 0xF0, 0x00, 0x0C, 0x30, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x30, 0xC0, 0x01,
  0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80,
  0x80, 0xC0, 0x40, 0x60, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xC1, 0xF7, 0x88, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x03, 0x80,
  0x1C, 0x00, 0x30, 0x0C, 0x00, 0x04, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x20, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x30, 0x0F, 0xE0, 0xCC, 0x0E,
  0x08, 0x12, 0x06, 0x06, 0x05, 0x81, 0x01, 0x83, 0x40, 0xC0, 0x40, 0xD0,
  0x20, 0x10, 0x3C, 0x18, 0x0C, 0x0F, 0x04, 0x02, 0x02, 0x81, 0x00, 0x80,
  0xA0, 0xC0, 0x60, 0x68, 0x30, 0x18, 0x12, 0x0C, 0x0E, 0x0C, 0x81, 0x03,
  0x86, 0x20, 0x61, 0x21, 0x08, 0x1F, 0x8F, 0x83, 0x01, 0x80, 0x80, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00,
  0xD8, 0x00, 0x13, 0x00, 0x06, 0x60, 0x00, 0x8C, 0x00, 0x31, 0x80, 0x04,
  0x30, 0x01, 0x82, 0x00, 0x20, 0x40, 0x0C, 0x08, 0x01, 0x01, 0x00, 0x60,
  0x20, 0x08, 0x04, 0x03, 0x00, 0xC0, 0x7F, 0xF8, 0x18, 0x03, 0x02, 0x00,
  0x60, 0xC0, 0x0C, 0x10, 0x00, 0x86, 0x00, 0x10, 0x80, 0x02, 0x30, 0x00,
  0x4C, 0x00, 0x09, 0x80, 0x01, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x03, 0xF8,
  0x00, 0x7F, 0xF0, 0x08, 0x03, 0x01, 0x00, 0x30, 0x60, 0x02, 0x0C, 0x00,
  0x41, 0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x0C, 0x30, 0x01,
  0x06, 0x00, 0x60, 0x80, 0x38, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xC0, 0x38,
  0x10, 0x01, 0x82, 0x00, 0x30, 0xC0, 0x02, 0x18, 0x00, 0x43, 0x00, 0x08,
  0x40, 0x01, 0x08, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0xE1,
  0x00, 0x38, 0x20, 0x7C, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x7C,
  0x06, 0x00, 0x81, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x06, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x80, 0x70,
  0x04, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x80,
  0x03, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x30,
  0x80, 0x01, 0x84, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x10, 0x00,
  0x10, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x43, 0x00, 0x06, 0x10,
  0x00, 0x60, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x03, 0x00, 0x30,
  0x10, 0x07, 0x00, 0x83, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xC0, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF0, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xDF, 0x80, 0x60, 0x06, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x03, 0xFC, 0x80, 0x00, 0x64,
  0x00, 0x02, 0x20, 0x00, 0x11, 0x00, 0x01, 0x88, 0x00, 0x0C, 0x40, 0x00,
  0x43, 0x00, 0x02, 0x18, 0x00, 0x30, 0x40, 0x01, 0x83, 0x00, 0x0C, 0x0C,
  0x00, 0x40, 0x38, 0x0E, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x08, 0x00, 0x18, 0x10, 0x00, 0x20, 0x60, 0x00, 0x40, 0xC0,
  0x01, 0x81, 0x80, 0x03, 0x02, 0x00, 0x04, 0x04, 0x00, 0x08, 0x18, 0x00,
  0x10, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x80, 0x01, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x30, 0x20, 0x00, 0x40,
  0xC0, 0x00, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x04, 0x00, 0x0C, 0x08,
  0x00, 0x10, 0x30, 0x00, 0x20, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x00,
  0x02, 0x02, 0x00, 0x04, 0x0C, 0x00, 0x18, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x02,
  0x38, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80, 0x80, 0x18,
  0x04, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0x80, 0x18, 0x1C, 0x00, 0x81,
  0xC0, 0x04, 0x1C, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x10, 0xC0, 0x00,
  0x8C, 0x00, 0x04, 0xE0, 0x00, 0x6F, 0x00, 0x03, 0x88, 0x00, 0x18, 0x60,
  0x00, 0x81, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x01, 0x00, 0x10,
  0x0C, 0x00, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x20,
  0x10, 0x01, 0x80, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0,
  0x68, 0x00, 0x0F, 0x03, 0x40, 0x00, 0xD0, 0x1A, 0x00, 0x04, 0x80, 0x90,
  0x00, 0x6C, 0x04, 0x80, 0x02, 0x60, 0x66, 0x00, 0x33, 0x03, 0x30, 0x01,
  0x10, 0x11, 0x80, 0x18, 0x80, 0x84, 0x00, 0x8C, 0x04, 0x20, 0x0C, 0x60,
  0x61, 0x00, 0xC3, 0x03, 0x08, 0x04, 0x10, 0x10, 0x40, 0x60, 0x80, 0x83,
  0x02, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC1, 0x03, 0x03, 0x02, 0x18,
  0x10, 0x10, 0x10, 0x80, 0x80, 0x80, 0x8C, 0x0C, 0x0C, 0x04, 0x40, 0x60,
  0x60, 0x26, 0x02, 0x03, 0x01, 0xE0, 0x10, 0x10, 0x0E, 0x01, 0x80, 0x80,
  0x70, 0x0C, 0x0C, 0x01, 0x00, 0x60, 0x00, 0x03, 0x00, 0x02, 0x06, 0x00,
  0x04, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x68, 0x00, 0x40, 0xD8, 0x00,
  0x81, 0x30, 0x03, 0x02, 0x20, 0x06, 0x04, 0x60, 0x0C, 0x18, 0xC0, 0x10,
  0x30, 0x80, 0x20, 0x41, 0x80, 0xC0, 0x83, 0x01, 0x81, 0x02, 0x03, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x08, 0x10, 0x08, 0x30, 0x20, 0x10, 0x60, 0xC0,
  0x30, 0xC1, 0x80, 0x21, 0x03, 0x00, 0x42, 0x04, 0x00, 0xCC, 0x08, 0x00,
  0x98, 0x30, 0x01, 0x20, 0x60, 0x03, 0x40, 0xC0, 0x02, 0x81, 0x00, 0x07,
  0x02, 0x00, 0x0E, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xBC,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x40,
  0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x50, 0x00,
  0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x00, 0x00, 0xC8,
  0x00, 0x06, 0x40, 0x00, 0x62, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01,
  0x03, 0x00, 0x18, 0x1C, 0x01, 0x80, 0x70, 0x38, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x08, 0x0E, 0x01, 0x00, 0x60, 0x60, 0x04,
  0x0C, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x03, 0x04, 0x00, 0x61, 0x80, 0x0C,
  0x30, 0x01, 0x06, 0x00, 0x60, 0x80, 0x08, 0x10, 0x03, 0x06, 0x01, 0xC0,
  0xC3, 0xE0, 0x1F, 0xF0, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xBC, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x0C, 0x00,
  0x18, 0x40, 0x00, 0x46, 0x00, 0x02, 0x20, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x60, 0x00, 0x0B, 0x00, 0x00,
  0x50, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xA0, 0x00, 0x09, 0x00,
  0x00, 0xC8, 0x00, 0x06, 0x40, 0x00, 0x62, 0x00, 0x03, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x03, 0x00, 0x18, 0x1C, 0x01, 0x80, 0x70, 0x38, 0x00, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xE0, 0x08, 0x06, 0x01, 0x00, 0x60, 0x60, 0x04, 0x0C, 0x00, 0xC1, 0x80,
  0x18, 0x20, 0x03, 0x04, 0x00, 0x61, 0x80, 0x08, 0x30, 0x03, 0x06, 0x00,
  0x60, 0x80, 0x18, 0x10, 0x06, 0x06, 0x03, 0x80, 0xFF, 0xC0, 0x10, 0x30,
  0x02, 0x06, 0x00, 0xC0, 0x40, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x30,
  0x08, 0x02, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0x81, 0x00, 0x18,
  0x20, 0x03, 0x0C, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x30, 0x04,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xC3, 0x81, 0xC0, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x08,
  0x40, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x31, 0x80, 0x01, 0x0C, 0x00,
  0x08, 0x40, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x01, 0x08,
  0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80, 0x01,
  0x08, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x21, 0x80,
  0x01, 0x08, 0x00, 0x18, 0x40, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x60,
  0xC0, 0x02, 0x06, 0x00, 0x30, 0x18, 0x03, 0x00, 0xE0, 0x70, 0x01, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x10, 0x03,
  0x04, 0x01, 0x81, 0x00, 0x60, 0x40, 0x30, 0x10, 0x0C, 0x04, 0x06, 0x01,
  0x01, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x63,
  0x00, 0x18, 0x80, 0x02, 0x60, 0x00, 0x90, 0x00, 0x2C, 0x00, 0x0A, 0x00,
  0x02, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x1E,
  0x00, 0x30, 0x00, 0xB0, 0x01, 0x80, 0x0D, 0x80, 0x1C, 0x00, 0x6C, 0x00,
  0xF0, 0x06, 0x60, 0x05, 0x80, 0x33, 0x00, 0x6C, 0x01, 0x18, 0x02, 0x60,
  0x18, 0x40, 0x33, 0x00, 0x82, 0x01, 0x18, 0x0C, 0x10, 0x18, 0xC0, 0x40,
  0x80, 0x86, 0x06, 0x04, 0x0C, 0x30, 0x30, 0x20, 0x61, 0x81, 0x01, 0x02,
  0x0C, 0x18, 0x08, 0x30, 0x60, 0x80, 0x41, 0x03, 0x0C, 0x02, 0x18, 0x18,
  0x40, 0x10, 0x80, 0xC6, 0x00, 0x8C, 0x02, 0x30, 0x04, 0x40, 0x11, 0x00,
  0x26, 0x00, 0x98, 0x01, 0x30, 0x04, 0x80, 0x09, 0x00, 0x2C, 0x00, 0x58,
  0x01, 0x40, 0x02, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20,
  0x18, 0x01, 0x80, 0x20, 0x0C, 0x00, 0x80, 0x20, 0x03, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x10, 0x60, 0x00, 0x41, 0x00, 0x01, 0x8C, 0x00, 0x02, 0x60,
  0x00, 0x09, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x58, 0x00, 0x03, 0x20, 0x00, 0x18, 0xC0, 0x00, 0x43,
  0x00, 0x03, 0x04, 0x00, 0x18, 0x10, 0x00, 0xC0, 0x60, 0x02, 0x01, 0x80,
  0x18, 0x02, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0x40, 0xC0,
  0x01, 0x80, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x06, 0xC0, 0x04, 0x40, 0x0C,
  0x40, 0x18, 0x40, 0x18, 0x60, 0x30, 0x60, 0x20, 0x20, 0x60, 0x20, 0xC0,
  0x30, 0x80, 0x31, 0x80, 0x13, 0x00, 0x12, 0x00, 0x16, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x02, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0xFC, 0x00, 0x83,
  0x0C, 0x10, 0x41, 0x04, 0x18, 0x60, 0x82, 0x08, 0x20, 0xC3, 0x0C, 0x10,
  0x41, 0x06, 0x18, 0x60, 0x82, 0x08, 0x30, 0xC3, 0x04, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x03, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x12, 0x00,
  0x19, 0x00, 0x18, 0xC0, 0x08, 0x20, 0x0C, 0x10, 0x04, 0x0C, 0x06, 0x02,
  0x06, 0x01, 0x02, 0x00, 0xC3, 0x00, 0x23, 0x00, 0x11, 0x80, 0x0D, 0x80,
  0x02, 0x80, 0x01, 0x80, 0xFF, 0xF8, 0x8C, 0x46, 0x21, 0x10, 0x00, 0x40,
  0x01, 0xFC, 0xC3, 0x82, 0x41, 0x80, 0xA1, 0x80, 0x51, 0x80, 0x38, 0x80,
  0x0C, 0xC0, 0x04, 0x40, 0x06, 0x20, 0x03, 0x30, 0x01, 0x98, 0x00, 0x88,
  0x00, 0x44, 0x00, 0x62, 0x00, 0x31, 0x00, 0x18, 0x80, 0x18, 0x40, 0x1C,
  0x30, 0x0A, 0x18, 0x0B, 0x06, 0x19, 0x81, 0xF8, 0x80, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x10, 0x06, 0x7F, 0x02, 0x60, 0xC1, 0x60, 0x30, 0xE0,
  0x18, 0xE0, 0x04, 0x70, 0x02, 0x30, 0x01, 0x18, 0x00, 0x98, 0x00, 0x4C,
  0x00, 0x66, 0x00, 0x32, 0x00, 0x19, 0x00, 0x09, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x02, 0x30, 0x03, 0x18, 0x03, 0x1A, 0x03, 0x09, 0x83, 0x04, 0x7F,
  0x00, 0x00, 0x60, 0x0F, 0xF0, 0x60, 0x43, 0x00, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x60, 0x7F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x40, 0x80, 0x7F, 0x30, 0x18, 0x36, 0x06, 0x02, 0xC1, 0x80, 0x30, 0x60,
  0x06, 0x08, 0x00, 0xC3, 0x00, 0x18, 0x40, 0x03, 0x08, 0x00, 0x43, 0x00,
  0x08, 0x60, 0x03, 0x08, 0x00, 0x61, 0x00, 0x08, 0x20, 0x03, 0x04, 0x00,
  0x60, 0x80, 0x1C, 0x10, 0x03, 0x83, 0x00, 0xA0, 0x60, 0x34, 0x06, 0x1C,
  0x80, 0x7E, 0x30, 0x00, 0x00, 0x40, 0x0F, 0xE0, 0x60, 0xC3, 0x01, 0x18,
  0x04, 0xC0, 0x12, 0x00, 0x58, 0x03, 0x40, 0x19, 0x01, 0xCC, 0x7C, 0x3F,
  0xC0, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x20, 0x7F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x3F,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xC4, 0x06, 0x0D, 0x81, 0x80, 0xB0,
  0x60, 0x0C, 0x18, 0x01, 0x82, 0x00, 0x30, 0xC0, 0x06, 0x10, 0x00, 0xC2,
  0x00, 0x10, 0xC0, 0x02, 0x18, 0x00, 0xC2, 0x00, 0x18, 0x40, 0x02, 0x08,
  0x00, 0xC1, 0x00, 0x18, 0x20, 0x07, 0x04, 0x01, 0xE0, 0xC0, 0x28, 0x18,
  0x0D, 0x01, 0x87, 0x60, 0x1F, 0x8C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0xC0, 0x1F, 0xF0, 0x00, 0x20, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x18, 0x06, 0x7F, 0x02, 0x60, 0xC1, 0x60, 0x20, 0xE0, 0x18, 0xE0, 0x0C,
  0x60, 0x04, 0x30, 0x02, 0x10, 0x01, 0x08, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x62, 0x00, 0x21, 0x00, 0x11, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x04, 0x20,
  0x02, 0x10, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x40, 0x02, 0x07,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18,
  0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0x80, 0x00, 0x08, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x18, 0x03, 0xE0, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x03, 0x0C, 0x06, 0x08, 0x0C,
  0x08, 0x18, 0x18, 0x30, 0x18, 0x60, 0x10, 0xC0, 0x11, 0x80, 0x33, 0x00,
  0x37, 0x00, 0x3D, 0x80, 0x29, 0x80, 0x30, 0x80, 0x60, 0xC0, 0x60, 0x40,
  0x60, 0x60, 0x40, 0x60, 0x40, 0x20, 0xC0, 0x30, 0xC0, 0x30, 0x80, 0x18,
  0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60,
  0x60, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x00, 0x10, 0x06, 0x01, 0x9F, 0x83,
  0xF0, 0x26, 0x18, 0xC3, 0x05, 0x01, 0x20, 0x30, 0xC0, 0x38, 0x06, 0x38,
  0x07, 0x00, 0xC6, 0x00, 0xC0, 0x18, 0xC0, 0x18, 0x02, 0x10, 0x02, 0x00,
  0x46, 0x00, 0x40, 0x08, 0xC0, 0x18, 0x03, 0x18, 0x03, 0x00, 0x62, 0x00,
  0x40, 0x08, 0x40, 0x08, 0x01, 0x18, 0x03, 0x00, 0x63, 0x00, 0x60, 0x0C,
  0x60, 0x0C, 0x01, 0x88, 0x01, 0x00, 0x21, 0x00, 0x20, 0x04, 0x60, 0x0C,
  0x01, 0x8C, 0x01, 0x80, 0x31, 0x00, 0x20, 0x06, 0x00, 0x00, 0x18, 0x06,
  0x7F, 0x02, 0x60, 0xC1, 0x60, 0x20, 0xE0, 0x18, 0xE0, 0x0C, 0x60, 0x06,
  0x30, 0x02, 0x10, 0x01, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x62, 0x00,
  0x21, 0x00, 0x11, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x04, 0x20, 0x02, 0x10,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x40, 0x00, 0x40, 0x03, 0xF8,
  0x06, 0x0C, 0x0C, 0x06, 0x18, 0x02, 0x30, 0x03, 0x20, 0x03, 0x60, 0x03,
  0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x30,
  0x70, 0x60, 0x1F, 0xC0, 0x00, 0x04, 0x00, 0x67, 0xF0, 0x09, 0x83, 0x01,
  0x60, 0x30, 0x38, 0x06, 0x0E, 0x00, 0x41, 0xC0, 0x08, 0x30, 0x01, 0x06,
  0x00, 0x20, 0x80, 0x04, 0x30, 0x01, 0x86, 0x00, 0x30, 0x80, 0x06, 0x10,
  0x00, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0x83, 0x00, 0x30, 0x60,
  0x0C, 0x1A, 0x03, 0x03, 0x60, 0xC0, 0x67, 0xF0, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFC, 0x43, 0x83,
  0x61, 0x80, 0xB1, 0x80, 0x31, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06, 0x40,
  0x03, 0x20, 0x01, 0x30, 0x00, 0x98, 0x00, 0xC8, 0x00, 0x64, 0x00, 0x22,
  0x00, 0x31, 0x00, 0x18, 0x80, 0x1C, 0x40, 0x0E, 0x30, 0x0A, 0x18, 0x0D,
  0x06, 0x1D, 0x81, 0xF8, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x67, 0xC2, 0x60, 0x16, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x00,
  0x00, 0x40, 0x1F, 0xF0, 0xC0, 0x46, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0xC0,
  0xE1, 0xFE, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x3F, 0xF1, 0x00,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x3F, 0x00,
  0x18, 0x01, 0x88, 0x00, 0x84, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x00,
  0x10, 0x80, 0x08, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x10, 0x01, 0x08,
  0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x61, 0x00, 0x30, 0x80, 0x38,
  0x40, 0x1C, 0x30, 0x16, 0x1C, 0x32, 0x07, 0xF1, 0x00, 0xC0, 0x07, 0x80,
  0x1B, 0x00, 0x26, 0x00, 0xC4, 0x01, 0x08, 0x06, 0x10, 0x08, 0x20, 0x30,
  0x40, 0x40, 0x81, 0x81, 0x82, 0x03, 0x0C, 0x06, 0x10, 0x0C, 0x60, 0x19,
  0x80, 0x13, 0x00, 0x2C, 0x00, 0x58, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x16, 0x03, 0xC0,
  0x6C, 0x05, 0x80, 0x98, 0x19, 0x03, 0x10, 0x22, 0x04, 0x20, 0x44, 0x18,
  0x41, 0x88, 0x20, 0x82, 0x10, 0x41, 0x0C, 0x21, 0x82, 0x10, 0x42, 0x04,
  0x60, 0x8C, 0x08, 0x81, 0x10, 0x13, 0x02, 0x60, 0x24, 0x04, 0x80, 0x58,
  0x0B, 0x00, 0xA0, 0x14, 0x01, 0xC0, 0x28, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x30, 0x08, 0x18, 0x03,
  0x04, 0x00, 0xC3, 0x00, 0x11, 0x80, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x60, 0x01, 0x88, 0x00, 0x42, 0x00,
  0x30, 0xC0, 0x18, 0x10, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x00, 0x20, 0xC0,
  0x0C, 0x00, 0x03, 0x00, 0x18, 0x08, 0x00, 0x80, 0x40, 0x0C, 0x02, 0x00,
  0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x06, 0x03, 0x00, 0x30, 0x10, 0x01,
  0x81, 0x80, 0x0C, 0x08, 0x00, 0x20, 0xC0, 0x01, 0x0C, 0x00, 0x08, 0x60,
  0x00, 0x46, 0x00, 0x02, 0x30, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0xF0, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x03,
  0xC0, 0x0F, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x07, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xF0, 0x03, 0xC0, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0xB1, 0xE0,
  0x70, 0x1F, 0xD0, 0x03, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 29, 9, 1, -29 },
  { 30, 9, 11, 12, 4, -29 },
  { 43, 21, 29, 21, 1, -29 },
  { 120, 18, 32, 19, 1, -30 },
  { 192, 23, 29, 27, 3, -29 },
  { 276, 20, 29, 22, 1, -29 },
  { 349, 4, 11, 7, 4, -29 },
  { 355, 12, 35, 10, 1, -29 },
  { 408, 12, 35, 10, -3, -29 },
  { 461, 14, 15, 18, 5, -30 },
  { 488, 17, 18, 20, 2, -23 },
  { 527, 6, 9, 7, -2, -4 },
  { 534, 9, 2, 12, 1, -12 },
  { 537, 3, 3, 8, 1, -3 },
  { 539, 18, 29, 12, -2, -29 },
  { 605, 17, 29, 19, 2, -29 },
  { 667, 9, 29, 19, 6, -29 },
  { 700, 18, 29, 19, 0, -29 },
  { 766, 19, 29, 19, 0, -29 },
  { 835, 18, 29, 19, 0, -29 },
  { 901, 18, 29, 19, 1, -29 },
  { 967, 17, 29, 19, 2, -29 },
  { 1029, 17, 29, 19, 3, -29 },
  { 1091, 18, 29, 19, 1, -29 },
  { 1157, 17, 29, 19, 1, -29 },
  { 1219, 6, 21, 8, 1, -21 },
  { 1235, 9, 26, 8, -2, -21 },
  { 1265, 17, 17, 20, 2, -23 },
  { 1302, 17, 10, 20, 2, -19 },
  { 1324, 17, 17, 20, 2, -23 },
  { 1361, 13, 29, 14, 2, -29 },
  { 1409, 26, 32, 29, 2, -28 },
  { 1513, 19, 29, 19, -2, -29 },
  { 1582, 19, 29, 21, 1, -29 },
  { 1651, 19, 29, 20, 3, -29 },
  { 1720, 21, 29, 23, 1, -29 },
  { 1797, 19, 29, 18, 1, -29 },
  { 1866, 19, 29, 17, 1, -29 },
  { 1935, 21, 29, 24, 3, -29 },
  { 2012, 23, 29, 24, 1, -29 },
  { 2096, 13, 29, 10, -1, -29 },
  { 2144, 15, 36, 8, -6, -29 },
  { 2212, 21, 29, 19, 1, -29 },
  { 2289, 13, 29, 17, 1, -29 },
  { 2337, 29, 29, 29, 1, -29 },
  { 2443, 23, 29, 24, 1, -29 },
  { 2527, 21, 29, 25, 3, -29 },
  { 2604, 19, 29, 20, 1, -29 },
  { 2673, 21, 36, 25, 3, -29 },
  { 2768, 19, 29, 20, 1, -29 },
  { 2837, 18, 29, 18, 0, -29 },
  { 2903, 16, 29, 17, 4, -29 },
  { 2961, 21, 29, 24, 3, -29 },
  { 3038, 18, 29, 19, 4, -29 },
  { 3104, 29, 29, 30, 4, -29 },
  { 3210, 22, 29, 17, -2, -29 },
  { 3290, 16, 29, 17, 4, -29 },
  { 3348, 21, 29, 18, -1, -29 },
  { 3425, 15, 35, 12, -1, -29 },
  { 3491, 6, 29, 13, 4, -29 },
  { 3513, 15, 35, 12, -3, -29 },
  { 3579, 17, 17, 20, 2, -29 },
  { 3616, 13, 1, 13, -3, 4 },
  { 3618, 4, 7, 9, 6, -31 },
  { 3622, 17, 22, 20, 2, -22 },
  { 3669, 17, 30, 20, 1, -30 },
  { 3733, 14, 22, 16, 2, -22 },
  { 3772, 19, 30, 20, 2, -30 },
  { 3844, 14, 22, 17, 2, -22 },
  { 3883, 20, 41, 10, -5, -31 },
  { 3986, 19, 32, 20, 0, -22 },
  { 4062, 17, 30, 20, 1, -30 },
  { 4126, 8, 29, 8, 1, -29 },
  { 4155, 14, 39, 8, -5, -29 },
  { 4224, 16, 30, 16, 1, -30 },
  { 4284, 8, 30, 8, 1, -30 },
  { 4314, 27, 22, 30, 1, -22 },
  { 4389, 17, 22, 20, 1, -22 },
  { 4436, 16, 22, 20, 2, -22 },
  { 4480, 19, 31, 20, -1, -22 },
  { 4554, 17, 31, 20, 2, -22 },
  { 4620, 13, 22, 13, 1, -22 },
  { 4656, 14, 22, 15, 0, -22 },
  { 4695, 10, 26, 11, 2, -26 },
  { 4728, 17, 21, 20, 2, -21 },
  { 4773, 15, 21, 15, 2, -21 },
  { 4813, 23, 21, 24, 2, -21 },
  { 4874, 18, 21, 16, -1, -21 },
  { 4922, 21, 31, 15, -4, -21 },
  { 5004, 16, 21, 15, -1, -21 },
  { 5046, 14, 35, 13, 1, -29 },
  { 5108, 2, 40, 19, 9, -30 },
  { 5118, 14, 35, 13, -2, -29 },
  { 5180, 17, 4, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC40PT7B_H_
