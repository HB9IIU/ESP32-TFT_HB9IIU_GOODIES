#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C,
  0x0C, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x40, 0xE0, 0xC0, 0x30, 0xCC, 0x62, 0x18, 0x86, 0x61,
  0x18, 0x44, 0x11, 0x0C, 0x42, 0x30, 0x80, 0x00, 0x30, 0x20, 0x01, 0x03,
  0x00, 0x08, 0x18, 0x00, 0xC0, 0x80, 0x04, 0x04, 0x00, 0x20, 0x60, 0x03,
  0x02, 0x00, 0x18, 0x10, 0x00, 0x81, 0x80, 0xFF, 0xFF, 0xC0, 0x60, 0x40,
  0x02, 0x06, 0x00, 0x10, 0x30, 0x01, 0x81, 0x00, 0x08, 0x08, 0x00, 0x40,
  0xC0, 0x06, 0x04, 0x00, 0x30, 0x20, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0,
  0xC0, 0x80, 0x04, 0x04, 0x00, 0x20, 0x60, 0x03, 0x02, 0x00, 0x10, 0x10,
  0x00, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0x40, 0x02, 0x06, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x01, 0xFF, 0xC0,
  0xC4, 0x30, 0x61, 0x00, 0x30, 0x40, 0x08, 0x30, 0x02, 0x08, 0x00, 0x82,
  0x00, 0x20, 0x80, 0x0C, 0x20, 0x01, 0x98, 0x00, 0x74, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0C, 0xC0, 0x02, 0x18, 0x00, 0x86, 0x00,
  0x20, 0x80, 0x18, 0x20, 0x04, 0x08, 0x01, 0x06, 0x00, 0x43, 0x08, 0x11,
  0xC3, 0xED, 0xC0, 0x3F, 0xC0, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x04, 0x1F, 0x80, 0x10, 0x61, 0x00, 0x61,
  0x83, 0x00, 0x82, 0x06, 0x02, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x20,
  0x30, 0x40, 0xC0, 0x41, 0x81, 0x80, 0x82, 0x03, 0x01, 0x0C, 0x04, 0x06,
  0x30, 0x08, 0x08, 0x43, 0x90, 0x11, 0x9D, 0xA0, 0x66, 0x61, 0xE0, 0x88,
  0x81, 0xC3, 0x33, 0x02, 0xFC, 0xC4, 0x04, 0x61, 0x18, 0x08, 0x06, 0x30,
  0x30, 0x18, 0x40, 0x60, 0x20, 0x80, 0xC0, 0xC1, 0x01, 0x03, 0x06, 0x02,
  0x04, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x20, 0x30, 0x60, 0x80, 0x20, 0x83,
  0x00, 0x63, 0x0C, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF8, 0x00,
  0x30, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06,
  0x00, 0x40, 0x30, 0x02, 0x01, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x02,
  0x18, 0x00, 0x1B, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE8, 0x00,
  0x0C, 0x60, 0x08, 0xC1, 0x80, 0x8C, 0x0C, 0x0C, 0xC0, 0x30, 0x44, 0x00,
  0x86, 0x60, 0x06, 0x23, 0x00, 0x13, 0x18, 0x00, 0xF0, 0xC0, 0x03, 0x06,
  0x00, 0x38, 0x30, 0x03, 0x60, 0xC0, 0x33, 0x07, 0x07, 0x0C, 0x0F, 0xE0,
  0x70, 0x33, 0x22, 0x66, 0x44, 0x4C, 0x00, 0x30, 0x04, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10,
  0x03, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x01, 0x00, 0x06, 0x04, 0x08, 0x0C,
  0x10, 0x0E, 0x20, 0x07, 0x41, 0x83, 0xFF, 0x07, 0x00, 0x1A, 0x00, 0x62,
  0x01, 0x84, 0x06, 0x0C, 0x08, 0x08, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x0C, 0x21, 0x86, 0x30, 0xC2, 0x18, 0xC0, 0xFF,
  0xFF, 0xE0, 0x5F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0x00, 0xC0, 0xC0, 0xC0, 0x60, 0x40, 0x18, 0x60, 0x0C, 0x60,
  0x06, 0x30, 0x03, 0x10, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x1B, 0x00, 0x0D, 0x00, 0x04, 0x80, 0x02, 0xC0, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x66, 0x00, 0x33, 0x00, 0x11, 0x80,
  0x18, 0xC0, 0x08, 0x60, 0x0C, 0x10, 0x0C, 0x0C, 0x0C, 0x03, 0x0C, 0x00,
  0xFC, 0x00, 0x01, 0x83, 0xC3, 0x67, 0x26, 0x16, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xE0, 0x0E, 0x06, 0x01, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x1F, 0xF0, 0x0E, 0x03, 0x03, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x40, 0x06, 0x0E, 0x03, 0x80, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0x60, 0x00, 0x4C, 0x00,
  0x19, 0x00, 0x06, 0x20, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x0C, 0x30, 0x03,
  0x04, 0x00, 0xC0, 0x80, 0x10, 0x30, 0x04, 0x06, 0x01, 0x80, 0x80, 0x60,
  0x10, 0x18, 0x02, 0x02, 0x00, 0xC0, 0x80, 0x18, 0x30, 0x02, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xC0, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x62, 0x00, 0x1F,
  0xF8, 0x02, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x08, 0x01, 0x83, 0x01, 0xC0, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x21, 0xF0, 0x19, 0xCF, 0x06, 0x80, 0xC1,
  0x40, 0x18, 0x60, 0x02, 0x38, 0x00, 0x8C, 0x00, 0x33, 0x00, 0x0C, 0xC0,
  0x02, 0x30, 0x00, 0x8C, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03,
  0x04, 0x01, 0x81, 0x80, 0xC0, 0x30, 0x70, 0x07, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x38, 0x18, 0x08, 0x03, 0x06, 0x00, 0xC1,
  0x00, 0x10, 0x40, 0x04, 0x30, 0x01, 0x0C, 0x00, 0xC1, 0x00, 0x30, 0x60,
  0x18, 0x18, 0x0C, 0x03, 0x06, 0x00, 0x66, 0x00, 0x0F, 0x00, 0x0E, 0xC0,
  0x0E, 0x18, 0x06, 0x03, 0x03, 0x00, 0x61, 0x80, 0x08, 0x40, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x84, 0x00,
  0x61, 0x80, 0x30, 0x38, 0x38, 0x07, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x7F,
  0x80, 0x30, 0x30, 0x18, 0x06, 0x0C, 0x00, 0x83, 0x00, 0x21, 0x80, 0x0C,
  0x60, 0x03, 0x10, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0x8C, 0x00, 0x61, 0x00, 0x38, 0x60, 0x1E, 0x0C, 0x0D, 0x83, 0xFE,
  0x40, 0x3C, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x81,
  0xC0, 0x3F, 0xC0, 0x00, 0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC3, 0x00, 0x01, 0x80, 0xC0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0xFF, 0xC1, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0x80, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x08, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x02, 0x10, 0x07, 0xE0, 0x66, 0x03,
  0xCE, 0x0C, 0x80, 0xC0, 0x81, 0xB0, 0x30, 0x10, 0x36, 0x04, 0x06, 0x06,
  0x81, 0x80, 0xC0, 0xD0, 0x20, 0x10, 0x16, 0x0C, 0x02, 0x02, 0xC1, 0x80,
  0xC0, 0xD0, 0x20, 0x18, 0x1A, 0x04, 0x02, 0x02, 0x40, 0x80, 0xC0, 0xC8,
  0x10, 0x18, 0x11, 0x02, 0x05, 0x06, 0x20, 0x61, 0xB1, 0x86, 0x07, 0xE3,
  0xE0, 0xC0, 0x20, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x20,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x02, 0xC0, 0x00, 0xD8, 0x00, 0x11, 0x00, 0x06,
  0x20, 0x00, 0x84, 0x00, 0x30, 0x80, 0x04, 0x10, 0x01, 0x82, 0x00, 0x20,
  0x60, 0x0C, 0x0C, 0x01, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00,
  0xC0, 0x7F, 0xF8, 0x18, 0x01, 0x02, 0x00, 0x20, 0xC0, 0x04, 0x10, 0x00,
  0x86, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x02, 0x03, 0xFF, 0x80, 0x30, 0x1C, 0x03, 0x00,
  0x60, 0x20, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40,
  0x03, 0x04, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x08,
  0x07, 0x00, 0xFF, 0xC0, 0x18, 0x1E, 0x01, 0x80, 0x30, 0x18, 0x01, 0x81,
  0x00, 0x0C, 0x10, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x0C,
  0x20, 0x00, 0x86, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x30, 0x40, 0x0E,
  0x04, 0x0F, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x01,
  0xC0, 0x20, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0C, 0x0F, 0x00, 0x30, 0x06, 0x00, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x60, 0x01, 0x81, 0x00, 0x02, 0x04, 0x00, 0x08, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x08, 0x00, 0x08, 0x20, 0x00, 0x21,
  0x80, 0x00, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x40, 0x00, 0x43, 0x00,
  0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x80, 0x01, 0x82, 0x00, 0x0C,
  0x18, 0x00, 0x60, 0x60, 0x03, 0x81, 0x80, 0x18, 0x04, 0x01, 0xC0, 0x10,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x1F, 0xFE, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0x80, 0x70, 0x06, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x03, 0xFC, 0x80, 0x1F, 0xE4, 0x00, 0x03, 0x20, 0x00,
  0x19, 0x00, 0x00, 0xC8, 0x00, 0x04, 0x40, 0x00, 0x22, 0x00, 0x03, 0x18,
  0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x04, 0x18, 0x00, 0x60, 0x60, 0x03,
  0x01, 0xC0, 0x78, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x03, 0x00, 0x02,
  0x02, 0x00, 0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x04,
  0x06, 0x00, 0x04, 0x04, 0x00, 0x0C, 0x04, 0x00, 0x0C, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x18, 0x0F, 0xFF, 0xF8,
  0x18, 0x00, 0x10, 0x18, 0x00, 0x10, 0x18, 0x00, 0x30, 0x10, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x20, 0x20, 0x00, 0x60,
  0x20, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x40, 0x60, 0x00, 0x40,
  0x40, 0x00, 0xC0, 0x40, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0x03, 0xF8, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x0F, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x02, 0x38, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0xC0, 0x20,
  0x06, 0x00, 0x80, 0x30, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x60,
  0x01, 0x03, 0x00, 0x04, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x03,
  0x38, 0x00, 0x09, 0xC0, 0x00, 0x2F, 0x00, 0x01, 0xA4, 0x00, 0x07, 0x18,
  0x00, 0x18, 0x20, 0x00, 0x40, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x04, 0x00,
  0x30, 0x18, 0x00, 0x80, 0x60, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x01, 0x80, 0x18, 0x04, 0x00, 0x60, 0x10, 0x00, 0xC0, 0xC0, 0x03,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xA0, 0x00, 0x1E,
  0x05, 0x00, 0x00, 0xA0, 0x68, 0x00, 0x0D, 0x03, 0x40, 0x00, 0x58, 0x1B,
  0x00, 0x06, 0xC0, 0x98, 0x00, 0x26, 0x04, 0xC0, 0x03, 0x20, 0x66, 0x00,
  0x31, 0x03, 0x10, 0x01, 0x98, 0x18, 0x80, 0x18, 0xC0, 0x84, 0x00, 0x86,
  0x04, 0x20, 0x0C, 0x20, 0x61, 0x80, 0x41, 0x03, 0x0C, 0x06, 0x18, 0x10,
  0x60, 0x20, 0xC0, 0x83, 0x03, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0x41,
  0x81, 0x03, 0x02, 0x18, 0x18, 0x10, 0x10, 0xC0, 0xC0, 0x80, 0xCC, 0x04,
  0x0C, 0x06, 0x40, 0x20, 0x60, 0x36, 0x03, 0x03, 0x01, 0xA0, 0x18, 0x10,
  0x07, 0x00, 0xC0, 0x80, 0x30, 0x04, 0x0C, 0x01, 0x80, 0x20, 0x00, 0x03,
  0x00, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x02, 0x02, 0x80, 0x02, 0x06,
  0xC0, 0x06, 0x06, 0xC0, 0x06, 0x06, 0x40, 0x04, 0x04, 0x60, 0x04, 0x04,
  0x60, 0x0C, 0x0C, 0x20, 0x0C, 0x0C, 0x30, 0x0C, 0x0C, 0x30, 0x08, 0x08,
  0x10, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x18, 0x10,
  0x0C, 0x10, 0x10, 0x0C, 0x10, 0x30, 0x04, 0x30, 0x30, 0x06, 0x30, 0x30,
  0x06, 0x30, 0x20, 0x02, 0x20, 0x20, 0x03, 0x20, 0x60, 0x03, 0x60, 0x60,
  0x01, 0x60, 0x60, 0x01, 0xC0, 0x40, 0x01, 0xC0, 0x40, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x60, 0x38, 0x0E, 0x00,
  0xE0, 0x40, 0x03, 0x06, 0x00, 0x08, 0x60, 0x00, 0x62, 0x00, 0x03, 0x30,
  0x00, 0x19, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0, 0x00, 0x34, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x02, 0x40, 0x00, 0x32,
  0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x00, 0xC2, 0x00, 0x0C, 0x18, 0x00,
  0xC0, 0x60, 0x0C, 0x01, 0xC1, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x60, 0x70, 0x0C, 0x03, 0x01, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x08, 0x20, 0x01, 0x04, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x86,
  0x00, 0x60, 0x80, 0x0C, 0x10, 0x03, 0x06, 0x01, 0xC0, 0xFF, 0xE0, 0x1F,
  0xE0, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00,
  0x60, 0x38, 0x0E, 0x00, 0xE0, 0x40, 0x03, 0x06, 0x00, 0x08, 0x60, 0x00,
  0x62, 0x00, 0x03, 0x30, 0x00, 0x19, 0x00, 0x00, 0x58, 0x00, 0x02, 0xC0,
  0x00, 0x34, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00,
  0x02, 0x40, 0x00, 0x32, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x00, 0xC2,
  0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0xC1, 0xC0, 0x07, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x60,
  0x70, 0x0C, 0x03, 0x01, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x41, 0x80,
  0x08, 0x20, 0x03, 0x04, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x06, 0x00,
  0x60, 0x80, 0x18, 0x10, 0x06, 0x06, 0x07, 0x80, 0xFF, 0xC0, 0x18, 0x30,
  0x02, 0x02, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x40, 0x18,
  0x08, 0x03, 0x03, 0x00, 0x60, 0x60, 0x04, 0x0C, 0x00, 0xC1, 0x00, 0x18,
  0x20, 0x01, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x0E, 0x01,
  0x81, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x40, 0x0E, 0x0E,
  0x07, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x20, 0x00,
  0x20, 0x80, 0x00, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61,
  0x00, 0x01, 0x04, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x02, 0x08, 0x00, 0x08, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x10, 0x00, 0x10, 0x40, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0x80, 0x00, 0x82, 0x00, 0x06, 0x08, 0x00, 0x18, 0x20, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x0E, 0x0E, 0x00,
  0x1F, 0xF0, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x82, 0x00, 0x30, 0x40, 0x04,
  0x08, 0x01, 0x81, 0x00, 0x20, 0x20, 0x0C, 0x04, 0x01, 0x00, 0xC0, 0x60,
  0x18, 0x08, 0x03, 0x03, 0x00, 0x60, 0x40, 0x0C, 0x18, 0x01, 0x82, 0x00,
  0x30, 0xC0, 0x02, 0x10, 0x00, 0x46, 0x00, 0x08, 0x80, 0x01, 0x30, 0x00,
  0x24, 0x00, 0x05, 0x80, 0x00, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x6C, 0x00, 0x70, 0x01, 0x10,
  0x01, 0x40, 0x0C, 0x40, 0x0D, 0x00, 0x31, 0x00, 0x24, 0x01, 0x84, 0x01,
  0x90, 0x06, 0x10, 0x04, 0x40, 0x10, 0x40, 0x31, 0x00, 0xC1, 0x00, 0xC4,
  0x02, 0x04, 0x06, 0x10, 0x18, 0x10, 0x18, 0x40, 0x60, 0x40, 0x41, 0x03,
  0x01, 0x03, 0x04, 0x0C, 0x04, 0x08, 0x10, 0x20, 0x10, 0x60, 0x41, 0x80,
  0x41, 0x01, 0x04, 0x01, 0x0C, 0x04, 0x30, 0x04, 0x30, 0x10, 0x80, 0x11,
  0x80, 0x46, 0x00, 0x46, 0x01, 0x18, 0x01, 0x10, 0x04, 0x40, 0x04, 0xC0,
  0x13, 0x00, 0x12, 0x00, 0x48, 0x00, 0x58, 0x01, 0x60, 0x01, 0x40, 0x05,
  0x00, 0x05, 0x00, 0x14, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x01,
  0x80, 0x0C, 0x02, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x00, 0x00, 0x46, 0x00, 0x00, 0x98, 0x00, 0x01, 0xA0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x48, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x08, 0x20, 0x00, 0x30,
  0x60, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x80, 0x04, 0x01, 0x00, 0x18, 0x03,
  0x00, 0x60, 0x06, 0x01, 0x80, 0x04, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x00, 0x80, 0x01, 0xE0, 0x01, 0xB0, 0x01, 0x88, 0x00, 0xC4, 0x00, 0xC3,
  0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x20, 0x20, 0x10, 0x30, 0x0C, 0x30,
  0x06, 0x10, 0x01, 0x18, 0x00, 0x98, 0x00, 0x68, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xFF, 0x00, 0xC3, 0x04, 0x10, 0x41, 0x86, 0x18,
  0x20, 0x82, 0x08, 0x30, 0xC1, 0x04, 0x10, 0x41, 0x86, 0x08, 0x20, 0x82,
  0x0C, 0x30, 0xC1, 0x04, 0x00, 0xFE, 0x02, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x03, 0xFC, 0x00, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x34, 0x00, 0x13, 0x00, 0x19, 0x80, 0x18, 0x40, 0x08,
  0x30, 0x0C, 0x18, 0x0C, 0x04, 0x04, 0x03, 0x06, 0x00, 0x82, 0x00, 0x43,
  0x00, 0x33, 0x00, 0x09, 0x00, 0x05, 0x80, 0x03, 0xFF, 0xFC, 0xC2, 0x18,
  0x41, 0x0C, 0x01, 0xF0, 0x83, 0xCC, 0x43, 0x01, 0x63, 0x00, 0xF1, 0x00,
  0x31, 0x80, 0x18, 0x80, 0x0C, 0xC0, 0x06, 0x40, 0x02, 0x20, 0x01, 0x30,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0x64, 0x00, 0x22, 0x00, 0x31, 0x00, 0x18,
  0x80, 0x1C, 0x60, 0x0E, 0x30, 0x0A, 0x18, 0x09, 0x06, 0x1C, 0x81, 0xF8,
  0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x0F, 0x80,
  0xCC, 0x70, 0x36, 0x06, 0x0A, 0x01, 0x83, 0x80, 0x31, 0xC0, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x02, 0x30, 0x00,
  0x88, 0x00, 0x62, 0x00, 0x19, 0x80, 0x04, 0x60, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x61, 0xC0, 0x30, 0xD0, 0x1C, 0x36, 0x0E, 0x08, 0xFE, 0x00, 0x01,
  0xFE, 0x0F, 0x18, 0x38, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x02, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x1F, 0x8C, 0x07, 0x9C, 0x80, 0xC0, 0x68, 0x18,
  0x03, 0x81, 0x00, 0x38, 0x30, 0x03, 0x02, 0x00, 0x30, 0x60, 0x03, 0x04,
  0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x0C, 0x00, 0x60,
  0x80, 0x06, 0x08, 0x00, 0xE0, 0x80, 0x0C, 0x08, 0x01, 0xC0, 0xC0, 0x14,
  0x0C, 0x03, 0xC0, 0xC0, 0x6C, 0x06, 0x1C, 0x80, 0x3F, 0x08, 0x00, 0x01,
  0xF8, 0x0F, 0x38, 0x38, 0x10, 0xC0, 0x31, 0x80, 0x66, 0x00, 0xC8, 0x01,
  0x30, 0x06, 0x40, 0x18, 0x80, 0xE3, 0xFF, 0x07, 0xC0, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x03, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x38, 0x40, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x30, 0x1E, 0x72, 0x03, 0x01,
  0xA0, 0x60, 0x0A, 0x04, 0x00, 0xE0, 0xC0, 0x0C, 0x08, 0x00, 0xC1, 0x80,
  0x0C, 0x10, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x83, 0x00, 0x08, 0x30,
  0x01, 0x82, 0x00, 0x18, 0x20, 0x03, 0x82, 0x00, 0x30, 0x20, 0x07, 0x03,
  0x00, 0x70, 0x30, 0x0F, 0x03, 0x01, 0xB0, 0x18, 0x72, 0x00, 0xFC, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x08, 0x03, 0x00, 0xFF, 0xE0, 0x01, 0xF8,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x3F, 0x03, 0x39,
  0xC1, 0xB0, 0x30, 0xA0, 0x18, 0x60, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x18,
  0x01, 0x88, 0x00, 0x84, 0x00, 0x46, 0x00, 0x63, 0x00, 0x31, 0x00, 0x18,
  0x80, 0x08, 0xC0, 0x04, 0x60, 0x06, 0x30, 0x03, 0x10, 0x01, 0x88, 0x00,
  0x8C, 0x00, 0x46, 0x00, 0x63, 0x00, 0x30, 0x02, 0x03, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10,
  0x10, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0,
  0xC0, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x3F, 0x00, 0x78, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0xC3, 0x00, 0xC1, 0x80, 0xC0, 0x80, 0xC0, 0x40, 0xC0, 0x60, 0xC0,
  0x30, 0xC0, 0x10, 0xC0, 0x08, 0xC0, 0x0C, 0xC0, 0x06, 0xF0, 0x03, 0xD8,
  0x01, 0xC4, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x30, 0x30, 0x10,
  0x08, 0x08, 0x06, 0x0C, 0x03, 0x06, 0x00, 0x83, 0x00, 0x60, 0x03, 0x03,
  0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60,
  0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x0C, 0x7C, 0x0F, 0x81, 0x99, 0xC3, 0x1C,
  0x24, 0x0C, 0x81, 0x85, 0x01, 0xA0, 0x10, 0xC0, 0x18, 0x02, 0x38, 0x03,
  0x00, 0x46, 0x00, 0xC0, 0x08, 0xC0, 0x18, 0x01, 0x10, 0x03, 0x00, 0x62,
  0x00, 0x40, 0x0C, 0xC0, 0x08, 0x01, 0x18, 0x03, 0x00, 0x22, 0x00, 0x60,
  0x0C, 0x40, 0x0C, 0x01, 0x98, 0x01, 0x00, 0x33, 0x00, 0x20, 0x04, 0x60,
  0x0C, 0x00, 0x88, 0x01, 0x80, 0x31, 0x00, 0x20, 0x06, 0x60, 0x04, 0x00,
  0xCC, 0x01, 0x80, 0x11, 0x80, 0x30, 0x06, 0x00, 0x0C, 0x7E, 0x06, 0x73,
  0x82, 0x60, 0x61, 0x40, 0x30, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x10, 0x01, 0x18, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31,
  0x00, 0x11, 0x80, 0x08, 0xC0, 0x0C, 0x60, 0x06, 0x20, 0x03, 0x10, 0x01,
  0x18, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x60, 0x01, 0xF8, 0x07, 0x9C, 0x0C,
  0x06, 0x18, 0x03, 0x18, 0x03, 0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x02, 0x80, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x18, 0x60, 0x30, 0x30,
  0x60, 0x1F, 0xC0, 0x03, 0x0F, 0x80, 0x33, 0x9C, 0x02, 0x60, 0x60, 0x2C,
  0x06, 0x03, 0x80, 0x30, 0x70, 0x03, 0x07, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x30, 0x40, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x02, 0x08, 0x00, 0x60,
  0x80, 0x06, 0x18, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x18,
  0x1C, 0x03, 0x03, 0x40, 0x70, 0x36, 0x0E, 0x03, 0x3F, 0x80, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xF8, 0xC1, 0xE7, 0x20, 0xC0, 0x68, 0x60, 0x0A, 0x10, 0x03, 0x8C, 0x00,
  0xE2, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x23,
  0x00, 0x08, 0xC0, 0x06, 0x20, 0x01, 0x88, 0x00, 0xE2, 0x00, 0x30, 0x80,
  0x1C, 0x30, 0x05, 0x0C, 0x03, 0xC3, 0x01, 0xB0, 0x60, 0xC8, 0x0F, 0xC2,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x0C,
  0x7C, 0x33, 0xA0, 0x98, 0x02, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x03, 0xF8, 0x0E, 0x3C, 0x30, 0x08, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC4, 0x01, 0x8C, 0x0E, 0x0F, 0xF8, 0x00, 0x04, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x1F, 0xFF, 0xFC, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x30, 0x07, 0xC0, 0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00,
  0x62, 0x00, 0x23, 0x00, 0x11, 0x80, 0x18, 0x80, 0x0C, 0x40, 0x04, 0x60,
  0x02, 0x30, 0x03, 0x18, 0x01, 0x88, 0x00, 0xC4, 0x00, 0x46, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x18, 0x80, 0x1C, 0x40, 0x0C, 0x20, 0x0A, 0x18, 0x09,
  0x0E, 0x19, 0x83, 0xF8, 0xC0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x36, 0x00,
  0x64, 0x01, 0x88, 0x03, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x60, 0xC0, 0x81,
  0x83, 0x03, 0x04, 0x06, 0x18, 0x0C, 0x20, 0x18, 0xC0, 0x11, 0x00, 0x26,
  0x00, 0x48, 0x00, 0xB0, 0x01, 0x40, 0x03, 0x80, 0x06, 0x00, 0x00, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x02, 0xC0, 0x38, 0x06, 0xC0, 0x28, 0x06, 0x40,
  0x68, 0x04, 0x40, 0x48, 0x0C, 0x40, 0x48, 0x08, 0x40, 0xC8, 0x18, 0x40,
  0x88, 0x10, 0x41, 0x88, 0x30, 0x41, 0x0C, 0x20, 0x43, 0x0C, 0x60, 0x42,
  0x0C, 0x60, 0x46, 0x0C, 0x40, 0x44, 0x0C, 0xC0, 0x4C, 0x0C, 0x80, 0x48,
  0x0D, 0x80, 0x58, 0x0D, 0x00, 0x50, 0x07, 0x00, 0x50, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x60, 0x40, 0x08, 0x0C, 0x03,
  0x00, 0x80, 0xC0, 0x18, 0x30, 0x03, 0x04, 0x00, 0x21, 0x80, 0x06, 0x60,
  0x00, 0xD8, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0x60, 0x00, 0xC4, 0x00, 0x10, 0xC0, 0x06, 0x08, 0x01, 0x81, 0x00,
  0x60, 0x30, 0x18, 0x02, 0x02, 0x00, 0x61, 0xC0, 0x0C, 0x00, 0x01, 0x80,
  0x06, 0x01, 0x00, 0x18, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x18, 0x06, 0x00, 0x30, 0x08, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40,
  0x01, 0x81, 0x80, 0x01, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x04, 0x10, 0x00,
  0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x33, 0x00, 0x00, 0x64, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x17, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x07, 0x80,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x0F, 0x00, 0x20, 0x00, 0x3F, 0x80, 0x78, 0x78, 0x38, 0x07, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 29, 9, 1, -29 },
  { 30, 10, 10, 13, 4, -29 },
  { 43, 21, 29, 22, 1, -29 },
  { 120, 18, 33, 20, 1, -31 },
  { 195, 23, 30, 28, 3, -30 },
  { 282, 21, 30, 23, 1, -30 },
  { 361, 4, 10, 7, 4, -29 },
  { 366, 12, 35, 10, 1, -29 },
  { 419, 12, 35, 10, -3, -29 },
  { 472, 15, 15, 19, 5, -31 },
  { 501, 18, 19, 21, 2, -24 },
  { 544, 6, 9, 8, -2, -4 },
  { 551, 10, 2, 12, 1, -12 },
  { 554, 3, 3, 8, 1, -3 },
  { 556, 18, 29, 13, -2, -29 },
  { 622, 17, 30, 20, 2, -30 },
  { 686, 9, 29, 20, 6, -29 },
  { 719, 19, 30, 20, 0, -30 },
  { 791, 19, 30, 20, 0, -30 },
  { 863, 19, 29, 20, 0, -29 },
  { 932, 18, 29, 20, 1, -29 },
  { 998, 18, 30, 20, 2, -30 },
  { 1066, 17, 29, 20, 3, -29 },
  { 1128, 18, 30, 20, 1, -30 },
  { 1196, 18, 30, 20, 1, -30 },
  { 1264, 6, 22, 8, 1, -22 },
  { 1281, 9, 27, 8, -2, -22 },
  { 1312, 18, 18, 21, 2, -24 },
  { 1353, 18, 9, 21, 2, -19 },
  { 1374, 18, 18, 21, 2, -24 },
  { 1415, 14, 30, 14, 2, -30 },
  { 1468, 27, 33, 30, 2, -29 },
  { 1580, 19, 29, 19, -2, -29 },
  { 1649, 20, 29, 21, 1, -29 },
  { 1722, 20, 30, 21, 3, -30 },
  { 1797, 22, 29, 24, 1, -29 },
  { 1877, 19, 29, 19, 1, -29 },
  { 1946, 19, 29, 17, 1, -29 },
  { 2015, 21, 30, 25, 3, -30 },
  { 2094, 24, 29, 24, 1, -29 },
  { 2181, 13, 29, 10, -1, -29 },
  { 2229, 15, 36, 9, -6, -29 },
  { 2297, 22, 29, 20, 1, -29 },
  { 2377, 13, 29, 17, 1, -29 },
  { 2425, 29, 29, 30, 1, -29 },
  { 2531, 24, 29, 25, 1, -29 },
  { 2618, 21, 30, 25, 3, -30 },
  { 2697, 19, 29, 20, 1, -29 },
  { 2766, 21, 37, 25, 3, -30 },
  { 2864, 19, 29, 20, 1, -29 },
  { 2933, 19, 30, 18, 0, -30 },
  { 3005, 17, 29, 17, 4, -29 },
  { 3067, 22, 29, 24, 3, -29 },
  { 3147, 19, 29, 19, 4, -29 },
  { 3216, 30, 29, 31, 4, -29 },
  { 3325, 23, 29, 18, -2, -29 },
  { 3409, 17, 29, 17, 4, -29 },
  { 3471, 21, 29, 19, -1, -29 },
  { 3548, 16, 35, 12, -1, -29 },
  { 3618, 6, 29, 13, 4, -29 },
  { 3640, 15, 35, 12, -3, -29 },
  { 3706, 17, 16, 20, 2, -29 },
  { 3740, 14, 1, 14, -3, 4 },
  { 3742, 5, 6, 9, 6, -31 },
  { 3746, 17, 22, 20, 2, -22 },
  { 3793, 18, 31, 21, 1, -31 },
  { 3863, 15, 22, 16, 2, -22 },
  { 3905, 20, 31, 21, 2, -31 },
  { 3983, 15, 22, 18, 2, -22 },
  { 4025, 21, 41, 10, -5, -31 },
  { 4133, 20, 32, 21, 0, -22 },
  { 4213, 17, 31, 20, 1, -31 },
  { 4279, 8, 30, 8, 1, -30 },
  { 4309, 15, 40, 8, -6, -30 },
  { 4384, 17, 31, 16, 1, -31 },
  { 4450, 8, 31, 8, 1, -31 },
  { 4481, 27, 22, 30, 1, -22 },
  { 4556, 17, 22, 20, 1, -22 },
  { 4603, 16, 22, 20, 2, -22 },
  { 4647, 20, 32, 21, -1, -22 },
  { 4727, 18, 32, 21, 2, -22 },
  { 4799, 14, 22, 13, 1, -22 },
  { 4838, 15, 22, 15, 0, -22 },
  { 4880, 10, 27, 11, 2, -27 },
  { 4914, 17, 22, 20, 2, -22 },
  { 4961, 15, 22, 15, 2, -22 },
  { 5003, 24, 22, 24, 2, -22 },
  { 5069, 19, 22, 16, -2, -22 },
  { 5122, 23, 32, 16, -5, -22 },
  { 5214, 16, 22, 15, -1, -22 },
  { 5258, 15, 35, 13, 1, -29 },
  { 5324, 1, 41, 19, 10, -31 },
  { 5330, 14, 36, 13, -2, -29 },
  { 5393, 18, 3, 21, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC41PT7B_H_
