#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x92, 0x92, 0x02, 0x00, 0xB6, 0xE0, 0x09, 0x0A, 0x12, 0x7B,
  0x14, 0x24, 0x24, 0xFE, 0x48, 0x48, 0x48, 0x08, 0x3C, 0xA2, 0x42, 0x82,
  0x07, 0x0A, 0x15, 0xD0, 0xC1, 0x00, 0x31, 0x28, 0xA4, 0x92, 0x89, 0x75,
  0x65, 0x52, 0x29, 0x29, 0x24, 0x91, 0x80, 0x0C, 0x12, 0x22, 0x24, 0x18,
  0x30, 0x49, 0x8A, 0x86, 0x84, 0x7A, 0xF0, 0x08, 0x88, 0x44, 0x21, 0x10,
  0x84, 0x21, 0x04, 0x00, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0xC0, 0x25,
  0x1E, 0xC9, 0x00, 0x10, 0x41, 0x3F, 0x10, 0x41, 0x00, 0x56, 0xF0, 0x80,
  0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x82, 0x00, 0x39, 0x14,
  0x61, 0x86, 0x18, 0x62, 0x8A, 0x4F, 0x00, 0x35, 0xA2, 0x22, 0x44, 0x44,
  0x40, 0x1C, 0x44, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x83, 0xE0, 0x1C,
  0x44, 0x08, 0x10, 0x47, 0x01, 0x02, 0x04, 0x0B, 0xE0, 0x02, 0x0C, 0x28,
  0xA1, 0x44, 0x91, 0x44, 0x7E, 0x10, 0x20, 0x1E, 0x40, 0x81, 0x07, 0x01,
  0x81, 0x02, 0x04, 0x0B, 0xE0, 0x1C, 0x84, 0x10, 0xB3, 0x28, 0x61, 0x8A,
  0x2F, 0x00, 0x7C, 0x10, 0x42, 0x08, 0x42, 0x08, 0x41, 0x08, 0x00, 0x1C,
  0x44, 0x89, 0x12, 0x43, 0x19, 0x42, 0x85, 0x09, 0xE0, 0x1C, 0x45, 0x0A,
  0x14, 0x28, 0xCE, 0x82, 0x04, 0x13, 0xC0, 0x20, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x24, 0x48, 0x04, 0x66, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F,
  0x81, 0x81, 0x81, 0x19, 0x88, 0x00, 0x70, 0x42, 0x11, 0x11, 0x10, 0x00,
  0x20, 0x0F, 0x0C, 0x24, 0x09, 0x39, 0x92, 0x68, 0x9A, 0x4A, 0x92, 0xAD,
  0x24, 0x88, 0x01, 0xF0, 0x04, 0x08, 0x28, 0x51, 0x22, 0x4F, 0x91, 0x42,
  0x86, 0x08, 0x1E, 0x21, 0x21, 0x21, 0x22, 0x3C, 0x42, 0x42, 0x42, 0x44,
  0xF8, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0xE0, 0x1C,
  0x23, 0x21, 0x21, 0x21, 0x41, 0x41, 0x41, 0x42, 0x44, 0xF8, 0x1E, 0x40,
  0x81, 0x02, 0x07, 0x90, 0x20, 0x40, 0x83, 0xE0, 0x1E, 0x40, 0x81, 0x02,
  0x0F, 0x90, 0x20, 0x40, 0x82, 0x00, 0x1F, 0x20, 0x40, 0x40, 0x80, 0x8C,
  0x82, 0x82, 0x82, 0x82, 0x7C, 0x20, 0x90, 0x48, 0x24, 0x12, 0x11, 0xF9,
  0x04, 0x82, 0x42, 0x21, 0x20, 0x80, 0x39, 0x08, 0x42, 0x11, 0x08, 0x42,
  0x30, 0x08, 0x42, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x60, 0x21, 0x22,
  0x24, 0x28, 0x30, 0x70, 0x48, 0x48, 0x48, 0x44, 0x84, 0x21, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x3E, 0x10, 0x26, 0x04, 0xC1, 0x98, 0x53, 0x0C, 0xA2,
  0x92, 0x52, 0x52, 0x4C, 0x49, 0x92, 0x22, 0x00, 0x10, 0x98, 0x4C, 0x25,
  0x12, 0x92, 0x49, 0x14, 0x8A, 0x45, 0x21, 0x20, 0x80, 0x1C, 0x22, 0x41,
  0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x78, 0x1C, 0x44, 0x89, 0x12,
  0x28, 0x9E, 0x20, 0x40, 0x82, 0x00, 0x1C, 0x22, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x82, 0x82, 0x84, 0x68, 0x10, 0x08, 0x08, 0x1C, 0x44, 0x89, 0x12,
  0x28, 0x9E, 0x24, 0x44, 0x8A, 0x10, 0x1E, 0x41, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x0B, 0xE0, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x00, 0x41, 0x41, 0x41, 0x41, 0x42, 0x82, 0x82, 0x82, 0x84, 0x84,
  0x78, 0x83, 0x06, 0x14, 0x24, 0x89, 0x14, 0x28, 0x60, 0xC1, 0x00, 0x88,
  0x62, 0x19, 0x46, 0x52, 0x94, 0xA9, 0x4A, 0x53, 0x18, 0xC6, 0x21, 0x08,
  0x40, 0x10, 0x88, 0x84, 0x82, 0x80, 0xC0, 0x40, 0x60, 0x48, 0x24, 0x22,
  0x20, 0x80, 0x83, 0x09, 0x22, 0x45, 0x0C, 0x08, 0x20, 0x40, 0x81, 0x00,
  0x3E, 0x04, 0x10, 0x20, 0x82, 0x08, 0x10, 0x41, 0x03, 0xE0, 0x19, 0x08,
  0x44, 0x21, 0x08, 0x44, 0x21, 0x0E, 0x00, 0xAA, 0xAA, 0x54, 0x1C, 0x20,
  0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0xE0, 0x10, 0xC2, 0x92, 0x46,
  0x10, 0xF8, 0x90, 0x3D, 0x18, 0x62, 0x8A, 0x29, 0xBA, 0x20, 0x40, 0x81,
  0xE2, 0x28, 0x50, 0xA1, 0x44, 0x8A, 0xE0, 0x3A, 0x21, 0x08, 0x42, 0x1E,
  0x02, 0x04, 0x11, 0xE4, 0x50, 0xA1, 0x44, 0x89, 0x33, 0xA0, 0x3A, 0x63,
  0xE8, 0x42, 0x1E, 0x07, 0x08, 0x08, 0x1C, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x1E, 0x45, 0x0A, 0x18, 0x50, 0x93,
  0x3A, 0x04, 0x10, 0x27, 0x80, 0x20, 0x40, 0x81, 0xE2, 0x28, 0x50, 0xA2,
  0x45, 0x0A, 0x10, 0x20, 0x14, 0x92, 0x52, 0x00, 0x08, 0x00, 0x10, 0x88,
  0x42, 0x11, 0x08, 0x42, 0x22, 0x00, 0x20, 0x40, 0x81, 0x34, 0x8A, 0x1C,
  0x28, 0x51, 0x12, 0x20, 0x24, 0x94, 0x92, 0x52, 0x00, 0x3D, 0xC8, 0x94,
  0x45, 0x11, 0x44, 0x51, 0x18, 0x46, 0x22, 0x3C, 0x45, 0x0A, 0x14, 0x48,
  0xA1, 0x42, 0x39, 0x18, 0x61, 0x86, 0x28, 0xBC, 0x3C, 0x45, 0x0A, 0x14,
  0x28, 0x91, 0x5C, 0x81, 0x02, 0x00, 0x3D, 0x18, 0x61, 0x8A, 0x29, 0xBA,
  0x08, 0x41, 0x04, 0x39, 0x10, 0x84, 0x22, 0x10, 0x3A, 0x10, 0x41, 0x04,
  0x3E, 0x4B, 0xC9, 0x24, 0x98, 0x46, 0x18, 0x62, 0x8A, 0x29, 0xBA, 0x8C,
  0x65, 0x2A, 0x53, 0x10, 0x88, 0xCC, 0xA6, 0x55, 0x4A, 0xA6, 0x62, 0x31,
  0x10, 0x22, 0x28, 0x50, 0xC1, 0x85, 0x12, 0x62, 0x11, 0x11, 0x12, 0x12,
  0x14, 0x14, 0x18, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x7C, 0x21, 0x04, 0x21,
  0x08, 0x3C, 0x0C, 0x41, 0x04, 0x20, 0x8C, 0x10, 0x41, 0x04, 0x10, 0x60,
  0xFF, 0xFE, 0x10, 0x20, 0x82, 0x08, 0x40, 0xC4, 0x10, 0x42, 0x08, 0xE0,
  0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 11, 3, 0, -11 },
  { 6, 3, 4, 5, 2, -11 },
  { 8, 8, 11, 8, 0, -11 },
  { 19, 7, 12, 7, 0, -11 },
  { 30, 9, 11, 10, 1, -11 },
  { 43, 8, 11, 8, 0, -11 },
  { 54, 1, 4, 3, 2, -11 },
  { 55, 5, 13, 4, 0, -11 },
  { 64, 4, 13, 4, -1, -11 },
  { 71, 5, 5, 7, 2, -11 },
  { 75, 6, 7, 8, 1, -9 },
  { 81, 2, 4, 3, -1, -2 },
  { 82, 4, 1, 4, 0, -5 },
  { 83, 1, 1, 3, 0, -1 },
  { 84, 7, 11, 5, -1, -11 },
  { 94, 6, 11, 7, 1, -11 },
  { 103, 4, 11, 7, 2, -11 },
  { 109, 7, 11, 7, 0, -11 },
  { 119, 7, 11, 7, 0, -11 },
  { 129, 7, 11, 7, 0, -11 },
  { 139, 7, 11, 7, 0, -11 },
  { 149, 6, 11, 7, 1, -11 },
  { 158, 6, 11, 7, 1, -11 },
  { 167, 7, 11, 7, 0, -11 },
  { 177, 7, 11, 7, 0, -11 },
  { 187, 3, 8, 3, 0, -8 },
  { 190, 4, 10, 3, -1, -8 },
  { 195, 6, 7, 8, 1, -9 },
  { 201, 6, 4, 8, 1, -7 },
  { 204, 6, 7, 8, 1, -9 },
  { 210, 5, 11, 5, 1, -11 },
  { 217, 10, 12, 11, 1, -11 },
  { 232, 7, 11, 7, -1, -11 },
  { 242, 8, 11, 8, 0, -11 },
  { 253, 7, 11, 8, 1, -11 },
  { 263, 8, 11, 9, 0, -11 },
  { 274, 7, 11, 7, 0, -11 },
  { 284, 7, 11, 6, 0, -11 },
  { 294, 8, 11, 9, 1, -11 },
  { 305, 9, 11, 9, 0, -11 },
  { 318, 5, 11, 4, 0, -11 },
  { 325, 5, 14, 3, -2, -11 },
  { 334, 8, 11, 7, 0, -11 },
  { 345, 5, 11, 6, 0, -11 },
  { 352, 11, 11, 11, 0, -11 },
  { 368, 9, 11, 9, 0, -11 },
  { 381, 8, 11, 9, 1, -11 },
  { 392, 7, 11, 7, 0, -11 },
  { 402, 8, 14, 9, 1, -11 },
  { 416, 7, 11, 7, 0, -11 },
  { 426, 7, 11, 7, 0, -11 },
  { 436, 7, 11, 6, 1, -11 },
  { 446, 8, 11, 9, 1, -11 },
  { 457, 7, 11, 7, 1, -11 },
  { 467, 10, 11, 11, 2, -11 },
  { 481, 9, 11, 6, -1, -11 },
  { 494, 7, 11, 6, 1, -11 },
  { 504, 7, 11, 7, 0, -11 },
  { 514, 5, 13, 4, 0, -11 },
  { 523, 2, 11, 5, 2, -11 },
  { 526, 6, 13, 4, -1, -11 },
  { 536, 6, 6, 7, 1, -11 },
  { 541, 5, 1, 5, -1, 1 },
  { 542, 2, 2, 3, 2, -11 },
  { 543, 6, 8, 7, 1, -8 },
  { 549, 7, 11, 8, 0, -11 },
  { 559, 5, 8, 6, 1, -8 },
  { 564, 7, 11, 8, 1, -11 },
  { 574, 5, 8, 7, 1, -8 },
  { 579, 8, 15, 4, -2, -11 },
  { 594, 7, 12, 8, 0, -8 },
  { 605, 7, 11, 7, 0, -11 },
  { 615, 3, 11, 3, 0, -11 },
  { 620, 5, 15, 3, -2, -11 },
  { 630, 7, 11, 6, 0, -11 },
  { 640, 3, 11, 3, 0, -11 },
  { 645, 10, 8, 11, 0, -8 },
  { 655, 7, 8, 7, 0, -8 },
  { 662, 6, 8, 7, 1, -8 },
  { 668, 7, 11, 8, 0, -8 },
  { 678, 6, 12, 8, 1, -8 },
  { 687, 5, 8, 5, 0, -8 },
  { 692, 5, 8, 6, 0, -8 },
  { 697, 3, 10, 4, 1, -10 },
  { 701, 6, 8, 7, 1, -8 },
  { 707, 5, 8, 6, 1, -8 },
  { 712, 9, 8, 9, 1, -8 },
  { 721, 7, 8, 6, -1, -8 },
  { 728, 8, 12, 6, -2, -8 },
  { 740, 6, 8, 5, 0, -8 },
  { 746, 6, 13, 5, 0, -11 },
  { 756, 1, 15, 7, 3, -11 },
  { 758, 6, 13, 5, -1, -11 },
  { 768, 6, 1, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC15PT7B_H_
