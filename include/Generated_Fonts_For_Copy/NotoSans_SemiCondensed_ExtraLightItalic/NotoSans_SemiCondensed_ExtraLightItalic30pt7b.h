#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x84,
  0x10, 0x00, 0x00, 0x30, 0x80, 0x66, 0x89, 0x12, 0x24, 0x50, 0xA2, 0x00,
  0x01, 0x04, 0x02, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x0F,
  0xFF, 0x82, 0x18, 0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x84,
  0x1F, 0xFF, 0x04, 0x30, 0x08, 0x40, 0x20, 0x80, 0x41, 0x00, 0x84, 0x02,
  0x08, 0x04, 0x10, 0x00, 0x00, 0x40, 0x04, 0x00, 0x20, 0x0F, 0xE0, 0x88,
  0x88, 0x40, 0x44, 0x06, 0x20, 0x31, 0x00, 0x88, 0x06, 0x80, 0x1C, 0x00,
  0x30, 0x01, 0x60, 0x09, 0x00, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10, 0x09,
  0x8F, 0xB8, 0x0E, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x09,
  0x81, 0x88, 0x40, 0x8C, 0x20, 0x84, 0x10, 0xC2, 0x08, 0x43, 0x04, 0x41,
  0x02, 0x20, 0x82, 0x20, 0x41, 0x23, 0xA0, 0x92, 0x30, 0x92, 0x14, 0x93,
  0x09, 0x89, 0x04, 0x08, 0x82, 0x0C, 0x41, 0x04, 0x40, 0x84, 0x20, 0x86,
  0x10, 0x42, 0x08, 0x62, 0x06, 0x23, 0x01, 0xE0, 0x01, 0xC0, 0x06, 0x40,
  0x10, 0x40, 0x60, 0x80, 0x81, 0x01, 0x02, 0x02, 0x0C, 0x04, 0x30, 0x04,
  0xC0, 0x0B, 0x00, 0x18, 0x00, 0xD0, 0x03, 0x10, 0x2C, 0x30, 0x90, 0x21,
  0x40, 0x64, 0x80, 0x59, 0x00, 0x62, 0x00, 0x84, 0x02, 0x8C, 0x19, 0x0F,
  0xE1, 0x00, 0x69, 0x25, 0x20, 0x03, 0x02, 0x04, 0x08, 0x18, 0x10, 0x30,
  0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x40,
  0x00, 0x04, 0x01, 0x00, 0x42, 0x10, 0x64, 0x07, 0xF0, 0x80, 0x50, 0x64,
  0x30, 0x80, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x32, 0x24, 0x48, 0x80, 0xFE, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x31, 0x83, 0x04, 0x10, 0x31,
  0x00, 0x88, 0x04, 0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0xD0, 0x06, 0x80,
  0x24, 0x01, 0x20, 0x0B, 0x00, 0xD8, 0x04, 0xC0, 0x26, 0x02, 0x10, 0x10,
  0x81, 0x06, 0x18, 0x1F, 0x00, 0x06, 0x34, 0xDE, 0x20, 0x40, 0x83, 0x04,
  0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81, 0x06, 0x00,
  0x01, 0xE0, 0x1C, 0xC0, 0x80, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xE0, 0x1C, 0xE0, 0x80, 0x80, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x7C, 0x00, 0x70,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x80, 0xC1, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0A, 0x00, 0x48, 0x02, 0x60, 0x19, 0x00, 0x44, 0x02, 0x10, 0x10, 0x40,
  0xC3, 0x02, 0x08, 0x10, 0x20, 0x80, 0x84, 0x02, 0x30, 0x11, 0xFF, 0xF8,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x07, 0xFC, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x17,
  0x80, 0x61, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x20, 0x30, 0x7F, 0x00, 0x00, 0xF0,
  0x31, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04,
  0xF8, 0xB0, 0xCC, 0x04, 0xC0, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x48,
  0x04, 0x80, 0xC8, 0x08, 0x41, 0x03, 0xE0, 0x7F, 0xF8, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x31, 0x82, 0x06, 0x30,
  0x11, 0x00, 0x88, 0x04, 0x40, 0x22, 0x02, 0x08, 0x20, 0x26, 0x00, 0xE0,
  0x1B, 0x03, 0x0C, 0x30, 0x33, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x84, 0x0C, 0x1F, 0x80, 0x01, 0xC0, 0x33, 0x02, 0x04, 0x20,
  0x23, 0x01, 0x90, 0x0C, 0x80, 0x24, 0x01, 0x60, 0x1B, 0x00, 0x88, 0x0C,
  0x40, 0xE1, 0x8D, 0x07, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x7E, 0x00, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x88, 0x04, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC2, 0x08, 0x41, 0x08, 0x20, 0x00, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x80, 0x00, 0x1C, 0x39, 0x80, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xFF, 0x00,
  0x18, 0x0C, 0x06, 0x00, 0x60, 0xC0, 0x02, 0x08, 0x00, 0x31, 0x00, 0x01,
  0x20, 0x7E, 0x12, 0x08, 0x21, 0x61, 0x04, 0x14, 0x30, 0x41, 0x42, 0x04,
  0x14, 0x20, 0x42, 0xC6, 0x08, 0x28, 0x40, 0x82, 0x84, 0x18, 0x48, 0x61,
  0x8C, 0x82, 0x6D, 0x84, 0x18, 0x60, 0x40, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x3E, 0x00, 0x00, 0x18, 0x00,
  0x50, 0x00, 0xA0, 0x02, 0x40, 0x04, 0x80, 0x11, 0x00, 0x22, 0x00, 0x84,
  0x01, 0x08, 0x04, 0x18, 0x08, 0x30, 0x20, 0x20, 0x7F, 0xC1, 0x00, 0x82,
  0x01, 0x08, 0x02, 0x10, 0x04, 0x40, 0x08, 0x80, 0x12, 0x00, 0x2C, 0x00,
  0x60, 0x0F, 0xF8, 0x20, 0x30, 0x80, 0x42, 0x01, 0x18, 0x04, 0x40, 0x11,
  0x00, 0x44, 0x02, 0x10, 0x10, 0xFF, 0x02, 0x06, 0x08, 0x04, 0x20, 0x18,
  0x80, 0x24, 0x00, 0x90, 0x06, 0x40, 0x11, 0x00, 0x4C, 0x02, 0x20, 0x30,
  0xFF, 0x00, 0x00, 0x70, 0x07, 0x1C, 0x18, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x02, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x08, 0x0C,
  0x08, 0x04, 0x08, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x03, 0x10, 0x03,
  0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x08, 0x40, 0x18, 0x40, 0x30, 0xC0, 0x60, 0x81, 0xC0,
  0xFE, 0x00, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xFF, 0x82, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFE, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00,
  0x20, 0x00, 0x80, 0x00, 0x00, 0x70, 0x03, 0x8F, 0x06, 0x01, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x7C, 0x80, 0x84, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C,
  0x80, 0x08, 0xC0, 0x08, 0x40, 0x08, 0x60, 0x18, 0x30, 0x10, 0x1F, 0xE0,
  0x0C, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x21, 0x80, 0x10, 0x80,
  0x08, 0x40, 0x0C, 0x20, 0x04, 0x10, 0x02, 0x1F, 0xFF, 0x08, 0x01, 0x84,
  0x00, 0x82, 0x00, 0x41, 0x00, 0x21, 0x00, 0x10, 0x80, 0x18, 0x40, 0x08,
  0x20, 0x04, 0x30, 0x02, 0x10, 0x01, 0x08, 0x01, 0x80, 0x07, 0xC0, 0x40,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0xFC, 0x00,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x0C, 0x0F, 0x80, 0x0C, 0x07, 0x08, 0x0C, 0x08, 0x18, 0x08, 0x30, 0x18,
  0x60, 0x10, 0xC0, 0x11, 0x80, 0x11, 0x00, 0x12, 0x00, 0x36, 0x00, 0x2A,
  0x00, 0x31, 0x00, 0x21, 0x00, 0x21, 0x80, 0x40, 0x80, 0x40, 0x80, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0x60, 0x80, 0x20, 0x80, 0x30, 0x0C, 0x04, 0x02,
  0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x30, 0x10, 0x0F, 0xF8, 0x0C, 0x00, 0x18,
  0x60, 0x01, 0xC3, 0x00, 0x0E, 0x14, 0x00, 0xA1, 0xA0, 0x05, 0x09, 0x00,
  0x48, 0x48, 0x02, 0x42, 0x40, 0x24, 0x12, 0x03, 0x21, 0x90, 0x11, 0x08,
  0x81, 0x88, 0x42, 0x08, 0xC2, 0x10, 0x84, 0x10, 0x84, 0x21, 0x04, 0x41,
  0x08, 0x22, 0x08, 0x41, 0x20, 0xC2, 0x09, 0x04, 0x30, 0x50, 0x21, 0x01,
  0x81, 0x08, 0x08, 0x18, 0x00, 0x0C, 0x00, 0x86, 0x00, 0x43, 0x80, 0x61,
  0x40, 0x21, 0xA0, 0x10, 0x98, 0x08, 0x44, 0x04, 0x22, 0x06, 0x11, 0x82,
  0x18, 0x41, 0x08, 0x20, 0x84, 0x18, 0x42, 0x04, 0x61, 0x02, 0x21, 0x01,
  0x90, 0x80, 0x48, 0x40, 0x24, 0x20, 0x1C, 0x30, 0x06, 0x10, 0x03, 0x08,
  0x01, 0x80, 0x00, 0xE0, 0x07, 0x38, 0x0C, 0x04, 0x18, 0x02, 0x10, 0x02,
  0x20, 0x03, 0x20, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C,
  0x80, 0x08, 0xC0, 0x18, 0x40, 0x30, 0x20, 0x60, 0x1F, 0xC0, 0x0F, 0xF0,
  0x20, 0x60, 0x80, 0x82, 0x03, 0x18, 0x04, 0x40, 0x11, 0x00, 0xC4, 0x02,
  0x10, 0x08, 0xC0, 0x42, 0x06, 0x0F, 0xE0, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00,
  0xE0, 0x07, 0x38, 0x0C, 0x04, 0x18, 0x02, 0x10, 0x02, 0x20, 0x03, 0x20,
  0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x02, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x40,
  0x18, 0x40, 0x30, 0x20, 0x60, 0x1F, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x0F, 0xF0, 0x20, 0x60, 0x80, 0x82, 0x01,
  0x18, 0x04, 0x40, 0x31, 0x00, 0xC4, 0x02, 0x10, 0x18, 0xC0, 0xC3, 0xFE,
  0x0F, 0xC0, 0x20, 0x80, 0x82, 0x04, 0x08, 0x10, 0x30, 0x40, 0x41, 0x01,
  0x0C, 0x04, 0x20, 0x08, 0x80, 0x20, 0x00, 0xE0, 0x1C, 0xF0, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x80, 0xC3, 0xFC, 0x00, 0xFF, 0xF0, 0x40,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x00, 0x10, 0x01, 0x10, 0x01, 0x10, 0x03, 0x30,
  0x02, 0x20, 0x02, 0x20, 0x02, 0x20, 0x06, 0x20, 0x04, 0x60, 0x04, 0x40,
  0x04, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0xC0, 0x08, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x10, 0x80, 0x30, 0xC0, 0x20, 0x60, 0xC0, 0x3F, 0x80, 0x80,
  0x0E, 0x00, 0x68, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x01, 0x8C, 0x04, 0x30,
  0x30, 0x40, 0x81, 0x06, 0x04, 0x10, 0x10, 0xC0, 0x42, 0x01, 0x18, 0x04,
  0x40, 0x13, 0x00, 0x48, 0x01, 0x60, 0x05, 0x00, 0x1C, 0x00, 0x20, 0x00,
  0x80, 0x30, 0x0E, 0x00, 0xC0, 0x28, 0x05, 0x01, 0x20, 0x14, 0x04, 0x80,
  0x90, 0x22, 0x02, 0x40, 0x8C, 0x11, 0x06, 0x30, 0x44, 0x10, 0xC3, 0x10,
  0x43, 0x08, 0x42, 0x0C, 0x21, 0x08, 0x11, 0x04, 0x40, 0x44, 0x11, 0x01,
  0x20, 0x4C, 0x04, 0x81, 0x20, 0x14, 0x04, 0x80, 0x50, 0x14, 0x01, 0xC0,
  0x50, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x40, 0x18, 0x00, 0x06, 0x01,
  0x81, 0x01, 0x80, 0x80, 0x80, 0x20, 0x80, 0x10, 0xC0, 0x08, 0x40, 0x06,
  0x40, 0x01, 0x60, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x28, 0x00,
  0x36, 0x00, 0x11, 0x00, 0x10, 0x80, 0x18, 0x40, 0x08, 0x30, 0x08, 0x08,
  0x08, 0x04, 0x0C, 0x03, 0x0C, 0x00, 0x80, 0x80, 0x38, 0x02, 0xC0, 0x44,
  0x04, 0x40, 0x84, 0x18, 0x41, 0x06, 0x20, 0x26, 0x02, 0x40, 0x28, 0x03,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x00, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x1F, 0x00, 0x84, 0x10, 0x84,
  0x21, 0x08, 0x61, 0x08, 0x42, 0x10, 0xC2, 0x10, 0x84, 0x21, 0x80, 0x07,
  0xE0, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0x80, 0x00,
  0x80, 0x0C, 0x00, 0xE0, 0x04, 0x80, 0x44, 0x02, 0x20, 0x20, 0x83, 0x04,
  0x10, 0x21, 0x00, 0x88, 0x04, 0x80, 0x3C, 0x00, 0x80, 0xFF, 0xC0, 0xC4,
  0x22, 0x10, 0x07, 0xC8, 0x63, 0x44, 0x0A, 0x60, 0x22, 0x01, 0x30, 0x09,
  0x00, 0xC8, 0x06, 0xC0, 0x26, 0x01, 0x20, 0x19, 0x00, 0xCC, 0x0C, 0x20,
  0x61, 0x05, 0x07, 0xC8, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x7C, 0x14, 0x31, 0xC0, 0x8C, 0x06, 0x60, 0x32,
  0x00, 0x90, 0x0D, 0x80, 0x68, 0x02, 0x40, 0x12, 0x00, 0x90, 0x09, 0x80,
  0x4C, 0x04, 0x50, 0x42, 0x7C, 0x00, 0x07, 0xE1, 0x80, 0x40, 0x18, 0x02,
  0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x18, 0x21, 0xFC, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x03, 0xE4, 0x0C, 0x28, 0x20, 0x50, 0xC0,
  0x61, 0x00, 0x84, 0x01, 0x08, 0x02, 0x10, 0x04, 0x60, 0x18, 0xC0, 0x21,
  0x00, 0x42, 0x01, 0x86, 0x07, 0x04, 0x0C, 0x08, 0x28, 0x0F, 0x90, 0x00,
  0x07, 0xC1, 0x84, 0x40, 0x98, 0x12, 0x02, 0x80, 0xD0, 0x33, 0xF8, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x21, 0xFC, 0x00, 0x1E,
  0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x01,
  0xF8, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xE4, 0x18, 0x50, 0x81,
  0x46, 0x03, 0x10, 0x08, 0x80, 0x22, 0x00, 0x88, 0x02, 0x60, 0x19, 0x80,
  0x44, 0x01, 0x10, 0x0C, 0x60, 0x70, 0x81, 0xC2, 0x0A, 0x07, 0xC8, 0x00,
  0x20, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x82, 0x06, 0x07, 0xE0, 0x00,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x3E,
  0x14, 0x31, 0x81, 0x30, 0x13, 0x01, 0x20, 0x12, 0x01, 0x60, 0x34, 0x02,
  0x40, 0x24, 0x02, 0x40, 0x2C, 0x04, 0x80, 0x48, 0x04, 0x80, 0x40, 0x08,
  0x30, 0x80, 0x00, 0x01, 0x04, 0x30, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41,
  0x0C, 0x20, 0x82, 0x00, 0x00, 0x40, 0x0C, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x08, 0x0F, 0x00, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x03, 0x10, 0x63, 0x0C, 0x20,
  0x82, 0x10, 0x22, 0x02, 0x40, 0x6C, 0x05, 0x40, 0x62, 0x04, 0x20, 0x43,
  0x0C, 0x10, 0x81, 0x08, 0x18, 0x80, 0x80, 0x0C, 0x20, 0x82, 0x08, 0x41,
  0x04, 0x10, 0xC2, 0x08, 0x20, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08,
  0x00, 0x13, 0xC3, 0xE1, 0x42, 0x42, 0x38, 0x28, 0x13, 0x03, 0x01, 0x30,
  0x30, 0x12, 0x02, 0x03, 0x20, 0x20, 0x26, 0x02, 0x02, 0x40, 0x60, 0x24,
  0x04, 0x02, 0x40, 0x40, 0x44, 0x04, 0x04, 0xC0, 0x40, 0x48, 0x0C, 0x04,
  0x80, 0x80, 0xC8, 0x08, 0x08, 0x13, 0xE1, 0x43, 0x38, 0x13, 0x01, 0x30,
  0x12, 0x01, 0x20, 0x16, 0x03, 0x40, 0x24, 0x02, 0x40, 0x24, 0x06, 0xC0,
  0x48, 0x04, 0x80, 0x48, 0x04, 0x07, 0xC0, 0xC2, 0x10, 0x13, 0x01, 0x20,
  0x16, 0x01, 0x40, 0x14, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x3C, 0x02, 0xC0,
  0x64, 0x04, 0x60, 0x83, 0xF0, 0x04, 0xF8, 0x0A, 0x18, 0x38, 0x10, 0x60,
  0x30, 0xC0, 0x21, 0x00, 0x42, 0x01, 0x8C, 0x03, 0x10, 0x04, 0x20, 0x08,
  0x40, 0x10, 0x80, 0x43, 0x00, 0x86, 0x02, 0x0A, 0x08, 0x13, 0xE0, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xC8, 0x61, 0x44, 0x0A, 0x60, 0x32, 0x01, 0x30, 0x09, 0x00,
  0x48, 0x02, 0xC0, 0x36, 0x01, 0x20, 0x09, 0x00, 0xCC, 0x0E, 0x20, 0x71,
  0x05, 0x07, 0xC8, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x06, 0x00, 0x13, 0xC5, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x02, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x0F,
  0xC2, 0x04, 0xC0, 0x10, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x20, 0x47, 0xF0, 0x08, 0x08, 0x10,
  0x10, 0x7F, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0xC0, 0x80, 0x80, 0xC0, 0x78, 0x10, 0x08, 0x80, 0xC8, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x09, 0x80, 0xC8, 0x04, 0x40, 0x22, 0x01, 0x10, 0x19, 0x80,
  0xC8, 0x0C, 0x60, 0x61, 0x0D, 0x0F, 0xC8, 0x80, 0x70, 0x0A, 0x02, 0x40,
  0x48, 0x11, 0x02, 0x20, 0x84, 0x10, 0x84, 0x19, 0x81, 0x20, 0x2C, 0x05,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x80, 0x80, 0xC0, 0xC0, 0xA0, 0x60, 0x50,
  0x50, 0x48, 0x28, 0x24, 0x24, 0x32, 0x12, 0x11, 0x11, 0x08, 0x88, 0x88,
  0x4C, 0x44, 0x24, 0x24, 0x16, 0x0A, 0x0A, 0x07, 0x05, 0x03, 0x03, 0x01,
  0x81, 0x80, 0x80, 0x18, 0x0C, 0x20, 0x60, 0xC1, 0x01, 0x08, 0x04, 0x40,
  0x1A, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x14, 0x00, 0x98, 0x06, 0x20,
  0x10, 0x80, 0x81, 0x04, 0x04, 0x30, 0x18, 0x04, 0x03, 0x04, 0x02, 0x04,
  0x06, 0x04, 0x04, 0x04, 0x0C, 0x04, 0x08, 0x06, 0x18, 0x02, 0x10, 0x02,
  0x30, 0x02, 0x20, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x18, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0x00, 0x20, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x40, 0x0F, 0xF8, 0x01, 0xC0, 0x80, 0x60, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0xC0, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x70,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x18, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x30, 0x18, 0x00, 0x78, 0x18, 0x73, 0x81, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 21, 6, 1, -21 },
  { 17, 7, 7, 9, 3, -21 },
  { 24, 15, 21, 16, 1, -21 },
  { 64, 13, 25, 14, 1, -23 },
  { 105, 17, 22, 21, 2, -22 },
  { 152, 15, 22, 17, 1, -22 },
  { 194, 3, 7, 5, 3, -21 },
  { 197, 8, 26, 7, 1, -21 },
  { 223, 9, 26, 7, -2, -21 },
  { 253, 10, 11, 14, 4, -23 },
  { 267, 12, 14, 15, 2, -18 },
  { 288, 4, 7, 6, -1, -3 },
  { 292, 7, 1, 9, 1, -9 },
  { 293, 2, 2, 6, 1, -2 },
  { 294, 13, 21, 9, -1, -21 },
  { 329, 13, 22, 14, 1, -22 },
  { 365, 7, 21, 14, 4, -21 },
  { 384, 14, 22, 14, 0, -22 },
  { 423, 14, 22, 14, 0, -22 },
  { 462, 14, 22, 14, 0, -22 },
  { 501, 14, 21, 14, 0, -21 },
  { 538, 12, 22, 14, 2, -22 },
  { 571, 13, 21, 14, 2, -21 },
  { 606, 13, 22, 14, 1, -22 },
  { 642, 13, 22, 14, 1, -22 },
  { 678, 4, 16, 6, 1, -16 },
  { 686, 6, 20, 6, -1, -16 },
  { 701, 12, 13, 15, 2, -17 },
  { 721, 12, 7, 15, 2, -14 },
  { 732, 12, 13, 15, 2, -17 },
  { 752, 9, 22, 11, 2, -22 },
  { 777, 20, 24, 22, 1, -21 },
  { 837, 15, 21, 14, -2, -21 },
  { 877, 14, 21, 16, 1, -21 },
  { 914, 15, 22, 15, 2, -22 },
  { 956, 16, 21, 17, 1, -21 },
  { 998, 14, 21, 14, 1, -21 },
  { 1035, 14, 21, 13, 1, -21 },
  { 1072, 16, 22, 18, 2, -22 },
  { 1116, 17, 21, 18, 1, -21 },
  { 1161, 10, 21, 8, -1, -21 },
  { 1188, 12, 26, 6, -5, -21 },
  { 1227, 16, 21, 14, 1, -21 },
  { 1269, 9, 21, 13, 1, -21 },
  { 1293, 21, 21, 22, 1, -21 },
  { 1349, 17, 21, 18, 1, -21 },
  { 1394, 16, 22, 19, 2, -22 },
  { 1438, 14, 21, 15, 1, -21 },
  { 1475, 16, 27, 19, 2, -22 },
  { 1529, 14, 21, 15, 1, -21 },
  { 1566, 14, 22, 13, 0, -22 },
  { 1605, 12, 21, 13, 3, -21 },
  { 1637, 16, 21, 18, 2, -21 },
  { 1679, 14, 21, 14, 3, -21 },
  { 1716, 22, 21, 23, 3, -21 },
  { 1774, 17, 21, 13, -2, -21 },
  { 1819, 12, 21, 13, 3, -21 },
  { 1851, 16, 21, 14, -1, -21 },
  { 1893, 11, 26, 9, 0, -21 },
  { 1929, 5, 21, 10, 3, -21 },
  { 1943, 11, 26, 9, -2, -21 },
  { 1979, 13, 13, 15, 1, -22 },
  { 2001, 10, 1, 10, -2, 3 },
  { 2003, 4, 5, 7, 4, -23 },
  { 2006, 13, 16, 15, 1, -16 },
  { 2032, 13, 23, 15, 1, -23 },
  { 2070, 11, 16, 12, 1, -16 },
  { 2092, 15, 23, 15, 1, -23 },
  { 2136, 11, 16, 13, 1, -16 },
  { 2158, 15, 30, 7, -4, -23 },
  { 2215, 14, 23, 15, 0, -16 },
  { 2256, 12, 23, 15, 1, -23 },
  { 2291, 6, 22, 6, 1, -22 },
  { 2308, 11, 29, 6, -4, -22 },
  { 2348, 12, 23, 12, 1, -23 },
  { 2383, 6, 23, 6, 1, -23 },
  { 2401, 20, 16, 22, 1, -16 },
  { 2441, 12, 16, 15, 1, -16 },
  { 2465, 12, 16, 15, 1, -16 },
  { 2489, 15, 23, 15, -1, -16 },
  { 2533, 13, 23, 15, 1, -16 },
  { 2571, 10, 16, 10, 1, -16 },
  { 2591, 11, 16, 11, 0, -16 },
  { 2613, 8, 20, 8, 1, -20 },
  { 2633, 13, 16, 15, 1, -16 },
  { 2659, 11, 16, 11, 2, -16 },
  { 2681, 17, 16, 18, 2, -16 },
  { 2715, 14, 16, 12, -1, -16 },
  { 2743, 16, 23, 11, -3, -16 },
  { 2789, 12, 16, 11, -1, -16 },
  { 2813, 10, 26, 10, 1, -21 },
  { 2846, 1, 30, 14, 7, -23 },
  { 2850, 11, 26, 10, -2, -21 },
  { 2886, 12, 3, 15, 2, -12 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC30PT7B_H_
