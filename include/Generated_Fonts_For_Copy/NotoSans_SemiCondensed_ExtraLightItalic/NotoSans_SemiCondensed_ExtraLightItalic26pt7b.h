#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0xC4, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x20, 0x00, 0x04,
  0x20, 0x4D, 0x24, 0xA2, 0x8A, 0x49, 0x00, 0x02, 0x10, 0x10, 0x80, 0x88,
  0x08, 0x40, 0x42, 0x02, 0x21, 0xFF, 0xE1, 0x08, 0x08, 0x40, 0x84, 0x04,
  0x20, 0x21, 0x0F, 0xFE, 0x10, 0x80, 0x84, 0x04, 0x20, 0x42, 0x02, 0x10,
  0x10, 0x80, 0x01, 0x00, 0x20, 0x0C, 0x06, 0xF1, 0x20, 0x44, 0x08, 0x81,
  0x10, 0x32, 0x03, 0x80, 0x30, 0x03, 0x80, 0x48, 0x11, 0x02, 0x20, 0x44,
  0x08, 0x91, 0x61, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x00, 0x1C, 0x04, 0x48,
  0x11, 0x08, 0x42, 0x10, 0x88, 0x22, 0x10, 0x48, 0x21, 0x10, 0x42, 0x40,
  0x84, 0xBD, 0x12, 0x8A, 0x69, 0x0B, 0x94, 0x10, 0x48, 0x41, 0x10, 0x82,
  0x21, 0x08, 0x42, 0x20, 0x88, 0x41, 0x11, 0x03, 0xC0, 0x03, 0x80, 0x62,
  0x02, 0x10, 0x30, 0x81, 0x04, 0x08, 0x20, 0x22, 0x01, 0x20, 0x0E, 0x00,
  0xE0, 0x0C, 0x82, 0x84, 0x28, 0x11, 0x40, 0x92, 0x02, 0x90, 0x18, 0x80,
  0xC4, 0x0B, 0x1F, 0x88, 0x56, 0xA8, 0x02, 0x08, 0x20, 0x41, 0x06, 0x08,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x00, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01,
  0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0xC0, 0x04, 0x02, 0x21, 0x19, 0x03, 0x98, 0x70, 0x50, 0x48, 0x42,
  0x01, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x32, 0x24, 0x48, 0xFC, 0xC0, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x00, 0x03, 0x81, 0x88, 0x60, 0x88, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x01,
  0x40, 0x28, 0x05, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x41,
  0x08, 0x40, 0xF0, 0x00, 0x04, 0x62, 0xB2, 0x88, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x00, 0x03, 0x80, 0xC2, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0x80,
  0x03, 0xC0, 0xC2, 0x10, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0xF0, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC8, 0x18, 0x7F, 0x00, 0x00, 0x30, 0x03, 0x00, 0x60, 0x0A, 0x01,
  0x20, 0x12, 0x02, 0x20, 0x44, 0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x40,
  0x8F, 0xFF, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x07, 0xF0,
  0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC8,
  0x18, 0x7E, 0x00, 0x01, 0xF0, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x5F, 0x86, 0x0C, 0x40, 0x4C, 0x04, 0x80, 0x48, 0x04,
  0x80, 0x48, 0x08, 0x40, 0x84, 0x10, 0x3E, 0x00, 0x7F, 0xE0, 0x04, 0x01,
  0x00, 0x20, 0x08, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x00, 0x07,
  0x81, 0x08, 0x40, 0x88, 0x12, 0x02, 0x40, 0x44, 0x10, 0x86, 0x0F, 0x01,
  0xC0, 0xC4, 0x20, 0x48, 0x09, 0x00, 0xA0, 0x14, 0x06, 0x80, 0x98, 0x21,
  0xF8, 0x00, 0x07, 0x01, 0x18, 0x41, 0x10, 0x12, 0x02, 0x80, 0x50, 0x0A,
  0x01, 0x40, 0x6C, 0x18, 0x85, 0x0F, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x83, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x60, 0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x20,
  0x84, 0x10, 0x80, 0x00, 0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x08, 0x00, 0x1E, 0x10, 0x80, 0x20, 0x10, 0x08, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x01, 0xFE, 0x03, 0x01, 0x82, 0x00, 0x42, 0x00, 0x12, 0x00, 0x09,
  0x07, 0xC5, 0x04, 0x22, 0x84, 0x21, 0x44, 0x10, 0xC2, 0x08, 0x61, 0x04,
  0x31, 0x04, 0x28, 0x82, 0x14, 0x23, 0x12, 0x1E, 0x71, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x14, 0x01, 0x20, 0x22, 0x02, 0x20, 0x42, 0x04, 0x20, 0x82, 0x08,
  0x21, 0xFE, 0x10, 0x22, 0x02, 0x20, 0x24, 0x01, 0x40, 0x18, 0x01, 0x80,
  0x10, 0x0F, 0x01, 0x86, 0x10, 0x11, 0x01, 0x10, 0x11, 0x01, 0x20, 0x12,
  0x02, 0x20, 0xC3, 0xF8, 0x20, 0x44, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x04, 0x80, 0x48, 0x18, 0xFE, 0x00, 0x01, 0xE0, 0x61, 0x18, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0x80, 0x0E,
  0x00, 0xC7, 0x04, 0x04, 0x20, 0x31, 0x00, 0x88, 0x04, 0x80, 0x24, 0x01,
  0x20, 0x09, 0x00, 0x48, 0x02, 0x80, 0x14, 0x01, 0x20, 0x09, 0x00, 0x88,
  0x0C, 0x80, 0xC4, 0x18, 0x3F, 0x00, 0x0F, 0xF1, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0xFC, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0xFF, 0x00, 0x0F,
  0xF1, 0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x04, 0x3F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x18, 0x31, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x1F, 0x20,
  0x04, 0x80, 0x12, 0x00, 0x88, 0x02, 0x20, 0x08, 0xC0, 0x21, 0x80, 0x83,
  0xFC, 0x00, 0x08, 0x02, 0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42,
  0x01, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0x7F, 0xF0, 0x80, 0x42, 0x00,
  0x84, 0x01, 0x08, 0x02, 0x10, 0x04, 0x20, 0x10, 0x80, 0x21, 0x00, 0x42,
  0x00, 0x80, 0x0F, 0x81, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x3E, 0x00,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x0C, 0x02, 0x0B, 0x01, 0x00, 0x08, 0x0C, 0x60, 0x61, 0x03, 0x04,
  0x18, 0x10, 0xC0, 0x46, 0x02, 0x30, 0x09, 0x80, 0x2C, 0x00, 0xF0, 0x03,
  0x20, 0x10, 0x80, 0x42, 0x01, 0x04, 0x04, 0x10, 0x10, 0x40, 0x80, 0x82,
  0x02, 0x08, 0x04, 0x00, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0xFF, 0x08,
  0x00, 0x46, 0x00, 0x31, 0x80, 0x1C, 0x50, 0x05, 0x14, 0x02, 0x85, 0x00,
  0xA2, 0x40, 0x48, 0x90, 0x12, 0x24, 0x09, 0x09, 0x02, 0x42, 0x41, 0x11,
  0x08, 0x44, 0x42, 0x21, 0x10, 0x98, 0x84, 0x24, 0x21, 0x0A, 0x08, 0x82,
  0x82, 0x20, 0xC0, 0x88, 0x30, 0x40, 0x08, 0x02, 0x30, 0x04, 0x60, 0x10,
  0xA0, 0x21, 0x40, 0x42, 0x80, 0x88, 0x81, 0x11, 0x04, 0x22, 0x08, 0x42,
  0x10, 0x84, 0x22, 0x08, 0x84, 0x09, 0x08, 0x12, 0x10, 0x24, 0x20, 0x28,
  0x80, 0x61, 0x00, 0xC2, 0x00, 0x80, 0x03, 0xC0, 0x61, 0x84, 0x04, 0x40,
  0x12, 0x00, 0xA0, 0x05, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x40, 0x0A, 0x00, 0xD0, 0x04, 0xC0, 0x42, 0x04, 0x0F,
  0xC0, 0x0F, 0x01, 0x8E, 0x10, 0x21, 0x01, 0x10, 0x11, 0x01, 0x20, 0x12,
  0x02, 0x20, 0x22, 0x0C, 0x3F, 0x84, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x61, 0x84, 0x04, 0x40,
  0x12, 0x00, 0xA0, 0x05, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x40, 0x0A, 0x00, 0xD0, 0x04, 0xC0, 0x42, 0x04, 0x0F,
  0xC0, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x0F, 0x01, 0x8E, 0x10,
  0x21, 0x01, 0x10, 0x11, 0x01, 0x20, 0x32, 0x02, 0x20, 0x62, 0x0C, 0x3E,
  0x04, 0x20, 0x41, 0x04, 0x10, 0x41, 0x04, 0x08, 0x80, 0x88, 0x08, 0x80,
  0xC0, 0x03, 0xE0, 0xC3, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x88, 0x18, 0xFE, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x00, 0x10, 0x04, 0x80,
  0x22, 0x00, 0x88, 0x02, 0x20, 0x09, 0x80, 0x24, 0x01, 0x10, 0x04, 0x40,
  0x11, 0x00, 0x48, 0x01, 0x20, 0x08, 0x80, 0x22, 0x00, 0x88, 0x02, 0x20,
  0x10, 0x80, 0xC3, 0x06, 0x07, 0xF0, 0x00, 0x80, 0x14, 0x01, 0x40, 0x24,
  0x02, 0x40, 0x44, 0x04, 0x40, 0x84, 0x08, 0x41, 0x04, 0x10, 0x42, 0x04,
  0x20, 0x44, 0x04, 0x40, 0x28, 0x02, 0x80, 0x30, 0x03, 0x00, 0x20, 0x00,
  0x80, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x0A, 0x05, 0x02, 0x81, 0x40, 0xA0,
  0x90, 0x48, 0x24, 0x12, 0x11, 0x08, 0x84, 0x42, 0x21, 0x11, 0x08, 0x84,
  0x42, 0x21, 0x10, 0x90, 0x48, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x81, 0x40,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x00, 0x04, 0x02, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x40, 0x21, 0x00, 0x46, 0x00, 0x48, 0x00, 0xA0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x14, 0x00, 0x44, 0x01, 0x88, 0x02, 0x10, 0x08,
  0x20, 0x20, 0x20, 0x40, 0x43, 0x00, 0x80, 0x80, 0x28, 0x0D, 0x01, 0x20,
  0x44, 0x08, 0x82, 0x08, 0x81, 0x10, 0x24, 0x05, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x84, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x03, 0xE0, 0x88, 0x88,
  0x88, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x10, 0x07, 0xC0, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x0F,
  0x80, 0x02, 0x00, 0x60, 0x14, 0x02, 0x80, 0x88, 0x21, 0x04, 0x11, 0x02,
  0x20, 0x48, 0x06, 0x00, 0x80, 0xFF, 0x80, 0x91, 0x10, 0x0F, 0x23, 0x14,
  0x81, 0x90, 0x34, 0x04, 0x80, 0xB0, 0x14, 0x02, 0x80, 0x90, 0x12, 0x06,
  0x40, 0xC4, 0x28, 0xFA, 0x00, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x09, 0xE1, 0x42, 0x30, 0x24, 0x04, 0x80, 0xA0, 0x14, 0x02, 0x80,
  0x50, 0x16, 0x02, 0xC0, 0xD8, 0x13, 0x04, 0x5F, 0x00, 0x0F, 0x8C, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x01,
  0xF0, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x3C,
  0x83, 0x14, 0x20, 0x61, 0x03, 0x10, 0x18, 0x80, 0x8C, 0x04, 0x40, 0x22,
  0x03, 0x10, 0x10, 0x81, 0x84, 0x0C, 0x10, 0xA0, 0xF9, 0x00, 0x07, 0x86,
  0x22, 0x04, 0x81, 0x40, 0x90, 0x65, 0xE3, 0x80, 0x80, 0x20, 0x08, 0x03,
  0x00, 0x40, 0x0F, 0xC0, 0x00, 0x78, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x3F, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x07, 0x00, 0x00, 0x07,
  0x90, 0xC5, 0x10, 0x31, 0x03, 0x20, 0x32, 0x02, 0x60, 0x24, 0x02, 0x40,
  0x64, 0x04, 0x40, 0xC4, 0x0C, 0x21, 0x43, 0xE4, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x83, 0x0F, 0xE0, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x78, 0xA1, 0x30, 0x48, 0x12, 0x05, 0x01, 0x40, 0x50, 0x14, 0x09,
  0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x10, 0xC0, 0x00, 0x10, 0x84, 0x21,
  0x10, 0x84, 0x23, 0x10, 0x84, 0x20, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x40,
  0xF0, 0x00, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x04, 0x82,
  0x21, 0x08, 0x82, 0x41, 0x20, 0x58, 0x1A, 0x04, 0x42, 0x10, 0x86, 0x20,
  0x88, 0x22, 0x04, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21,
  0x10, 0x84, 0x21, 0x00, 0x27, 0x8F, 0x14, 0x68, 0x4C, 0x18, 0x24, 0x08,
  0x12, 0x04, 0x0A, 0x02, 0x05, 0x02, 0x04, 0x81, 0x02, 0x40, 0x81, 0x60,
  0x40, 0xA0, 0x40, 0x50, 0x20, 0x48, 0x10, 0x24, 0x08, 0x10, 0x27, 0x8A,
  0x13, 0x04, 0x81, 0x20, 0x50, 0x14, 0x05, 0x01, 0x40, 0xB0, 0x28, 0x0A,
  0x02, 0x80, 0xA0, 0x40, 0x0F, 0x83, 0x18, 0x81, 0x10, 0x14, 0x02, 0x80,
  0x70, 0x0C, 0x02, 0x80, 0x50, 0x0A, 0x02, 0x40, 0x44, 0x10, 0x7C, 0x00,
  0x09, 0xE0, 0x50, 0x83, 0x02, 0x18, 0x10, 0x80, 0x8C, 0x04, 0x40, 0x22,
  0x01, 0x10, 0x10, 0x80, 0x8C, 0x0C, 0x60, 0x43, 0x04, 0x17, 0xC1, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x00, 0x0F, 0x23, 0x14,
  0x81, 0x90, 0x34, 0x06, 0x80, 0xB0, 0x14, 0x02, 0x80, 0xD0, 0x12, 0x02,
  0x40, 0xC4, 0x28, 0xF9, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x00, 0x27, 0x28, 0x30, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x0F, 0x98, 0x48, 0x04, 0x02, 0x01, 0x80, 0x60, 0x08,
  0x02, 0x00, 0x80, 0x40, 0x28, 0x27, 0xE0, 0x10, 0x20, 0x43, 0xFA, 0x04,
  0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0xF0, 0x20, 0x24,
  0x04, 0x80, 0x90, 0x24, 0x04, 0x80, 0x90, 0x12, 0x06, 0x40, 0x90, 0x12,
  0x06, 0x40, 0xC8, 0x28, 0xFA, 0x00, 0x80, 0x60, 0x24, 0x09, 0x04, 0x41,
  0x10, 0x84, 0x21, 0x10, 0x44, 0x12, 0x05, 0x81, 0x40, 0x50, 0x08, 0x00,
  0x83, 0x06, 0x0C, 0x18, 0x50, 0xA1, 0x42, 0x89, 0x0A, 0x24, 0x48, 0x91,
  0x24, 0x48, 0x91, 0x22, 0x85, 0x0A, 0x14, 0x30, 0x60, 0xC1, 0x82, 0x06,
  0x00, 0x10, 0x10, 0x82, 0x08, 0x40, 0x88, 0x04, 0x80, 0x50, 0x06, 0x00,
  0x60, 0x0A, 0x00, 0x90, 0x11, 0x02, 0x10, 0x40, 0x8C, 0x08, 0x04, 0x04,
  0x10, 0x20, 0x40, 0x81, 0x04, 0x04, 0x10, 0x10, 0x80, 0x42, 0x01, 0x10,
  0x04, 0x40, 0x0A, 0x00, 0x28, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x3C, 0x00, 0x0F, 0xE0, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40,
  0x10, 0x04, 0x01, 0xFE, 0x00, 0x00, 0x83, 0x81, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x18, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x08,
  0x03, 0x00, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x70, 0x60, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x83,
  0x00, 0xF8, 0x61, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 6, 1, -19 },
  { 13, 6, 7, 8, 3, -19 },
  { 19, 13, 19, 14, 1, -19 },
  { 50, 11, 22, 12, 1, -20 },
  { 81, 15, 19, 18, 2, -19 },
  { 117, 13, 19, 14, 1, -19 },
  { 148, 2, 7, 4, 3, -19 },
  { 150, 7, 23, 6, 1, -19 },
  { 171, 8, 23, 6, -2, -19 },
  { 194, 9, 10, 12, 3, -20 },
  { 206, 10, 12, 13, 2, -15 },
  { 221, 4, 6, 5, -1, -3 },
  { 224, 6, 1, 8, 1, -8 },
  { 225, 1, 2, 5, 1, -2 },
  { 226, 11, 19, 8, -1, -19 },
  { 253, 11, 19, 12, 1, -19 },
  { 280, 6, 19, 12, 4, -19 },
  { 295, 12, 19, 12, 0, -19 },
  { 324, 12, 19, 12, 0, -19 },
  { 353, 12, 19, 12, 0, -19 },
  { 382, 12, 19, 12, 0, -19 },
  { 411, 12, 19, 12, 1, -19 },
  { 440, 11, 19, 12, 2, -19 },
  { 467, 11, 19, 12, 1, -19 },
  { 494, 11, 19, 12, 1, -19 },
  { 521, 5, 14, 5, 0, -14 },
  { 530, 6, 17, 5, -1, -14 },
  { 543, 10, 11, 13, 2, -15 },
  { 557, 10, 6, 13, 2, -12 },
  { 565, 10, 11, 13, 2, -15 },
  { 579, 9, 19, 9, 1, -19 },
  { 601, 17, 20, 19, 1, -18 },
  { 644, 12, 19, 12, -1, -19 },
  { 673, 12, 19, 14, 1, -19 },
  { 702, 12, 19, 13, 2, -19 },
  { 731, 13, 19, 15, 1, -19 },
  { 762, 12, 19, 12, 1, -19 },
  { 791, 12, 19, 11, 1, -19 },
  { 820, 14, 19, 16, 2, -19 },
  { 854, 15, 19, 16, 1, -19 },
  { 890, 9, 19, 7, -1, -19 },
  { 912, 10, 24, 6, -4, -19 },
  { 942, 14, 19, 12, 1, -19 },
  { 976, 8, 19, 11, 1, -19 },
  { 995, 18, 19, 19, 1, -19 },
  { 1038, 15, 19, 16, 1, -19 },
  { 1074, 13, 19, 16, 2, -19 },
  { 1105, 12, 19, 13, 1, -19 },
  { 1134, 13, 23, 16, 2, -19 },
  { 1172, 12, 19, 13, 1, -19 },
  { 1201, 12, 19, 12, 0, -19 },
  { 1230, 11, 19, 11, 2, -19 },
  { 1257, 14, 19, 15, 2, -19 },
  { 1291, 12, 19, 12, 2, -19 },
  { 1320, 18, 19, 20, 3, -19 },
  { 1363, 15, 19, 11, -2, -19 },
  { 1399, 11, 19, 11, 2, -19 },
  { 1426, 14, 19, 12, -1, -19 },
  { 1460, 9, 23, 8, 0, -19 },
  { 1486, 4, 19, 8, 3, -19 },
  { 1496, 10, 23, 8, -2, -19 },
  { 1525, 11, 11, 13, 1, -19 },
  { 1541, 9, 1, 9, -2, 3 },
  { 1543, 3, 4, 6, 4, -20 },
  { 1545, 11, 14, 13, 1, -14 },
  { 1565, 11, 20, 13, 1, -20 },
  { 1593, 9, 14, 10, 1, -14 },
  { 1609, 13, 20, 13, 1, -20 },
  { 1642, 10, 14, 11, 1, -14 },
  { 1660, 13, 26, 6, -3, -20 },
  { 1703, 12, 20, 13, 0, -14 },
  { 1733, 10, 20, 13, 1, -20 },
  { 1758, 5, 19, 5, 1, -19 },
  { 1770, 10, 25, 5, -4, -19 },
  { 1802, 10, 20, 10, 1, -20 },
  { 1827, 5, 20, 5, 1, -20 },
  { 1840, 17, 14, 19, 1, -14 },
  { 1870, 10, 14, 13, 1, -14 },
  { 1888, 11, 14, 13, 1, -14 },
  { 1908, 13, 20, 13, -1, -14 },
  { 1941, 11, 20, 13, 1, -14 },
  { 1969, 8, 14, 9, 1, -14 },
  { 1983, 9, 14, 10, 0, -14 },
  { 1999, 7, 17, 7, 1, -17 },
  { 2014, 11, 14, 13, 1, -14 },
  { 2034, 10, 14, 10, 1, -14 },
  { 2052, 14, 14, 16, 2, -14 },
  { 2077, 12, 14, 10, -1, -14 },
  { 2098, 14, 20, 10, -3, -14 },
  { 2133, 11, 14, 10, -1, -14 },
  { 2153, 9, 23, 8, 1, -19 },
  { 2179, 1, 26, 12, 6, -20 },
  { 2183, 9, 23, 8, -1, -19 },
  { 2209, 10, 2, 13, 2, -10 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC26PT7B_H_
