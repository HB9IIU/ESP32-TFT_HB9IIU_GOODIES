#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x42, 0x31, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21, 0x00, 0x00,
  0x21, 0x00, 0x45, 0x14, 0x52, 0x8A, 0x28, 0x80, 0x01, 0x08, 0x08, 0x40,
  0x21, 0x00, 0x84, 0x04, 0x10, 0x10, 0x87, 0xFF, 0xC1, 0x08, 0x08, 0x40,
  0x21, 0x00, 0x84, 0x04, 0x10, 0x10, 0x83, 0xFF, 0xC2, 0x08, 0x08, 0x40,
  0x21, 0x00, 0x84, 0x04, 0x20, 0x10, 0x80, 0x00, 0x80, 0x08, 0x07, 0xE0,
  0x93, 0x11, 0x02, 0x10, 0x21, 0x02, 0x20, 0x12, 0x01, 0xA0, 0x0E, 0x00,
  0x30, 0x04, 0x80, 0x44, 0x04, 0x40, 0x44, 0x08, 0x40, 0x88, 0xCB, 0x03,
  0xC0, 0x08, 0x01, 0x00, 0x10, 0x00, 0x1E, 0x02, 0x22, 0x04, 0x42, 0x08,
  0x42, 0x08, 0x42, 0x10, 0x82, 0x20, 0x82, 0x20, 0x82, 0x40, 0x84, 0x9E,
  0x84, 0xB1, 0x89, 0x21, 0x7B, 0x41, 0x02, 0x41, 0x04, 0x41, 0x0C, 0x42,
  0x08, 0x42, 0x10, 0x82, 0x10, 0x84, 0x20, 0x44, 0x40, 0x78, 0x03, 0xC0,
  0x10, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x21, 0x80, 0x84, 0x02, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x20, 0x08, 0xC3, 0x41, 0x0A, 0x02, 0x68, 0x09,
  0x20, 0x18, 0x80, 0x62, 0x03, 0x8C, 0x1B, 0x1F, 0x84, 0x55, 0xA8, 0x03,
  0x06, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x60, 0x06,
  0x02, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x02,
  0x01, 0x08, 0x41, 0x90, 0x1F, 0xC3, 0x01, 0x40, 0x88, 0x42, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x32, 0x24, 0x48, 0x80, 0xFC, 0xC0,
  0x00, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x07, 0xC0, 0xC2, 0x08, 0x11, 0x01,
  0x30, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x14, 0x03, 0x40, 0x24, 0x02,
  0xC0, 0x28, 0x06, 0x80, 0x48, 0x04, 0xC0, 0x84, 0x18, 0x61, 0x03, 0xE0,
  0x04, 0x73, 0x71, 0x88, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0xC2, 0x08,
  0x20, 0x84, 0x10, 0x07, 0xE0, 0x60, 0x80, 0x06, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0xFF, 0x80,
  0x07, 0xE0, 0x60, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x06, 0x00, 0x60, 0x7C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x02, 0x20, 0x20, 0xFE, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x98, 0x08, 0x80, 0xC4, 0x04, 0x20,
  0x41, 0x04, 0x18, 0x40, 0x86, 0x04, 0x20, 0x23, 0xFF, 0xE0, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x1F, 0x80, 0x82, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x20,
  0x20, 0xFE, 0x00, 0x01, 0xF8, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x4F, 0x82, 0x82, 0x18, 0x08, 0x80, 0x44, 0x02,
  0x60, 0x12, 0x00, 0x98, 0x08, 0x40, 0x42, 0x04, 0x18, 0x60, 0x7E, 0x00,
  0x7F, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x07, 0xE0, 0x83, 0x10, 0x11, 0x01,
  0x10, 0x11, 0x01, 0x10, 0x21, 0x86, 0x0D, 0x80, 0x60, 0x19, 0x02, 0x08,
  0x40, 0x48, 0x04, 0x80, 0x48, 0x04, 0x80, 0x48, 0x04, 0x40, 0x83, 0xF0,
  0x07, 0xC0, 0x82, 0x10, 0x22, 0x01, 0x20, 0x12, 0x01, 0x40, 0x14, 0x03,
  0x40, 0x36, 0x06, 0x20, 0xE1, 0xF2, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08,
  0x01, 0x80, 0x10, 0x06, 0x0F, 0x80, 0x13, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x80, 0x04, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x82, 0x10, 0x42, 0x08, 0x00, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40,
  0x00, 0x7E, 0x20, 0x80, 0x40, 0x10, 0x18, 0x08, 0x04, 0x04, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x02, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x10, 0x00,
  0x00, 0x7C, 0x00, 0x30, 0x60, 0x18, 0x02, 0x04, 0x00, 0x21, 0x00, 0x04,
  0x20, 0x00, 0x88, 0x3F, 0x09, 0x0C, 0x21, 0x43, 0x08, 0x28, 0x41, 0x09,
  0x10, 0x21, 0x42, 0x04, 0x28, 0x41, 0x05, 0x08, 0x21, 0x21, 0x0C, 0x24,
  0x22, 0x88, 0x83, 0x8E, 0x08, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x05,
  0x00, 0x14, 0x00, 0x90, 0x02, 0x40, 0x11, 0x00, 0x42, 0x02, 0x08, 0x08,
  0x20, 0x40, 0x81, 0x02, 0x0F, 0xF8, 0x20, 0x21, 0x00, 0x84, 0x02, 0x20,
  0x08, 0x80, 0x24, 0x00, 0x70, 0x01, 0x0F, 0xE0, 0x40, 0xC2, 0x02, 0x20,
  0x11, 0x00, 0x88, 0x04, 0x40, 0x22, 0x02, 0x20, 0x61, 0xFC, 0x08, 0x18,
  0x40, 0x46, 0x01, 0x20, 0x09, 0x00, 0x48, 0x06, 0x40, 0x26, 0x03, 0x20,
  0x31, 0xFE, 0x00, 0x03, 0xFC, 0x18, 0x20, 0x80, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x20, 0xC0, 0x80, 0x84, 0x01, 0x10, 0x04, 0x40,
  0x11, 0x00, 0x44, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x48, 0x01, 0x60,
  0x0D, 0x00, 0x24, 0x01, 0x90, 0x04, 0x40, 0x22, 0x01, 0x08, 0x18, 0x3F,
  0x80, 0x0F, 0xF8, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0xFE, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20,
  0x01, 0x00, 0x0F, 0xF0, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x03, 0xFC, 0x0C, 0x0C, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x03, 0xE4, 0x00, 0x48, 0x00, 0x90, 0x03, 0x20, 0x04, 0x40,
  0x08, 0xC0, 0x10, 0x80, 0x20, 0x80, 0xC0, 0xFF, 0x00, 0x08, 0x01, 0x08,
  0x02, 0x08, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10,
  0x04, 0x20, 0x04, 0x3F, 0xFC, 0x20, 0x0C, 0x20, 0x08, 0x60, 0x08, 0x40,
  0x08, 0x40, 0x08, 0x40, 0x18, 0x40, 0x10, 0xC0, 0x10, 0x80, 0x10, 0x80,
  0x30, 0x07, 0x81, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x04, 0x1F, 0x00,
  0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x60, 0xF0, 0x00, 0x08, 0x06, 0x10, 0x10,
  0x20, 0x40, 0x81, 0x01, 0x04, 0x02, 0x10, 0x04, 0x40, 0x09, 0x00, 0x24,
  0x00, 0x5C, 0x00, 0xC8, 0x01, 0x10, 0x06, 0x10, 0x08, 0x20, 0x10, 0x60,
  0x20, 0x40, 0x40, 0x81, 0x00, 0x82, 0x01, 0x04, 0x03, 0x00, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x1F, 0xF0, 0x0C, 0x00, 0x30,
  0xC0, 0x06, 0x0C, 0x00, 0x61, 0x40, 0x0A, 0x14, 0x00, 0xA1, 0x40, 0x16,
  0x14, 0x03, 0x41, 0x20, 0x24, 0x22, 0x04, 0x42, 0x20, 0x44, 0x22, 0x08,
  0x82, 0x20, 0x88, 0x62, 0x10, 0x84, 0x21, 0x08, 0x42, 0x20, 0x84, 0x16,
  0x10, 0x41, 0x41, 0x08, 0x1C, 0x10, 0x81, 0x81, 0x08, 0x10, 0x30, 0x08,
  0x01, 0x0C, 0x01, 0x0C, 0x03, 0x14, 0x02, 0x12, 0x02, 0x12, 0x02, 0x12,
  0x02, 0x11, 0x04, 0x21, 0x04, 0x21, 0x04, 0x20, 0x84, 0x20, 0x8C, 0x60,
  0x88, 0x40, 0x48, 0x40, 0x48, 0x40, 0x48, 0x40, 0x38, 0x80, 0x30, 0x80,
  0x30, 0x80, 0x10, 0x03, 0xF0, 0x18, 0x30, 0x60, 0x31, 0x80, 0x22, 0x00,
  0x4C, 0x00, 0x90, 0x01, 0xA0, 0x02, 0xC0, 0x05, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x28, 0x00, 0xD0, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x10, 0x80,
  0x41, 0x83, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x41, 0x82, 0x04, 0x20, 0x11,
  0x00, 0x88, 0x04, 0x40, 0x62, 0x02, 0x20, 0x11, 0x01, 0x08, 0x70, 0x7C,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x00, 0x03, 0xF0, 0x18, 0x30, 0x60, 0x31, 0x80, 0x22, 0x00, 0x4C,
  0x00, 0x90, 0x01, 0xA0, 0x02, 0xC0, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00,
  0x28, 0x00, 0xD0, 0x01, 0x20, 0x02, 0x40, 0x08, 0x80, 0x10, 0x80, 0x41,
  0x83, 0x01, 0xFC, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x0F, 0xC0, 0x41, 0x82, 0x04, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40,
  0x62, 0x02, 0x20, 0x31, 0x03, 0x0F, 0xE0, 0x42, 0x06, 0x10, 0x20, 0x81,
  0x02, 0x08, 0x10, 0x40, 0x84, 0x02, 0x20, 0x11, 0x00, 0x80, 0x07, 0xF0,
  0x60, 0x46, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x02, 0x20, 0x61, 0xFE, 0x00, 0xFF, 0xF0, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x10, 0x02, 0x20, 0x04, 0x80, 0x11, 0x00, 0x22, 0x00, 0x44, 0x00,
  0x88, 0x03, 0x20, 0x04, 0x40, 0x08, 0x80, 0x11, 0x00, 0x26, 0x00, 0x88,
  0x01, 0x10, 0x02, 0x20, 0x04, 0x40, 0x10, 0x80, 0x21, 0x00, 0x81, 0x03,
  0x01, 0xF8, 0x00, 0x80, 0x18, 0x03, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04,
  0x80, 0x88, 0x08, 0x81, 0x08, 0x10, 0xC2, 0x04, 0x20, 0x44, 0x04, 0x40,
  0x48, 0x04, 0x80, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x04, 0x81, 0xA0, 0x48, 0x12, 0x0C,
  0x81, 0x20, 0x88, 0x22, 0x08, 0x82, 0x21, 0x08, 0x42, 0x10, 0x84, 0x22,
  0x08, 0x82, 0x20, 0x88, 0x26, 0x09, 0x82, 0x40, 0x90, 0x24, 0x09, 0x02,
  0x80, 0xA0, 0x28, 0x0A, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x04,
  0x01, 0x02, 0x02, 0x02, 0x04, 0x02, 0x0C, 0x01, 0x08, 0x01, 0x10, 0x01,
  0x30, 0x01, 0x20, 0x00, 0xC0, 0x00, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x02,
  0x40, 0x04, 0x40, 0x0C, 0x20, 0x08, 0x20, 0x10, 0x20, 0x20, 0x30, 0x60,
  0x10, 0xC0, 0x10, 0x80, 0x30, 0x0A, 0x03, 0x40, 0x44, 0x10, 0x82, 0x10,
  0x82, 0x30, 0x44, 0x05, 0x00, 0xE0, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x00, 0x07, 0xFE, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xC1, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20,
  0x08, 0x03, 0xE0, 0x88, 0x88, 0x44, 0x44, 0x44, 0x22, 0x22, 0x22, 0x21,
  0x11, 0x07, 0xC0, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x00, 0x43, 0xE0, 0x01, 0x00, 0x28, 0x02, 0x80,
  0x48, 0x08, 0x40, 0x84, 0x10, 0x43, 0x02, 0x20, 0x24, 0x02, 0xC0, 0x10,
  0xFF, 0x80, 0xC8, 0x90, 0x07, 0x91, 0x85, 0x10, 0x52, 0x02, 0x60, 0x24,
  0x02, 0x40, 0x2C, 0x06, 0x80, 0x48, 0x04, 0x80, 0xC8, 0x0C, 0xC1, 0x44,
  0x28, 0x3C, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x13, 0xC2, 0xC2, 0x28, 0x23, 0x01, 0x20, 0x12, 0x01, 0x60, 0x14, 0x03,
  0x40, 0x24, 0x02, 0x40, 0x6C, 0x04, 0xC0, 0xCA, 0x18, 0xBF, 0x00, 0x07,
  0xC6, 0x01, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x40, 0x18, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x79, 0x06, 0x14, 0x10, 0x30, 0x80, 0xC6,
  0x02, 0x10, 0x08, 0x40, 0x23, 0x00, 0x88, 0x06, 0x20, 0x10, 0x80, 0x42,
  0x03, 0x0C, 0x14, 0x10, 0xD0, 0x3C, 0x80, 0x07, 0x82, 0x11, 0x04, 0x81,
  0x60, 0x50, 0x34, 0x31, 0xF0, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x23, 0xF0, 0x00, 0x3E, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00,
  0x10, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x02, 0x40, 0x07, 0x00, 0x00, 0x03, 0xC8, 0x61, 0x42, 0x06,
  0x20, 0x33, 0x01, 0x10, 0x08, 0x80, 0x4C, 0x02, 0x40, 0x32, 0x01, 0x10,
  0x08, 0x80, 0xC6, 0x0A, 0x10, 0xD0, 0x79, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x20, 0x03, 0x0C, 0x30, 0x1E, 0x00, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x04, 0xF1, 0x61, 0x28, 0x26, 0x04, 0x80, 0x90, 0x14,
  0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0x50, 0x0A, 0x03, 0x40, 0x48, 0x08,
  0x18, 0xC0, 0x00, 0x08, 0xC4, 0x21, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x00, 0x00, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x18, 0x2C, 0x0C, 0x00, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x09, 0x82, 0x20, 0x84,
  0x20, 0x88, 0x12, 0x04, 0x80, 0xA8, 0x19, 0x02, 0x20, 0x42, 0x10, 0x42,
  0x0C, 0x40, 0x88, 0x18, 0x08, 0x42, 0x21, 0x08, 0x46, 0x21, 0x08, 0x44,
  0x21, 0x08, 0x44, 0x21, 0x08, 0x00, 0x13, 0xC7, 0x8B, 0x12, 0x13, 0x03,
  0x04, 0xC0, 0x81, 0x20, 0x20, 0x48, 0x10, 0x16, 0x04, 0x05, 0x01, 0x01,
  0x40, 0x40, 0x90, 0x30, 0x24, 0x08, 0x0A, 0x02, 0x02, 0x80, 0x80, 0xA0,
  0x20, 0x48, 0x10, 0x10, 0x13, 0xC5, 0x84, 0xA0, 0x98, 0x12, 0x02, 0x40,
  0x58, 0x0A, 0x01, 0x40, 0x48, 0x09, 0x01, 0x40, 0x28, 0x0D, 0x01, 0x20,
  0x20, 0x07, 0x81, 0x86, 0x10, 0x22, 0x02, 0x60, 0x34, 0x03, 0x40, 0x3C,
  0x02, 0x80, 0x28, 0x02, 0x80, 0x68, 0x04, 0x40, 0x84, 0x18, 0x3E, 0x00,
  0x04, 0xF0, 0x24, 0x20, 0xA0, 0x83, 0x01, 0x08, 0x04, 0x20, 0x11, 0x80,
  0x44, 0x03, 0x10, 0x08, 0x40, 0x21, 0x00, 0x8C, 0x04, 0x30, 0x30, 0xA1,
  0x82, 0xFC, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x00, 0x07, 0x91, 0x85, 0x10, 0x32, 0x03, 0x60, 0x24, 0x02,
  0x40, 0x2C, 0x02, 0x80, 0x68, 0x04, 0x80, 0x48, 0x0C, 0xC1, 0x44, 0x34,
  0x3C, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x13, 0x96, 0x0A, 0x06, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x0F, 0xC4, 0x12, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x20, 0xCF, 0xE0,
  0x10, 0x20, 0x43, 0xF2, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x18,
  0x20, 0x40, 0x80, 0xE0, 0x10, 0x12, 0x01, 0x20, 0x22, 0x02, 0x20, 0x26,
  0x02, 0x40, 0x24, 0x04, 0x40, 0x44, 0x04, 0x80, 0xC8, 0x0C, 0x81, 0x8C,
  0x28, 0x7C, 0x80, 0xC0, 0x68, 0x09, 0x03, 0x20, 0x44, 0x18, 0x82, 0x10,
  0x82, 0x10, 0x44, 0x08, 0x81, 0x20, 0x14, 0x03, 0x00, 0x60, 0x08, 0x00,
  0x81, 0x03, 0x81, 0x02, 0x83, 0x02, 0x83, 0x04, 0x85, 0x04, 0x84, 0x88,
  0x88, 0x88, 0x88, 0x90, 0x90, 0x90, 0x90, 0x90, 0xA0, 0xA0, 0xA0, 0xA0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x18, 0x18, 0x40, 0x82, 0x08, 0x08,
  0x80, 0x48, 0x02, 0xC0, 0x0C, 0x00, 0x40, 0x05, 0x00, 0x48, 0x06, 0x40,
  0x21, 0x02, 0x08, 0x20, 0x43, 0x01, 0x00, 0x04, 0x02, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x40, 0x80, 0x82, 0x01, 0x04, 0x02, 0x10, 0x02, 0x20,
  0x04, 0x80, 0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xF0, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0x80,
  0x01, 0xC0, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x04,
  0x01, 0x00, 0x80, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x06, 0x00, 0xC0, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x02, 0x00, 0x83, 0xC0, 0xF8, 0x30, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 20, 6, 1, -20 },
  { 14, 6, 7, 9, 3, -20 },
  { 20, 14, 20, 15, 1, -20 },
  { 55, 12, 23, 13, 1, -21 },
  { 90, 16, 20, 19, 2, -20 },
  { 130, 14, 20, 16, 1, -20 },
  { 165, 2, 7, 5, 3, -20 },
  { 167, 8, 24, 7, 1, -20 },
  { 191, 8, 24, 7, -2, -20 },
  { 215, 10, 10, 13, 3, -21 },
  { 228, 11, 13, 14, 2, -16 },
  { 246, 4, 7, 5, -1, -3 },
  { 250, 6, 1, 8, 1, -8 },
  { 251, 1, 2, 6, 1, -2 },
  { 252, 12, 20, 9, -1, -20 },
  { 282, 12, 20, 13, 1, -20 },
  { 312, 6, 20, 13, 4, -20 },
  { 327, 13, 20, 13, 0, -20 },
  { 360, 13, 20, 13, 0, -20 },
  { 393, 13, 20, 13, 0, -20 },
  { 426, 13, 20, 13, 0, -20 },
  { 459, 13, 20, 13, 1, -20 },
  { 492, 12, 20, 13, 2, -20 },
  { 522, 12, 20, 13, 1, -20 },
  { 552, 12, 20, 13, 1, -20 },
  { 582, 4, 15, 6, 1, -15 },
  { 590, 6, 19, 6, -1, -15 },
  { 605, 11, 12, 14, 2, -16 },
  { 622, 11, 7, 14, 2, -13 },
  { 632, 11, 12, 14, 2, -16 },
  { 649, 9, 20, 10, 2, -20 },
  { 672, 19, 23, 20, 1, -20 },
  { 727, 14, 20, 13, -2, -20 },
  { 762, 13, 20, 15, 1, -20 },
  { 795, 14, 20, 14, 2, -20 },
  { 830, 14, 20, 16, 1, -20 },
  { 865, 13, 20, 13, 1, -20 },
  { 898, 13, 20, 12, 1, -20 },
  { 931, 15, 20, 17, 2, -20 },
  { 969, 16, 20, 17, 1, -20 },
  { 1009, 9, 20, 7, -1, -20 },
  { 1032, 10, 25, 6, -4, -20 },
  { 1064, 15, 20, 13, 1, -20 },
  { 1102, 9, 20, 12, 1, -20 },
  { 1125, 20, 20, 21, 1, -20 },
  { 1175, 16, 20, 17, 1, -20 },
  { 1215, 15, 20, 17, 2, -20 },
  { 1253, 13, 20, 14, 1, -20 },
  { 1286, 15, 25, 17, 2, -20 },
  { 1333, 13, 20, 14, 1, -20 },
  { 1366, 13, 20, 12, 0, -20 },
  { 1399, 12, 20, 12, 2, -20 },
  { 1429, 15, 20, 17, 2, -20 },
  { 1467, 12, 20, 13, 3, -20 },
  { 1497, 20, 20, 21, 3, -20 },
  { 1547, 16, 20, 12, -2, -20 },
  { 1587, 11, 20, 12, 3, -20 },
  { 1615, 15, 20, 13, -1, -20 },
  { 1653, 10, 24, 8, 0, -20 },
  { 1683, 4, 20, 9, 3, -20 },
  { 1693, 10, 24, 8, -2, -20 },
  { 1723, 12, 11, 14, 1, -20 },
  { 1740, 9, 1, 9, -2, 3 },
  { 1742, 3, 4, 6, 4, -21 },
  { 1744, 12, 15, 14, 1, -15 },
  { 1767, 12, 21, 14, 1, -21 },
  { 1799, 10, 15, 11, 1, -15 },
  { 1818, 14, 21, 14, 1, -21 },
  { 1855, 10, 15, 12, 1, -15 },
  { 1874, 15, 28, 7, -4, -21 },
  { 1927, 13, 22, 14, 0, -15 },
  { 1963, 11, 21, 14, 1, -21 },
  { 1992, 5, 20, 6, 1, -20 },
  { 2005, 10, 27, 6, -4, -20 },
  { 2039, 11, 21, 11, 1, -21 },
  { 2068, 5, 21, 5, 1, -21 },
  { 2082, 18, 15, 21, 1, -15 },
  { 2116, 11, 15, 14, 1, -15 },
  { 2137, 12, 15, 14, 1, -15 },
  { 2160, 14, 22, 14, -1, -15 },
  { 2199, 12, 22, 14, 1, -15 },
  { 2232, 9, 15, 9, 1, -15 },
  { 2249, 10, 15, 10, 0, -15 },
  { 2268, 7, 18, 8, 1, -18 },
  { 2284, 12, 15, 14, 1, -15 },
  { 2307, 11, 15, 10, 1, -15 },
  { 2328, 16, 15, 17, 2, -15 },
  { 2358, 13, 15, 11, -1, -15 },
  { 2383, 15, 22, 11, -3, -15 },
  { 2425, 12, 15, 10, -1, -15 },
  { 2448, 10, 24, 9, 1, -20 },
  { 2478, 1, 28, 13, 6, -21 },
  { 2482, 10, 24, 9, -2, -20 },
  { 2512, 11, 2, 14, 2, -11 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC28PT7B_H_
