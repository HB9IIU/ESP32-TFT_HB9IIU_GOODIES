#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x07, 0x00, 0x18, 0x1C, 0x60, 0x61, 0x81, 0x8E, 0x0E, 0x30,
  0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x61, 0x81, 0x86, 0x06, 0x18,
  0x18, 0x40, 0x43, 0x03, 0x0C, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x01, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x01, 0x80, 0x00, 0x38, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x07, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFC,
  0x01, 0xF3, 0x1F, 0x01, 0xE1, 0x81, 0x81, 0xC0, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0xE0, 0x20, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x06, 0x02, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x20, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x05, 0xE0, 0x00,
  0x06, 0x78, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x40, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x0C, 0x06, 0x00, 0x04, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03,
  0x82, 0x01, 0x83, 0x81, 0xC0, 0x87, 0x80, 0xFF, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xC0, 0x78, 0xE0, 0x00, 0x60, 0x18, 0x18, 0x00,
  0x30, 0x0C, 0x06, 0x00, 0x18, 0x07, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x30,
  0x03, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x30, 0x07, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60,
  0x06, 0x03, 0x00, 0x18, 0x01, 0x81, 0xC0, 0x06, 0x00, 0x60, 0x60, 0x03,
  0x80, 0x18, 0x30, 0x00, 0xC0, 0x0C, 0x1C, 0x00, 0x30, 0x03, 0x06, 0x07,
  0x0C, 0x00, 0xC3, 0x07, 0xF3, 0x00, 0x61, 0xC7, 0x8E, 0xC0, 0x18, 0x61,
  0x81, 0xB0, 0x0C, 0x30, 0xC0, 0x6E, 0x03, 0x1C, 0x70, 0x1D, 0x81, 0x86,
  0x18, 0x07, 0x79, 0xC3, 0x0E, 0x01, 0xCF, 0xE0, 0xC3, 0x00, 0x70, 0xE0,
  0x60, 0xC0, 0x1C, 0x00, 0x30, 0x60, 0x06, 0x00, 0x0C, 0x18, 0x01, 0x80,
  0x06, 0x06, 0x00, 0x60, 0x03, 0x81, 0x80, 0x18, 0x00, 0xC0, 0xE0, 0x06,
  0x00, 0x60, 0x30, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x70, 0x0C, 0x00,
  0x18, 0x18, 0x06, 0x00, 0x07, 0x1C, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0,
  0x0E, 0x00, 0x03, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x60, 0x01,
  0x80, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x0C, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01,
  0xBC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x03, 0x80,
  0x0C, 0x38, 0x06, 0x00, 0x61, 0xC0, 0x1C, 0x01, 0x86, 0x00, 0x38, 0x0E,
  0x30, 0x00, 0x60, 0x31, 0xC0, 0x01, 0xC1, 0xC6, 0x00, 0x03, 0x06, 0x18,
  0x00, 0x0E, 0x30, 0x60, 0x00, 0x19, 0xC3, 0x80, 0x00, 0x7E, 0x0E, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x7C, 0x07, 0x00, 0x03, 0xB8, 0x1C, 0x00, 0x38, 0x60, 0x3C, 0x03, 0xC1,
  0xC0, 0x7E, 0xFE, 0x03, 0x00, 0x7F, 0xE0, 0x0E, 0x00, 0x30, 0x00, 0x00,
  0x18, 0xC6, 0x73, 0x18, 0xC6, 0x63, 0x18, 0xC4, 0x63, 0x00, 0x00, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x20, 0x08, 0x03, 0x80, 0xC0, 0x0F, 0x06, 0x00, 0x1C, 0x30, 0x00,
  0x39, 0x00, 0x40, 0x79, 0xFE, 0x00, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0xD8,
  0x00, 0x0C, 0x40, 0x00, 0xC3, 0x00, 0x0C, 0x0C, 0x01, 0xC0, 0x60, 0x1C,
  0x03, 0x80, 0x40, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x1C, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x77, 0xF7,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x06, 0x03,
  0x80, 0x07, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x70,
  0x00, 0x03, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x76,
  0x07, 0x98, 0x38, 0xE3, 0xC3, 0xBC, 0x0C, 0x60, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFE, 0x7C, 0x00, 0x7C, 0x01, 0xC0, 0x06, 0x00, 0x1C,
  0x00, 0x80, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x7C, 0x01, 0xE0, 0x1E,
  0x00, 0x0C, 0x01, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x04, 0x00, 0x03, 0x80,
  0xE0, 0x01, 0xE0, 0x1F, 0xF3, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x30,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x07, 0x00, 0x0C, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x60, 0x0E,
  0x00, 0x1C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x0C,
  0x07, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xDF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x20, 0x00, 0x38, 0x07,
  0x00, 0x1E, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x60,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x1F, 0xC0, 0x0C, 0x3F,
  0xF8, 0x06, 0x78, 0x1E, 0x03, 0x70, 0x03, 0x83, 0xF0, 0x00, 0xC1, 0xA0,
  0x00, 0x70, 0xF0, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x38,
  0x00, 0x03, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03,
  0x01, 0xC0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x0F, 0xDF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x1C,
  0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x07,
  0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x06, 0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xFB, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x1C,
  0x00, 0x38, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03,
  0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0xF0, 0xE0, 0x00, 0xF8, 0x38, 0x00, 0xEC, 0x1E, 0x00, 0xEC, 0x07, 0xC3,
  0xE6, 0x00, 0xFF, 0xC3, 0x00, 0x1F, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x80, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x08, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x7E, 0x3E, 0x06, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x70, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x1F, 0xE0, 0x0C, 0x70, 0x01, 0xFF, 0xC0, 0x31, 0x80, 0x0E, 0x03,
  0x00, 0xC6, 0x00, 0x60, 0x0C, 0x03, 0x30, 0x03, 0x00, 0x70, 0x0C, 0xC0,
  0x18, 0x01, 0x80, 0x37, 0x00, 0xE0, 0x06, 0x00, 0xD8, 0x03, 0x00, 0x18,
  0x03, 0x60, 0x18, 0x00, 0xE0, 0x0D, 0x80, 0x60, 0x03, 0x00, 0x3C, 0x03,
  0x80, 0x0C, 0x01, 0xF0, 0x0C, 0x00, 0x30, 0x06, 0xC0, 0x30, 0x01, 0x80,
  0x1B, 0x00, 0xC0, 0x06, 0x00, 0x6C, 0x07, 0x00, 0x18, 0x03, 0x30, 0x1C,
  0x00, 0xE0, 0x0C, 0xC0, 0x70, 0x03, 0x80, 0x73, 0x01, 0xC0, 0x1E, 0x01,
  0x8C, 0x03, 0x00, 0x58, 0x0C, 0x30, 0x0C, 0x03, 0x60, 0x70, 0xC0, 0x38,
  0x19, 0x83, 0x83, 0x00, 0x71, 0xC7, 0xBC, 0x0C, 0x00, 0xFE, 0x0F, 0xE0,
  0x30, 0x00, 0x40, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x38, 0x18, 0x00,
  0x03, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0,
  0x18, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x1C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0,
  0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x70, 0x06, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x70, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x38, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00,
  0x03, 0xC0, 0x60, 0x00, 0x78, 0x0E, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x3C, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x10, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x06, 0x00, 0x0F, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0xC0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00,
  0x07, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x0F, 0x00, 0x18,
  0x00, 0x7C, 0x00, 0x70, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x20, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0xFC, 0x60, 0x00, 0x7F, 0xF8, 0xC0, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x18, 0x07, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x17,
  0xF0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x03, 0x80, 0x0C, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x0E, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0xF0, 0x00,
  0x00, 0x33, 0xE0, 0x00, 0x00, 0xEE, 0xC0, 0x00, 0x01, 0xB9, 0xC0, 0x00,
  0x03, 0xE1, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x38, 0x06, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x70, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x18, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x36, 0x00, 0x00, 0x06,
  0xC0, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x01,
  0x98, 0x00, 0x00, 0x77, 0x00, 0x66, 0x00, 0x00, 0x19, 0xC0, 0x39, 0x80,
  0x00, 0x0E, 0x60, 0x0E, 0x60, 0x00, 0x03, 0x18, 0x03, 0x1C, 0x00, 0x01,
  0xC6, 0x00, 0xC3, 0x00, 0x00, 0x63, 0x80, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x1C, 0x30, 0x00, 0x1C, 0x30, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x01, 0x83,
  0x00, 0x03, 0x83, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0xC0, 0x18, 0x30, 0x00,
  0x70, 0x60, 0x0E, 0x0E, 0x00, 0x18, 0x18, 0x03, 0x01, 0x80, 0x0E, 0x06,
  0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x30, 0x18, 0x01, 0x80, 0xE0, 0x0C,
  0x06, 0x00, 0x60, 0x30, 0x07, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x18, 0x07, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xC0, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x70, 0x06, 0x00,
  0xC0, 0x0C, 0x18, 0x01, 0x80, 0x30, 0x03, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC3, 0x00, 0x30, 0x07, 0x00, 0x31, 0x80, 0x0C, 0x01, 0x80, 0x0C, 0x60,
  0x03, 0x00, 0x60, 0x03, 0xB0, 0x00, 0xC0, 0x18, 0x00, 0x7C, 0x00, 0x70,
  0x06, 0x00, 0x1E, 0x00, 0x18, 0x03, 0x80, 0x07, 0x80, 0x06, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x18, 0x03,
  0xC0, 0x00, 0x06, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x36, 0x00, 0x00, 0xE0,
  0x1D, 0x80, 0x00, 0x30, 0x06, 0x70, 0x00, 0x0C, 0x01, 0x8C, 0x00, 0x03,
  0x00, 0x63, 0x00, 0x00, 0xC0, 0x38, 0xE0, 0x00, 0x70, 0x0E, 0x18, 0x00,
  0x18, 0x03, 0x06, 0x00, 0x06, 0x00, 0xC1, 0xC0, 0x01, 0x80, 0x30, 0x30,
  0x00, 0xE0, 0x1C, 0x0C, 0x00, 0x38, 0x06, 0x03, 0x80, 0x0C, 0x01, 0x80,
  0x60, 0x03, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xC0, 0x1C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0E, 0x01, 0x80,
  0x30, 0x01, 0x80, 0x60, 0x0C, 0x00, 0x60, 0x38, 0x07, 0x00, 0x1C, 0x0C,
  0x01, 0x80, 0x03, 0x03, 0x00, 0x60, 0x00, 0xC0, 0xC0, 0x18, 0x00, 0x38,
  0x30, 0x0E, 0x00, 0x06, 0x1C, 0x03, 0x80, 0x01, 0x86, 0x00, 0xC0, 0x00,
  0x71, 0x80, 0x30, 0x00, 0x0C, 0x60, 0x0C, 0x00, 0x03, 0x18, 0x07, 0x00,
  0x00, 0xEE, 0x01, 0x80, 0x00, 0x1B, 0x00, 0x60, 0x00, 0x06, 0xC0, 0x18,
  0x00, 0x01, 0xF0, 0x06, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xC0, 0x07,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x60,
  0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x38,
  0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0E, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x30, 0x38, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x18,
  0x00, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x18, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x80, 0x3E, 0x00, 0x60,
  0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x38,
  0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x0E, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x70, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x80, 0x30, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00,
  0x30, 0x00, 0x60, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x06, 0x07,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x3C, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x04, 0x00, 0x07,
  0x80, 0xE0, 0x01, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x28, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x06, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x0C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x07,
  0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0x80,
  0x01, 0x80, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x0C, 0x18, 0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x38,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x78,
  0x00, 0x0E, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x18, 0x00, 0x0D, 0x80, 0x00,
  0xC6, 0x00, 0x07, 0x60, 0x00, 0x71, 0x80, 0x01, 0x98, 0x00, 0x18, 0x60,
  0x00, 0x66, 0x00, 0x0E, 0x18, 0x00, 0x31, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x60, 0x01, 0xC1, 0x80, 0x06, 0x18, 0x00, 0x60, 0x60, 0x01, 0x86, 0x00,
  0x18, 0x18, 0x00, 0xE1, 0x80, 0x0E, 0x06, 0x00, 0x30, 0x60, 0x03, 0x01,
  0x80, 0x1C, 0x18, 0x01, 0xC0, 0x60, 0x06, 0x06, 0x00, 0x60, 0x18, 0x03,
  0x81, 0x80, 0x38, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x06, 0x03, 0x80, 0x60, 0x38, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x00, 0x60,
  0x70, 0x06, 0x07, 0x00, 0x18, 0x18, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x00,
  0x60, 0x60, 0x01, 0x83, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x06, 0x0C,
  0x00, 0x18, 0x60, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x61, 0x80, 0x01,
  0x8C, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x19, 0xC0,
  0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x19,
  0x80, 0x00, 0x6C, 0x00, 0x02, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0xB0, 0x00,
  0x07, 0x80, 0x00, 0x2C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x03, 0x80, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x98, 0x00,
  0x01, 0x8C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x60, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x70, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x18, 0x00,
  0x30, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70,
  0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x38, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0E,
  0x00, 0x1C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x31, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x86, 0x1C, 0x30,
  0xE1, 0x83, 0x04, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x30, 0x0F, 0x87,
  0x18, 0x07, 0x80, 0x66, 0x03, 0x80, 0x09, 0x80, 0xC0, 0x03, 0x60, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x18, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x78,
  0x18, 0x00, 0x3C, 0x06, 0x00, 0x0B, 0x01, 0xC0, 0x06, 0xC0, 0x30, 0x03,
  0x30, 0x0E, 0x03, 0x8C, 0x01, 0xF7, 0xC6, 0x00, 0x3F, 0xC1, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x3C,
  0x00, 0x18, 0x7F, 0xC0, 0x0E, 0x3C, 0x7C, 0x03, 0x1C, 0x07, 0x00, 0xCC,
  0x00, 0xE0, 0x36, 0x00, 0x18, 0x0F, 0x00, 0x07, 0x07, 0xC0, 0x01, 0xC1,
  0xE0, 0x00, 0x30, 0x70, 0x00, 0x0C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0C, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18,
  0x00, 0x03, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xA0, 0x00,
  0x60, 0x6C, 0x00, 0x38, 0x19, 0x80, 0x1C, 0x06, 0x70, 0x1E, 0x01, 0x0F,
  0x3F, 0x00, 0xC1, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xC0, 0x3E, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0xE0, 0x60, 0x00, 0xFF, 0xC3, 0x00, 0x1F, 0x0F, 0x18, 0x01, 0xE0,
  0x1D, 0xC0, 0x1C, 0x00, 0x6C, 0x00, 0xC0, 0x01, 0x60, 0x0E, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x78, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x3C, 0x01, 0x80, 0x03, 0xE0, 0x0C, 0x00, 0x1B,
  0x00, 0x70, 0x01, 0x98, 0x01, 0x80, 0x19, 0x80, 0x0E, 0x03, 0x8C, 0x00,
  0x3E, 0xF8, 0x60, 0x00, 0xFF, 0x83, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0x00, 0x3C, 0x3C, 0x03, 0x80, 0x60, 0x38, 0x03,
  0x83, 0x80, 0x0C, 0x38, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x19, 0xC0,
  0x01, 0xCC, 0x00, 0x0C, 0xE0, 0x00, 0xE6, 0x00, 0x0E, 0x30, 0x01, 0xE1,
  0x80, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0xC0, 0x7E, 0x7E, 0x00, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xE0, 0x40, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xFF, 0x0C, 0x01, 0xF0, 0xF1, 0x80, 0x78, 0x07, 0x30, 0x1C, 0x00,
  0x6C, 0x03, 0x00, 0x05, 0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x06,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0E, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x38, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xC1, 0xC0,
  0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x3C, 0x06, 0x00, 0x0F, 0x80,
  0xC0, 0x01, 0xB0, 0x1C, 0x00, 0x6E, 0x01, 0x80, 0x19, 0x80, 0x38, 0x0E,
  0x30, 0x03, 0xEF, 0x86, 0x00, 0x3F, 0xE1, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x02, 0x00, 0x1C, 0x00, 0x70, 0x0F, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x07, 0xC0, 0x06, 0x1F, 0xF8, 0x03, 0x1E, 0x3E, 0x03, 0x18,
  0x07, 0x01, 0x98, 0x01, 0xC0, 0xD8, 0x00, 0x60, 0x78, 0x00, 0x30, 0x78,
  0x00, 0x18, 0x3C, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06,
  0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x07, 0x00, 0x01,
  0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0xE0, 0x00,
  0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0C, 0x00,
  0x06, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x04,
  0x06, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x0E, 0x00, 0x01, 0x8F, 0x00, 0x00, 0xCF, 0x80, 0x00, 0x6E,
  0xC0, 0x00, 0x6E, 0x70, 0x00, 0x3E, 0x18, 0x00, 0x1E, 0x0C, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x01, 0x80, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x01, 0x80,
  0x30, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0x87, 0xF8, 0x07, 0xFC, 0x01, 0x1E, 0x3C, 0x1E, 0x3E,
  0x03, 0x38, 0x0E, 0x38, 0x0E, 0x03, 0x70, 0x06, 0x70, 0x07, 0x03, 0x60,
  0x06, 0x60, 0x07, 0x03, 0xC0, 0x06, 0xC0, 0x03, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x07, 0x80, 0x07, 0x80, 0x03, 0x07, 0x00, 0x07, 0x00, 0x03, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x06, 0x00, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x00, 0x0E,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x18, 0x00, 0x18, 0x00, 0x18, 0x38, 0x00, 0x18, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x30, 0x00, 0x38, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x30, 0x00, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x60, 0x00, 0x60, 0x00, 0x70, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x00, 0xF8, 0x00, 0xC3, 0xFF, 0x00, 0xC3, 0xC7, 0xC0, 0x67,
  0x00, 0xE0, 0x33, 0x00, 0x38, 0x1B, 0x00, 0x0C, 0x0F, 0x00, 0x06, 0x0F,
  0x00, 0x03, 0x07, 0x80, 0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x1C,
  0x18, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0xE0, 0x00,
  0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x1C, 0x00,
  0x06, 0x0E, 0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0xC1, 0xC0, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x03,
  0xC3, 0xE0, 0x1E, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x8E, 0x00, 0x03, 0x18, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x06, 0x60,
  0x00, 0x1C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x80, 0x01, 0x83, 0x00,
  0x06, 0x07, 0x00, 0x1C, 0x07, 0x00, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0x87, 0xFC, 0x00,
  0x08, 0x78, 0xF8, 0x00, 0xC7, 0x01, 0xC0, 0x06, 0x60, 0x07, 0x00, 0x36,
  0x00, 0x18, 0x01, 0xE0, 0x00, 0xE0, 0x1F, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x18, 0x07, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30,
  0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x07, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0xE0, 0x1B, 0x00, 0x0E, 0x00, 0xDC, 0x00,
  0xE0, 0x06, 0x70, 0x1E, 0x00, 0x31, 0xF7, 0xE0, 0x03, 0x87, 0xFC, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x30, 0x0F, 0x87,
  0x8C, 0x07, 0x80, 0x73, 0x03, 0x80, 0x0D, 0x80, 0xC0, 0x01, 0x60, 0x70,
  0x00, 0x78, 0x38, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00,
  0x03, 0x86, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x78,
  0x18, 0x00, 0x3E, 0x06, 0x00, 0x0D, 0x81, 0xC0, 0x06, 0xE0, 0x30, 0x03,
  0x30, 0x0E, 0x03, 0x8C, 0x01, 0xF7, 0xC3, 0x00, 0x3F, 0xE1, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x18, 0x7F, 0x01, 0x0F, 0x30, 0x33, 0x80, 0x03, 0x30, 0x00, 0x36, 0x00,
  0x03, 0xC0, 0x00, 0x68, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x78,
  0x3E, 0x07, 0x00, 0x30, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x08, 0x00, 0x38, 0x60, 0x03, 0x83,
  0xF9, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x3F,
  0xFE, 0xFF, 0xFC, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x0F, 0x30, 0x0F, 0xE0, 0x02, 0x00, 0x0E,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C,
  0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x18,
  0x00, 0x0C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x1C, 0x30, 0x00, 0x18, 0x70, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x38, 0x60, 0x00, 0x38, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0xE0, 0xC0,
  0x01, 0xE0, 0xC0, 0x03, 0x60, 0xC0, 0x03, 0x60, 0xE0, 0x0E, 0xC0, 0xE0,
  0x1C, 0xC0, 0x7F, 0xF8, 0xC0, 0x3F, 0xE0, 0xC0, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x6E, 0x00, 0x03, 0x38, 0x00, 0x1C, 0x60, 0x00,
  0x61, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x81,
  0x80, 0x0E, 0x06, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x70, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xE0,
  0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x03,
  0x1C, 0x00, 0x0E, 0x60, 0x00, 0x39, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x76, 0x00, 0x1E,
  0x00, 0x19, 0x80, 0x07, 0x80, 0x0E, 0x60, 0x03, 0x60, 0x03, 0x18, 0x00,
  0xD8, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x61, 0x80, 0x19, 0x80, 0x18, 0x60,
  0x0C, 0x60, 0x0C, 0x18, 0x03, 0x18, 0x03, 0x06, 0x01, 0x86, 0x01, 0xC1,
  0x80, 0x61, 0x80, 0x60, 0x60, 0x38, 0x60, 0x38, 0x18, 0x0C, 0x18, 0x0C,
  0x06, 0x07, 0x06, 0x03, 0x01, 0x81, 0x81, 0x81, 0x80, 0x60, 0xE0, 0x60,
  0x60, 0x18, 0x30, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x0C, 0x01, 0x86, 0x00,
  0xC7, 0x00, 0x61, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x18, 0x00,
  0x03, 0x83, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x06, 0x00, 0x06, 0x00,
  0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x03,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x70, 0x01, 0x80,
  0x00, 0xC0, 0x03, 0x00, 0x03, 0x80, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x30, 0x01,
  0x80, 0x00, 0x60, 0x07, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x5F, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0xFC, 0x00, 0x7F, 0xF4, 0x00, 0x07,
  0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 12, 42, 13, 1, -42 },
  { 64, 14, 15, 18, 6, -42 },
  { 91, 31, 42, 31, 1, -42 },
  { 254, 25, 48, 28, 2, -45 },
  { 404, 34, 44, 40, 4, -43 },
  { 591, 30, 44, 33, 1, -43 },
  { 756, 5, 15, 10, 6, -42 },
  { 766, 17, 51, 15, 2, -42 },
  { 875, 17, 51, 15, -4, -42 },
  { 984, 21, 22, 27, 7, -45 },
  { 1042, 25, 28, 30, 3, -35 },
  { 1130, 9, 14, 11, -3, -6 },
  { 1146, 13, 2, 17, 2, -17 },
  { 1150, 4, 4, 12, 1, -4 },
  { 1152, 26, 42, 18, -3, -42 },
  { 1289, 24, 44, 28, 3, -43 },
  { 1421, 14, 42, 28, 8, -42 },
  { 1495, 27, 43, 28, 0, -43 },
  { 1641, 27, 44, 28, 0, -43 },
  { 1790, 27, 42, 28, 0, -42 },
  { 1932, 27, 43, 28, 1, -42 },
  { 2078, 25, 44, 28, 3, -43 },
  { 2216, 24, 42, 28, 5, -42 },
  { 2342, 27, 44, 28, 1, -43 },
  { 2491, 25, 44, 28, 2, -43 },
  { 2629, 10, 32, 12, 1, -32 },
  { 2669, 14, 40, 12, -3, -32 },
  { 2739, 25, 26, 30, 3, -34 },
  { 2821, 25, 14, 30, 3, -28 },
  { 2865, 25, 26, 30, 3, -34 },
  { 2947, 19, 43, 21, 3, -43 },
  { 3050, 38, 47, 43, 3, -42 },
  { 3274, 28, 42, 28, -3, -42 },
  { 3421, 28, 42, 31, 2, -42 },
  { 3568, 29, 44, 30, 4, -43 },
  { 3728, 31, 42, 34, 2, -42 },
  { 3891, 27, 42, 27, 2, -42 },
  { 4033, 27, 42, 25, 2, -42 },
  { 4175, 31, 44, 36, 4, -43 },
  { 4346, 33, 42, 35, 2, -42 },
  { 4520, 19, 42, 15, -1, -42 },
  { 4620, 22, 52, 13, -9, -42 },
  { 4763, 31, 42, 28, 2, -42 },
  { 4926, 18, 42, 25, 2, -42 },
  { 5021, 42, 42, 43, 2, -42 },
  { 5242, 34, 42, 36, 2, -42 },
  { 5421, 31, 44, 37, 4, -43 },
  { 5592, 27, 42, 29, 2, -42 },
  { 5734, 31, 53, 37, 4, -43 },
  { 5940, 27, 42, 29, 2, -42 },
  { 6082, 27, 44, 26, 0, -43 },
  { 6231, 25, 42, 25, 5, -42 },
  { 6363, 32, 43, 35, 4, -42 },
  { 6535, 27, 42, 28, 6, -42 },
  { 6677, 42, 42, 44, 6, -42 },
  { 6898, 33, 42, 25, -3, -42 },
  { 7072, 25, 42, 25, 5, -42 },
  { 7204, 30, 42, 27, -1, -42 },
  { 7362, 22, 51, 17, -1, -42 },
  { 7503, 9, 42, 19, 6, -42 },
  { 7551, 22, 51, 17, -4, -42 },
  { 7692, 25, 24, 29, 2, -42 },
  { 7767, 20, 2, 20, -5, 6 },
  { 7772, 6, 9, 13, 9, -45 },
  { 7779, 26, 33, 29, 2, -32 },
  { 7887, 26, 46, 30, 1, -45 },
  { 8037, 21, 33, 23, 3, -32 },
  { 8124, 29, 46, 30, 2, -45 },
  { 8291, 21, 33, 26, 3, -32 },
  { 8378, 30, 59, 14, -8, -45 },
  { 8600, 27, 46, 30, 1, -32 },
  { 8756, 25, 45, 29, 1, -45 },
  { 8897, 12, 43, 12, 1, -43 },
  { 8962, 21, 57, 12, -8, -43 },
  { 9112, 25, 45, 24, 1, -45 },
  { 9253, 12, 45, 12, 1, -45 },
  { 9321, 40, 32, 44, 1, -32 },
  { 9481, 25, 32, 29, 1, -32 },
  { 9581, 23, 33, 29, 3, -32 },
  { 9676, 29, 46, 30, -2, -32 },
  { 9843, 26, 46, 30, 2, -32 },
  { 9993, 20, 32, 19, 1, -32 },
  { 10073, 21, 33, 22, 0, -32 },
  { 10160, 15, 40, 16, 2, -39 },
  { 10235, 24, 32, 29, 3, -31 },
  { 10331, 22, 31, 22, 3, -31 },
  { 10417, 34, 31, 35, 3, -31 },
  { 10549, 27, 31, 24, -2, -31 },
  { 10654, 31, 45, 22, -6, -31 },
  { 10829, 23, 31, 22, -1, -31 },
  { 10919, 21, 51, 19, 2, -42 },
  { 11053, 2, 59, 28, 14, -45 },
  { 11068, 21, 51, 19, -3, -42 },
  { 11202, 25, 6, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC59PT7B_H_
