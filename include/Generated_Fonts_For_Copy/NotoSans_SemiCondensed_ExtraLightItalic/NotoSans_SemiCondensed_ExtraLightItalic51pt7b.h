#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x18, 0x0E, 0x03, 0x80, 0x18, 0x33,
  0x06, 0x30, 0x63, 0x06, 0x30, 0x62, 0x04, 0x20, 0xC6, 0x0C, 0x60, 0xC6,
  0x08, 0x40, 0x84, 0x08, 0xC1, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80,
  0x60, 0x00, 0x30, 0x08, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x0C,
  0x00, 0x06, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x07, 0xFF, 0xFF, 0xF1, 0x06,
  0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x20, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0,
  0x20, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0x01, 0x80, 0x00, 0x40, 0x30, 0x00, 0x18, 0x04,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x40, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x40, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x07,
  0xFF, 0x00, 0x3E, 0xDF, 0x80, 0xE1, 0x02, 0x03, 0x02, 0x00, 0x06, 0x04,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x10, 0x00,
  0x07, 0x20, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x05, 0xE0, 0x00, 0x08, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x81, 0x80, 0x01, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x20, 0x60, 0x00, 0x41, 0xC1, 0x01, 0x87, 0x03, 0xC3, 0x3C,
  0x03, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x20, 0x3F, 0x80, 0x06, 0x03, 0x0C, 0x00, 0x30, 0x30, 0x30, 0x03, 0x03,
  0x01, 0x80, 0x30, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x0C, 0x02, 0x00, 0xC0, 0xC0, 0x30, 0x06, 0x04,
  0x01, 0x80, 0x20, 0x60, 0x0C, 0x03, 0x06, 0x00, 0x60, 0x18, 0x30, 0x03,
  0x00, 0xC3, 0x00, 0x10, 0x04, 0x30, 0xFC, 0x80, 0x61, 0x8E, 0xF4, 0x03,
  0x18, 0xC1, 0xB0, 0x31, 0x8C, 0x0D, 0x81, 0x8C, 0x60, 0x2E, 0x18, 0xC6,
  0x01, 0xBF, 0x8C, 0x30, 0x0C, 0xF0, 0x63, 0x00, 0x40, 0x06, 0x18, 0x02,
  0x00, 0x60, 0xC0, 0x30, 0x03, 0x06, 0x01, 0x80, 0x30, 0x60, 0x0C, 0x03,
  0x03, 0x00, 0x60, 0x18, 0x18, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x08, 0x0C, 0x01, 0x80, 0xC0, 0x60, 0x0C, 0x0C,
  0x06, 0x00, 0x60, 0x60, 0x60, 0x01, 0x8E, 0x07, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x83,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x70,
  0x00, 0x06, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x43,
  0x01, 0x80, 0x21, 0x80, 0x60, 0x18, 0xC0, 0x0C, 0x06, 0x70, 0x03, 0x03,
  0x18, 0x00, 0x60, 0xC6, 0x00, 0x18, 0x63, 0x00, 0x03, 0x30, 0xC0, 0x00,
  0xEC, 0x30, 0x00, 0x1E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0xC0, 0x60,
  0x00, 0xD8, 0x18, 0x00, 0x66, 0x07, 0x00, 0x70, 0xC0, 0xF0, 0xF8, 0x30,
  0x0F, 0xF8, 0x06, 0x00, 0x60, 0x00, 0x00, 0x19, 0x8C, 0x63, 0x10, 0x8C,
  0x63, 0x10, 0x8C, 0x00, 0x00, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x10, 0x18, 0x0F, 0x04, 0x00, 0xF1, 0x00, 0x0E, 0x40, 0xC0, 0xFF,
  0xF0, 0x0E, 0x00, 0x0D, 0x00, 0x06, 0x60, 0x03, 0x08, 0x01, 0x83, 0x00,
  0xC0, 0x40, 0x60, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x06, 0x0C, 0x30, 0x61, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x08, 0x00,
  0xFF, 0xFF, 0xFC, 0x2F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0x80, 0x0F, 0x07, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0x60, 0x70, 0x01, 0x81, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x63, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC1, 0x00, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0x60, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x81, 0xC0, 0x07, 0x1E, 0x00, 0x0F,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x03, 0xE0, 0xF6, 0x1C,
  0x63, 0x86, 0xE0, 0xC4, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xC0, 0xE0, 0x0E, 0x00, 0x60, 0x08,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x0E, 0x01, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xF8, 0x1F, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x33,
  0x00, 0x00, 0xC6, 0x00, 0x03, 0x08, 0x00, 0x06, 0x30, 0x00, 0x18, 0x60,
  0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x06, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x3F, 0x00, 0x07, 0xFF,
  0x80, 0x04, 0x03, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x81, 0x00, 0x1E, 0x03, 0xE0, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x7F, 0x80, 0x67, 0x8F,
  0x81, 0xB8, 0x06, 0x07, 0x80, 0x0C, 0x34, 0x00, 0x30, 0xE0, 0x00, 0x63,
  0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00,
  0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x01, 0x80, 0x18, 0x07,
  0x00, 0xC0, 0x0F, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xC0, 0xE0, 0x06, 0x00, 0x60, 0x18, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06,
  0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0x77, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x38, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0x38, 0x18, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xE0, 0x01, 0x80,
  0xE0, 0x0E, 0x00, 0xF8, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x03,
  0x80, 0x18, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x70,
  0x00, 0xF0, 0xC0, 0x07, 0x83, 0x80, 0x36, 0x07, 0x01, 0x98, 0x0F, 0xFC,
  0x60, 0x0F, 0xC3, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x38, 0x3C, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x07, 0x07, 0x07,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xE0, 0xE0,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0xFC, 0x38, 0x0E, 0x10, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0xC0, 0x07, 0xF0, 0x0C, 0x30, 0x07,
  0xFE, 0x03, 0x18, 0x03, 0x01, 0x80, 0xC6, 0x01, 0x80, 0x60, 0x33, 0x00,
  0xC0, 0x30, 0x0C, 0xC0, 0x60, 0x0C, 0x03, 0x20, 0x18, 0x03, 0x00, 0x98,
  0x0C, 0x00, 0xC0, 0x66, 0x03, 0x00, 0x60, 0x19, 0x81, 0x80, 0x18, 0x06,
  0x40, 0x60, 0x06, 0x01, 0xB0, 0x18, 0x01, 0x00, 0xCC, 0x06, 0x00, 0xC0,
  0x33, 0x01, 0x80, 0x30, 0x0C, 0xC0, 0x60, 0x1C, 0x06, 0x30, 0x18, 0x07,
  0x01, 0x8C, 0x06, 0x03, 0xC0, 0xC3, 0x01, 0x81, 0xB0, 0x60, 0xC0, 0x31,
  0xC6, 0x70, 0x10, 0x07, 0xE1, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x68, 0x00, 0x00, 0x68, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x30, 0x06,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x06,
  0x00, 0xFF, 0xFE, 0x01, 0x80, 0x06, 0x01, 0x80, 0x06, 0x03, 0x00, 0x06,
  0x07, 0x00, 0x06, 0x06, 0x00, 0x02, 0x0E, 0x00, 0x03, 0x0C, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x38, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x01, 0xFF, 0xF0,
  0x01, 0x80, 0xFC, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0E,
  0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0xF0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x18, 0x00, 0x38,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC0,
  0xC0, 0x07, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x10, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x08, 0x00, 0xF0,
  0x78, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x60, 0x7E, 0x00, 0x18, 0x01, 0xE0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0x60, 0x00,
  0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x07,
  0x01, 0x80, 0x07, 0x80, 0xC0, 0x03, 0x80, 0x30, 0x07, 0xC0, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x38, 0x00, 0x10, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xC6, 0x00, 0x1F, 0xF9, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0C,
  0x03, 0x80, 0x01, 0x80, 0x38, 0x00, 0x70, 0x03, 0xE1, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x38, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x06,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1E, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x30, 0x00, 0x70, 0x06,
  0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x70,
  0x00, 0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0,
  0x70, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x18, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0D, 0xF0,
  0x00, 0x03, 0x36, 0x00, 0x00, 0x6C, 0xE0, 0x00, 0x0F, 0x0C, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x0E, 0x01, 0x40, 0x00, 0x01, 0xE0, 0x36, 0x00, 0x00, 0x3E,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x36, 0x00, 0x00, 0x6C, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x36, 0x00, 0x00, 0xCC, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x62,
  0x00, 0x01, 0x8C, 0x06, 0x20, 0x00, 0x19, 0x80, 0x63, 0x00, 0x03, 0x18,
  0x04, 0x30, 0x00, 0x31, 0x80, 0xC3, 0x00, 0x06, 0x18, 0x0C, 0x30, 0x00,
  0xC1, 0x80, 0xC3, 0x00, 0x0C, 0x30, 0x0C, 0x30, 0x01, 0x83, 0x01, 0x83,
  0x00, 0x18, 0x30, 0x18, 0x10, 0x03, 0x03, 0x01, 0x81, 0x80, 0x30, 0x60,
  0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x03, 0x01,
  0x83, 0x00, 0xC0, 0x30, 0x08, 0x30, 0x0C, 0x06, 0x00, 0xC6, 0x00, 0xC0,
  0x60, 0x0C, 0x60, 0x0C, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x60, 0x0C, 0xC0,
  0x18, 0x04, 0x00, 0xD8, 0x01, 0x80, 0xC0, 0x0D, 0x80, 0x18, 0x0C, 0x00,
  0xF0, 0x01, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x06,
  0xC0, 0x00, 0x60, 0x36, 0x00, 0x03, 0x01, 0xB0, 0x00, 0x18, 0x0C, 0xC0,
  0x00, 0xC0, 0x66, 0x00, 0x0C, 0x06, 0x30, 0x00, 0x60, 0x30, 0xC0, 0x03,
  0x01, 0x86, 0x00, 0x18, 0x0C, 0x30, 0x00, 0xC0, 0x60, 0xC0, 0x0C, 0x06,
  0x06, 0x00, 0x60, 0x30, 0x30, 0x03, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x06, 0x03,
  0x01, 0x80, 0x30, 0x18, 0x0C, 0x00, 0xC1, 0x80, 0xC0, 0x06, 0x0C, 0x06,
  0x00, 0x30, 0x60, 0x30, 0x00, 0xC3, 0x01, 0x80, 0x06, 0x18, 0x0C, 0x00,
  0x31, 0x80, 0xC0, 0x00, 0xCC, 0x06, 0x00, 0x06, 0x60, 0x30, 0x00, 0x33,
  0x01, 0x80, 0x01, 0xD0, 0x08, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x3C, 0x06,
  0x00, 0x01, 0xE0, 0x30, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x30,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x07, 0xE3, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0x07, 0xE0, 0x06, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE1, 0x80, 0x01,
  0x83, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0xC0,
  0x60, 0x0F, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xE0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0x07, 0xF0, 0x06, 0x00,
  0xF0, 0x18, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0xC0, 0x01,
  0x81, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x06, 0x06,
  0x00, 0x1C, 0x0C, 0x00, 0x70, 0x30, 0x03, 0xC0, 0x7F, 0xFE, 0x00, 0xFF,
  0xE0, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18,
  0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x02,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x07, 0x80, 0xF8, 0x7E, 0x00,
  0x3F, 0xF8, 0x00, 0x02, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x18,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0E, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x76,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x30, 0x40, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0,
  0x02, 0x01, 0x80, 0x04, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x06, 0x80, 0x01, 0xE0, 0x00,
  0x68, 0x00, 0x1E, 0x00, 0x0C, 0x80, 0x01, 0x60, 0x00, 0xCC, 0x00, 0x36,
  0x00, 0x18, 0xC0, 0x03, 0x60, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x30, 0xC0,
  0x06, 0x60, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x06,
  0x0C, 0x01, 0x86, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x0C, 0x0C, 0x01, 0x86,
  0x00, 0xC0, 0xC0, 0x30, 0x60, 0x18, 0x0C, 0x03, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x60, 0x38, 0x0C, 0x06, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30,
  0x0C, 0x0C, 0x06, 0x06, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x0C, 0x18, 0x02,
  0x0C, 0x00, 0xC1, 0x80, 0x20, 0xC0, 0x0C, 0x30, 0x02, 0x18, 0x00, 0xC3,
  0x00, 0x21, 0x80, 0x0C, 0x60, 0x02, 0x18, 0x00, 0xC6, 0x00, 0x23, 0x00,
  0x0C, 0xC0, 0x02, 0x30, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x0D, 0x80, 0x02,
  0x60, 0x00, 0xD8, 0x00, 0x24, 0x00, 0x0D, 0x00, 0x02, 0xC0, 0x00, 0xF0,
  0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x70,
  0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x18,
  0x80, 0x01, 0xC6, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x0C, 0x00,
  0x60, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x01,
  0x01, 0x80, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0,
  0x00, 0x6E, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0xC0, 0x40,
  0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04,
  0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x00, 0x7F, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x80, 0x00,
  0x33, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC1,
  0x80, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x60,
  0x18, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0,
  0x00, 0x43, 0x00, 0x01, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE1, 0x83, 0x0C, 0x18, 0x60, 0xC1, 0x00, 0x7F, 0x0C,
  0x07, 0x8E, 0x30, 0x38, 0x0C, 0x81, 0xC0, 0x16, 0x0E, 0x00, 0x78, 0x30,
  0x00, 0xE1, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0xC6, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x8C,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00,
  0x1C, 0x30, 0x00, 0x70, 0xC0, 0x03, 0xC3, 0x00, 0x0A, 0x06, 0x00, 0x78,
  0x18, 0x03, 0x60, 0x70, 0x19, 0x80, 0xF1, 0xC4, 0x01, 0xFE, 0x10, 0x00,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x0F, 0xE0, 0x18, 0xE3, 0xC0, 0x66, 0x03, 0x81, 0xB0, 0x06, 0x07, 0x80,
  0x0C, 0x14, 0x00, 0x30, 0xF0, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00,
  0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x61, 0xC0, 0x01, 0x87,
  0x80, 0x0C, 0x1A, 0x00, 0x70, 0x4C, 0x03, 0x83, 0x1C, 0x38, 0x0C, 0x3F,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xE0, 0x3E, 0x18, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x02, 0x03, 0xC3, 0x80, 0x3F, 0xF0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x80, 0x07, 0xF8, 0xC0, 0x0F, 0x1E, 0x60, 0x0E, 0x03, 0x30, 0x0E, 0x00,
  0xD8, 0x0E, 0x00, 0x28, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x03, 0x00,
  0x07, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x03, 0x80, 0xC0, 0x03, 0xC0, 0x60, 0x01, 0xE0, 0x18, 0x01, 0xB0,
  0x0C, 0x01, 0x90, 0x07, 0x01, 0x88, 0x01, 0xE3, 0x8C, 0x00, 0x7F, 0x86,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3C, 0x78, 0x0E, 0x03, 0x03,
  0x80, 0x30, 0xE0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0E, 0x30, 0x0F, 0x06, 0x7F, 0x80, 0xFF,
  0xC0, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x02, 0x03, 0xC3, 0xC0, 0x3F, 0xF0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE1,
  0x00, 0x78, 0xF3, 0x00, 0xE0, 0x33, 0x01, 0xC0, 0x1B, 0x03, 0x80, 0x0A,
  0x03, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x0E,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x38,
  0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0xF0,
  0x30, 0x00, 0xF0, 0x18, 0x01, 0xB0, 0x18, 0x03, 0x20, 0x1C, 0x06, 0x60,
  0x0F, 0x1C, 0x60, 0x07, 0xF8, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x0E, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0xFE, 0x01, 0x1E, 0x38, 0x19, 0x80, 0xE0, 0xD8, 0x03,
  0x07, 0x80, 0x18, 0x28, 0x00, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x30, 0xC0,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x03, 0x83, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x18, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x18,
  0x00, 0x21, 0x80, 0x03, 0x1C, 0x00, 0x19, 0xE0, 0x00, 0xDB, 0x00, 0x07,
  0x8C, 0x00, 0x78, 0x60, 0x03, 0x83, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x60,
  0x06, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0,
  0x0C, 0x06, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x00, 0x02,
  0x1F, 0xC0, 0x7F, 0x01, 0x8E, 0x38, 0x79, 0xE0, 0x66, 0x07, 0x38, 0x1C,
  0x1B, 0x00, 0xD8, 0x03, 0x07, 0x80, 0x36, 0x00, 0xC1, 0x40, 0x0F, 0x00,
  0x30, 0xE0, 0x03, 0x80, 0x0C, 0x38, 0x00, 0xE0, 0x03, 0x0C, 0x00, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0C, 0x60, 0x01,
  0x80, 0x06, 0x18, 0x00, 0x60, 0x01, 0x86, 0x00, 0x18, 0x00, 0x61, 0x80,
  0x06, 0x00, 0x18, 0x40, 0x01, 0x80, 0x06, 0x30, 0x00, 0xC0, 0x03, 0x0C,
  0x00, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0C,
  0x60, 0x00, 0x80, 0x03, 0x18, 0x00, 0x60, 0x01, 0x86, 0x00, 0x18, 0x00,
  0x61, 0x80, 0x06, 0x00, 0x18, 0x60, 0x01, 0x80, 0x06, 0x30, 0x00, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x1F, 0xE0, 0x31, 0xE3, 0x81,
  0x98, 0x0E, 0x0D, 0x80, 0x30, 0x78, 0x01, 0x82, 0x80, 0x0C, 0x38, 0x00,
  0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x30,
  0x00, 0x21, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6,
  0x00, 0x06, 0x30, 0x00, 0x60, 0x00, 0x7F, 0x80, 0x0F, 0x1E, 0x00, 0xE0,
  0x18, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x06, 0x00, 0x1C, 0x60, 0x00, 0x67,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0C,
  0x30, 0x00, 0xE1, 0x80, 0x06, 0x0E, 0x00, 0x60, 0x38, 0x0E, 0x00, 0xF1,
  0xE0, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x83, 0xF8, 0x01, 0x8E,
  0x3C, 0x01, 0x98, 0x0E, 0x01, 0xB0, 0x07, 0x01, 0xE0, 0x03, 0x01, 0x60,
  0x03, 0x03, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x18, 0x1E, 0x00, 0x30, 0x1A, 0x00, 0x60, 0x1B, 0x00, 0xE0, 0x31, 0xC3,
  0x80, 0x30, 0xFF, 0x00, 0x30, 0x10, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x84, 0x07, 0x8F, 0x30, 0x38, 0x0C,
  0xC1, 0xC0, 0x1B, 0x0E, 0x00, 0x28, 0x30, 0x00, 0xE1, 0x80, 0x03, 0x86,
  0x00, 0x0E, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0,
  0x01, 0xC3, 0x00, 0x0F, 0x06, 0x00, 0x6C, 0x18, 0x03, 0x20, 0x70, 0x19,
  0x80, 0xF1, 0xC6, 0x01, 0xFE, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x1F, 0x81, 0x1E, 0x41, 0x98, 0x00, 0xD8,
  0x00, 0x78, 0x00, 0x28, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0xF0, 0xF0, 0x60, 0x04, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x80, 0x1C, 0x3C, 0x1E,
  0x07, 0xFF, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x0F, 0xFF, 0x7F, 0xF8, 0x60, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE1, 0x03, 0xF8,
  0x02, 0x00, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x00,
  0xC1, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x83,
  0x00, 0x0E, 0x0C, 0x00, 0x78, 0x38, 0x03, 0x60, 0x60, 0x19, 0x01, 0xE3,
  0xC4, 0x03, 0xFC, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00,
  0x38, 0xC0, 0x0C, 0x10, 0x06, 0x06, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x06,
  0x18, 0x00, 0x8C, 0x00, 0x23, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x6C, 0x00,
  0xB0, 0x06, 0x60, 0x0D, 0x80, 0x33, 0x00, 0x6C, 0x03, 0x18, 0x06, 0x60,
  0x18, 0xC0, 0x33, 0x00, 0xC6, 0x03, 0x18, 0x0C, 0x30, 0x18, 0xC0, 0x61,
  0x81, 0x86, 0x06, 0x0C, 0x0C, 0x10, 0x30, 0x60, 0xC0, 0x83, 0x03, 0x06,
  0x04, 0x18, 0x18, 0x60, 0x21, 0x80, 0xC3, 0x01, 0x0C, 0x02, 0x30, 0x0C,
  0x60, 0x11, 0x80, 0x66, 0x00, 0x88, 0x03, 0x30, 0x04, 0xC0, 0x1B, 0x00,
  0x24, 0x00, 0xD8, 0x01, 0x60, 0x06, 0x80, 0x0B, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x07, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x30, 0x00, 0xC0, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xC4,
  0x00, 0x01, 0xC6, 0x00, 0x01, 0x86, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x0E, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x06,
  0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x18, 0x00, 0x01, 0x01, 0x80, 0x00, 0x10, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x0F, 0xE0,
  0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x0B, 0x8F, 0x80, 0x70, 0x0F, 0x9F, 0x00,
  0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 36, 11, 1, -36 },
  { 46, 12, 13, 16, 5, -36 },
  { 66, 27, 36, 27, 1, -36 },
  { 188, 23, 42, 24, 1, -39 },
  { 309, 29, 38, 35, 4, -37 },
  { 447, 26, 38, 28, 1, -37 },
  { 571, 5, 13, 9, 5, -36 },
  { 580, 14, 44, 13, 2, -36 },
  { 657, 14, 44, 13, -3, -36 },
  { 734, 18, 19, 23, 6, -39 },
  { 777, 21, 24, 26, 3, -30 },
  { 840, 7, 13, 9, -2, -6 },
  { 852, 11, 2, 15, 2, -15 },
  { 855, 3, 4, 10, 1, -4 },
  { 857, 22, 36, 16, -2, -36 },
  { 956, 22, 38, 24, 2, -37 },
  { 1061, 12, 36, 24, 7, -36 },
  { 1115, 23, 37, 24, 0, -37 },
  { 1222, 24, 38, 24, 0, -37 },
  { 1336, 23, 37, 24, 0, -37 },
  { 1443, 23, 37, 24, 1, -36 },
  { 1550, 22, 38, 24, 3, -37 },
  { 1655, 21, 36, 24, 4, -36 },
  { 1750, 23, 38, 24, 1, -37 },
  { 1860, 22, 38, 24, 1, -37 },
  { 1965, 8, 27, 10, 1, -27 },
  { 1992, 11, 34, 10, -2, -27 },
  { 2039, 21, 23, 26, 3, -30 },
  { 2100, 21, 12, 26, 3, -24 },
  { 2132, 21, 23, 26, 3, -30 },
  { 2193, 16, 37, 18, 3, -37 },
  { 2267, 34, 41, 37, 2, -36 },
  { 2442, 24, 37, 24, -3, -37 },
  { 2553, 24, 36, 27, 2, -36 },
  { 2661, 25, 38, 26, 3, -37 },
  { 2780, 26, 36, 30, 2, -36 },
  { 2897, 23, 36, 24, 2, -36 },
  { 3001, 23, 36, 22, 2, -36 },
  { 3105, 27, 38, 31, 3, -37 },
  { 3234, 29, 36, 30, 2, -36 },
  { 3365, 16, 36, 13, -1, -36 },
  { 3437, 19, 45, 11, -8, -36 },
  { 3544, 27, 36, 24, 2, -36 },
  { 3666, 16, 36, 22, 2, -36 },
  { 3738, 36, 36, 37, 2, -36 },
  { 3900, 29, 36, 31, 2, -36 },
  { 4031, 27, 38, 32, 3, -37 },
  { 4160, 23, 36, 25, 2, -36 },
  { 4264, 27, 46, 32, 3, -37 },
  { 4420, 23, 36, 25, 2, -36 },
  { 4524, 24, 38, 23, 0, -37 },
  { 4638, 21, 36, 21, 5, -36 },
  { 4733, 28, 37, 30, 3, -36 },
  { 4863, 23, 36, 24, 5, -36 },
  { 4967, 36, 36, 38, 6, -36 },
  { 5129, 29, 36, 22, -3, -36 },
  { 5260, 21, 36, 21, 5, -36 },
  { 5355, 26, 36, 23, -1, -36 },
  { 5472, 19, 44, 15, -1, -36 },
  { 5577, 8, 36, 16, 5, -36 },
  { 5613, 18, 44, 15, -3, -36 },
  { 5712, 22, 21, 25, 2, -37 },
  { 5770, 17, 2, 17, -4, 5 },
  { 5775, 6, 8, 12, 7, -39 },
  { 5781, 22, 28, 25, 2, -27 },
  { 5858, 22, 40, 26, 1, -39 },
  { 5968, 19, 28, 20, 2, -27 },
  { 6035, 25, 40, 26, 2, -39 },
  { 6160, 19, 28, 22, 2, -27 },
  { 6227, 26, 51, 13, -7, -39 },
  { 6393, 24, 39, 26, 0, -27 },
  { 6510, 21, 39, 25, 1, -39 },
  { 6613, 10, 37, 10, 1, -37 },
  { 6660, 18, 49, 10, -7, -37 },
  { 6771, 21, 39, 20, 1, -39 },
  { 6874, 10, 39, 10, 1, -39 },
  { 6923, 34, 27, 38, 1, -27 },
  { 7038, 21, 27, 25, 1, -27 },
  { 7109, 21, 28, 25, 2, -27 },
  { 7183, 24, 39, 26, -1, -27 },
  { 7300, 22, 39, 26, 2, -27 },
  { 7408, 17, 27, 17, 1, -27 },
  { 7466, 18, 28, 19, 0, -27 },
  { 7529, 13, 35, 14, 2, -34 },
  { 7586, 22, 28, 25, 2, -27 },
  { 7663, 18, 27, 19, 3, -27 },
  { 7724, 29, 27, 30, 3, -27 },
  { 7822, 24, 27, 20, -2, -27 },
  { 7903, 28, 39, 19, -6, -27 },
  { 8040, 20, 27, 19, -1, -27 },
  { 8108, 18, 44, 17, 1, -36 },
  { 8207, 2, 51, 24, 12, -39 },
  { 8220, 18, 44, 17, -3, -36 },
  { 8319, 21, 4, 26, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC51PT7B_H_
