#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x24, 0x44, 0x44, 0x00, 0x88, 0x4D, 0x24, 0x92,
  0x8A, 0x40, 0x02, 0x20, 0x11, 0x01, 0x08, 0x08, 0x83, 0xFF, 0x82, 0x20,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x84, 0x3F, 0xF8, 0x22, 0x02, 0x10, 0x11,
  0x00, 0x88, 0x04, 0x40, 0x02, 0x01, 0xC1, 0xAC, 0x90, 0x24, 0x09, 0x02,
  0x40, 0xD0, 0x08, 0x03, 0x80, 0x90, 0x24, 0x09, 0x04, 0x49, 0x23, 0xF0,
  0x10, 0x08, 0x00, 0x10, 0x13, 0x41, 0x11, 0x09, 0x08, 0x88, 0x48, 0x42,
  0x42, 0x24, 0x11, 0x2E, 0x8A, 0x8C, 0xA4, 0x59, 0x42, 0x12, 0x11, 0x11,
  0x08, 0x88, 0x84, 0x48, 0x24, 0xC1, 0xC0, 0x07, 0x01, 0x10, 0x42, 0x08,
  0x41, 0x08, 0x22, 0x04, 0x80, 0x60, 0x18, 0x04, 0x81, 0x10, 0xC1, 0x28,
  0x25, 0x03, 0x20, 0x64, 0x14, 0x7C, 0x40, 0x55, 0xA0, 0x0C, 0x21, 0x08,
  0x21, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10,
  0x04, 0x08, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x82, 0x04, 0x10, 0x41, 0x06, 0x00, 0x08, 0x08, 0xC8, 0x3F, 0x10, 0x28,
  0xC8, 0x04, 0x04, 0x01, 0x00, 0x40, 0x10, 0xFF, 0xC1, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x25, 0x28, 0xF8, 0xC0, 0x00, 0xC0, 0x20, 0x10, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x07, 0x02, 0x21, 0x08, 0x81, 0x20, 0x50, 0x14, 0x05,
  0x01, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x48, 0x21, 0x18, 0x7C,
  0x00, 0x1C, 0xAC, 0x82, 0x08, 0x41, 0x04, 0x10, 0x82, 0x08, 0x20, 0x84,
  0x10, 0x07, 0x06, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x01,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x00, 0x07,
  0x03, 0x18, 0x41, 0x00, 0x10, 0x02, 0x00, 0x80, 0x10, 0x0C, 0x0E, 0x00,
  0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x24, 0x08, 0xFE, 0x00, 0x00,
  0x40, 0x10, 0x0C, 0x05, 0x02, 0x41, 0x20, 0x48, 0x22, 0x10, 0x88, 0x24,
  0x11, 0x04, 0xFF, 0xC0, 0x40, 0x10, 0x08, 0x02, 0x00, 0x0F, 0xE1, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x0F, 0x80, 0x0C, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x20, 0x47, 0xF0, 0x03, 0xC1, 0x00, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x7C, 0x61, 0x30, 0x28, 0x0A, 0x02, 0x80, 0xA0,
  0x48, 0x11, 0x08, 0x3C, 0x00, 0x7F, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x07,
  0x06, 0x22, 0x04, 0x81, 0x20, 0x48, 0x21, 0x08, 0x4C, 0x0C, 0x0C, 0x84,
  0x12, 0x04, 0x81, 0x20, 0x48, 0x12, 0x0C, 0x7C, 0x00, 0x06, 0x06, 0x62,
  0x08, 0x82, 0x40, 0x50, 0x14, 0x09, 0x02, 0x41, 0x88, 0xA1, 0xC8, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x10, 0xF8, 0x00, 0x11, 0x00, 0x00, 0x00, 0x00,
  0x4C, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x08, 0x84, 0x22, 0x00, 0x00,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x20, 0x00, 0x1C, 0x62, 0x01,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x00, 0x00,
  0x40, 0xC0, 0x03, 0xF8, 0x18, 0x08, 0x40, 0x11, 0x00, 0x12, 0x1E, 0x28,
  0x44, 0x51, 0x08, 0xC2, 0x11, 0x88, 0x43, 0x10, 0x86, 0x21, 0x14, 0x46,
  0x28, 0x95, 0x90, 0xC4, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x3F, 0x80,
  0x00, 0x80, 0x30, 0x06, 0x01, 0x20, 0x24, 0x08, 0x81, 0x10, 0x42, 0x08,
  0x43, 0xF8, 0x81, 0x10, 0x24, 0x04, 0x80, 0xA0, 0x0C, 0x01, 0x1F, 0xC2,
  0x0C, 0x40, 0x90, 0x12, 0x02, 0x40, 0x88, 0x21, 0xF8, 0x40, 0x88, 0x11,
  0x01, 0x20, 0x28, 0x09, 0x01, 0x20, 0x47, 0xF0, 0x01, 0xC0, 0x63, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80,
  0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x1F, 0x80, 0x1F, 0xC1,
  0x06, 0x10, 0x22, 0x02, 0x20, 0x12, 0x01, 0x20, 0x14, 0x01, 0x40, 0x24,
  0x02, 0x40, 0x24, 0x04, 0x80, 0xC8, 0x18, 0x83, 0x0F, 0xC0, 0x1F, 0xC4,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFC, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x03, 0xF8, 0x1F, 0xC4, 0x01, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x7F, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x01, 0xE0, 0x30, 0xC2, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x0F, 0xA0, 0x09, 0x00, 0x44, 0x02, 0x20,
  0x11, 0x01, 0x04, 0x08, 0x1F, 0xC0, 0x10, 0x08, 0x80, 0x84, 0x04, 0x40,
  0x22, 0x01, 0x10, 0x08, 0x80, 0x87, 0xFC, 0x40, 0x22, 0x01, 0x10, 0x08,
  0x80, 0x88, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x1E, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x04, 0x10, 0x78, 0x00, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x1E, 0x00, 0x10, 0x31, 0x04,
  0x10, 0x82, 0x10, 0x22, 0x02, 0x40, 0x28, 0x05, 0x80, 0x64, 0x04, 0x40,
  0x44, 0x04, 0x20, 0x82, 0x08, 0x10, 0x81, 0x08, 0x18, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x7F, 0x18,
  0x03, 0x18, 0x05, 0x28, 0x06, 0x28, 0x0A, 0x28, 0x0A, 0x28, 0x12, 0x28,
  0x12, 0x44, 0x24, 0x44, 0x24, 0x44, 0x44, 0x44, 0x44, 0x44, 0x84, 0x85,
  0x08, 0x85, 0x08, 0x86, 0x08, 0x82, 0x08, 0x10, 0x08, 0xC0, 0x4A, 0x04,
  0x50, 0x22, 0x41, 0x12, 0x08, 0x90, 0x48, 0x44, 0x42, 0x22, 0x11, 0x10,
  0x48, 0x82, 0x48, 0x14, 0x40, 0x62, 0x03, 0x10, 0x18, 0x03, 0x80, 0x63,
  0x06, 0x04, 0x20, 0x22, 0x01, 0x10, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x02, 0x20, 0x11, 0x01, 0x04, 0x10, 0x1F,
  0x00, 0x1F, 0x84, 0x11, 0x04, 0x81, 0x20, 0x48, 0x12, 0x05, 0x06, 0x7E,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x03, 0x80, 0x63,
  0x06, 0x04, 0x20, 0x22, 0x01, 0x10, 0x05, 0x00, 0x28, 0x01, 0x40, 0x12,
  0x00, 0xA0, 0x05, 0x00, 0x28, 0x02, 0x20, 0x11, 0x01, 0x04, 0x10, 0x1F,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x1F, 0x84, 0x11, 0x04,
  0x81, 0x20, 0x48, 0x12, 0x09, 0x06, 0x7E, 0x11, 0x04, 0x21, 0x08, 0x82,
  0x20, 0x48, 0x12, 0x04, 0x03, 0x81, 0x8C, 0x40, 0x10, 0x02, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x40, 0x08, 0xFE, 0x00, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0x20, 0x12, 0x01, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x48, 0x04,
  0x80, 0x48, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x10, 0x81, 0x07, 0xE0,
  0x80, 0x70, 0x0A, 0x02, 0x40, 0x44, 0x10, 0x82, 0x10, 0x82, 0x10, 0x44,
  0x08, 0x81, 0x20, 0x24, 0x05, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x80, 0x80,
  0xC0, 0xC0, 0xA0, 0x60, 0x50, 0x50, 0x44, 0x28, 0x22, 0x14, 0x21, 0x12,
  0x10, 0x89, 0x10, 0x48, 0x88, 0x24, 0x24, 0x14, 0x14, 0x0A, 0x0A, 0x06,
  0x06, 0x03, 0x03, 0x01, 0x01, 0x00, 0x80, 0x80, 0x08, 0x18, 0x41, 0x02,
  0x08, 0x08, 0x80, 0x48, 0x02, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x48,
  0x02, 0x40, 0x22, 0x02, 0x10, 0x20, 0x41, 0x02, 0x10, 0x10, 0x80, 0xE0,
  0x24, 0x11, 0x08, 0x42, 0x11, 0x02, 0x80, 0xA0, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x1F, 0xE0, 0x08, 0x01, 0x00, 0x40,
  0x10, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x80, 0x20, 0x07, 0xF8, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0xF0,
  0x84, 0x44, 0x44, 0x42, 0x22, 0x22, 0x22, 0x11, 0x0F, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x1F, 0x00, 0x06, 0x02, 0x80, 0x90, 0x44,
  0x11, 0x08, 0x24, 0x09, 0x02, 0x80, 0x40, 0xFF, 0x89, 0x10, 0x1F, 0x48,
  0x54, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x51,
  0xE8, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0x00, 0x2F, 0x86, 0x11, 0x82,
  0x30, 0x24, 0x04, 0x81, 0x10, 0x24, 0x04, 0x80, 0x90, 0x23, 0x08, 0x9E,
  0x00, 0x1F, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x7C, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x3E, 0x88, 0x32, 0x04,
  0x40, 0x88, 0x12, 0x02, 0x40, 0x48, 0x11, 0x02, 0x20, 0xC4, 0x28, 0x79,
  0x00, 0x1F, 0x21, 0x41, 0x41, 0x42, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x7E, 0x00, 0x70, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x0F, 0x80,
  0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x0C,
  0x00, 0x0F, 0xA2, 0x0C, 0x81, 0x10, 0x22, 0x04, 0x80, 0x90, 0x12, 0x04,
  0x40, 0x88, 0x31, 0x0A, 0x1E, 0x40, 0x10, 0x02, 0x00, 0x40, 0x10, 0xCC,
  0x06, 0x00, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x05, 0xF1, 0x84, 0x41,
  0x20, 0x48, 0x12, 0x04, 0x82, 0x40, 0x90, 0x24, 0x09, 0x02, 0xC1, 0x00,
  0x08, 0x40, 0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0xC0, 0x01,
  0x01, 0x00, 0x00, 0x00, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x31, 0x10, 0x88, 0x22, 0x09, 0x02, 0x80,
  0xD0, 0x64, 0x10, 0x84, 0x21, 0x08, 0xC1, 0x00, 0x08, 0x44, 0x21, 0x08,
  0x44, 0x21, 0x08, 0x44, 0x21, 0x08, 0xC0, 0x17, 0x9E, 0x18, 0x61, 0x10,
  0x41, 0x20, 0x41, 0x20, 0x81, 0x20, 0x82, 0x20, 0x82, 0x40, 0x82, 0x41,
  0x02, 0x41, 0x02, 0x41, 0x04, 0xC1, 0x04, 0x17, 0xC6, 0x13, 0x04, 0x81,
  0x20, 0x48, 0x12, 0x09, 0x02, 0x40, 0x90, 0x24, 0x0B, 0x04, 0x1F, 0x10,
  0x50, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x40, 0x90, 0x8F, 0x80,
  0x0B, 0xE0, 0xC2, 0x08, 0x21, 0x81, 0x10, 0x11, 0x02, 0x10, 0x22, 0x02,
  0x20, 0x22, 0x04, 0x30, 0x82, 0xF0, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x00, 0x1F, 0x48, 0x34, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x0A, 0x04,
  0x81, 0x20, 0xC8, 0x51, 0xE4, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x00,
  0x17, 0x18, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0xC0,
  0x1F, 0x20, 0x20, 0x20, 0x20, 0x18, 0x04, 0x02, 0x02, 0x02, 0x02, 0xFC,
  0x10, 0x82, 0x3F, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x0E, 0x00,
  0x20, 0x48, 0x24, 0x09, 0x02, 0x40, 0x90, 0x28, 0x12, 0x04, 0x81, 0x20,
  0xC8, 0x51, 0xE8, 0x81, 0xC0, 0xA0, 0x90, 0x44, 0x42, 0x21, 0x20, 0x90,
  0x50, 0x28, 0x18, 0x0C, 0x00, 0x82, 0x0E, 0x08, 0x28, 0x51, 0x21, 0x44,
  0x89, 0x12, 0x24, 0x89, 0x12, 0x24, 0x50, 0x61, 0x41, 0x86, 0x04, 0x18,
  0x10, 0x40, 0x10, 0x62, 0x10, 0x22, 0x04, 0x80, 0x60, 0x08, 0x03, 0x00,
  0x50, 0x12, 0x04, 0x41, 0x04, 0x60, 0x80, 0x08, 0x08, 0x40, 0x81, 0x08,
  0x08, 0x40, 0x44, 0x02, 0x20, 0x12, 0x00, 0x90, 0x05, 0x00, 0x28, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x07, 0x00,
  0x00, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x20, 0x1F, 0x80, 0x07, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20,
  0xC0, 0x40, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x40, 0x30, 0xFF,
  0xFF, 0xFF, 0x0E, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x04, 0x03,
  0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x78, 0x61,
  0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 5, 1, -16 },
  { 9, 6, 6, 7, 2, -16 },
  { 14, 13, 16, 12, 0, -16 },
  { 40, 10, 18, 11, 1, -17 },
  { 63, 13, 17, 16, 2, -17 },
  { 91, 11, 17, 13, 1, -17 },
  { 115, 2, 6, 4, 2, -16 },
  { 117, 6, 20, 6, 1, -16 },
  { 132, 7, 20, 6, -2, -16 },
  { 150, 8, 8, 11, 3, -17 },
  { 158, 10, 10, 12, 1, -13 },
  { 171, 3, 5, 4, -1, -2 },
  { 173, 5, 1, 7, 1, -7 },
  { 174, 1, 2, 5, 1, -2 },
  { 175, 10, 16, 7, -1, -16 },
  { 195, 10, 17, 11, 1, -17 },
  { 217, 6, 16, 11, 3, -16 },
  { 229, 10, 17, 11, 0, -17 },
  { 251, 11, 17, 11, 0, -17 },
  { 275, 10, 17, 11, 0, -17 },
  { 297, 11, 16, 11, 0, -16 },
  { 319, 10, 17, 11, 1, -17 },
  { 341, 9, 16, 11, 2, -16 },
  { 359, 10, 17, 11, 1, -17 },
  { 381, 10, 17, 11, 1, -17 },
  { 403, 4, 12, 5, 0, -12 },
  { 409, 5, 15, 5, -1, -12 },
  { 419, 10, 10, 12, 1, -13 },
  { 432, 10, 6, 12, 1, -11 },
  { 440, 10, 10, 12, 1, -13 },
  { 453, 8, 17, 8, 1, -17 },
  { 470, 15, 18, 17, 1, -16 },
  { 504, 11, 16, 11, -1, -16 },
  { 526, 11, 16, 12, 1, -16 },
  { 548, 12, 17, 12, 1, -17 },
  { 574, 12, 16, 13, 1, -16 },
  { 598, 10, 16, 11, 1, -16 },
  { 618, 10, 16, 10, 1, -16 },
  { 638, 13, 17, 14, 1, -17 },
  { 666, 13, 16, 14, 1, -16 },
  { 692, 7, 16, 6, 0, -16 },
  { 706, 9, 20, 5, -4, -16 },
  { 729, 12, 16, 11, 1, -16 },
  { 753, 7, 16, 10, 1, -16 },
  { 767, 16, 16, 17, 1, -16 },
  { 799, 13, 16, 14, 1, -16 },
  { 825, 13, 17, 14, 1, -17 },
  { 853, 10, 16, 11, 1, -16 },
  { 873, 13, 21, 14, 1, -17 },
  { 908, 10, 16, 11, 1, -16 },
  { 928, 11, 17, 10, 0, -17 },
  { 952, 10, 16, 10, 2, -16 },
  { 972, 12, 16, 14, 2, -16 },
  { 996, 11, 16, 11, 2, -16 },
  { 1018, 17, 16, 17, 2, -16 },
  { 1052, 13, 16, 10, -1, -16 },
  { 1078, 10, 16, 10, 2, -16 },
  { 1098, 11, 16, 10, 0, -16 },
  { 1120, 8, 20, 7, 0, -16 },
  { 1140, 4, 16, 7, 2, -16 },
  { 1148, 9, 20, 7, -2, -16 },
  { 1171, 10, 9, 11, 1, -16 },
  { 1183, 8, 1, 8, -2, 2 },
  { 1184, 3, 4, 5, 3, -18 },
  { 1186, 10, 12, 11, 1, -12 },
  { 1201, 11, 17, 12, 0, -17 },
  { 1225, 8, 12, 9, 1, -12 },
  { 1237, 11, 17, 12, 1, -17 },
  { 1261, 8, 12, 10, 1, -12 },
  { 1273, 12, 24, 6, -3, -18 },
  { 1309, 11, 18, 12, 0, -12 },
  { 1334, 10, 17, 11, 0, -17 },
  { 1356, 5, 17, 5, 0, -17 },
  { 1367, 8, 23, 5, -3, -17 },
  { 1390, 10, 17, 9, 0, -17 },
  { 1412, 5, 17, 4, 0, -17 },
  { 1423, 16, 12, 17, 0, -12 },
  { 1447, 10, 12, 11, 0, -12 },
  { 1462, 9, 12, 11, 1, -12 },
  { 1476, 12, 17, 12, -1, -12 },
  { 1502, 10, 17, 12, 1, -12 },
  { 1524, 8, 12, 8, 0, -12 },
  { 1536, 8, 12, 9, 0, -12 },
  { 1548, 6, 15, 6, 1, -15 },
  { 1560, 10, 12, 11, 1, -12 },
  { 1575, 9, 12, 9, 1, -12 },
  { 1589, 14, 12, 14, 1, -12 },
  { 1610, 11, 12, 9, -1, -12 },
  { 1627, 13, 18, 9, -3, -12 },
  { 1657, 9, 12, 8, 0, -12 },
  { 1671, 8, 20, 7, 1, -16 },
  { 1691, 1, 24, 11, 5, -18 },
  { 1694, 8, 20, 7, -1, -16 },
  { 1714, 10, 2, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC23PT7B_H_
