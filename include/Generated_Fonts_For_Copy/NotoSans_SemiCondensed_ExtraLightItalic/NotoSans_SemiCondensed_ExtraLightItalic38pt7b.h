#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x40, 0xC0, 0xC0, 0x21, 0xB0, 0x98, 0xCC, 0x64, 0x22, 0x11, 0x09,
  0x84, 0x84, 0x42, 0x00, 0x00, 0x60, 0xC0, 0x04, 0x08, 0x00, 0x40, 0x80,
  0x0C, 0x08, 0x00, 0xC1, 0x80, 0x08, 0x10, 0x00, 0x81, 0x00, 0x18, 0x30,
  0x3F, 0xFF, 0xF0, 0x10, 0x20, 0x03, 0x06, 0x00, 0x20, 0x40, 0x02, 0x04,
  0x00, 0x20, 0x40, 0x06, 0x0C, 0x00, 0x40, 0x80, 0x04, 0x08, 0x0F, 0xFF,
  0xF8, 0x08, 0x10, 0x00, 0x81, 0x00, 0x18, 0x10, 0x01, 0x03, 0x00, 0x10,
  0x20, 0x01, 0x02, 0x00, 0x30, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x3F, 0xF8, 0x31,
  0x08, 0x30, 0x80, 0x10, 0x40, 0x18, 0x60, 0x0C, 0x20, 0x06, 0x10, 0x01,
  0x08, 0x00, 0xC4, 0x00, 0x36, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0xF0,
  0x00, 0x4C, 0x00, 0x63, 0x00, 0x21, 0x80, 0x10, 0x40, 0x08, 0x20, 0x04,
  0x30, 0x04, 0x10, 0x02, 0x18, 0x61, 0x38, 0x1F, 0xF0, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x7C, 0x01, 0x84,
  0x20, 0x08, 0x41, 0x80, 0x86, 0x0C, 0x0C, 0x20, 0x60, 0x41, 0x03, 0x04,
  0x18, 0x18, 0x60, 0xC0, 0x82, 0x04, 0x04, 0x20, 0x20, 0x23, 0x01, 0x03,
  0x10, 0xC8, 0x11, 0x1F, 0x41, 0x99, 0x8E, 0x08, 0x98, 0x38, 0xCC, 0x81,
  0x7C, 0xC4, 0x08, 0x84, 0x60, 0x40, 0x62, 0x02, 0x06, 0x10, 0x30, 0x21,
  0x81, 0x83, 0x0C, 0x08, 0x10, 0x60, 0x41, 0x03, 0x06, 0x18, 0x18, 0x20,
  0x80, 0xC3, 0x08, 0x02, 0x10, 0xC0, 0x1F, 0x00, 0x00, 0x10, 0x00, 0x1F,
  0x80, 0x06, 0x18, 0x01, 0x81, 0x80, 0x20, 0x30, 0x04, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x10, 0x06, 0x06, 0x00, 0x41, 0x80, 0x08, 0x60, 0x01, 0x98,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xB0, 0x00, 0x62, 0x00, 0x30, 0x60,
  0x64, 0x04, 0x09, 0x80, 0xC3, 0x60, 0x08, 0x4C, 0x01, 0x99, 0x00, 0x16,
  0x20, 0x03, 0x84, 0x00, 0x30, 0xC0, 0x0A, 0x18, 0x06, 0x61, 0x81, 0x84,
  0x1F, 0xE0, 0xC0, 0x2D, 0xB4, 0x96, 0x90, 0x00, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x30, 0x00, 0x01, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x01,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x08, 0x00, 0xC1, 0x06, 0x0C, 0x20, 0x39,
  0x00, 0x68, 0xE0, 0xFC, 0x0E, 0x00, 0xC8, 0x0C, 0x41, 0xC3, 0x04, 0x08,
  0x00, 0x60, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x0C, 0x21, 0x84, 0x30, 0x82, 0x10, 0xC0, 0xFF, 0x80, 0x7C, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x01, 0xF8,
  0x03, 0x0C, 0x06, 0x06, 0x0C, 0x02, 0x18, 0x02, 0x10, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x20, 0x03, 0x60, 0x02, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C,
  0x80, 0x08, 0x80, 0x18, 0x80, 0x10, 0xC0, 0x30, 0xC0, 0x20, 0x40, 0x60,
  0x61, 0xC0, 0x3F, 0x00, 0x01, 0x83, 0xC3, 0x63, 0x26, 0x16, 0x18, 0x0C,
  0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x08, 0x00, 0x00,
  0x10, 0x00, 0xFF, 0x01, 0xC0, 0xC0, 0x40, 0x30, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x7F, 0x80, 0x70, 0x30, 0x10, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x0C, 0x07, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x01, 0x40, 0x01, 0xE0, 0x01, 0xB0, 0x00,
  0x90, 0x00, 0x88, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x42, 0x00, 0x41, 0x00,
  0x60, 0x80, 0x60, 0xC0, 0x60, 0x60, 0x20, 0x20, 0x20, 0x10, 0x30, 0x18,
  0x30, 0x0C, 0x30, 0x06, 0x10, 0x02, 0x1F, 0xFF, 0xF0, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0x81, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0xFC, 0x01, 0x03, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x80, 0x30, 0x60, 0x70, 0x3F, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x7F, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x21, 0xC0, 0x67, 0xF0,
  0x58, 0x18, 0x70, 0x0C, 0xE0, 0x04, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x04,
  0x80, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x08, 0xC0, 0x18, 0xC0, 0x10,
  0x60, 0x30, 0x30, 0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0x00, 0xFF, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0x40, 0x18, 0x60,
  0x0C, 0x20, 0x06, 0x10, 0x03, 0x0C, 0x01, 0x06, 0x01, 0x81, 0x01, 0x80,
  0xC1, 0x80, 0x33, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x18, 0x60, 0x38, 0x18,
  0x30, 0x06, 0x10, 0x01, 0x18, 0x00, 0x8C, 0x00, 0x64, 0x00, 0x32, 0x00,
  0x11, 0x80, 0x08, 0xC0, 0x0C, 0x30, 0x0C, 0x0C, 0x0C, 0x03, 0xFC, 0x00,
  0x00, 0x20, 0x01, 0xFC, 0x03, 0x06, 0x06, 0x03, 0x0C, 0x03, 0x18, 0x01,
  0x18, 0x01, 0x10, 0x01, 0x30, 0x01, 0x30, 0x01, 0x30, 0x01, 0x30, 0x03,
  0x30, 0x03, 0x30, 0x07, 0x10, 0x0F, 0x18, 0x1A, 0x0F, 0xF2, 0x01, 0x86,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x81, 0x80, 0xFE, 0x00, 0x0C, 0x70, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x30, 0x01,
  0x81, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x01,
  0x80, 0x80, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0x01, 0xFC, 0x30, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0xE0, 0x0C, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0x20, 0x60, 0x00, 0x18, 0x60, 0x00, 0x04, 0x20, 0x00,
  0x02, 0x30, 0x1F, 0xC1, 0x90, 0x18, 0x20, 0xD8, 0x10, 0x30, 0x68, 0x18,
  0x10, 0x34, 0x18, 0x08, 0x16, 0x08, 0x04, 0x0B, 0x04, 0x06, 0x05, 0x06,
  0x02, 0x06, 0x82, 0x01, 0x03, 0x41, 0x01, 0x81, 0x20, 0x80, 0xC1, 0x90,
  0x40, 0xA0, 0x88, 0x30, 0xD0, 0x84, 0x0D, 0xCD, 0xC2, 0x03, 0x83, 0x81,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x04, 0x40,
  0x03, 0x10, 0x00, 0x84, 0x00, 0x61, 0x00, 0x10, 0x40, 0x0C, 0x10, 0x02,
  0x04, 0x01, 0x81, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x06, 0x07, 0xFF,
  0x81, 0x00, 0x20, 0xC0, 0x08, 0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x23,
  0x00, 0x08, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0C, 0x03,
  0xFE, 0x00, 0x80, 0xE0, 0x60, 0x0C, 0x18, 0x01, 0x04, 0x00, 0x41, 0x00,
  0x10, 0x40, 0x04, 0x30, 0x01, 0x0C, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x18,
  0x60, 0x18, 0x1F, 0xF8, 0x06, 0x0F, 0x01, 0x00, 0x60, 0x40, 0x0C, 0x30,
  0x01, 0x0C, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04, 0x20, 0x01, 0x18, 0x00,
  0xC6, 0x00, 0x21, 0x00, 0x18, 0x40, 0x0C, 0x10, 0x1E, 0x0F, 0xFC, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xFC, 0x03, 0x01, 0x81, 0xC0, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x30, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x20, 0x78,
  0x06, 0x01, 0xC0, 0x60, 0x04, 0x04, 0x00, 0x60, 0x40, 0x02, 0x04, 0x00,
  0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80, 0x03, 0x08, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x10, 0x00, 0x21, 0x00, 0x02, 0x30,
  0x00, 0x63, 0x00, 0x04, 0x20, 0x00, 0xC2, 0x00, 0x0C, 0x20, 0x01, 0x86,
  0x00, 0x30, 0x60, 0x07, 0x04, 0x00, 0xE0, 0x40, 0x18, 0x0C, 0x1F, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFE, 0x06, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x30,
  0x0E, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x7F, 0x88, 0x03, 0xFC, 0x40,
  0x00, 0x46, 0x00, 0x02, 0x30, 0x00, 0x31, 0x80, 0x01, 0x84, 0x00, 0x0C,
  0x20, 0x00, 0x41, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x30, 0x01, 0x81, 0xC0,
  0x08, 0x07, 0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x0C, 0x08, 0x00,
  0x20, 0x60, 0x00, 0x81, 0x80, 0x02, 0x04, 0x00, 0x18, 0x10, 0x00, 0x60,
  0x40, 0x01, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x20, 0x00, 0xC0, 0x80,
  0x03, 0x06, 0x00, 0x08, 0x1F, 0xFF, 0xE0, 0x60, 0x01, 0x81, 0x00, 0x06,
  0x04, 0x00, 0x10, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x02, 0x00, 0x0C, 0x08,
  0x00, 0x30, 0x20, 0x00, 0x81, 0x80, 0x02, 0x06, 0x00, 0x08, 0x10, 0x00,
  0x60, 0x40, 0x01, 0x83, 0x00, 0x04, 0x0C, 0x00, 0x10, 0x00, 0x03, 0xF8,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x3F, 0x80, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x01, 0x80, 0xFC, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x30, 0x20, 0x06, 0x06,
  0x00, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x00, 0x40, 0x60, 0x04, 0x0C, 0x00,
  0xC1, 0x80, 0x0C, 0x30, 0x00, 0x86, 0x00, 0x08, 0xC0, 0x01, 0x98, 0x00,
  0x1B, 0x80, 0x01, 0x6C, 0x00, 0x1C, 0xC0, 0x01, 0x84, 0x00, 0x30, 0x60,
  0x03, 0x02, 0x00, 0x20, 0x30, 0x02, 0x03, 0x00, 0x20, 0x10, 0x06, 0x01,
  0x80, 0x60, 0x08, 0x04, 0x00, 0x80, 0x40, 0x0C, 0x0C, 0x00, 0x40, 0xC0,
  0x06, 0x00, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xA0, 0x58, 0x00, 0x34,
  0x0B, 0x00, 0x05, 0x81, 0x60, 0x01, 0xB0, 0x64, 0x00, 0x24, 0x0C, 0x80,
  0x0C, 0x81, 0x10, 0x01, 0x10, 0x22, 0x00, 0x46, 0x0C, 0x40, 0x18, 0xC1,
  0x8C, 0x02, 0x10, 0x21, 0x80, 0xC2, 0x04, 0x30, 0x10, 0xC0, 0x82, 0x06,
  0x18, 0x30, 0x40, 0x83, 0x06, 0x08, 0x30, 0x40, 0x81, 0x04, 0x08, 0x10,
  0x21, 0x83, 0x02, 0x06, 0x60, 0x60, 0xC0, 0xC8, 0x08, 0x18, 0x1B, 0x01,
  0x02, 0x01, 0x40, 0x20, 0x40, 0x38, 0x0C, 0x18, 0x06, 0x01, 0x83, 0x00,
  0xC0, 0x20, 0x00, 0x03, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x70, 0x00, 0xC1,
  0xE0, 0x02, 0x05, 0x80, 0x08, 0x12, 0x00, 0x60, 0x4C, 0x01, 0x83, 0x30,
  0x06, 0x0C, 0x40, 0x10, 0x21, 0x80, 0x40, 0x86, 0x03, 0x06, 0x08, 0x0C,
  0x18, 0x30, 0x20, 0x60, 0xC0, 0x81, 0x01, 0x02, 0x04, 0x06, 0x18, 0x30,
  0x18, 0x60, 0xC0, 0x21, 0x02, 0x00, 0xC4, 0x08, 0x03, 0x30, 0x20, 0x04,
  0xC1, 0x80, 0x1B, 0x06, 0x00, 0x68, 0x10, 0x00, 0xA0, 0x40, 0x03, 0x83,
  0x00, 0x0E, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x01,
  0x80, 0xC0, 0x30, 0x06, 0x06, 0x00, 0x20, 0xC0, 0x03, 0x08, 0x00, 0x11,
  0x80, 0x01, 0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x01,
  0x60, 0x00, 0x16, 0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00,
  0x3C, 0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x44, 0x00,
  0x0C, 0x40, 0x00, 0x86, 0x00, 0x18, 0x20, 0x03, 0x03, 0x00, 0x60, 0x1C,
  0x1C, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x81, 0xC0, 0x60, 0x18, 0x18,
  0x02, 0x04, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x0C, 0x30, 0x03, 0x0C, 0x00,
  0xC2, 0x00, 0x20, 0x80, 0x18, 0x60, 0x04, 0x18, 0x03, 0x06, 0x03, 0x81,
  0xFF, 0x80, 0x7E, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x01, 0x80,
  0xC0, 0x30, 0x06, 0x06, 0x00, 0x20, 0xC0, 0x03, 0x08, 0x00, 0x11, 0x80,
  0x01, 0x10, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00, 0x16, 0x00, 0x01, 0x60,
  0x00, 0x16, 0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x3C,
  0x00, 0x02, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x44, 0x00, 0x0C,
  0x40, 0x00, 0x86, 0x00, 0x18, 0x20, 0x03, 0x03, 0x00, 0x60, 0x1C, 0x1C,
  0x00, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0x81, 0xC0, 0x60,
  0x18, 0x18, 0x02, 0x04, 0x00, 0xC1, 0x00, 0x30, 0x40, 0x0C, 0x30, 0x03,
  0x0C, 0x00, 0x82, 0x00, 0x20, 0x80, 0x18, 0x60, 0x0C, 0x18, 0x06, 0x06,
  0x07, 0x01, 0xFF, 0x00, 0x40, 0x80, 0x30, 0x20, 0x0C, 0x0C, 0x02, 0x03,
  0x00, 0x80, 0x40, 0x20, 0x18, 0x18, 0x06, 0x06, 0x00, 0x81, 0x00, 0x20,
  0x40, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00, 0x7F, 0xF0,
  0x38, 0x18, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x0C, 0x07, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x08, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x21,
  0x00, 0x02, 0x10, 0x00, 0x23, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x04,
  0x20, 0x00, 0x42, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x08, 0x60, 0x00,
  0x84, 0x00, 0x08, 0x40, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x02, 0x08, 0x00, 0x60, 0x80,
  0x06, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x07, 0x03, 0x00, 0x3F, 0xE0, 0x00,
  0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x66, 0x00,
  0x23, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x08,
  0x04, 0x04, 0x06, 0x02, 0x02, 0x01, 0x03, 0x00, 0x81, 0x00, 0x41, 0x80,
  0x20, 0x80, 0x10, 0xC0, 0x0C, 0x40, 0x06, 0x60, 0x03, 0x20, 0x01, 0xB0,
  0x00, 0xD0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x04,
  0x00, 0x78, 0x01, 0x80, 0x0F, 0x00, 0x38, 0x01, 0x60, 0x0F, 0x00, 0x6C,
  0x01, 0x60, 0x09, 0x80, 0x6C, 0x03, 0x30, 0x09, 0x80, 0x46, 0x01, 0x30,
  0x18, 0xC0, 0x66, 0x02, 0x18, 0x08, 0xC0, 0xC3, 0x03, 0x18, 0x18, 0x60,
  0x43, 0x02, 0x0C, 0x18, 0x60, 0xC1, 0x82, 0x0C, 0x10, 0x30, 0xC1, 0x86,
  0x06, 0x10, 0x10, 0x80, 0xC2, 0x02, 0x30, 0x08, 0xC0, 0x46, 0x01, 0x10,
  0x08, 0x80, 0x26, 0x01, 0x30, 0x04, 0x80, 0x24, 0x00, 0xB0, 0x05, 0x80,
  0x14, 0x00, 0xA0, 0x02, 0x80, 0x14, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x18, 0x08, 0x01, 0x80,
  0x60, 0x08, 0x03, 0x00, 0xC0, 0x08, 0x0C, 0x00, 0x40, 0x40, 0x03, 0x04,
  0x00, 0x08, 0x60, 0x00, 0x46, 0x00, 0x03, 0x20, 0x00, 0x0B, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x1B, 0x00,
  0x01, 0x98, 0x00, 0x08, 0x40, 0x00, 0xC2, 0x00, 0x0C, 0x18, 0x00, 0x40,
  0x40, 0x04, 0x02, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x20, 0x02, 0x03,
  0x00, 0x10, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x40, 0x02, 0x40, 0x06, 0x60,
  0x0C, 0x60, 0x08, 0x20, 0x18, 0x20, 0x10, 0x30, 0x30, 0x30, 0x60, 0x10,
  0x40, 0x10, 0xC0, 0x11, 0x80, 0x19, 0x00, 0x1B, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xFF, 0x00, 0x82, 0x0C, 0x30,
  0x41, 0x04, 0x10, 0x61, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x10, 0x41, 0x04,
  0x18, 0x60, 0x82, 0x08, 0x20, 0xC0, 0x01, 0xFC, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0xC0, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x38, 0x00, 0x34, 0x00, 0x13,
  0x00, 0x18, 0x80, 0x18, 0x40, 0x08, 0x30, 0x0C, 0x08, 0x04, 0x04, 0x06,
  0x03, 0x06, 0x00, 0x82, 0x00, 0x43, 0x00, 0x31, 0x00, 0x0B, 0x80, 0x06,
  0xFF, 0xF8, 0x8C, 0x46, 0x21, 0x07, 0xF3, 0x0C, 0x1A, 0x18, 0x0A, 0x30,
  0x0A, 0x30, 0x06, 0x60, 0x06, 0x60, 0x04, 0x40, 0x04, 0xC0, 0x0C, 0xC0,
  0x0C, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x18, 0x80, 0x18, 0x80, 0x18, 0x80,
  0x38, 0x80, 0x50, 0xC0, 0xD0, 0x61, 0x90, 0x3E, 0x30, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0xFC, 0x09, 0x86, 0x1A, 0x03, 0x1C, 0x01, 0x1C,
  0x01, 0x18, 0x01, 0x18, 0x01, 0x30, 0x01, 0x30, 0x01, 0x20, 0x01, 0x20,
  0x03, 0x20, 0x03, 0x60, 0x02, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60,
  0x08, 0xF0, 0x18, 0x98, 0x70, 0x8F, 0xC0, 0x03, 0xF8, 0x70, 0x46, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x1C, 0x10, 0x7F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x01, 0xFC, 0x40, 0xC1, 0xB0, 0x60, 0x3C, 0x30, 0x06, 0x0C, 0x01, 0x86,
  0x00, 0x61, 0x80, 0x18, 0x40, 0x06, 0x30, 0x01, 0x0C, 0x00, 0x42, 0x00,
  0x30, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x01, 0x82, 0x00, 0x60, 0x80, 0x38,
  0x20, 0x1E, 0x0C, 0x0D, 0x01, 0x86, 0x40, 0x3F, 0x10, 0x00, 0x03, 0xF0,
  0x38, 0x61, 0x80, 0x84, 0x03, 0x30, 0x09, 0x80, 0x24, 0x01, 0x90, 0x0C,
  0xC0, 0xE3, 0xFE, 0x0E, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x07, 0x06, 0x07, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0xC4, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x09, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x40, 0xE1, 0x90, 0x60, 0x3C, 0x30,
  0x06, 0x0C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x40, 0x06, 0x30, 0x01,
  0x0C, 0x00, 0x42, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x01, 0x82,
  0x00, 0x60, 0x80, 0x38, 0x20, 0x1E, 0x0C, 0x0D, 0x01, 0x86, 0x40, 0x3F,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x0C, 0x08, 0x02, 0x03, 0x87, 0x00, 0x3F, 0x80, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0xFC, 0x09, 0x86, 0x0A, 0x03, 0x1C, 0x03,
  0x18, 0x03, 0x18, 0x03, 0x10, 0x02, 0x30, 0x02, 0x30, 0x02, 0x30, 0x06,
  0x20, 0x06, 0x20, 0x04, 0x60, 0x04, 0x60, 0x0C, 0x40, 0x0C, 0x40, 0x0C,
  0x40, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0x80, 0x18, 0x06, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0x40,
  0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x26, 0x01, 0xE0, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x01, 0x08, 0x06, 0x08, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x18, 0x60, 0x10,
  0x40, 0x10, 0x80, 0x31, 0x00, 0x33, 0x00, 0x25, 0x00, 0x29, 0x00, 0x31,
  0x80, 0x60, 0x80, 0x60, 0xC0, 0x40, 0xC0, 0x40, 0x40, 0x40, 0x60, 0xC0,
  0x60, 0xC0, 0x20, 0x80, 0x30, 0x02, 0x04, 0x18, 0x30, 0x40, 0x81, 0x06,
  0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C,
  0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x00, 0x08, 0xFC, 0x3F, 0x05, 0x86,
  0x20, 0xC2, 0x81, 0xA0, 0x23, 0x80, 0xE0, 0x11, 0x80, 0x70, 0x08, 0xC0,
  0x30, 0x04, 0x40, 0x18, 0x02, 0x60, 0x08, 0x03, 0x30, 0x04, 0x01, 0x98,
  0x02, 0x00, 0x88, 0x03, 0x00, 0x44, 0x01, 0x80, 0x26, 0x00, 0x80, 0x33,
  0x00, 0x40, 0x19, 0x00, 0x60, 0x08, 0x80, 0x30, 0x04, 0x40, 0x10, 0x06,
  0x60, 0x08, 0x03, 0x30, 0x04, 0x01, 0x90, 0x06, 0x00, 0x80, 0x08, 0xFC,
  0x09, 0x06, 0x1A, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x02,
  0x30, 0x02, 0x30, 0x02, 0x30, 0x06, 0x20, 0x06, 0x20, 0x04, 0x60, 0x04,
  0x60, 0x0C, 0x40, 0x0C, 0x40, 0x0C, 0x40, 0x08, 0xC0, 0x08, 0xC0, 0x18,
  0x80, 0x18, 0x03, 0xF8, 0x1C, 0x18, 0x60, 0x11, 0x80, 0x33, 0x00, 0x6C,
  0x00, 0x58, 0x00, 0xA0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x28, 0x00, 0x50, 0x01, 0xA0, 0x02, 0x40, 0x0C, 0xC0, 0x10, 0x80, 0x61,
  0x83, 0x81, 0xFC, 0x00, 0x02, 0x3F, 0x00, 0x98, 0x60, 0x28, 0x0C, 0x1C,
  0x01, 0x07, 0x00, 0x41, 0x80, 0x10, 0x60, 0x04, 0x30, 0x01, 0x0C, 0x00,
  0x43, 0x00, 0x10, 0x80, 0x0C, 0x20, 0x03, 0x18, 0x00, 0x86, 0x00, 0x61,
  0x80, 0x18, 0x60, 0x0C, 0x18, 0x02, 0x0F, 0x01, 0x83, 0x61, 0xC0, 0x8F,
  0xC0, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF1,
  0x0E, 0x19, 0x18, 0x0F, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x40, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x0C,
  0x80, 0x18, 0x80, 0x18, 0x80, 0x38, 0x80, 0x78, 0xC0, 0xD0, 0x61, 0x90,
  0x3F, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x08, 0xF8, 0x48, 0x02,
  0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x07, 0xFC, 0x30, 0x21, 0x80, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x8C, 0x0C, 0x1F, 0xE0, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x1F, 0xF0,
  0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x01, 0x00, 0x7C, 0x00,
  0x10, 0x03, 0x10, 0x02, 0x30, 0x02, 0x30, 0x06, 0x20, 0x06, 0x20, 0x04,
  0x60, 0x04, 0x60, 0x04, 0x40, 0x0C, 0x40, 0x0C, 0x40, 0x08, 0xC0, 0x08,
  0xC0, 0x18, 0x80, 0x18, 0x80, 0x38, 0x80, 0x30, 0x80, 0x50, 0x80, 0xD0,
  0xC1, 0xB0, 0x7E, 0x20, 0x80, 0x0F, 0x00, 0x2C, 0x01, 0xB0, 0x04, 0xC0,
  0x31, 0x01, 0x84, 0x06, 0x10, 0x30, 0x40, 0x81, 0x06, 0x04, 0x10, 0x18,
  0xC0, 0x62, 0x01, 0x98, 0x06, 0x40, 0x1B, 0x00, 0x28, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x2C, 0x07, 0x01, 0xB0,
  0x14, 0x04, 0xC0, 0xD0, 0x13, 0x02, 0x40, 0xCC, 0x19, 0x02, 0x30, 0x44,
  0x18, 0xC3, 0x10, 0x41, 0x08, 0x43, 0x04, 0x61, 0x08, 0x11, 0x04, 0x60,
  0x44, 0x19, 0x01, 0x20, 0x64, 0x04, 0x81, 0xB0, 0x16, 0x06, 0x80, 0x50,
  0x1E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x0C, 0x01,
  0x82, 0x01, 0x81, 0x81, 0x80, 0xC0, 0x80, 0x20, 0x80, 0x18, 0xC0, 0x04,
  0xC0, 0x02, 0x40, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x68, 0x00,
  0x64, 0x00, 0x23, 0x00, 0x20, 0x80, 0x30, 0x60, 0x30, 0x30, 0x10, 0x08,
  0x10, 0x06, 0x18, 0x03, 0x00, 0x03, 0x00, 0x30, 0x30, 0x02, 0x01, 0x00,
  0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x10, 0x08, 0x01, 0x01, 0x80, 0x10,
  0x10, 0x01, 0x83, 0x00, 0x18, 0x20, 0x01, 0x86, 0x00, 0x08, 0x40, 0x00,
  0x8C, 0x00, 0x08, 0x80, 0x00, 0x98, 0x00, 0x09, 0x00, 0x00, 0xB0, 0x00,
  0x0A, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x03, 0x80,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x0C, 0x00, 0x18, 0x03, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x07, 0x00, 0xE0, 0x00, 0x3F, 0x01, 0xC3, 0xC3, 0x80, 0x7E,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 27, 8, 1, -27 },
  { 28, 9, 10, 12, 4, -27 },
  { 40, 20, 27, 20, 1, -27 },
  { 108, 17, 31, 18, 1, -29 },
  { 174, 21, 28, 26, 3, -28 },
  { 248, 19, 28, 21, 1, -28 },
  { 315, 3, 10, 7, 4, -27 },
  { 319, 11, 33, 9, 1, -27 },
  { 365, 11, 33, 9, -3, -27 },
  { 411, 13, 14, 17, 5, -29 },
  { 434, 16, 17, 19, 2, -22 },
  { 468, 6, 9, 7, -2, -4 },
  { 475, 9, 1, 11, 1, -11 },
  { 477, 2, 3, 8, 1, -3 },
  { 478, 17, 27, 12, -2, -27 },
  { 536, 16, 28, 18, 2, -28 },
  { 592, 9, 27, 18, 5, -27 },
  { 623, 17, 28, 18, 0, -28 },
  { 683, 18, 28, 18, 0, -28 },
  { 746, 17, 27, 18, 0, -27 },
  { 804, 17, 27, 18, 1, -27 },
  { 862, 16, 28, 18, 2, -28 },
  { 918, 16, 27, 18, 3, -27 },
  { 972, 17, 28, 18, 1, -28 },
  { 1032, 16, 28, 18, 1, -28 },
  { 1088, 6, 20, 8, 1, -20 },
  { 1103, 9, 25, 8, -2, -20 },
  { 1132, 16, 17, 19, 2, -22 },
  { 1166, 16, 9, 19, 2, -18 },
  { 1184, 16, 17, 19, 2, -22 },
  { 1218, 12, 28, 13, 2, -28 },
  { 1260, 25, 30, 27, 2, -27 },
  { 1354, 18, 27, 18, -2, -27 },
  { 1415, 18, 27, 20, 1, -27 },
  { 1476, 19, 28, 19, 2, -28 },
  { 1543, 20, 27, 22, 1, -27 },
  { 1611, 18, 27, 18, 1, -27 },
  { 1672, 18, 27, 16, 1, -27 },
  { 1733, 21, 28, 23, 2, -28 },
  { 1807, 22, 27, 23, 1, -27 },
  { 1882, 13, 27, 10, -1, -27 },
  { 1926, 14, 34, 8, -6, -27 },
  { 1986, 20, 27, 18, 1, -27 },
  { 2054, 12, 27, 16, 1, -27 },
  { 2095, 27, 27, 28, 1, -27 },
  { 2187, 22, 27, 23, 1, -27 },
  { 2262, 20, 28, 24, 2, -28 },
  { 2332, 18, 27, 19, 1, -27 },
  { 2393, 20, 34, 24, 2, -28 },
  { 2478, 18, 27, 19, 1, -27 },
  { 2539, 18, 28, 17, 0, -28 },
  { 2602, 16, 27, 16, 3, -27 },
  { 2656, 20, 27, 23, 3, -27 },
  { 2724, 17, 27, 18, 4, -27 },
  { 2782, 27, 27, 29, 4, -27 },
  { 2874, 21, 27, 16, -2, -27 },
  { 2945, 16, 27, 16, 3, -27 },
  { 2999, 20, 27, 17, -1, -27 },
  { 3067, 15, 33, 11, -1, -27 },
  { 3129, 6, 27, 12, 4, -27 },
  { 3150, 14, 33, 11, -3, -27 },
  { 3208, 17, 15, 19, 1, -27 },
  { 3240, 13, 1, 13, -3, 4 },
  { 3242, 4, 6, 9, 6, -29 },
  { 3245, 16, 20, 19, 2, -20 },
  { 3285, 16, 29, 19, 1, -29 },
  { 3343, 13, 20, 15, 2, -20 },
  { 3376, 18, 29, 19, 2, -29 },
  { 3442, 14, 20, 17, 2, -20 },
  { 3477, 19, 38, 9, -5, -29 },
  { 3568, 18, 29, 19, 0, -20 },
  { 3634, 16, 29, 19, 1, -29 },
  { 3692, 7, 27, 7, 1, -27 },
  { 3716, 13, 36, 8, -5, -27 },
  { 3775, 16, 29, 15, 1, -29 },
  { 3833, 7, 29, 7, 1, -29 },
  { 3859, 25, 20, 28, 1, -20 },
  { 3922, 16, 20, 19, 1, -20 },
  { 3962, 15, 20, 19, 2, -20 },
  { 4000, 18, 29, 19, -1, -20 },
  { 4066, 16, 29, 19, 2, -20 },
  { 4124, 13, 20, 12, 1, -20 },
  { 4157, 14, 20, 14, 0, -20 },
  { 4192, 10, 25, 10, 1, -25 },
  { 4224, 16, 20, 19, 2, -20 },
  { 4264, 14, 20, 14, 2, -20 },
  { 4299, 22, 20, 23, 2, -20 },
  { 4354, 17, 20, 15, -1, -20 },
  { 4397, 20, 29, 14, -4, -20 },
  { 4470, 15, 20, 14, -1, -20 },
  { 4508, 14, 33, 12, 1, -27 },
  { 4566, 1, 38, 18, 9, -29 },
  { 4571, 13, 33, 12, -2, -27 },
  { 4625, 16, 3, 19, 2, -15 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC38PT7B_H_
