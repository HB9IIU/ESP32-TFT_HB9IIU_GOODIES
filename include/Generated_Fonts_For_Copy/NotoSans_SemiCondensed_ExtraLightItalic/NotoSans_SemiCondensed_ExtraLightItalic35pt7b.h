#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81,
  0x02, 0x0C, 0x10, 0x20, 0x41, 0x80, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x63,
  0x42, 0x42, 0x46, 0x44, 0xC4, 0x84, 0x84, 0x8C, 0x00, 0x41, 0x00, 0x30,
  0x40, 0x08, 0x30, 0x02, 0x08, 0x01, 0x82, 0x00, 0x40, 0x80, 0x10, 0x40,
  0x04, 0x10, 0x3F, 0xFF, 0xC0, 0x83, 0x00, 0x20, 0x80, 0x18, 0x20, 0x04,
  0x18, 0x01, 0x04, 0x00, 0xC1, 0x00, 0x20, 0x40, 0xFF, 0xFF, 0x02, 0x08,
  0x01, 0x02, 0x00, 0x41, 0x80, 0x10, 0x40, 0x0C, 0x10, 0x02, 0x04, 0x00,
  0x82, 0x00, 0x60, 0x80, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x07,
  0x80, 0x3F, 0xE1, 0x88, 0x42, 0x10, 0x0C, 0x20, 0x10, 0x40, 0x21, 0x00,
  0x62, 0x00, 0xC4, 0x00, 0xC8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0xF0, 0x01,
  0x30, 0x02, 0x30, 0x0C, 0x60, 0x10, 0x40, 0x21, 0x80, 0x42, 0x00, 0x8C,
  0x42, 0x30, 0xFF, 0xC0, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x00,
  0x0F, 0x80, 0x21, 0x88, 0x04, 0x10, 0xC0, 0xC2, 0x0C, 0x08, 0x20, 0xC1,
  0x06, 0x0C, 0x30, 0x40, 0x82, 0x04, 0x08, 0x40, 0x40, 0x8C, 0x04, 0x08,
  0x80, 0xC1, 0x91, 0xEC, 0x13, 0x23, 0x43, 0x26, 0x14, 0x64, 0x41, 0x3C,
  0xCC, 0x10, 0x08, 0x81, 0x01, 0x88, 0x10, 0x11, 0x81, 0x02, 0x18, 0x30,
  0x61, 0x02, 0x04, 0x10, 0x20, 0x81, 0x06, 0x18, 0x10, 0x41, 0x01, 0x8C,
  0x20, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0x86, 0x00, 0x81, 0x00, 0xC0, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x30, 0x08, 0x10, 0x06, 0x10, 0x01, 0x30,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0x78, 0x00, 0xC4, 0x00, 0xC3, 0x02, 0xC0,
  0x83, 0x40, 0x61, 0x60, 0x19, 0xA0, 0x04, 0x90, 0x03, 0x88, 0x00, 0xC4,
  0x00, 0xE3, 0x00, 0xD0, 0xC1, 0x8C, 0x3F, 0x83, 0x00, 0x69, 0x25, 0xA4,
  0x80, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00,
  0x60, 0x08, 0x02, 0x00, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02,
  0x01, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x00, 0x02, 0x00, 0x08, 0x00, 0x41,
  0x06, 0x0E, 0x20, 0x19, 0x00, 0x3B, 0xE0, 0xE0, 0x0A, 0x00, 0x88, 0x08,
  0x40, 0x81, 0x00, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x08, 0x46, 0x23, 0x11, 0x88, 0xC0, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0xF0,
  0x18, 0x60, 0xC0, 0xC6, 0x01, 0x10, 0x04, 0xC0, 0x12, 0x00, 0x48, 0x01,
  0x60, 0x05, 0x00, 0x14, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x80, 0x1A, 0x00, 0x48, 0x03, 0x20, 0x0C, 0x80, 0x62, 0x01,
  0x0C, 0x0C, 0x18, 0x60, 0x3F, 0x00, 0x03, 0x07, 0x1A, 0x32, 0xC2, 0x86,
  0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10,
  0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x01, 0xFC, 0x07, 0x06, 0x04,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0x0F,
  0x06, 0x04, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1C, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0xC0, 0x60, 0x7F, 0xC0, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1A, 0x00, 0x12, 0x00, 0x26, 0x00,
  0x46, 0x00, 0xC4, 0x01, 0x84, 0x01, 0x04, 0x02, 0x0C, 0x06, 0x08, 0x0C,
  0x08, 0x08, 0x08, 0x10, 0x18, 0x20, 0x18, 0x60, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x03, 0xFF, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x1F, 0xC0, 0x38,
  0x70, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x80,
  0xC0, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x3F, 0x82,
  0xC1, 0x8E, 0x01, 0x18, 0x03, 0x30, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00,
  0x32, 0x00, 0x64, 0x00, 0x88, 0x03, 0x18, 0x04, 0x10, 0x18, 0x30, 0x60,
  0x3F, 0x00, 0x7F, 0xFC, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x01, 0xF8,
  0x0C, 0x18, 0x10, 0x08, 0x40, 0x10, 0x80, 0x21, 0x00, 0x42, 0x00, 0x84,
  0x03, 0x0C, 0x04, 0x08, 0x30, 0x08, 0xC0, 0x0E, 0x00, 0x7C, 0x03, 0x8C,
  0x0C, 0x0C, 0x30, 0x0C, 0x40, 0x09, 0x80, 0x12, 0x00, 0x24, 0x00, 0x48,
  0x00, 0x98, 0x03, 0x10, 0x0C, 0x30, 0x30, 0x1F, 0xC0, 0x03, 0xF8, 0x0C,
  0x18, 0x30, 0x10, 0x40, 0x31, 0x00, 0x62, 0x00, 0x4C, 0x00, 0x90, 0x01,
  0x20, 0x02, 0x40, 0x0C, 0x80, 0x19, 0x00, 0x73, 0x01, 0xC3, 0x06, 0x83,
  0xFB, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0xFE, 0x00, 0x08, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x30, 0x01, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x18, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0x80, 0x00, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0x84, 0x18, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0xC0,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xC1, 0xC0, 0x0E, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x00,
  0xC3, 0x00, 0x00, 0x84, 0x00, 0x01, 0x18, 0x0F, 0x82, 0x20, 0x61, 0x84,
  0xC1, 0x82, 0x0D, 0x06, 0x04, 0x16, 0x08, 0x18, 0x28, 0x30, 0x20, 0x50,
  0x40, 0x40, 0xA0, 0x80, 0x83, 0x43, 0x03, 0x04, 0x86, 0x04, 0x09, 0x0C,
  0x18, 0x32, 0x18, 0x30, 0xC4, 0x10, 0xB3, 0x08, 0x1E, 0x3C, 0x10, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x10, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x02, 0xC0, 0x01, 0x20, 0x01, 0x10, 0x00, 0x88, 0x00, 0x84,
  0x00, 0xC2, 0x00, 0x41, 0x00, 0x60, 0x80, 0x20, 0x40, 0x30, 0x20, 0x10,
  0x18, 0x1F, 0xFC, 0x0F, 0xFE, 0x0C, 0x01, 0x04, 0x00, 0x86, 0x00, 0x42,
  0x00, 0x23, 0x00, 0x11, 0x00, 0x09, 0x80, 0x04, 0x80, 0x02, 0xC0, 0x01,
  0x80, 0x07, 0xFC, 0x02, 0x03, 0x81, 0x00, 0x40, 0x80, 0x30, 0xC0, 0x18,
  0x60, 0x0C, 0x20, 0x06, 0x10, 0x02, 0x08, 0x01, 0x0C, 0x01, 0x06, 0x03,
  0x03, 0xFF, 0x01, 0x0F, 0x80, 0x80, 0x60, 0xC0, 0x18, 0x40, 0x0C, 0x20,
  0x02, 0x10, 0x01, 0x18, 0x00, 0x8C, 0x00, 0xC4, 0x00, 0x42, 0x00, 0x61,
  0x00, 0x61, 0x80, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x70, 0x20,
  0x30, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x20, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0x07, 0x80, 0x40, 0x30, 0x10,
  0x06, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x04, 0x20, 0x01, 0x08, 0x00,
  0x46, 0x00, 0x11, 0x80, 0x04, 0x40, 0x01, 0x10, 0x00, 0x44, 0x00, 0x33,
  0x00, 0x0C, 0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x46, 0x00, 0x31, 0x80,
  0x08, 0x40, 0x06, 0x10, 0x03, 0x04, 0x03, 0x03, 0x07, 0x80, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F,
  0xF8, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x30, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x38, 0x1C, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x7F, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00, 0x23,
  0x00, 0x04, 0x20, 0x01, 0x84, 0x00, 0x20, 0xC0, 0x04, 0x0C, 0x00, 0x80,
  0xC0, 0x70, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x10, 0x40, 0x03, 0x04, 0x00,
  0x20, 0x40, 0x02, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x08, 0x00, 0x60, 0x80,
  0x04, 0x08, 0x00, 0x41, 0x80, 0x04, 0x18, 0x00, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x81, 0x00, 0x08, 0x30, 0x00, 0x82, 0x00, 0x18, 0x20, 0x01, 0x02,
  0x00, 0x10, 0x60, 0x01, 0x06, 0x00, 0x30, 0x40, 0x03, 0x04, 0x00, 0x20,
  0x40, 0x02, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x00, 0x07, 0xF0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x80, 0x30, 0x10, 0x0C,
  0x02, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x02, 0x0C, 0x00, 0x43, 0x00,
  0x08, 0xC0, 0x03, 0x10, 0x00, 0x64, 0x00, 0x09, 0x80, 0x01, 0x58, 0x00,
  0x31, 0x00, 0x0C, 0x30, 0x01, 0x06, 0x00, 0x20, 0x40, 0x04, 0x0C, 0x01,
  0x80, 0x80, 0x30, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x10, 0x06, 0x06,
  0x00, 0x40, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0xFF, 0xE0, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0xA0, 0xD0, 0x00, 0xD0, 0x68, 0x00, 0x58, 0x24,
  0x00, 0x68, 0x12, 0x00, 0x24, 0x09, 0x00, 0x32, 0x0C, 0x80, 0x13, 0x04,
  0x60, 0x11, 0x82, 0x30, 0x18, 0x81, 0x08, 0x08, 0x40, 0x84, 0x0C, 0x20,
  0xC2, 0x04, 0x30, 0x41, 0x06, 0x18, 0x20, 0x82, 0x08, 0x10, 0x43, 0x04,
  0x18, 0x31, 0x02, 0x0C, 0x19, 0x03, 0x04, 0x04, 0x81, 0x82, 0x02, 0x80,
  0x81, 0x01, 0xC0, 0x41, 0x80, 0xC0, 0x20, 0xC0, 0x60, 0x30, 0x00, 0x06,
  0x00, 0x10, 0x60, 0x01, 0x07, 0x00, 0x30, 0x50, 0x03, 0x0D, 0x00, 0x20,
  0xD8, 0x02, 0x08, 0x80, 0x20, 0x88, 0x06, 0x08, 0xC0, 0x41, 0x84, 0x04,
  0x18, 0x40, 0x41, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x02, 0x08, 0x30, 0x30,
  0x82, 0x03, 0x08, 0x20, 0x11, 0x82, 0x01, 0x98, 0x60, 0x19, 0x06, 0x00,
  0x90, 0x40, 0x0D, 0x04, 0x00, 0xF0, 0x40, 0x07, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x60, 0x18, 0x02, 0x06, 0x00, 0x61,
  0x80, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0x6C,
  0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x24, 0x00, 0x05, 0x80, 0x00, 0xB0,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x98, 0x00, 0x33, 0x00, 0x04, 0x20,
  0x01, 0x84, 0x00, 0x20, 0xC0, 0x0C, 0x08, 0x03, 0x01, 0xC1, 0xC0, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x04, 0x0E, 0x04, 0x02, 0x04, 0x03, 0x0C, 0x01,
  0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x01, 0x18, 0x03, 0x18, 0x02,
  0x10, 0x04, 0x10, 0x18, 0x1F, 0xF0, 0x3F, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x60, 0x18, 0x02, 0x06,
  0x00, 0x61, 0x80, 0x04, 0x20, 0x00, 0x8C, 0x00, 0x19, 0x00, 0x03, 0x20,
  0x00, 0x6C, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x24, 0x00, 0x05, 0x80,
  0x00, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x98, 0x00, 0x33, 0x00,
  0x04, 0x20, 0x01, 0x84, 0x00, 0x20, 0xC0, 0x0C, 0x08, 0x03, 0x01, 0xC1,
  0xC0, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x04, 0x0E, 0x04, 0x02,
  0x04, 0x03, 0x0C, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x08, 0x03,
  0x18, 0x02, 0x18, 0x06, 0x10, 0x0C, 0x10, 0x38, 0x1F, 0xE0, 0x30, 0x40,
  0x20, 0x40, 0x20, 0x60, 0x20, 0x20, 0x60, 0x20, 0x60, 0x30, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x08, 0x01, 0xFE, 0x03, 0x03,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x60, 0x7F, 0xC0, 0xFF, 0xFE,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x21,
  0x00, 0x0C, 0x20, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x04, 0x20, 0x00, 0x84,
  0x00, 0x30, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x10, 0x80, 0x02, 0x10,
  0x00, 0xC6, 0x00, 0x10, 0xC0, 0x02, 0x10, 0x00, 0x42, 0x00, 0x18, 0x40,
  0x03, 0x18, 0x00, 0x43, 0x00, 0x08, 0x60, 0x03, 0x0C, 0x00, 0x40, 0x80,
  0x18, 0x18, 0x06, 0x01, 0x81, 0x80, 0x1F, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x40, 0x02, 0x40, 0x06, 0x40, 0x04, 0x40, 0x0C, 0x40, 0x08, 0x40,
  0x18, 0x40, 0x10, 0x40, 0x30, 0x40, 0x20, 0x60, 0x60, 0x60, 0x40, 0x60,
  0xC0, 0x60, 0x80, 0x21, 0x80, 0x21, 0x00, 0x23, 0x00, 0x22, 0x00, 0x26,
  0x00, 0x24, 0x00, 0x2C, 0x00, 0x28, 0x00, 0x38, 0x00, 0x30, 0x00, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xA0, 0x06, 0x00, 0xD0, 0x05, 0x00, 0x48,
  0x02, 0x80, 0x64, 0x03, 0x40, 0x22, 0x01, 0x20, 0x31, 0x01, 0x90, 0x10,
  0x80, 0x88, 0x08, 0x40, 0xC4, 0x0C, 0x20, 0x42, 0x04, 0x10, 0x61, 0x06,
  0x08, 0x20, 0x82, 0x04, 0x10, 0x43, 0x02, 0x18, 0x21, 0x01, 0x08, 0x10,
  0x80, 0x8C, 0x08, 0xC0, 0x44, 0x04, 0x40, 0x36, 0x02, 0x60, 0x1A, 0x01,
  0x20, 0x0D, 0x00, 0xB0, 0x05, 0x00, 0x50, 0x02, 0x80, 0x28, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x30, 0x30, 0x06, 0x01,
  0x00, 0xC0, 0x10, 0x08, 0x01, 0x81, 0x00, 0x08, 0x30, 0x00, 0x82, 0x00,
  0x0C, 0x40, 0x00, 0x4C, 0x00, 0x05, 0x80, 0x00, 0x50, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xB0, 0x00, 0x11, 0x00, 0x03, 0x10,
  0x00, 0x61, 0x80, 0x04, 0x08, 0x00, 0x80, 0x80, 0x18, 0x08, 0x03, 0x00,
  0xC0, 0x20, 0x04, 0x06, 0x00, 0x40, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x80,
  0x19, 0x00, 0x22, 0x00, 0xC6, 0x03, 0x0C, 0x04, 0x08, 0x18, 0x10, 0x20,
  0x20, 0x80, 0x63, 0x00, 0x44, 0x00, 0x90, 0x01, 0x60, 0x02, 0x80, 0x07,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x84, 0x21, 0x08, 0x61,
  0x08, 0x42, 0x10, 0xC2, 0x10, 0x84, 0x21, 0x84, 0x21, 0x08, 0x43, 0x08,
  0x03, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x02, 0x80, 0x09, 0x00, 0x31,
  0x00, 0x42, 0x01, 0x86, 0x06, 0x04, 0x08, 0x08, 0x30, 0x18, 0x40, 0x11,
  0x00, 0x26, 0x00, 0x78, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xC4, 0x62, 0x31,
  0x01, 0xE2, 0x0E, 0x64, 0x30, 0x28, 0xC0, 0x51, 0x00, 0xE6, 0x00, 0x88,
  0x01, 0x30, 0x06, 0x60, 0x0C, 0x80, 0x11, 0x00, 0x22, 0x00, 0x4C, 0x01,
  0x98, 0x03, 0x10, 0x0C, 0x20, 0x18, 0x40, 0x50, 0xC3, 0x20, 0xFC, 0xC0,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0xF0, 0x33, 0x38, 0x78, 0x10, 0xA0, 0x31, 0x80,
  0x23, 0x00, 0x4C, 0x00, 0x98, 0x01, 0x20, 0x06, 0x40, 0x0C, 0x80, 0x13,
  0x00, 0x26, 0x00, 0xCC, 0x01, 0x98, 0x02, 0x70, 0x08, 0xA0, 0x31, 0x20,
  0xC2, 0x3F, 0x00, 0x03, 0xE0, 0xE3, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x08, 0x3F, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x01, 0xE3, 0x03, 0x9D, 0x83, 0x02, 0x83, 0x00, 0xC1, 0x00, 0x61,
  0x80, 0x30, 0x80, 0x10, 0xC0, 0x08, 0x40, 0x04, 0x20, 0x06, 0x10, 0x03,
  0x08, 0x01, 0x0C, 0x01, 0x86, 0x00, 0xC1, 0x00, 0xE0, 0x80, 0x70, 0x40,
  0x50, 0x30, 0xC8, 0x0F, 0xC4, 0x00, 0x03, 0xC0, 0xE7, 0x18, 0x13, 0x01,
  0x20, 0x16, 0x01, 0x40, 0x3C, 0x06, 0xC1, 0xCF, 0xF0, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x04, 0x3F, 0x80, 0x00,
  0x07, 0x80, 0x0E, 0x40, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x81, 0xCE, 0xC1, 0x81, 0x41, 0x80, 0x60, 0x80,
  0x30, 0xC0, 0x18, 0x40, 0x08, 0x60, 0x04, 0x20, 0x02, 0x10, 0x03, 0x08,
  0x01, 0x84, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x60, 0x80, 0x70, 0x40, 0x38,
  0x20, 0x28, 0x18, 0x24, 0x07, 0xE2, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x40, 0x60, 0x1F, 0xE0, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x08, 0xF0, 0x66, 0x71, 0xE0, 0x45, 0x01, 0x18, 0x04, 0x60,
  0x13, 0x00, 0x4C, 0x01, 0x20, 0x0C, 0x80, 0x32, 0x00, 0x98, 0x02, 0x40,
  0x09, 0x00, 0x64, 0x01, 0x30, 0x04, 0xC0, 0x12, 0x00, 0xC8, 0x03, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x00, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x06,
  0x08, 0x10, 0x20, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0x80, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x01, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x04, 0x60, 0x21, 0x81, 0x04,
  0x08, 0x10, 0x40, 0x42, 0x03, 0x18, 0x08, 0xC0, 0x26, 0x00, 0xB8, 0x03,
  0xB0, 0x1C, 0x40, 0x61, 0x81, 0x06, 0x04, 0x08, 0x30, 0x30, 0xC0, 0x42,
  0x01, 0x08, 0x06, 0x00, 0x06, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08,
  0x30, 0x60, 0x81, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10,
  0x60, 0xC1, 0x02, 0x00, 0x08, 0xF0, 0x78, 0x37, 0x71, 0x9C, 0x58, 0x24,
  0x08, 0xA0, 0x50, 0x11, 0x80, 0xC0, 0x22, 0x01, 0x80, 0x4C, 0x02, 0x00,
  0x98, 0x04, 0x03, 0x20, 0x08, 0x06, 0x40, 0x30, 0x08, 0x80, 0x60, 0x13,
  0x00, 0x80, 0x24, 0x01, 0x00, 0xC8, 0x02, 0x01, 0x90, 0x0C, 0x02, 0x60,
  0x10, 0x04, 0xC0, 0x20, 0x09, 0x00, 0x40, 0x32, 0x01, 0x80, 0x40, 0x08,
  0xF0, 0x6E, 0x71, 0x60, 0x45, 0x01, 0x18, 0x04, 0x60, 0x13, 0x00, 0x4C,
  0x01, 0x20, 0x0C, 0x80, 0x32, 0x00, 0x98, 0x02, 0x40, 0x09, 0x00, 0x64,
  0x01, 0x30, 0x04, 0xC0, 0x12, 0x00, 0xC8, 0x03, 0x00, 0x03, 0xC0, 0x39,
  0xC1, 0x81, 0x8C, 0x02, 0x20, 0x0D, 0x80, 0x34, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x1A, 0x00, 0x48, 0x03, 0x20,
  0x08, 0xC0, 0x61, 0x83, 0x03, 0xF0, 0x00, 0x02, 0x3C, 0x03, 0x33, 0x81,
  0x20, 0x40, 0xA0, 0x30, 0x60, 0x08, 0x30, 0x04, 0x30, 0x02, 0x18, 0x01,
  0x08, 0x01, 0x84, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x21, 0x80, 0x10, 0xC0,
  0x18, 0x60, 0x08, 0x70, 0x0C, 0x38, 0x0C, 0x12, 0x0C, 0x08, 0xFC, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE1, 0x07, 0x3B, 0x0C, 0x0A, 0x18,
  0x06, 0x10, 0x06, 0x30, 0x06, 0x20, 0x04, 0x60, 0x04, 0x60, 0x04, 0x40,
  0x0C, 0x40, 0x0C, 0x40, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0x40, 0x38, 0x40,
  0x38, 0x40, 0x50, 0x60, 0x90, 0x3F, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x08,
  0xF1, 0xBA, 0x16, 0x01, 0x40, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x73, 0xC6, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x08, 0x00, 0x44, 0x04, 0x1F, 0xC0, 0x04,
  0x06, 0x02, 0x01, 0x01, 0xFB, 0xFC, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x04,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x01,
  0xF0, 0x30, 0x04, 0xC0, 0x12, 0x00, 0xC8, 0x03, 0x20, 0x09, 0x80, 0x26,
  0x00, 0x90, 0x06, 0x40, 0x19, 0x00, 0x4C, 0x01, 0x20, 0x0C, 0x80, 0x32,
  0x00, 0x88, 0x06, 0x20, 0x18, 0x80, 0xA3, 0x0D, 0x87, 0xE4, 0x00, 0x80,
  0x1C, 0x00, 0xA0, 0x0D, 0x00, 0x4C, 0x06, 0x60, 0x23, 0x03, 0x18, 0x10,
  0x41, 0x82, 0x08, 0x10, 0x80, 0x84, 0x04, 0x40, 0x26, 0x01, 0x20, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x08, 0x00, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80,
  0x60, 0x28, 0x0A, 0x06, 0x80, 0xA0, 0x48, 0x12, 0x04, 0x81, 0x20, 0xCC,
  0x22, 0x08, 0xC2, 0x21, 0x8C, 0x62, 0x10, 0xC4, 0x23, 0x0C, 0xC2, 0x20,
  0xC8, 0x22, 0x0D, 0x82, 0x40, 0xD0, 0x34, 0x07, 0x03, 0xC0, 0x60, 0x38,
  0x06, 0x03, 0x80, 0x40, 0x10, 0x00, 0x08, 0x03, 0x0C, 0x06, 0x04, 0x04,
  0x04, 0x08, 0x06, 0x18, 0x02, 0x30, 0x02, 0x20, 0x03, 0x40, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x04, 0xC0, 0x08, 0x40, 0x18, 0x60,
  0x30, 0x20, 0x20, 0x20, 0x40, 0x30, 0xC0, 0x10, 0x02, 0x00, 0x20, 0x60,
  0x08, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x10, 0x18, 0x02, 0x02, 0x00, 0x40,
  0xC0, 0x08, 0x10, 0x01, 0x06, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0xC4,
  0x00, 0x19, 0x80, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x05, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x04, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x70, 0x0C, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x70, 0x0E, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0xC0, 0x04, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x60, 0x01, 0xA0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x80, 0x78, 0x02, 0x00, 0x00, 0x3E, 0x03, 0x87, 0x0E, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 25, 8, 1, -25 },
  { 23, 8, 9, 11, 4, -25 },
  { 32, 18, 25, 19, 1, -25 },
  { 89, 15, 29, 17, 1, -27 },
  { 144, 20, 25, 24, 2, -25 },
  { 207, 17, 25, 20, 1, -25 },
  { 261, 3, 9, 6, 4, -25 },
  { 265, 10, 31, 9, 1, -25 },
  { 304, 10, 31, 9, -2, -25 },
  { 343, 13, 14, 16, 4, -27 },
  { 366, 15, 16, 18, 2, -20 },
  { 396, 5, 9, 7, -2, -4 },
  { 402, 8, 1, 10, 1, -10 },
  { 403, 2, 2, 7, 1, -2 },
  { 404, 16, 25, 11, -2, -25 },
  { 454, 14, 25, 17, 2, -25 },
  { 498, 8, 25, 17, 5, -25 },
  { 523, 16, 25, 17, 0, -25 },
  { 573, 16, 25, 17, 0, -25 },
  { 623, 16, 25, 17, 0, -25 },
  { 673, 16, 25, 17, 1, -25 },
  { 723, 15, 25, 17, 2, -25 },
  { 770, 14, 25, 17, 3, -25 },
  { 814, 15, 25, 17, 1, -25 },
  { 861, 15, 25, 17, 1, -25 },
  { 908, 5, 19, 7, 1, -19 },
  { 920, 8, 24, 7, -2, -19 },
  { 944, 15, 15, 18, 2, -20 },
  { 973, 15, 9, 18, 2, -17 },
  { 990, 15, 15, 18, 2, -20 },
  { 1019, 11, 25, 12, 2, -25 },
  { 1054, 23, 28, 25, 2, -25 },
  { 1135, 17, 25, 17, -2, -25 },
  { 1189, 17, 25, 18, 1, -25 },
  { 1243, 18, 25, 18, 2, -25 },
  { 1300, 18, 25, 20, 1, -25 },
  { 1357, 16, 25, 16, 1, -25 },
  { 1407, 16, 25, 15, 1, -25 },
  { 1457, 19, 25, 21, 2, -25 },
  { 1517, 20, 25, 21, 1, -25 },
  { 1580, 12, 25, 9, -1, -25 },
  { 1618, 14, 31, 7, -6, -25 },
  { 1673, 19, 25, 17, 1, -25 },
  { 1733, 11, 25, 15, 1, -25 },
  { 1768, 25, 25, 26, 1, -25 },
  { 1847, 20, 25, 21, 1, -25 },
  { 1910, 19, 25, 22, 2, -25 },
  { 1970, 16, 25, 17, 1, -25 },
  { 2020, 19, 31, 22, 2, -25 },
  { 2094, 16, 25, 17, 1, -25 },
  { 2144, 16, 25, 16, 0, -25 },
  { 2194, 15, 25, 15, 3, -25 },
  { 2241, 19, 25, 21, 2, -25 },
  { 2301, 16, 25, 17, 3, -25 },
  { 2351, 25, 25, 26, 4, -25 },
  { 2430, 20, 25, 15, -2, -25 },
  { 2493, 15, 25, 15, 3, -25 },
  { 2540, 18, 25, 16, -1, -25 },
  { 2597, 13, 31, 10, 0, -25 },
  { 2648, 5, 25, 11, 4, -25 },
  { 2664, 13, 31, 10, -2, -25 },
  { 2715, 15, 14, 17, 1, -25 },
  { 2742, 12, 2, 12, -3, 3 },
  { 2745, 4, 6, 8, 5, -27 },
  { 2748, 15, 19, 17, 1, -19 },
  { 2784, 15, 27, 18, 1, -27 },
  { 2835, 12, 19, 14, 2, -19 },
  { 2864, 17, 27, 18, 1, -27 },
  { 2922, 12, 19, 15, 2, -19 },
  { 2951, 17, 35, 9, -4, -27 },
  { 3026, 17, 27, 18, 0, -19 },
  { 3084, 14, 27, 17, 1, -27 },
  { 3132, 7, 25, 7, 1, -25 },
  { 3154, 13, 33, 7, -5, -25 },
  { 3208, 14, 27, 14, 1, -27 },
  { 3256, 7, 27, 7, 1, -27 },
  { 3280, 23, 19, 26, 1, -19 },
  { 3335, 14, 19, 17, 1, -19 },
  { 3369, 14, 19, 17, 2, -19 },
  { 3403, 17, 27, 18, -1, -19 },
  { 3461, 16, 27, 18, 1, -19 },
  { 3515, 12, 19, 11, 1, -19 },
  { 3544, 13, 19, 13, 0, -19 },
  { 3575, 9, 23, 9, 1, -23 },
  { 3601, 14, 19, 17, 2, -19 },
  { 3635, 13, 19, 13, 2, -19 },
  { 3666, 20, 19, 21, 2, -19 },
  { 3714, 16, 19, 14, -1, -19 },
  { 3752, 19, 27, 13, -4, -19 },
  { 3817, 14, 19, 13, -1, -19 },
  { 3851, 12, 31, 11, 1, -25 },
  { 3898, 1, 35, 16, 8, -27 },
  { 3903, 13, 31, 11, -2, -25 },
  { 3954, 15, 3, 18, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC35PT7B_H_
