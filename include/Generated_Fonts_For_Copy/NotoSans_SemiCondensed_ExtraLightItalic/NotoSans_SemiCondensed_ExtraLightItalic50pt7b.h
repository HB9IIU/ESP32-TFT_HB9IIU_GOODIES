#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x18, 0x0E, 0x03, 0x80, 0x18, 0x73,
  0x06, 0x30, 0x63, 0x06, 0x30, 0x62, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0xC6,
  0x08, 0x40, 0x84, 0x18, 0xC1, 0x80, 0x00, 0x06, 0x03, 0x00, 0x01, 0x00,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x08, 0x06, 0x00, 0x06,
  0x01, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x30, 0x08, 0x00,
  0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC0, 0x18, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x30, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30, 0x08, 0x03, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x40, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C,
  0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x20,
  0x18, 0x00, 0x18, 0x04, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x20, 0x00, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x1E, 0x21, 0xC0, 0xE0,
  0x81, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x40, 0x01, 0x81, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x03,
  0x08, 0x00, 0x06, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x20, 0xC0,
  0x00, 0x81, 0x80, 0x02, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x01, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x70, 0x80, 0xC3, 0x83, 0xC3, 0x3C,
  0x07, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xC0,
  0xFF, 0x00, 0x0C, 0x1C, 0x30, 0x01, 0x81, 0x81, 0x00, 0x30, 0x30, 0x18,
  0x03, 0x03, 0x01, 0x80, 0x60, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x40, 0x18, 0x18, 0x0C, 0x01, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x0C, 0x03,
  0x06, 0x00, 0xC0, 0x30, 0xC0, 0x08, 0x03, 0x0C, 0x00, 0x80, 0x61, 0x83,
  0x88, 0x06, 0x10, 0xFE, 0x80, 0x63, 0x18, 0x68, 0x0C, 0x63, 0x03, 0xC0,
  0x84, 0x60, 0x3C, 0x18, 0xC6, 0x03, 0x7F, 0x18, 0x40, 0x33, 0xE1, 0x8C,
  0x03, 0x00, 0x30, 0xC0, 0x30, 0x06, 0x08, 0x03, 0x00, 0x61, 0x80, 0x20,
  0x0C, 0x18, 0x06, 0x01, 0x81, 0x80, 0x60, 0x18, 0x18, 0x06, 0x03, 0x01,
  0x80, 0x60, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0xC0, 0x18, 0x08,
  0x18, 0x01, 0x81, 0x81, 0x80, 0x18, 0x30, 0x30, 0x00, 0xC6, 0x06, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x18, 0x00, 0x20, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x1C, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xE0, 0xC0, 0x18,
  0xC0, 0x30, 0x0C, 0xC0, 0x18, 0x0C, 0x60, 0x06, 0x06, 0x60, 0x03, 0x06,
  0x30, 0x00, 0xC3, 0x30, 0x00, 0x73, 0x18, 0x00, 0x1B, 0x0C, 0x00, 0x07,
  0x86, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0x60, 0x03,
  0x98, 0x38, 0x03, 0x8C, 0x0F, 0x0F, 0x03, 0x01, 0xFF, 0x01, 0xC0, 0x10,
  0x00, 0x00, 0x19, 0x8C, 0x63, 0x11, 0x8C, 0x63, 0x10, 0x8C, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x80, 0x40, 0x38, 0x10, 0x07, 0x04, 0x00, 0x73, 0x00, 0x07, 0x87, 0xC0,
  0x7F, 0xF0, 0x1C, 0x00, 0x0D, 0x00, 0x0E, 0x60, 0x07, 0x08, 0x03, 0x83,
  0x01, 0xC0, 0xC0, 0x20, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x01, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x0E,
  0x18, 0x30, 0xE1, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0xFF, 0xE0, 0x2F,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x38, 0x1C,
  0x03, 0x80, 0x60, 0x38, 0x03, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x31,
  0x80, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30,
  0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x06,
  0x30, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x30, 0x01, 0xC1, 0x80,
  0x0C, 0x0C, 0x00, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0xE0, 0x07, 0x1E, 0x00,
  0x1F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x76,
  0x0E, 0x63, 0x84, 0x70, 0xCC, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0x80, 0x60, 0x04, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF0, 0x07, 0x80, 0x70, 0x1C, 0x00, 0x60, 0x10, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC1, 0x80, 0x07, 0x03, 0xE0, 0x78,
  0x01, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x62, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x06, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x60, 0x10, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x30, 0x03, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x18, 0x06, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x01, 0x00, 0x1C, 0x03, 0xC0, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x83, 0xF0, 0x0C, 0x7F, 0xE0, 0x6E, 0x03, 0x83, 0xC0,
  0x0C, 0x34, 0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x60, 0x00, 0x63,
  0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x20, 0x00,
  0x31, 0x00, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0x60, 0x06, 0x03, 0x80, 0xE0, 0x0F, 0x1E, 0x00, 0x3F, 0xE0,
  0x00, 0x10, 0x00, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0x80, 0xE0,
  0x0E, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0xC0, 0x30, 0x03, 0x80, 0x30, 0x0E, 0x00, 0x30, 0x38, 0x00, 0x31,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xB8, 0x00, 0x3C, 0x18,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x30,
  0x60, 0x00, 0x60, 0xC0, 0x00, 0x43, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x30, 0x00, 0x60, 0x70,
  0x01, 0xC0, 0x70, 0x07, 0x00, 0x78, 0x7C, 0x00, 0x7F, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0C, 0x07, 0x00, 0x60,
  0x0E, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x31, 0x80, 0x01, 0xC6, 0x00, 0x06, 0x18, 0x00,
  0x38, 0x30, 0x01, 0xE0, 0xC0, 0x0D, 0x81, 0x80, 0x66, 0x07, 0xDF, 0x30,
  0x07, 0xF0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x0E,
  0x0F, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x07, 0x07, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0xE0, 0xE0, 0xE0, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0xFC, 0x10, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x61, 0x80,
  0x3F, 0xF0, 0x31, 0x80, 0x38, 0x30, 0x18, 0xC0, 0x30, 0x18, 0x0C, 0xC0,
  0x30, 0x0C, 0x06, 0x60, 0x30, 0x06, 0x03, 0x20, 0x18, 0x02, 0x01, 0xB0,
  0x18, 0x03, 0x00, 0xD8, 0x0C, 0x01, 0x80, 0x6C, 0x0C, 0x00, 0xC0, 0x24,
  0x06, 0x00, 0x40, 0x36, 0x03, 0x00, 0x60, 0x1B, 0x01, 0x00, 0x30, 0x09,
  0x80, 0x80, 0x38, 0x0C, 0xC0, 0xC0, 0x18, 0x06, 0x60, 0x20, 0x1C, 0x06,
  0x30, 0x18, 0x0A, 0x07, 0x18, 0x0C, 0x0D, 0x83, 0x0C, 0x07, 0x1C, 0xC7,
  0x06, 0x01, 0xFC, 0x3F, 0x01, 0x80, 0x30, 0x04, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x20, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x98,
  0x00, 0x01, 0x88, 0x00, 0x03, 0x08, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x06, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x06, 0x18, 0x00, 0x06,
  0x38, 0x00, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0x80, 0x3C,
  0x03, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x02,
  0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x38,
  0x0C, 0x00, 0x70, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x18, 0x03, 0xC0,
  0x18, 0x00, 0x60, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x60, 0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x40, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x07, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0E, 0x00,
  0x40, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x20, 0x03, 0xE0, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x18, 0x07, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18,
  0x00, 0x06, 0x04, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x70, 0x60, 0x00, 0x38, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x07,
  0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xE0, 0x07, 0x80, 0x70,
  0x00, 0x20, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x07, 0xFC, 0x60, 0x01, 0xFF, 0x8C, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x06, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x18, 0x00, 0x18, 0x03, 0xC0, 0x03, 0x00, 0x1F, 0x0F, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x20, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x04, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x04,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x18, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x18, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x30, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18,
  0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x02, 0x0E, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x03,
  0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x03, 0x80,
  0x06, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x38,
  0x00, 0x04, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0x6C, 0x00, 0x01, 0xB3, 0x00, 0x00,
  0x78, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x06, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x34, 0x00, 0x00,
  0x3C, 0x06, 0x80, 0x00, 0x0D, 0x80, 0xD8, 0x00, 0x03, 0xB0, 0x13, 0x00,
  0x00, 0x6C, 0x06, 0x60, 0x00, 0x19, 0x80, 0xCC, 0x00, 0x03, 0x30, 0x19,
  0x80, 0x00, 0xC6, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x42, 0x00, 0x06, 0x30,
  0x18, 0x40, 0x00, 0xC6, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x61, 0x80, 0x06,
  0x18, 0x0C, 0x30, 0x01, 0x82, 0x03, 0x06, 0x00, 0x70, 0xC0, 0x60, 0xC0,
  0x0C, 0x18, 0x0C, 0x18, 0x03, 0x03, 0x01, 0x81, 0x00, 0x60, 0x60, 0x30,
  0x20, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x06, 0x01, 0x80, 0x80, 0x60, 0xC0,
  0x60, 0x30, 0x0C, 0x30, 0x0C, 0x06, 0x00, 0x8C, 0x01, 0x80, 0xC0, 0x11,
  0x80, 0x30, 0x18, 0x03, 0x60, 0x06, 0x06, 0x00, 0x6C, 0x01, 0x80, 0xC0,
  0x0F, 0x00, 0x30, 0x18, 0x01, 0xE0, 0x06, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x60, 0x07, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x30, 0x18, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x30, 0x3C, 0x00, 0x03, 0x03, 0x40, 0x00, 0x30, 0x36,
  0x00, 0x06, 0x03, 0x60, 0x00, 0x60, 0x26, 0x00, 0x06, 0x06, 0x30, 0x00,
  0x60, 0x63, 0x00, 0x04, 0x06, 0x30, 0x00, 0xC0, 0x61, 0x80, 0x0C, 0x04,
  0x18, 0x00, 0xC0, 0xC1, 0x80, 0x0C, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0xC0,
  0x18, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x18, 0x18, 0x06, 0x01, 0x81,
  0x80, 0x60, 0x30, 0x18, 0x03, 0x03, 0x01, 0x80, 0x30, 0x30, 0x30, 0x03,
  0x03, 0x03, 0x00, 0x18, 0x30, 0x30, 0x01, 0x86, 0x03, 0x00, 0x18, 0x60,
  0x20, 0x00, 0xC6, 0x06, 0x00, 0x0C, 0x60, 0x60, 0x00, 0xC4, 0x06, 0x00,
  0x06, 0xC0, 0x60, 0x00, 0x6C, 0x0C, 0x00, 0x06, 0xC0, 0xC0, 0x00, 0x3C,
  0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x01,
  0x80, 0x38, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x70,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xE0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x06, 0x03,
  0xC0, 0x18, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x60, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x60, 0x07, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x38, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30,
  0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x06, 0x01, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x06, 0x03, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x81, 0x80, 0x07, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0x40, 0x00, 0xC1, 0x80, 0x01,
  0x83, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x30, 0x03, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x81, 0x00, 0x0E, 0x03, 0xE1, 0xF8, 0x03, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x30,
  0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x03, 0x02, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x06,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x80, 0x01, 0x81,
  0x00, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x18,
  0x00, 0x10, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x00, 0xC6, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x07,
  0xC0, 0x00, 0xE0, 0x00, 0x6C, 0x00, 0x0E, 0x00, 0x06, 0x40, 0x01, 0xA0,
  0x00, 0xC4, 0x00, 0x1A, 0x00, 0x0C, 0x40, 0x01, 0x20, 0x01, 0x84, 0x00,
  0x32, 0x00, 0x18, 0x40, 0x03, 0x20, 0x03, 0x04, 0x00, 0x62, 0x00, 0x30,
  0x40, 0x06, 0x30, 0x03, 0x04, 0x00, 0xC3, 0x00, 0x60, 0x60, 0x0C, 0x30,
  0x06, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x60, 0x18, 0x30, 0x0C, 0x06, 0x01,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x30, 0x18, 0x06, 0x03, 0x03, 0x01, 0x80,
  0x60, 0x60, 0x30, 0x30, 0x06, 0x06, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x30,
  0x60, 0x06, 0x0C, 0x03, 0x06, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x06, 0x18,
  0x03, 0x0C, 0x00, 0x61, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x06, 0x60, 0x03, 0x30, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x06, 0xC0, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x06, 0x80,
  0x03, 0x40, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x03, 0x00, 0x38, 0x00, 0x10, 0x03, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x30, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0E,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x80,
  0x01, 0xCC, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x60,
  0x60, 0x06, 0x01, 0x00, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x03, 0x01,
  0x80, 0x18, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0xC0, 0x00,
  0xCC, 0x00, 0x02, 0x60, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0xC0, 0xC0, 0x40,
  0x40, 0x60, 0x60, 0x60, 0x60, 0x20, 0x20, 0x30, 0x30, 0x30, 0x30, 0x10,
  0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x30,
  0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x04, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x04, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x83, 0x00, 0x04, 0x30, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00,
  0x06, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC1, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x40,
  0xE0, 0x66, 0x0E, 0x01, 0xB0, 0xE0, 0x05, 0x86, 0x00, 0x28, 0x60, 0x01,
  0xC3, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80, 0x03, 0x98, 0x00, 0x18, 0xC0,
  0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00, 0x01, 0x18, 0x00, 0x18,
  0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00,
  0x38, 0x60, 0x03, 0xC1, 0x80, 0x16, 0x0C, 0x01, 0xB0, 0x70, 0x19, 0x01,
  0xE3, 0x88, 0x07, 0xF0, 0xC0, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC3, 0xF0, 0x06, 0x1F, 0xE0, 0x19, 0xC1, 0xC0, 0x6C,
  0x01, 0x81, 0xE0, 0x06, 0x05, 0x80, 0x0C, 0x3C, 0x00, 0x30, 0xE0, 0x00,
  0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x18,
  0x70, 0x00, 0xE1, 0xE0, 0x03, 0x05, 0x80, 0x18, 0x13, 0x00, 0xC0, 0xC7,
  0x1E, 0x03, 0x0F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0xF0, 0x3C, 0x04, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x04, 0x07, 0x07, 0x00, 0xFF, 0x80, 0x02, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x3E, 0x0C, 0x00,
  0xFF, 0x8C, 0x03, 0x81, 0xC8, 0x07, 0x00, 0x58, 0x0E, 0x00, 0x78, 0x0C,
  0x00, 0x38, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0xC0, 0xC0,
  0x02, 0x80, 0x60, 0x07, 0x80, 0x60, 0x0D, 0x80, 0x70, 0x19, 0x80, 0x3C,
  0x71, 0x80, 0x1F, 0xE1, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0xE0, 0x1C, 0x1C, 0x1C, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x11, 0x80, 0x0C,
  0x60, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x31, 0x80, 0x38, 0x60,
  0xFC, 0x1F, 0xF8, 0x07, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x02, 0x07, 0x87, 0x80, 0xFF, 0xC0, 0x02, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE3, 0x00, 0xF0, 0x73, 0x01, 0xC0, 0x12,
  0x03, 0x80, 0x1E, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x0C,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18,
  0x30, 0x00, 0x38, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0x70,
  0x30, 0x00, 0xF0, 0x30, 0x00, 0xA0, 0x18, 0x01, 0xE0, 0x18, 0x03, 0x60,
  0x1C, 0x06, 0x60, 0x0F, 0x1C, 0x60, 0x07, 0xF8, 0x40, 0x00, 0x80, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0xE0, 0x1C, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x1F, 0x80, 0x63, 0xFE, 0x03, 0x38, 0x38, 0x1B, 0x00,
  0xE0, 0xF0, 0x03, 0x05, 0x00, 0x18, 0x78, 0x00, 0xC3, 0x80, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x84, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x10, 0x60, 0x03, 0x03, 0x00, 0x30, 0x18,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x03, 0x03, 0x00,
  0x18, 0x30, 0x00, 0xC3, 0x00, 0x04, 0x30, 0x00, 0x63, 0x00, 0x03, 0x3C,
  0x00, 0x1B, 0x60, 0x00, 0xB3, 0x00, 0x0F, 0x0C, 0x00, 0x70, 0x60, 0x03,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x01, 0x8F, 0xF0, 0x3F, 0xC0, 0x66,
  0x0E, 0x38, 0x38, 0x1B, 0x01, 0x98, 0x06, 0x07, 0x80, 0x34, 0x00, 0xC1,
  0x40, 0x0F, 0x00, 0x30, 0xE0, 0x03, 0x80, 0x0C, 0x38, 0x00, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0x00, 0x83, 0x00, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x00,
  0x18, 0x60, 0x01, 0x80, 0x06, 0x18, 0x00, 0x60, 0x01, 0x86, 0x00, 0x18,
  0x00, 0xC1, 0x80, 0x04, 0x00, 0x30, 0xC0, 0x03, 0x00, 0x0C, 0x30, 0x00,
  0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x00, 0x18, 0x60, 0x01, 0x80, 0x06, 0x18, 0x00, 0x60, 0x01, 0x86,
  0x00, 0x18, 0x00, 0x41, 0x80, 0x04, 0x00, 0x30, 0x60, 0x03, 0x00, 0x0C,
  0x30, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0F, 0xC0,
  0x31, 0xFF, 0x81, 0x9C, 0x1C, 0x0D, 0x80, 0x70, 0x78, 0x01, 0x82, 0x80,
  0x0C, 0x3C, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC6, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60,
  0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x0F,
  0xF8, 0x03, 0xC1, 0xC0, 0x70, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00,
  0xC6, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x30, 0x30, 0x0E, 0x01, 0xC3,
  0xC0, 0x0F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x01, 0x87, 0xF8,
  0x01, 0x9C, 0x1C, 0x01, 0xB0, 0x06, 0x01, 0xA0, 0x06, 0x01, 0x60, 0x03,
  0x03, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x30, 0x1E, 0x00, 0x60, 0x1B, 0x01, 0xC0, 0x31, 0xC7, 0x80,
  0x30, 0xFF, 0x00, 0x30, 0x10, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x30, 0x3C, 0x1C, 0xC1,
  0xC0, 0x12, 0x0E, 0x00, 0x78, 0x30, 0x00, 0xE1, 0x80, 0x03, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x03,
  0xC3, 0x00, 0x0A, 0x06, 0x00, 0x78, 0x18, 0x03, 0x60, 0x70, 0x19, 0x80,
  0xF1, 0xC6, 0x01, 0xFC, 0x10, 0x00, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x83, 0x1F, 0xC1, 0x9C, 0x00, 0xD8, 0x00,
  0x78, 0x00, 0x28, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x70, 0x0C, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x80, 0x1C, 0x3C, 0x1E, 0x07,
  0xFE, 0x00, 0x08, 0x00, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x2F, 0xFE, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x20, 0x7F, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x10, 0x00, 0x61, 0x80,
  0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x04, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00,
  0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x30,
  0x00, 0x61, 0x80, 0x07, 0x0C, 0x00, 0x78, 0x60, 0x02, 0xC3, 0x00, 0x34,
  0x0C, 0x07, 0x60, 0x78, 0xF3, 0x01, 0xFE, 0x18, 0x01, 0x80, 0x00, 0xC0,
  0x01, 0xF0, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x01,
  0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x10, 0x06, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x60, 0x18, 0x18, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x61,
  0x80, 0x18, 0x60, 0x06, 0x30, 0x00, 0x8C, 0x00, 0x26, 0x00, 0x09, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x3E, 0x00, 0x70, 0x01, 0xB0, 0x03, 0x80, 0x19, 0x80, 0x14, 0x00,
  0xCC, 0x01, 0xB0, 0x04, 0x60, 0x09, 0x80, 0x63, 0x00, 0xCC, 0x03, 0x18,
  0x04, 0x60, 0x30, 0xC0, 0x63, 0x01, 0x86, 0x03, 0x18, 0x18, 0x30, 0x30,
  0xC0, 0xC1, 0x81, 0x86, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC1, 0x82,
  0x03, 0x0C, 0x0C, 0x30, 0x18, 0x60, 0x61, 0x80, 0xC6, 0x03, 0x18, 0x06,
  0x30, 0x18, 0xC0, 0x13, 0x00, 0x4C, 0x00, 0x98, 0x02, 0x60, 0x04, 0x80,
  0x12, 0x00, 0x2C, 0x00, 0xB0, 0x01, 0x40, 0x05, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0E,
  0x03, 0x00, 0x38, 0x06, 0x00, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x60,
  0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x70, 0x01, 0x81, 0xC0, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x20, 0x60, 0x00,
  0x04, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x0F, 0xC0,
  0x03, 0xC0, 0x00, 0x1F, 0x80, 0x0B, 0xFF, 0x00, 0x70, 0x1E, 0x0F, 0x00,
  0x3F, 0xC0, 0x00, 0x78, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 36, 11, 1, -36 },
  { 46, 12, 13, 15, 5, -36 },
  { 66, 26, 36, 27, 1, -36 },
  { 183, 22, 41, 24, 1, -38 },
  { 296, 28, 37, 34, 4, -36 },
  { 426, 25, 37, 28, 1, -36 },
  { 542, 5, 13, 9, 5, -36 },
  { 551, 15, 44, 12, 1, -36 },
  { 634, 14, 44, 12, -3, -36 },
  { 711, 18, 19, 23, 6, -38 },
  { 754, 21, 23, 26, 3, -29 },
  { 815, 7, 11, 9, -2, -5 },
  { 825, 11, 1, 15, 2, -14 },
  { 827, 3, 4, 10, 1, -4 },
  { 829, 22, 36, 16, -2, -36 },
  { 928, 21, 37, 24, 2, -36 },
  { 1026, 12, 36, 24, 7, -36 },
  { 1080, 23, 36, 24, 0, -36 },
  { 1184, 23, 37, 24, 0, -36 },
  { 1291, 23, 36, 24, 0, -36 },
  { 1395, 23, 37, 24, 1, -36 },
  { 1502, 21, 37, 24, 3, -36 },
  { 1600, 21, 36, 24, 4, -36 },
  { 1695, 23, 37, 24, 1, -36 },
  { 1802, 22, 37, 24, 1, -36 },
  { 1904, 8, 27, 10, 1, -27 },
  { 1931, 11, 33, 10, -2, -27 },
  { 1977, 21, 22, 26, 3, -29 },
  { 2035, 21, 12, 26, 3, -24 },
  { 2067, 21, 22, 26, 3, -29 },
  { 2125, 16, 36, 18, 3, -36 },
  { 2197, 33, 41, 36, 2, -36 },
  { 2367, 24, 36, 24, -3, -36 },
  { 2475, 24, 36, 26, 2, -36 },
  { 2583, 25, 37, 25, 3, -36 },
  { 2699, 26, 36, 29, 2, -36 },
  { 2816, 23, 36, 23, 2, -36 },
  { 2920, 23, 36, 21, 2, -36 },
  { 3024, 27, 37, 30, 3, -36 },
  { 3149, 28, 36, 30, 2, -36 },
  { 3275, 16, 36, 13, -1, -36 },
  { 3347, 19, 45, 11, -8, -36 },
  { 3454, 26, 36, 24, 2, -36 },
  { 3571, 15, 36, 21, 2, -36 },
  { 3639, 35, 36, 37, 2, -36 },
  { 3797, 28, 36, 30, 2, -36 },
  { 3923, 27, 37, 31, 3, -36 },
  { 4048, 23, 36, 24, 2, -36 },
  { 4152, 27, 45, 31, 3, -36 },
  { 4304, 23, 36, 25, 2, -36 },
  { 4408, 23, 37, 22, 0, -36 },
  { 4515, 21, 36, 21, 4, -36 },
  { 4610, 27, 37, 30, 3, -36 },
  { 4735, 23, 36, 24, 5, -36 },
  { 4839, 36, 36, 38, 5, -36 },
  { 5001, 28, 36, 22, -3, -36 },
  { 5127, 21, 36, 21, 5, -36 },
  { 5222, 26, 36, 23, -1, -36 },
  { 5339, 19, 44, 15, -1, -36 },
  { 5444, 8, 36, 16, 5, -36 },
  { 5480, 18, 44, 15, -3, -36 },
  { 5579, 21, 21, 25, 2, -36 },
  { 5635, 17, 2, 17, -4, 5 },
  { 5640, 6, 8, 11, 7, -38 },
  { 5646, 21, 28, 25, 2, -27 },
  { 5720, 22, 39, 25, 1, -38 },
  { 5828, 18, 28, 19, 2, -27 },
  { 5891, 24, 39, 25, 2, -38 },
  { 6008, 18, 28, 22, 2, -27 },
  { 6071, 25, 50, 12, -6, -38 },
  { 6228, 24, 39, 25, 0, -27 },
  { 6345, 21, 38, 24, 1, -38 },
  { 6445, 10, 36, 10, 1, -36 },
  { 6490, 18, 48, 10, -7, -36 },
  { 6598, 21, 38, 20, 1, -38 },
  { 6698, 10, 38, 10, 1, -38 },
  { 6746, 34, 27, 37, 1, -27 },
  { 6861, 21, 27, 24, 1, -27 },
  { 6932, 20, 28, 25, 2, -27 },
  { 7002, 24, 39, 25, -1, -27 },
  { 7119, 22, 39, 25, 2, -27 },
  { 7227, 17, 27, 16, 1, -27 },
  { 7285, 18, 28, 19, 0, -27 },
  { 7348, 13, 34, 13, 2, -33 },
  { 7404, 21, 27, 24, 2, -26 },
  { 7475, 18, 26, 19, 3, -26 },
  { 7534, 29, 26, 30, 3, -26 },
  { 7629, 23, 26, 20, -2, -26 },
  { 7704, 27, 38, 19, -6, -26 },
  { 7833, 20, 26, 18, -1, -26 },
  { 7898, 18, 44, 16, 1, -36 },
  { 7997, 1, 50, 23, 12, -38 },
  { 8004, 18, 44, 16, -3, -36 },
  { 8103, 21, 5, 26, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC50PT7B_H_
