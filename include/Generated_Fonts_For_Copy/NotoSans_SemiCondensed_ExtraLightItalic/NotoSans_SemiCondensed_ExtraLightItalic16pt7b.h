#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x24, 0x44, 0x00, 0x80, 0xB6, 0xD0, 0x09, 0x04, 0x84,
  0x8F, 0xF1, 0x21, 0x20, 0x91, 0xFE, 0x24, 0x24, 0x12, 0x00, 0x04, 0x3C,
  0xA1, 0x42, 0x87, 0x02, 0x0A, 0x12, 0x2B, 0x61, 0x02, 0x00, 0x20, 0xA8,
  0xA2, 0x52, 0x49, 0x44, 0xAE, 0xAA, 0xA9, 0x14, 0x92, 0x51, 0x28, 0xE0,
  0x0C, 0x12, 0x12, 0x22, 0x14, 0x18, 0x28, 0x49, 0x85, 0x82, 0x86, 0x7B,
  0xF0, 0x18, 0x88, 0x44, 0x21, 0x10, 0x84, 0x20, 0x84, 0x20, 0x11, 0x11,
  0x11, 0x11, 0x12, 0x24, 0x48, 0x12, 0x87, 0xC8, 0xD0, 0x40, 0x10, 0x20,
  0x47, 0xF1, 0x02, 0x04, 0x00, 0x29, 0x40, 0xF0, 0x80, 0x02, 0x08, 0x10,
  0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x00, 0x18, 0x94, 0x51, 0x86, 0x18,
  0x61, 0x86, 0x28, 0x9C, 0x3D, 0x12, 0x22, 0x24, 0x44, 0x40, 0x1C, 0x44,
  0x08, 0x10, 0x20, 0x41, 0x04, 0x10, 0x41, 0x07, 0xE0, 0x1C, 0x44, 0x08,
  0x10, 0x20, 0x8F, 0x02, 0x02, 0x04, 0x17, 0xC0, 0x02, 0x04, 0x18, 0x51,
  0x24, 0x89, 0x22, 0xFE, 0x08, 0x20, 0x40, 0x1F, 0x20, 0x20, 0x20, 0x38,
  0x04, 0x02, 0x02, 0x02, 0x04, 0xF8, 0x0E, 0x20, 0x82, 0x08, 0x1F, 0x21,
  0x42, 0x85, 0x0A, 0x23, 0x80, 0x7E, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10,
  0x40, 0x82, 0x00, 0x0C, 0x12, 0x21, 0x21, 0x22, 0x14, 0x38, 0x44, 0x82,
  0x82, 0x84, 0x78, 0x0C, 0x64, 0x8A, 0x14, 0x28, 0x49, 0x8D, 0x04, 0x08,
  0x27, 0x80, 0x24, 0x00, 0x00, 0x80, 0x11, 0x00, 0x00, 0x02, 0x44, 0x80,
  0x06, 0x31, 0x86, 0x03, 0x01, 0x80, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0xC0,
  0x60, 0x30, 0x31, 0x8C, 0x20, 0x00, 0x70, 0x42, 0x10, 0x88, 0x88, 0x80,
  0x01, 0x00, 0x1F, 0x88, 0x14, 0x06, 0x3D, 0x92, 0x64, 0x9A, 0x26, 0x89,
  0xBF, 0xA0, 0x08, 0x01, 0xF8, 0x06, 0x06, 0x0A, 0x0A, 0x12, 0x12, 0x3E,
  0x21, 0x41, 0x41, 0x81, 0x3E, 0x85, 0x0A, 0x14, 0x57, 0xA1, 0x41, 0x85,
  0x0B, 0xE0, 0x0E, 0x11, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x7C, 0x1F, 0x10, 0x48, 0x24, 0x12, 0x0A, 0x05, 0x02, 0x82, 0x41,
  0x23, 0x3E, 0x00, 0x1F, 0x20, 0x20, 0x20, 0x3E, 0x40, 0x40, 0x40, 0x40,
  0x40, 0xFC, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x3C, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x0F, 0x08, 0x48, 0x08, 0x08, 0x04, 0x02, 0x1D, 0x02, 0x82, 0x41,
  0x20, 0x8F, 0xC0, 0x10, 0x48, 0x22, 0x08, 0x82, 0x20, 0x97, 0xE4, 0x11,
  0x04, 0x41, 0x10, 0x48, 0x20, 0x38, 0x88, 0x42, 0x11, 0x08, 0x42, 0x38,
  0x02, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x1C,
  0x00, 0x11, 0x91, 0x09, 0x05, 0x03, 0x01, 0x41, 0x20, 0x90, 0x44, 0x22,
  0x20, 0x80, 0x10, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x0F, 0xC0, 0x10,
  0x31, 0x02, 0x30, 0x63, 0x06, 0x28, 0xA4, 0x92, 0x49, 0x24, 0xA4, 0x4A,
  0x44, 0xC4, 0x84, 0x40, 0x10, 0x4C, 0x12, 0x88, 0xA2, 0x28, 0x91, 0x24,
  0x51, 0x14, 0x43, 0x10, 0xC8, 0x20, 0x0E, 0x31, 0x41, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x82, 0x7C, 0x1E, 0x21, 0x21, 0x21, 0x22, 0x7C,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x0E, 0x31, 0x41, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x7C, 0x08, 0x08, 0x04, 0x1E, 0x21, 0x21, 0x21,
  0x22, 0x3C, 0x48, 0x44, 0x44, 0x44, 0x82, 0x0C, 0x64, 0x82, 0x02, 0x06,
  0x02, 0x02, 0x04, 0x08, 0x17, 0xC0, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x00, 0x40, 0xA0, 0x90, 0x48, 0x24, 0x14, 0x0A, 0x09,
  0x04, 0x82, 0x42, 0x1E, 0x00, 0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x50,
  0xA1, 0x82, 0x00, 0x84, 0x31, 0x8A, 0x31, 0x4A, 0x29, 0x49, 0x49, 0x29,
  0x46, 0x28, 0xC6, 0x10, 0xC2, 0x10, 0x00, 0x10, 0x88, 0x84, 0x81, 0x80,
  0xC0, 0x40, 0x50, 0x48, 0x24, 0x21, 0x20, 0x80, 0x82, 0x89, 0x22, 0x45,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x00, 0x3F, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x20, 0x20, 0x40, 0x80, 0xFC, 0x3C, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42,
  0x08, 0x20, 0x83, 0x80, 0xAA, 0xA5, 0x54, 0x1C, 0x10, 0x82, 0x08, 0x20,
  0x84, 0x10, 0x41, 0x08, 0x23, 0x80, 0x10, 0xA2, 0x91, 0x86, 0x10, 0xF8,
  0x90, 0x39, 0x18, 0x61, 0x86, 0x18, 0xA2, 0xF8, 0x10, 0x40, 0x81, 0x63,
  0x24, 0x50, 0xA1, 0x42, 0x85, 0x15, 0xC0, 0x3A, 0x21, 0x08, 0x42, 0x10,
  0x70, 0x02, 0x04, 0x09, 0xD4, 0x50, 0xA1, 0x42, 0x85, 0x12, 0x27, 0xC0,
  0x39, 0x18, 0x62, 0xF2, 0x08, 0x20, 0x70, 0x07, 0x04, 0x08, 0x1E, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x1D,
  0x22, 0x42, 0x42, 0x42, 0x42, 0x84, 0x44, 0x7C, 0x04, 0x04, 0x08, 0xF0,
  0x10, 0x40, 0x81, 0x63, 0x24, 0x50, 0xA1, 0x42, 0x8A, 0x14, 0x20, 0x24,
  0x02, 0x52, 0x4A, 0x40, 0x08, 0x40, 0x00, 0x84, 0x42, 0x10, 0x88, 0x42,
  0x10, 0x98, 0x10, 0x40, 0x81, 0x12, 0x45, 0x14, 0x38, 0x50, 0x92, 0x24,
  0x40, 0x12, 0x22, 0x22, 0x44, 0x44, 0x88, 0x0C, 0xC6, 0x64, 0x88, 0xA1,
  0x14, 0x22, 0x88, 0x51, 0x14, 0x22, 0x84, 0x40, 0x0C, 0x64, 0x8A, 0x14,
  0x28, 0x51, 0x42, 0x84, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0xF0, 0x0C,
  0x64, 0x8A, 0x14, 0x28, 0x50, 0xA2, 0xB9, 0x02, 0x04, 0x08, 0x00, 0x3A,
  0x8A, 0x14, 0x28, 0x50, 0xA2, 0x44, 0xF8, 0x10, 0x20, 0x41, 0x00, 0x0C,
  0xC2, 0x10, 0x41, 0x04, 0x20, 0x80, 0x39, 0x14, 0x10, 0x20, 0x40, 0x82,
  0xF0, 0x44, 0xF4, 0x88, 0x88, 0x88, 0xC0, 0x46, 0x18, 0x61, 0x86, 0x28,
  0xBE, 0x8E, 0x29, 0x24, 0xA2, 0x8C, 0x10, 0x88, 0xCC, 0xA6, 0x55, 0x2A,
  0xA6, 0x53, 0x11, 0x08, 0x23, 0x14, 0x14, 0x08, 0x18, 0x28, 0x44, 0xC4,
  0x10, 0x88, 0x84, 0x82, 0x41, 0x40, 0xA0, 0x60, 0x10, 0x10, 0x08, 0x08,
  0x18, 0x00, 0x3C, 0x21, 0x04, 0x21, 0x08, 0x3C, 0x0C, 0x41, 0x04, 0x20,
  0x8C, 0x08, 0x21, 0x04, 0x10, 0x40, 0x80, 0xFF, 0xFF, 0x18, 0x20, 0x82,
  0x08, 0x20, 0xC4, 0x10, 0x42, 0x08, 0x23, 0x00, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 11, 3, 0, -11 },
  { 7, 3, 4, 5, 2, -11 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 7, 13, 8, 0, -12 },
  { 34, 9, 12, 11, 1, -12 },
  { 48, 8, 12, 9, 0, -12 },
  { 60, 1, 4, 3, 2, -11 },
  { 61, 5, 14, 4, 0, -11 },
  { 70, 4, 14, 4, -1, -11 },
  { 77, 6, 6, 7, 2, -12 },
  { 82, 7, 7, 8, 1, -9 },
  { 89, 3, 4, 3, -1, -2 },
  { 91, 4, 1, 5, 0, -5 },
  { 92, 1, 1, 3, 0, -1 },
  { 93, 7, 11, 5, -1, -11 },
  { 103, 6, 12, 8, 1, -12 },
  { 112, 4, 11, 8, 2, -11 },
  { 118, 7, 12, 8, 0, -12 },
  { 129, 7, 12, 8, 0, -12 },
  { 140, 7, 12, 8, 0, -12 },
  { 151, 8, 11, 8, 0, -11 },
  { 162, 7, 12, 8, 1, -12 },
  { 173, 7, 11, 8, 1, -11 },
  { 183, 8, 12, 8, 0, -12 },
  { 195, 7, 12, 8, 0, -12 },
  { 206, 3, 9, 3, 0, -9 },
  { 210, 4, 11, 3, -1, -9 },
  { 216, 7, 7, 8, 1, -9 },
  { 223, 7, 4, 8, 1, -8 },
  { 227, 7, 7, 8, 1, -9 },
  { 234, 5, 12, 6, 1, -12 },
  { 242, 10, 12, 12, 1, -11 },
  { 257, 8, 11, 8, -1, -11 },
  { 268, 7, 11, 8, 1, -11 },
  { 278, 8, 12, 8, 1, -12 },
  { 290, 9, 11, 9, 0, -11 },
  { 303, 8, 11, 7, 0, -11 },
  { 314, 8, 11, 7, 0, -11 },
  { 325, 9, 12, 10, 1, -12 },
  { 339, 10, 11, 10, 0, -11 },
  { 353, 5, 11, 4, 0, -11 },
  { 360, 7, 14, 3, -3, -11 },
  { 373, 9, 11, 8, 0, -11 },
  { 386, 6, 11, 7, 0, -11 },
  { 395, 12, 11, 12, 0, -11 },
  { 412, 10, 11, 10, 0, -11 },
  { 426, 8, 12, 10, 1, -12 },
  { 438, 8, 11, 8, 0, -11 },
  { 449, 8, 15, 10, 1, -12 },
  { 464, 8, 11, 8, 0, -11 },
  { 475, 7, 12, 7, 0, -12 },
  { 486, 7, 11, 7, 1, -11 },
  { 496, 9, 11, 10, 1, -11 },
  { 509, 7, 11, 8, 2, -11 },
  { 519, 11, 11, 12, 2, -11 },
  { 535, 9, 11, 7, -1, -11 },
  { 548, 7, 11, 7, 1, -11 },
  { 558, 8, 11, 7, 0, -11 },
  { 569, 6, 14, 5, 0, -11 },
  { 580, 2, 11, 5, 2, -11 },
  { 583, 6, 14, 5, -1, -11 },
  { 594, 6, 6, 8, 1, -11 },
  { 599, 5, 1, 5, -1, 1 },
  { 600, 2, 2, 4, 2, -12 },
  { 601, 6, 9, 8, 1, -9 },
  { 608, 7, 12, 8, 0, -12 },
  { 619, 5, 9, 6, 1, -9 },
  { 625, 7, 12, 8, 1, -12 },
  { 636, 6, 9, 7, 1, -9 },
  { 643, 8, 16, 4, -2, -12 },
  { 659, 8, 13, 8, 0, -9 },
  { 672, 7, 12, 8, 0, -12 },
  { 683, 3, 12, 3, 0, -12 },
  { 688, 5, 16, 3, -2, -12 },
  { 698, 7, 12, 6, 0, -12 },
  { 709, 4, 12, 3, 0, -12 },
  { 715, 11, 9, 12, 0, -9 },
  { 728, 7, 9, 8, 0, -9 },
  { 736, 6, 9, 8, 1, -9 },
  { 743, 7, 13, 8, 0, -9 },
  { 755, 7, 13, 8, 1, -9 },
  { 767, 6, 9, 5, 0, -9 },
  { 774, 6, 9, 6, 0, -9 },
  { 781, 4, 11, 4, 1, -11 },
  { 787, 6, 8, 8, 1, -8 },
  { 793, 6, 8, 6, 1, -8 },
  { 799, 9, 8, 10, 1, -8 },
  { 808, 8, 8, 6, -1, -8 },
  { 816, 9, 12, 6, -2, -8 },
  { 830, 6, 8, 6, 0, -8 },
  { 836, 6, 14, 5, 0, -11 },
  { 847, 1, 16, 7, 3, -12 },
  { 849, 6, 14, 5, -1, -11 },
  { 860, 7, 1, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC16PT7B_H_
