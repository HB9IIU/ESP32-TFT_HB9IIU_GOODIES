#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x38, 0x0F, 0x01, 0xC0, 0x00, 0x30, 0x73, 0x06, 0x30, 0x66, 0x06,
  0x60, 0xE6, 0x0C, 0x60, 0xC6, 0x0C, 0x40, 0xCC, 0x08, 0xC1, 0x8C, 0x18,
  0x81, 0x88, 0x10, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x60, 0x10, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x0C, 0x02, 0x00, 0x00, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0x00, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x60, 0x18, 0x00, 0x04, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x18, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0xC0, 0x00, 0x20, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x01, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x08, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0xF1,
  0x1E, 0x01, 0xC3, 0x02, 0x03, 0x83, 0x00, 0x03, 0x03, 0x00, 0x06, 0x02,
  0x00, 0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x07, 0x04, 0x00, 0x03, 0x04, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x19, 0xC0, 0x00, 0x10, 0xE0, 0x00, 0x10, 0x60, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x20, 0x30, 0x00, 0x20,
  0x30, 0x00, 0x60, 0x60, 0x00, 0x60, 0x60, 0x00, 0x60, 0xC0, 0xC0, 0x43,
  0x80, 0xFC, 0x5F, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x30, 0x1D, 0xE0, 0x01, 0x80, 0xC1, 0x80, 0x06,
  0x06, 0x02, 0x00, 0x30, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x03, 0x01, 0x80, 0x60, 0x0C, 0x06, 0x01, 0x80,
  0x20, 0x30, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x06, 0x06, 0x00, 0xC0, 0x18,
  0x30, 0x03, 0x00, 0x61, 0x80, 0x0C, 0x01, 0x06, 0x00, 0x30, 0x0C, 0x30,
  0xFC, 0xC0, 0x30, 0xC7, 0xFB, 0x01, 0x86, 0x30, 0x6C, 0x06, 0x31, 0xC0,
  0xF0, 0x30, 0xC6, 0x03, 0xC1, 0xC6, 0x30, 0x0D, 0xDE, 0x30, 0xC0, 0x33,
  0xF0, 0xC6, 0x00, 0xC0, 0x06, 0x18, 0x03, 0x00, 0x30, 0x60, 0x0C, 0x00,
  0xC1, 0x80, 0x60, 0x06, 0x0C, 0x01, 0x80, 0x30, 0x30, 0x06, 0x00, 0xC0,
  0xC0, 0x18, 0x06, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x06, 0x00, 0xC0, 0x20, 0x30, 0x03, 0x01, 0x80, 0xC0, 0x0C, 0x0C,
  0x06, 0x00, 0x30, 0x30, 0x38, 0x00, 0x63, 0x80, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x18,
  0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x18,
  0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0xC7, 0x01, 0xC0, 0x30, 0xC0, 0x18,
  0x06, 0x30, 0x01, 0x81, 0x8E, 0x00, 0x30, 0x31, 0x80, 0x03, 0x0C, 0x30,
  0x00, 0x61, 0x8C, 0x00, 0x06, 0x61, 0x80, 0x00, 0xF8, 0x30, 0x00, 0x0F,
  0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x0C, 0x00, 0x1F, 0x81, 0xC0,
  0x07, 0x30, 0x1C, 0x03, 0xC3, 0x03, 0xE1, 0xE0, 0x60, 0x1F, 0xF0, 0x06,
  0x00, 0x20, 0x00, 0x00, 0x33, 0x36, 0x66, 0x66, 0x4C, 0xCC, 0x88, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x04, 0x02, 0x01, 0xC0, 0x40,
  0x1E, 0x18, 0x00, 0xE3, 0x00, 0x07, 0x40, 0xE0, 0x3F, 0xFC, 0x03, 0x00,
  0x00, 0xD0, 0x00, 0x32, 0x00, 0x0C, 0x60, 0x07, 0x04, 0x01, 0xC0, 0xC0,
  0x70, 0x08, 0x04, 0x01, 0x80, 0x00, 0x38, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x06, 0x0C, 0x38, 0x61, 0xC3,
  0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x67, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xF7, 0x80, 0x0C, 0x07, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06,
  0x0C, 0x00, 0x1C, 0x60, 0x00, 0x31, 0x80, 0x01, 0xCC, 0x00, 0x07, 0x30,
  0x00, 0x1C, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00,
  0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x07,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x06,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0x3C, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x70, 0x0E, 0x03, 0xE0, 0x76, 0x0E, 0x63, 0x86, 0x70,
  0xCC, 0x0C, 0x80, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0x0E, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x78, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x10, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x78, 0x0F, 0xC1, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x30, 0x06, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0x60, 0x30, 0x00, 0x60, 0x70, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x78,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x80, 0x03, 0x80, 0xC0, 0x07,
  0x00, 0xF8, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xB8, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x7F, 0x80, 0x63, 0xFF, 0x80, 0xCC,
  0x03, 0x81, 0xB0, 0x03, 0x83, 0xC0, 0x03, 0x0F, 0x00, 0x06, 0x1C, 0x00,
  0x06, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00,
  0x63, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x1C,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x80, 0xC0, 0x07, 0x01,
  0x80, 0x1C, 0x01, 0x80, 0x70, 0x01, 0xC7, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x07, 0x01, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x01, 0x80, 0x0C, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0xE0,
  0x00, 0x73, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF7, 0x00,
  0x03, 0x81, 0x80, 0x0F, 0x00, 0xC0, 0x1C, 0x00, 0x60, 0x38, 0x00, 0x70,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x18, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x30,
  0x60, 0x00, 0x30, 0x60, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x38, 0x01, 0xC0,
  0x1F, 0x9F, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xE0, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x00, 0xC0,
  0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x18, 0x00,
  0x3C, 0x30, 0x00, 0xF0, 0x70, 0x03, 0x60, 0x70, 0x0E, 0xC0, 0x78, 0xF1,
  0x80, 0x7F, 0xC6, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x0F, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x03, 0xC1, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x70, 0x38, 0x1C, 0x00, 0x00, 0x60,
  0x0F, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x06, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x1F, 0xC0, 0x30, 0xC0, 0x0F, 0xFC, 0x06, 0x30, 0x07, 0x01,
  0x80, 0xC6, 0x01, 0xC0, 0x30, 0x19, 0x80, 0x30, 0x0C, 0x03, 0x30, 0x0C,
  0x01, 0x80, 0x66, 0x03, 0x00, 0x30, 0x0D, 0x80, 0x60, 0x06, 0x01, 0xB0,
  0x18, 0x01, 0x80, 0x36, 0x03, 0x00, 0x30, 0x0C, 0xC0, 0x60, 0x06, 0x01,
  0x98, 0x18, 0x00, 0xC0, 0x32, 0x03, 0x00, 0x30, 0x06, 0xC0, 0x60, 0x06,
  0x01, 0x98, 0x0C, 0x01, 0xC0, 0x33, 0x01, 0x80, 0x38, 0x0C, 0x60, 0x30,
  0x0F, 0x01, 0x8C, 0x06, 0x03, 0x60, 0x61, 0x80, 0x60, 0xEC, 0x18, 0x10,
  0x0F, 0x78, 0xFE, 0x03, 0x00, 0x7C, 0x0F, 0x80, 0x60, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01,
  0x84, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00,
  0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x38, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x60, 0x07, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x60, 0x00,
  0x30, 0x30, 0x00, 0x38, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x0C, 0x00,
  0x78, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0x80, 0x1E, 0x01, 0x80,
  0x03, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x01, 0x83,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x38, 0x30, 0x00, 0x38, 0x30, 0x00, 0x38, 0x18, 0x00, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0xF0, 0x03, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x10, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x06, 0x00, 0xF8, 0x00, 0xC0, 0x07, 0x80, 0x18, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x06, 0x03, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C,
  0x18, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x0C, 0x00,
  0x1C, 0x03, 0x00, 0x0F, 0x00, 0x60, 0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0xFF, 0x86, 0x00, 0x1F, 0xFC, 0x30, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x01, 0x87, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x1E,
  0x00, 0x1C, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00,
  0x60, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x03, 0x80,
  0x03, 0x00, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60,
  0x38, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x0D,
  0xF8, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x1E, 0x18, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x03, 0x00, 0x30, 0x00, 0x30, 0x03,
  0x00, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0F,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x0D, 0x80, 0x00, 0x0E, 0xC0, 0x64, 0x00,
  0x00, 0x66, 0x03, 0x30, 0x00, 0x07, 0x60, 0x19, 0x80, 0x00, 0x33, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x63, 0x00, 0x01,
  0x8E, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x18, 0xC0, 0x00, 0xC3, 0x01, 0x82,
  0x00, 0x06, 0x18, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x60, 0xC0, 0x07, 0x0C,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x18, 0x30, 0x03, 0x03, 0x01, 0x81, 0x80,
  0x18, 0x18, 0x0C, 0x0C, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x0C, 0x0C, 0x03,
  0x01, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x60,
  0x18, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x30, 0x0C, 0x03, 0x00,
  0xC3, 0x80, 0x60, 0x30, 0x06, 0x18, 0x03, 0x01, 0x80, 0x31, 0x80, 0x18,
  0x0C, 0x00, 0x8C, 0x01, 0x80, 0x60, 0x06, 0xC0, 0x0C, 0x03, 0x00, 0x36,
  0x00, 0x60, 0x30, 0x01, 0xE0, 0x03, 0x01, 0x80, 0x0F, 0x00, 0x18, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0xC0, 0x78, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x18, 0x0D, 0x80, 0x00, 0x60, 0x33, 0x00, 0x01, 0x80,
  0xCC, 0x00, 0x06, 0x03, 0x30, 0x00, 0x30, 0x0C, 0x60, 0x00, 0xC0, 0x61,
  0x80, 0x03, 0x01, 0x86, 0x00, 0x0C, 0x06, 0x0C, 0x00, 0x30, 0x18, 0x30,
  0x01, 0x80, 0x60, 0xC0, 0x06, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x06, 0x00,
  0x60, 0x30, 0x18, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x01, 0x80, 0x18, 0x1C, 0x06,
  0x00, 0x60, 0x60, 0x38, 0x00, 0xC1, 0x80, 0xC0, 0x03, 0x06, 0x03, 0x00,
  0x0C, 0x18, 0x0C, 0x00, 0x18, 0xC0, 0x30, 0x00, 0x63, 0x01, 0x80, 0x01,
  0x8C, 0x06, 0x00, 0x03, 0x30, 0x18, 0x00, 0x0C, 0xC0, 0x60, 0x00, 0x36,
  0x01, 0x80, 0x00, 0x78, 0x0C, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x07, 0x80,
  0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x0F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0x80, 0x3C, 0x01, 0x80,
  0x0E, 0x01, 0x80, 0x06, 0x03, 0x80, 0x07, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x0C, 0x01,
  0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x60, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x07, 0x07, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x0F,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0x80,
  0x3C, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x06, 0x03, 0x80, 0x07, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x03, 0x07, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x0C, 0x00,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x06, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x30, 0x01, 0x80, 0x70, 0x01, 0x80, 0x60, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x70, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xF0, 0x03, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xFC, 0x7F,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80,
  0x60, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x1C, 0x00, 0x78,
  0x03, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0x60, 0x00, 0x18, 0x60,
  0x00, 0x38, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0x60,
  0x00, 0xE0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x01, 0x80, 0x60,
  0x03, 0x80, 0x60, 0x03, 0x00, 0x60, 0x07, 0x00, 0x20, 0x06, 0x00, 0x30,
  0x0E, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x38, 0x00, 0x30, 0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x30,
  0xE0, 0x00, 0x30, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x13,
  0x80, 0x00, 0x13, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1F, 0x00, 0x01, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x00, 0x03, 0xB0, 0x00,
  0x3C, 0x00, 0x0C, 0xC0, 0x00, 0xF0, 0x00, 0x73, 0x00, 0x06, 0xC0, 0x01,
  0x8C, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x30, 0xC0, 0x03,
  0x30, 0x00, 0xC3, 0x00, 0x1C, 0xC0, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x18,
  0x30, 0x01, 0x8C, 0x00, 0xE0, 0xC0, 0x0C, 0x30, 0x03, 0x03, 0x00, 0x30,
  0xC0, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x30, 0x06, 0x0C, 0x01, 0x80,
  0xC0, 0x30, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x06, 0x03,
  0x01, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x30, 0x60, 0x0C,
  0x18, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x43, 0x00, 0x0C,
  0x30, 0x01, 0x0C, 0x00, 0x31, 0x80, 0x04, 0x30, 0x00, 0xC6, 0x00, 0x11,
  0x80, 0x03, 0x18, 0x00, 0x46, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x33,
  0x00, 0x04, 0xC0, 0x00, 0xD8, 0x00, 0x16, 0x00, 0x01, 0x60, 0x00, 0x58,
  0x00, 0x05, 0x00, 0x01, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x00, 0x01, 0x80, 0x18, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E,
  0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x70, 0x03, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x60, 0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x6C, 0x00, 0x03, 0x98, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x80, 0x03,
  0x86, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00,
  0x03, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x20, 0x0F, 0xFC, 0x00, 0xC0, 0x40, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00,
  0x1C, 0x60, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x06, 0x03, 0x80,
  0x0C, 0x06, 0x00, 0x08, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x33, 0x80, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x82, 0x0C, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0x0C, 0x07, 0xCF, 0x10, 0x1C, 0x03, 0x20, 0x70, 0x02,
  0xC0, 0xC0, 0x05, 0x83, 0x00, 0x0F, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x70, 0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x0C,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x71, 0x80,
  0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00,
  0x38, 0x30, 0x00, 0x70, 0x70, 0x01, 0xE0, 0x60, 0x06, 0xC0, 0xC0, 0x19,
  0x80, 0xC0, 0x72, 0x01, 0xE3, 0x8C, 0x01, 0xFE, 0x18, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x30, 0xFF, 0x00, 0x67, 0x8F, 0x01, 0x9C, 0x07, 0x03, 0x70, 0x06, 0x06,
  0xC0, 0x0E, 0x0F, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x78, 0x00, 0x30, 0xE0,
  0x00, 0x61, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x18, 0x00,
  0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x00,
  0xC6, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x38,
  0xE0, 0x00, 0x61, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x06, 0xC0, 0x1C, 0x09,
  0x80, 0x70, 0x31, 0xE3, 0xC0, 0x61, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x0F, 0xFC, 0x07, 0xC3, 0x81, 0xC0, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x08, 0x0F, 0x0F, 0x00, 0x7F, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x38, 0x18, 0x00, 0x7F, 0x86, 0x00, 0x7C, 0x71, 0x80, 0x38, 0x06, 0x60,
  0x1C, 0x00, 0xD8, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00,
  0x78, 0x0E, 0x00, 0x36, 0x01, 0x80, 0x1F, 0x00, 0x60, 0x0E, 0xC0, 0x0C,
  0x07, 0x30, 0x03, 0xC7, 0x8C, 0x00, 0x7F, 0x83, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x07, 0xF8, 0x00, 0xF1, 0xE0, 0x3C, 0x06, 0x03,
  0x00, 0x60, 0x60, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x63,
  0x80, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x1C, 0x60, 0x07, 0x06, 0x03, 0xE0,
  0x7F, 0xF8, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x01, 0x01, 0xF0, 0xF0, 0x07,
  0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xF1, 0x80, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x43, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xF0, 0x40, 0x1F, 0x1C, 0x60, 0x1C, 0x03, 0x30, 0x1C, 0x00, 0xD8, 0x0C,
  0x00, 0x28, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0C,
  0x18, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x81, 0x80, 0x01, 0xC0, 0xC0, 0x01, 0xE0, 0x70, 0x01, 0xB0, 0x18, 0x01,
  0xF0, 0x0C, 0x01, 0xD8, 0x03, 0x01, 0xCC, 0x01, 0xE3, 0xC6, 0x00, 0x7F,
  0x82, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x02, 0x00, 0x1C, 0x01, 0xE0, 0x78, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x20, 0x03, 0x0F, 0xF0, 0x0C, 0xF1, 0xE0, 0x27, 0x01,
  0xC1, 0xB0, 0x03, 0x06, 0x80, 0x0C, 0x1E, 0x00, 0x30, 0x70, 0x00, 0xC1,
  0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x18, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x70, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x3C,
  0x07, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x8E, 0x00, 0x1F, 0x80,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x70, 0x07, 0x01, 0x80, 0x38,
  0x06, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x18, 0x00, 0x18, 0xE0,
  0x00, 0x66, 0xC0, 0x01, 0xB3, 0x00, 0x07, 0x8C, 0x00, 0x1C, 0x18, 0x00,
  0xE0, 0x60, 0x03, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x04, 0x00, 0x31, 0xFE, 0x03, 0xFC, 0x02, 0x38,
  0xF0, 0xF1, 0xE0, 0x26, 0x03, 0x1C, 0x06, 0x06, 0xC0, 0x1B, 0x00, 0x70,
  0x78, 0x01, 0xB0, 0x03, 0x07, 0x00, 0x1E, 0x00, 0x30, 0x70, 0x01, 0xC0,
  0x03, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x80, 0x06, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x00, 0x61,
  0x80, 0x03, 0x00, 0x06, 0x18, 0x00, 0x30, 0x00, 0xC1, 0x80, 0x03, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x00, 0x0C, 0x30, 0x00,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0x01, 0x83,
  0x00, 0x0C, 0x00, 0x18, 0x70, 0x00, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x00,
  0x38, 0x60, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x00, 0x30, 0x60, 0x01,
  0x80, 0x03, 0x0C, 0x00, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x00, 0x80, 0x0C, 0x3F, 0xC0, 0x23, 0xC7, 0x81, 0x9C, 0x07, 0x06,
  0xC0, 0x0C, 0x1A, 0x00, 0x30, 0x78, 0x00, 0xC1, 0xC0, 0x03, 0x0E, 0x00,
  0x0C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60,
  0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01,
  0xC7, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x86,
  0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0x1E, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x18, 0x00,
  0x60, 0xC0, 0x01, 0x87, 0x00, 0x07, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x33,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x76, 0x00,
  0x01, 0x98, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6C, 0x00, 0x03,
  0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x01, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x30, 0x60, 0x01, 0xC1, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x07, 0x8F,
  0x80, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x61,
  0xFE, 0x00, 0x21, 0xC7, 0x80, 0x13, 0x80, 0xE0, 0x19, 0x80, 0x30, 0x0D,
  0x80, 0x1C, 0x07, 0x80, 0x06, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x81,
  0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x18,
  0x38, 0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00,
  0x60, 0x60, 0x00, 0x70, 0x30, 0x00, 0x30, 0x3C, 0x00, 0x38, 0x1E, 0x00,
  0x38, 0x0D, 0x00, 0x38, 0x06, 0xC0, 0x38, 0x07, 0x3C, 0x78, 0x03, 0x0F,
  0xF8, 0x01, 0x80, 0x40, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x04, 0x07, 0xC7,
  0x18, 0x1C, 0x03, 0x30, 0x70, 0x03, 0x60, 0xC0, 0x02, 0x83, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xC0, 0x00, 0x61,
  0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xC6, 0x00,
  0x03, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x78, 0x70, 0x01,
  0xB0, 0x60, 0x03, 0xC0, 0xC0, 0x0D, 0x80, 0xC0, 0x73, 0x01, 0xE3, 0xC6,
  0x01, 0xFE, 0x0C, 0x00, 0x20, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0xC3, 0xF0, 0x23, 0xCC, 0x09, 0xC0, 0x06,
  0xC0, 0x01, 0xA0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3F,
  0xF8, 0x0F, 0x0F, 0x83, 0x80, 0x10, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x30,
  0x7C, 0x3E, 0x07, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x0F, 0xFF, 0x7F, 0xF8, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x88, 0x1F, 0xC0, 0x10, 0x00, 0x06, 0x00, 0x0E, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x03,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x70,
  0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80,
  0x03, 0x83, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00,
  0xF0, 0x60, 0x03, 0x60, 0x60, 0x0C, 0x80, 0xE0, 0x33, 0x00, 0xF3, 0xC6,
  0x00, 0xFF, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x06, 0x30, 0x00, 0xC6,
  0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x60, 0xE0, 0x0C,
  0x18, 0x00, 0xC7, 0x00, 0x18, 0xC0, 0x03, 0x38, 0x00, 0x66, 0x00, 0x0D,
  0x80, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x1B, 0x00, 0x1C,
  0x00, 0x66, 0x00, 0x3C, 0x00, 0xCC, 0x00, 0xD8, 0x03, 0x98, 0x01, 0xB0,
  0x06, 0x30, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0xC0, 0x30, 0xC0, 0x31, 0x80,
  0x61, 0x80, 0x63, 0x01, 0x83, 0x01, 0x86, 0x03, 0x06, 0x03, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0x08, 0x18, 0x30, 0x30, 0x10, 0x20, 0x60, 0xC0,
  0x20, 0xC0, 0xC1, 0x80, 0x41, 0x81, 0x86, 0x00, 0xC6, 0x03, 0x0C, 0x01,
  0x8C, 0x02, 0x30, 0x03, 0x30, 0x04, 0x60, 0x06, 0x60, 0x09, 0x80, 0x0D,
  0x80, 0x13, 0x00, 0x1B, 0x00, 0x26, 0x00, 0x3C, 0x00, 0x58, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x03, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x60,
  0x00, 0x60, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xC6, 0x00,
  0x01, 0x83, 0x00, 0x03, 0x03, 0x00, 0x06, 0x01, 0x80, 0x0E, 0x01, 0x80,
  0x0C, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xC0,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0xE0, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x1C, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x05, 0xFF, 0xC0, 0x1E, 0x03, 0xC1,
  0xE0, 0x03, 0xFE, 0x80, 0x01, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 38, 11, 1, -38 },
  { 54, 12, 14, 16, 6, -38 },
  { 75, 28, 38, 28, 1, -38 },
  { 208, 24, 43, 25, 1, -40 },
  { 337, 30, 39, 36, 4, -38 },
  { 484, 27, 39, 30, 1, -38 },
  { 616, 4, 14, 9, 6, -38 },
  { 623, 15, 46, 13, 2, -38 },
  { 710, 16, 46, 13, -4, -38 },
  { 802, 19, 20, 24, 6, -40 },
  { 850, 22, 25, 27, 3, -31 },
  { 919, 7, 13, 10, -2, -6 },
  { 931, 12, 2, 16, 2, -15 },
  { 934, 4, 4, 11, 1, -4 },
  { 936, 23, 38, 16, -2, -38 },
  { 1046, 22, 39, 25, 3, -38 },
  { 1154, 12, 38, 25, 8, -38 },
  { 1211, 24, 38, 25, 0, -38 },
  { 1325, 25, 39, 25, 0, -38 },
  { 1447, 24, 38, 25, 0, -38 },
  { 1561, 24, 39, 25, 1, -38 },
  { 1678, 23, 39, 25, 3, -38 },
  { 1791, 22, 38, 25, 4, -38 },
  { 1896, 24, 39, 25, 1, -38 },
  { 2013, 23, 39, 25, 1, -38 },
  { 2126, 9, 28, 11, 1, -28 },
  { 2158, 12, 35, 11, -2, -28 },
  { 2211, 22, 24, 27, 3, -31 },
  { 2277, 22, 13, 27, 3, -25 },
  { 2313, 22, 24, 27, 3, -31 },
  { 2379, 17, 38, 19, 3, -38 },
  { 2460, 35, 43, 38, 2, -38 },
  { 2649, 25, 38, 25, -3, -38 },
  { 2768, 25, 38, 28, 2, -38 },
  { 2887, 27, 39, 27, 3, -38 },
  { 3019, 27, 38, 31, 2, -38 },
  { 3148, 24, 38, 24, 2, -38 },
  { 3262, 24, 38, 22, 2, -38 },
  { 3376, 29, 39, 32, 3, -38 },
  { 3518, 30, 38, 32, 2, -38 },
  { 3661, 17, 38, 13, -1, -38 },
  { 3742, 20, 47, 11, -8, -38 },
  { 3860, 28, 38, 25, 2, -38 },
  { 3993, 16, 38, 22, 2, -38 },
  { 4069, 37, 38, 39, 2, -38 },
  { 4245, 30, 38, 32, 2, -38 },
  { 4388, 28, 39, 33, 3, -38 },
  { 4525, 24, 38, 26, 2, -38 },
  { 4639, 28, 47, 33, 3, -38 },
  { 4804, 24, 38, 26, 2, -38 },
  { 4918, 24, 39, 24, 0, -38 },
  { 5035, 22, 38, 22, 5, -38 },
  { 5140, 29, 39, 32, 3, -38 },
  { 5282, 24, 38, 25, 5, -38 },
  { 5396, 38, 38, 40, 6, -38 },
  { 5577, 30, 38, 23, -3, -38 },
  { 5720, 22, 38, 22, 5, -38 },
  { 5825, 27, 38, 24, -1, -38 },
  { 5954, 20, 46, 15, -1, -38 },
  { 6069, 8, 38, 17, 5, -38 },
  { 6107, 20, 46, 15, -4, -38 },
  { 6222, 23, 22, 26, 2, -38 },
  { 6286, 18, 2, 18, -4, 5 },
  { 6291, 6, 9, 12, 8, -41 },
  { 6298, 23, 30, 26, 2, -29 },
  { 6385, 23, 41, 27, 1, -40 },
  { 6503, 19, 30, 21, 2, -29 },
  { 6575, 26, 41, 27, 2, -40 },
  { 6709, 20, 30, 23, 2, -29 },
  { 6784, 27, 54, 13, -7, -41 },
  { 6967, 25, 42, 27, 0, -29 },
  { 7099, 22, 40, 26, 1, -40 },
  { 7209, 11, 38, 10, 1, -38 },
  { 7262, 19, 51, 11, -7, -38 },
  { 7384, 22, 40, 21, 1, -40 },
  { 7494, 11, 40, 10, 1, -40 },
  { 7549, 36, 29, 39, 1, -29 },
  { 7680, 22, 29, 26, 1, -29 },
  { 7760, 22, 30, 26, 2, -29 },
  { 7843, 25, 41, 27, -1, -29 },
  { 7972, 23, 41, 27, 2, -29 },
  { 8090, 18, 29, 17, 1, -29 },
  { 8156, 19, 30, 20, 0, -29 },
  { 8228, 13, 36, 14, 2, -35 },
  { 8287, 23, 29, 26, 2, -28 },
  { 8371, 19, 28, 20, 3, -28 },
  { 8438, 31, 28, 32, 3, -28 },
  { 8547, 24, 28, 21, -2, -28 },
  { 8631, 29, 41, 20, -6, -28 },
  { 8780, 21, 28, 19, -1, -28 },
  { 8854, 19, 46, 17, 1, -38 },
  { 8964, 2, 53, 25, 12, -40 },
  { 8978, 19, 46, 17, -3, -38 },
  { 9088, 22, 5, 27, 3, -21 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC53PT7B_H_
