#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x81,
  0xC0, 0x30, 0xC8, 0x36, 0x09, 0x86, 0x61, 0x90, 0x64, 0x13, 0x04, 0xC3,
  0x20, 0xC8, 0x20, 0x00, 0x18, 0x08, 0x00, 0x30, 0x30, 0x00, 0x40, 0x60,
  0x01, 0x80, 0x80, 0x03, 0x03, 0x00, 0x04, 0x06, 0x00, 0x08, 0x08, 0x00,
  0x30, 0x10, 0x00, 0x60, 0x60, 0x00, 0x80, 0xC0, 0x7F, 0xFF, 0xF8, 0x06,
  0x06, 0x00, 0x08, 0x0C, 0x00, 0x30, 0x10, 0x00, 0x60, 0x60, 0x00, 0x80,
  0xC0, 0x01, 0x01, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x18,
  0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x01, 0x01, 0x80, 0x02, 0x02, 0x00,
  0x0C, 0x04, 0x00, 0x10, 0x18, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x40, 0x01,
  0x81, 0x80, 0x02, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xC0,
  0x1C, 0xCF, 0x03, 0x08, 0x10, 0x60, 0x80, 0x04, 0x08, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0xC1, 0x00, 0x0C, 0x10, 0x00, 0xC1, 0x00, 0x06, 0x30,
  0x00, 0x33, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x06,
  0xE0, 0x00, 0x67, 0x00, 0x04, 0x30, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x00,
  0xC1, 0x80, 0x08, 0x18, 0x00, 0x81, 0x00, 0x08, 0x30, 0x01, 0x86, 0x0C,
  0x18, 0xE0, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0xC0, 0xC6, 0x00, 0x20, 0x60, 0xC0, 0x18, 0x10, 0x30, 0x0C,
  0x0C, 0x0C, 0x02, 0x02, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x30,
  0x20, 0x10, 0x0C, 0x18, 0x04, 0x03, 0x0C, 0x03, 0x00, 0x82, 0x00, 0xC0,
  0x61, 0x80, 0x30, 0x18, 0xC3, 0x0C, 0x04, 0x21, 0xFB, 0x03, 0x19, 0xC6,
  0xC0, 0xCC, 0x60, 0xB0, 0x62, 0x30, 0x36, 0x31, 0x88, 0x0D, 0xF8, 0xC6,
  0x03, 0x08, 0x31, 0x80, 0xC0, 0x18, 0x40, 0x20, 0x04, 0x30, 0x08, 0x03,
  0x0C, 0x02, 0x01, 0x83, 0x01, 0x80, 0x40, 0xC0, 0x60, 0x30, 0x20, 0x10,
  0x18, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x03, 0x00, 0xC1, 0x81, 0x80, 0x30,
  0x60, 0x40, 0x0C, 0x30, 0x30, 0x01, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x87, 0x00, 0x06, 0x06, 0x00, 0x18,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x40, 0x18, 0x00, 0x80, 0x30, 0x01, 0x00,
  0x40, 0x02, 0x01, 0x80, 0x04, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x70,
  0x00, 0x19, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x60, 0x00, 0x30, 0xC0, 0x08, 0xC0, 0xC0, 0x23, 0x00, 0xC0, 0xCC,
  0x01, 0x81, 0x18, 0x01, 0x86, 0x20, 0x03, 0x08, 0xC0, 0x03, 0x31, 0x80,
  0x06, 0xC3, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x3C, 0x1C, 0x00,
  0xC8, 0x18, 0x03, 0x18, 0x1C, 0x1C, 0x18, 0x1F, 0xF0, 0x30, 0x32, 0x66,
  0x64, 0x4C, 0xC8, 0x80, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x04, 0x0C, 0x07, 0x84,
  0x00, 0x72, 0x00, 0x0D, 0x1F, 0x01, 0xFE, 0x01, 0xC0, 0x01, 0xB0, 0x01,
  0x88, 0x01, 0x86, 0x03, 0x81, 0x00, 0x80, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x0C, 0x30, 0xC6, 0x18, 0xC3, 0x08, 0x61, 0x0C, 0x00,
  0x7F, 0xFF, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x07, 0x06, 0x01, 0xC0, 0x60, 0x30,
  0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00,
  0x0C, 0x40, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x40, 0x00, 0xD8, 0x00,
  0x13, 0x00, 0x02, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x00, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x04, 0x00, 0xC0, 0xC0, 0x30,
  0x1C, 0x0E, 0x01, 0xC3, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x1F,
  0x07, 0x63, 0x8D, 0xE1, 0x90, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x00, 0x04, 0x00, 0x07, 0xFC, 0x01, 0xE0, 0xE0,
  0x38, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x78, 0x38, 0x06,
  0x00, 0x60, 0x20, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x82, 0x00, 0x18,
  0x1E, 0x07, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x1B, 0x00, 0x01, 0x20, 0x00, 0x32, 0x00, 0x06, 0x60,
  0x00, 0xC6, 0x00, 0x18, 0x60, 0x01, 0x04, 0x00, 0x30, 0xC0, 0x06, 0x0C,
  0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x01, 0x80, 0x80, 0x30, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x18, 0x08, 0x01, 0x01, 0x80, 0x10, 0x30, 0x03, 0x06, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x01, 0xFF, 0xF0, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0x80, 0x1E, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x08, 0x01, 0xC0, 0xE0, 0x78, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xFF, 0x00, 0x78, 0x10, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x0F, 0x00, 0x33, 0xFE, 0x02,
  0x60, 0x70, 0x68, 0x03, 0x07, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00, 0x18,
  0x60, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01,
  0x8C, 0x00, 0x10, 0xC0, 0x03, 0x04, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00,
  0xE0, 0x30, 0x1C, 0x03, 0x83, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x07, 0xF8, 0x01, 0xC0, 0xE0, 0x18, 0x06, 0x03, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00,
  0x60, 0x20, 0x06, 0x03, 0x00, 0xC0, 0x18, 0x38, 0x00, 0xC6, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x39, 0xC0, 0x0E, 0x06, 0x01, 0x80, 0x30, 0x30,
  0x03, 0x06, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x08, 0xC0, 0x00, 0x8C,
  0x00, 0x08, 0xC0, 0x00, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00, 0x30,
  0x70, 0x06, 0x03, 0xC1, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xF0, 0x01, 0xC1, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0C,
  0x00, 0x20, 0xC0, 0x02, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x31,
  0x80, 0x03, 0x10, 0x00, 0x21, 0x00, 0x06, 0x10, 0x00, 0x61, 0x80, 0x0E,
  0x18, 0x01, 0xE0, 0xC0, 0x36, 0x0E, 0x06, 0x40, 0x7F, 0xCC, 0x01, 0xE0,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x0C, 0x1E, 0x00, 0xFF, 0x80, 0x00, 0x06, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x38, 0x60, 0x00, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0x40, 0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x7F, 0xC3, 0x83, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x08,
  0x60, 0x07, 0xE0, 0x21, 0x80, 0x7B, 0xC0, 0x8C, 0x03, 0x03, 0x03, 0x30,
  0x18, 0x08, 0x08, 0x80, 0xC0, 0x60, 0x26, 0x06, 0x01, 0x80, 0x98, 0x18,
  0x06, 0x02, 0x40, 0xC0, 0x10, 0x1B, 0x03, 0x00, 0xC0, 0x6C, 0x08, 0x03,
  0x01, 0xB0, 0x20, 0x0C, 0x04, 0xC1, 0x80, 0x60, 0x33, 0x06, 0x01, 0x80,
  0x8C, 0x18, 0x0E, 0x06, 0x30, 0x20, 0x28, 0x30, 0xC0, 0xC1, 0xA0, 0xC3,
  0x03, 0x9C, 0xEE, 0x0C, 0x03, 0xC1, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x80, 0x00, 0x3E, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x23,
  0x00, 0x01, 0x8C, 0x00, 0x04, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x01, 0x00, 0x18,
  0x04, 0x00, 0xC0, 0x10, 0x03, 0x00, 0x40, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x21, 0x80, 0x00, 0x86, 0x00, 0x02, 0x30, 0x00,
  0x08, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x01, 0xFF, 0xC0,
  0x06, 0x0F, 0xC0, 0x10, 0x03, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x30, 0x60, 0x01, 0x81, 0x80, 0x06, 0x04, 0x00, 0x30, 0x30, 0x03, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x08, 0x03, 0xC0, 0x60, 0x03, 0x01, 0x80,
  0x06, 0x06, 0x00, 0x08, 0x18, 0x00, 0x30, 0x40, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x08, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x82, 0x00, 0x06, 0x18,
  0x00, 0x30, 0x60, 0x01, 0x81, 0x80, 0x1C, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0x81, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x81, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0x87, 0xE0, 0x01, 0x00, 0x38, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x02, 0x00, 0x02, 0x06, 0x00, 0x03, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00, 0x02, 0x08, 0x00, 0x06, 0x18,
  0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x10,
  0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x30, 0x30,
  0x00, 0x70, 0x20, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x60,
  0x0E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x78, 0x0F, 0x01, 0xC0, 0x02, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x07, 0xFC, 0xC0, 0x07, 0xF8, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x20, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x60, 0x0F, 0x03, 0xE0, 0x07, 0xFF, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x10, 0x00, 0x08, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x08, 0x00,
  0x04, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x04, 0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x08, 0x00, 0x04, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00,
  0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C, 0x04, 0x00, 0x02, 0x03, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x02,
  0x00, 0x01, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x04, 0x00, 0x02, 0x03, 0x00, 0x01, 0x80, 0x01, 0xFE, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x7F, 0x80, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x07, 0x01,
  0x80, 0x0E, 0x01, 0x00, 0x1C, 0x03, 0x00, 0x38, 0x03, 0x00, 0x70, 0x03,
  0x00, 0xE0, 0x03, 0x01, 0xC0, 0x02, 0x03, 0x80, 0x06, 0x07, 0x00, 0x06,
  0x0E, 0x00, 0x06, 0x1C, 0x00, 0x04, 0x18, 0x00, 0x04, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0D, 0xA0, 0x00, 0x0B, 0x30, 0x00, 0x1E,
  0x30, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x10,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x01, 0x00, 0x60,
  0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0x40, 0x00, 0x0A,
  0x03, 0x40, 0x00, 0x1A, 0x03, 0x40, 0x00, 0x36, 0x02, 0x40, 0x00, 0x36,
  0x02, 0x60, 0x00, 0x66, 0x06, 0x60, 0x00, 0x64, 0x06, 0x60, 0x00, 0xCC,
  0x06, 0x60, 0x00, 0xCC, 0x04, 0x20, 0x01, 0x8C, 0x04, 0x20, 0x01, 0x0C,
  0x0C, 0x20, 0x03, 0x08, 0x0C, 0x20, 0x02, 0x18, 0x0C, 0x30, 0x06, 0x18,
  0x08, 0x30, 0x0C, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x18, 0x30, 0x18, 0x10,
  0x18, 0x30, 0x18, 0x30, 0x18, 0x10, 0x30, 0x30, 0x10, 0x10, 0x20, 0x30,
  0x30, 0x10, 0x60, 0x20, 0x30, 0x18, 0x40, 0x60, 0x30, 0x18, 0xC0, 0x60,
  0x30, 0x19, 0x80, 0x60, 0x20, 0x19, 0x80, 0x60, 0x60, 0x1B, 0x00, 0x40,
  0x60, 0x0B, 0x00, 0xC0, 0x60, 0x0E, 0x00, 0xC0, 0x40, 0x0E, 0x00, 0xC0,
  0xC0, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x1C,
  0x00, 0x0C, 0x0F, 0x00, 0x03, 0x03, 0x40, 0x00, 0x80, 0xD8, 0x00, 0x60,
  0x26, 0x00, 0x18, 0x08, 0x80, 0x06, 0x06, 0x30, 0x01, 0x81, 0x8C, 0x00,
  0x40, 0x61, 0x00, 0x30, 0x10, 0x60, 0x0C, 0x04, 0x18, 0x03, 0x03, 0x02,
  0x00, 0x80, 0xC0, 0xC0, 0x20, 0x30, 0x30, 0x18, 0x08, 0x04, 0x06, 0x06,
  0x01, 0x81, 0x81, 0x80, 0x60, 0x40, 0x60, 0x08, 0x30, 0x18, 0x03, 0x0C,
  0x04, 0x00, 0xC3, 0x03, 0x00, 0x10, 0xC0, 0xC0, 0x06, 0x20, 0x30, 0x01,
  0x98, 0x0C, 0x00, 0x26, 0x02, 0x00, 0x0D, 0x81, 0x80, 0x03, 0x60, 0x60,
  0x00, 0x50, 0x18, 0x00, 0x1C, 0x04, 0x00, 0x07, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x70, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x06,
  0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x60, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x1E, 0x0F, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0C, 0x3F, 0x00, 0x40, 0x1C, 0x06,
  0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x40, 0x03,
  0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x40,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x18, 0x08, 0x07, 0x80,
  0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x70,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x06,
  0x08, 0x00, 0x06, 0x18, 0x00, 0x02, 0x10, 0x00, 0x02, 0x30, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02,
  0x40, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x1E, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x80, 0x0C, 0x3F, 0x00,
  0x40, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00,
  0x60, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x06, 0x0C,
  0x00, 0x20, 0x40, 0x03, 0x06, 0x00, 0x30, 0x30, 0x03, 0x81, 0x80, 0x78,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x06, 0x02, 0x00, 0x30, 0x18, 0x01, 0x80,
  0xC0, 0x08, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x10, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x00,
  0xC1, 0x00, 0x06, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x80,
  0x78, 0x1E, 0x07, 0x00, 0x20, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x82, 0x00, 0x38, 0x1E, 0x07, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x03, 0x04, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x0C, 0x00,
  0x02, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x18, 0x00,
  0x06, 0x18, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x30, 0x00, 0x18, 0x20, 0x00,
  0x18, 0x60, 0x00, 0x18, 0x60, 0x00, 0x10, 0x60, 0x00, 0x30, 0x60, 0x00,
  0x30, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x20, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x01,
  0x80, 0x60, 0x03, 0x80, 0x70, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0xF8,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0x90, 0x00, 0x08, 0x80, 0x00, 0xC4,
  0x00, 0x04, 0x20, 0x00, 0x61, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x03, 0x00, 0x18, 0x18, 0x00, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x40, 0x30,
  0x06, 0x01, 0x80, 0x20, 0x04, 0x03, 0x00, 0x20, 0x10, 0x01, 0x01, 0x80,
  0x08, 0x08, 0x00, 0x40, 0xC0, 0x03, 0x04, 0x00, 0x18, 0x60, 0x00, 0xC2,
  0x00, 0x06, 0x30, 0x00, 0x31, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x80, 0x00,
  0x6C, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x06, 0xC0, 0x03, 0x80,
  0x06, 0xC0, 0x07, 0x80, 0x04, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x05, 0x80,
  0x0C, 0xC0, 0x0D, 0x80, 0x18, 0xC0, 0x09, 0x80, 0x18, 0xC0, 0x19, 0x80,
  0x30, 0xC0, 0x19, 0x80, 0x30, 0xC0, 0x30, 0x80, 0x20, 0xC0, 0x30, 0x80,
  0x60, 0xC0, 0x60, 0x80, 0x40, 0xC0, 0x60, 0x80, 0xC0, 0xC0, 0x40, 0x80,
  0xC0, 0xC0, 0xC0, 0x81, 0x80, 0xC0, 0x80, 0x81, 0x80, 0xC1, 0x80, 0x83,
  0x00, 0xC1, 0x80, 0x83, 0x00, 0xC3, 0x00, 0x82, 0x00, 0xC3, 0x00, 0x86,
  0x00, 0xC6, 0x00, 0x86, 0x00, 0xC6, 0x00, 0x8C, 0x00, 0xC4, 0x00, 0x8C,
  0x00, 0xCC, 0x00, 0x88, 0x00, 0xC8, 0x00, 0x98, 0x00, 0xD8, 0x00, 0x90,
  0x00, 0x50, 0x00, 0xB0, 0x00, 0x70, 0x00, 0xA0, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x01,
  0xC0, 0x10, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x20,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x10, 0x30, 0x00, 0x06, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0x40, 0x00, 0x18, 0x18, 0x00,
  0x04, 0x06, 0x00, 0x03, 0x00, 0x80, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x78, 0x00, 0x19, 0x00, 0x06,
  0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x0C, 0x08, 0x01, 0x81, 0x00, 0x60,
  0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x08, 0x18, 0x01, 0x86, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x00, 0x4C, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0xFE, 0x00, 0x82, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x61, 0x86,
  0x18, 0x20, 0x82, 0x0C, 0x30, 0xC1, 0x04, 0x10, 0x61, 0x86, 0x08, 0x20,
  0x83, 0x0C, 0x30, 0x41, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x03, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xA0, 0x00, 0x36,
  0x00, 0x0C, 0x40, 0x01, 0x08, 0x00, 0x61, 0x80, 0x18, 0x10, 0x03, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x04, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x01,
  0x0C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0x58, 0x00, 0x0C, 0x7F, 0xFF,
  0xFF, 0xFE, 0xC6, 0x18, 0x43, 0x08, 0x20, 0x00, 0xFC, 0x20, 0x79, 0xCC,
  0x18, 0x0D, 0x86, 0x00, 0xA1, 0x80, 0x14, 0x30, 0x03, 0x8C, 0x00, 0x71,
  0x80, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x11, 0x80, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x07, 0x18,
  0x00, 0xC3, 0x00, 0x38, 0x60, 0x07, 0x0C, 0x01, 0x60, 0xC0, 0x6C, 0x1C,
  0x39, 0x01, 0xFC, 0x20, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x3F, 0x00, 0x47, 0x3C, 0x0C, 0xC0,
  0xC0, 0xD8, 0x06, 0x0F, 0x00, 0x60, 0xE0, 0x02, 0x0C, 0x00, 0x31, 0xC0,
  0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x21, 0x00, 0x06, 0x30,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x30, 0x00, 0xC7,
  0x00, 0x08, 0x70, 0x01, 0x85, 0x00, 0x30, 0x50, 0x07, 0x0D, 0x80, 0xE0,
  0xCC, 0x1C, 0x08, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xC3, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x30, 0x1F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xC2, 0x00,
  0xF3, 0x88, 0x06, 0x03, 0x60, 0x30, 0x07, 0x81, 0x80, 0x0E, 0x06, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30,
  0x40, 0x00, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0xC0, 0xC0, 0x0F,
  0x03, 0x00, 0x28, 0x0C, 0x01, 0xA0, 0x18, 0x0D, 0x80, 0x70, 0xE6, 0x00,
  0x7E, 0x18, 0x00, 0x00, 0xFC, 0x03, 0xCE, 0x07, 0x03, 0x0C, 0x01, 0x18,
  0x01, 0x18, 0x01, 0x30, 0x03, 0x30, 0x03, 0x60, 0x06, 0x60, 0x0C, 0x60,
  0x78, 0x7F, 0xE0, 0xFE, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x70, 0x04, 0x38,
  0x38, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0x84, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x0C, 0x03, 0xCE, 0x20, 0x18, 0x0C, 0x80, 0xC0, 0x1E,
  0x06, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0xC1, 0x00, 0x02, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0xC0,
  0xC0, 0x07, 0x03, 0x00, 0x3C, 0x0C, 0x00, 0xA0, 0x30, 0x06, 0x80, 0x60,
  0x36, 0x01, 0xC3, 0x98, 0x03, 0xF8, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x38, 0x03, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0xFE, 0x02, 0x38, 0xE0, 0x4C, 0x0C, 0x1A, 0x00, 0xC3,
  0x80, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x20, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x04, 0x30,
  0x01, 0x86, 0x00, 0x30, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x10, 0xC0,
  0x06, 0x10, 0x00, 0xC2, 0x00, 0x18, 0xC0, 0x02, 0x18, 0x00, 0xC0, 0x03,
  0x81, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x02, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x03, 0x82, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03,
  0x80, 0x60, 0x60, 0x08, 0x18, 0x03, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x60,
  0x01, 0x18, 0x00, 0x27, 0x80, 0x0D, 0xB0, 0x01, 0xE2, 0x00, 0x38, 0x60,
  0x06, 0x0C, 0x00, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x10, 0x06, 0x06, 0x00, 0x40, 0xC0, 0x0C, 0x18, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80,
  0x40, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60,
  0x00, 0x04, 0x3F, 0x03, 0xF0, 0x13, 0x8E, 0x18, 0xE0, 0x58, 0x19, 0x80,
  0xC3, 0x40, 0x34, 0x03, 0x0E, 0x00, 0xE0, 0x0C, 0x38, 0x03, 0x80, 0x30,
  0xC0, 0x0C, 0x00, 0xC7, 0x00, 0x30, 0x03, 0x18, 0x00, 0x80, 0x0C, 0x60,
  0x06, 0x00, 0x31, 0x80, 0x18, 0x00, 0x84, 0x00, 0x60, 0x06, 0x30, 0x01,
  0x80, 0x18, 0xC0, 0x04, 0x00, 0x63, 0x00, 0x30, 0x01, 0x08, 0x00, 0xC0,
  0x04, 0x20, 0x03, 0x00, 0x31, 0x80, 0x08, 0x00, 0xC6, 0x00, 0x20, 0x03,
  0x18, 0x01, 0x80, 0x08, 0x40, 0x06, 0x00, 0x63, 0x00, 0x18, 0x01, 0x8C,
  0x00, 0x40, 0x06, 0x30, 0x03, 0x00, 0x18, 0x04, 0x3F, 0x80, 0x8E, 0x78,
  0x33, 0x03, 0x06, 0x80, 0x30, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x18,
  0xE0, 0x03, 0x18, 0x00, 0x43, 0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0x63,
  0x00, 0x0C, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x20, 0x01, 0x8C,
  0x00, 0x21, 0x80, 0x0C, 0x30, 0x01, 0x84, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x00, 0x86, 0x00, 0x30, 0x00, 0xFE, 0x00, 0xF1, 0xC0, 0x60, 0x38, 0x30,
  0x06, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x00,
  0xD8, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00,
  0x18, 0x60, 0x0C, 0x18, 0x07, 0x03, 0x87, 0x80, 0x7F, 0x80, 0x01, 0x0F,
  0xE0, 0x04, 0x73, 0xC0, 0x13, 0x03, 0x00, 0xD8, 0x06, 0x03, 0xC0, 0x18,
  0x0E, 0x00, 0x20, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0x81, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x70, 0x00, 0x81,
  0xC0, 0x06, 0x07, 0x00, 0x30, 0x14, 0x01, 0xC0, 0x58, 0x0E, 0x03, 0x30,
  0x70, 0x0C, 0x7F, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x30, 0x3C,
  0xE2, 0x06, 0x03, 0x20, 0xC0, 0x1E, 0x18, 0x00, 0xE1, 0x80, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x8C,
  0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x70, 0xC0, 0x0F, 0x0C, 0x00, 0xA0, 0xC0, 0x1A,
  0x06, 0x03, 0x60, 0x70, 0xE6, 0x03, 0xF8, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x04, 0x3E, 0x08, 0xE4, 0x13, 0x00, 0x68, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x01, 0xFE, 0x07,
  0x8F, 0x0C, 0x01, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x80, 0x38, 0xE0, 0x70, 0x7F, 0xC0, 0x02, 0x00, 0xC0,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x1F, 0xFB, 0xFF, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x20, 0xFC, 0x00, 0x08, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x0C, 0x00,
  0x61, 0x80, 0x0C, 0x20, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x04, 0x30, 0x01,
  0x86, 0x00, 0x30, 0x80, 0x06, 0x30, 0x00, 0x86, 0x00, 0x30, 0xC0, 0x06,
  0x10, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x38,
  0x60, 0x07, 0x0C, 0x01, 0x61, 0x80, 0x48, 0x1C, 0x31, 0x01, 0xFC, 0x60,
  0xC0, 0x01, 0xE0, 0x01, 0x90, 0x00, 0xC8, 0x00, 0xC4, 0x00, 0x63, 0x00,
  0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18, 0x18, 0x0C, 0x0C,
  0x0C, 0x02, 0x04, 0x01, 0x06, 0x00, 0x82, 0x00, 0x43, 0x00, 0x31, 0x00,
  0x19, 0x80, 0x0C, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x50, 0x07, 0x80, 0x68, 0x02, 0xC0, 0x34, 0x03, 0x60, 0x32, 0x01, 0x30,
  0x19, 0x01, 0x98, 0x08, 0x80, 0xCC, 0x0C, 0x60, 0xC6, 0x04, 0x30, 0x63,
  0x06, 0x18, 0x61, 0x82, 0x0C, 0x30, 0x43, 0x06, 0x30, 0x21, 0x83, 0x18,
  0x11, 0x81, 0x88, 0x08, 0xC0, 0xCC, 0x04, 0x40, 0x64, 0x02, 0x60, 0x36,
  0x01, 0x20, 0x1A, 0x00, 0xB0, 0x0F, 0x00, 0x50, 0x07, 0x00, 0x28, 0x03,
  0x80, 0x1C, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80,
  0x40, 0x18, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0x40, 0xC0, 0x03, 0x0C,
  0x00, 0x18, 0xC0, 0x00, 0x46, 0x00, 0x03, 0x60, 0x00, 0x1E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x31, 0x00,
  0x03, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x81, 0x00, 0x18, 0x0C, 0x01, 0x80,
  0x60, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0x40, 0x30,
  0x00, 0x40, 0x20, 0x00, 0x40, 0x60, 0x00, 0x60, 0x40, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0x80, 0x00, 0x61, 0x80, 0x00, 0x61, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x26, 0x00, 0x00, 0x24, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x43, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x19, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x3E, 0xF8, 0x0E, 0x03, 0xE7, 0x40, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 32, 10, 1, -32 },
  { 37, 10, 11, 14, 5, -32 },
  { 51, 23, 32, 24, 1, -32 },
  { 143, 20, 37, 21, 1, -34 },
  { 236, 26, 34, 31, 3, -33 },
  { 347, 23, 33, 25, 1, -33 },
  { 442, 4, 11, 8, 5, -32 },
  { 448, 13, 39, 11, 1, -32 },
  { 512, 13, 39, 11, -3, -32 },
  { 576, 17, 17, 21, 5, -34 },
  { 613, 19, 21, 23, 3, -26 },
  { 663, 6, 11, 8, -2, -5 },
  { 672, 11, 2, 13, 1, -13 },
  { 675, 3, 3, 9, 1, -3 },
  { 677, 20, 32, 14, -2, -32 },
  { 757, 19, 33, 22, 2, -33 },
  { 836, 11, 32, 22, 6, -32 },
  { 880, 20, 33, 22, 0, -33 },
  { 963, 21, 33, 22, 0, -33 },
  { 1050, 20, 32, 22, 0, -32 },
  { 1130, 20, 32, 22, 1, -32 },
  { 1210, 20, 33, 22, 2, -33 },
  { 1293, 18, 32, 22, 4, -32 },
  { 1365, 20, 33, 22, 1, -33 },
  { 1448, 20, 33, 22, 1, -33 },
  { 1531, 7, 24, 9, 1, -24 },
  { 1552, 10, 30, 9, -2, -24 },
  { 1590, 18, 20, 23, 3, -26 },
  { 1635, 18, 11, 23, 3, -21 },
  { 1660, 19, 20, 23, 3, -26 },
  { 1708, 14, 33, 16, 3, -33 },
  { 1766, 30, 36, 32, 2, -32 },
  { 1901, 22, 32, 21, -3, -32 },
  { 1989, 22, 32, 23, 1, -32 },
  { 2077, 22, 33, 23, 3, -33 },
  { 2168, 24, 32, 26, 1, -32 },
  { 2264, 21, 32, 21, 1, -32 },
  { 2348, 21, 32, 19, 1, -32 },
  { 2432, 24, 33, 27, 3, -33 },
  { 2531, 26, 32, 27, 1, -32 },
  { 2635, 15, 32, 11, -1, -32 },
  { 2695, 17, 40, 10, -7, -32 },
  { 2780, 24, 32, 22, 1, -32 },
  { 2876, 15, 32, 19, 1, -32 },
  { 2936, 32, 32, 33, 1, -32 },
  { 3064, 26, 32, 27, 1, -32 },
  { 3168, 24, 33, 28, 3, -33 },
  { 3267, 21, 32, 22, 1, -32 },
  { 3351, 24, 41, 28, 3, -33 },
  { 3474, 21, 32, 22, 1, -32 },
  { 3558, 21, 33, 20, 0, -33 },
  { 3645, 19, 32, 19, 4, -32 },
  { 3721, 24, 32, 27, 3, -32 },
  { 3817, 21, 32, 21, 4, -32 },
  { 3901, 32, 32, 34, 5, -32 },
  { 4029, 26, 32, 19, -3, -32 },
  { 4133, 19, 32, 19, 4, -32 },
  { 4209, 23, 32, 20, -1, -32 },
  { 4301, 17, 39, 13, -1, -32 },
  { 4384, 6, 32, 14, 5, -32 },
  { 4408, 17, 39, 13, -3, -32 },
  { 4491, 19, 18, 22, 2, -32 },
  { 4534, 16, 2, 15, -4, 4 },
  { 4538, 5, 7, 10, 7, -34 },
  { 4543, 19, 24, 22, 2, -24 },
  { 4600, 20, 34, 23, 1, -34 },
  { 4685, 16, 24, 18, 2, -24 },
  { 4733, 22, 34, 23, 2, -34 },
  { 4827, 16, 24, 20, 2, -24 },
  { 4875, 23, 45, 11, -6, -34 },
  { 5005, 22, 35, 23, 0, -24 },
  { 5102, 19, 34, 22, 1, -34 },
  { 5183, 9, 32, 9, 1, -32 },
  { 5219, 16, 43, 9, -6, -32 },
  { 5305, 19, 34, 18, 1, -34 },
  { 5386, 9, 34, 9, 1, -34 },
  { 5425, 30, 24, 33, 1, -24 },
  { 5515, 19, 24, 22, 1, -24 },
  { 5572, 18, 24, 22, 2, -24 },
  { 5626, 22, 34, 23, -1, -24 },
  { 5720, 20, 35, 23, 2, -24 },
  { 5808, 15, 24, 15, 1, -24 },
  { 5853, 16, 24, 17, 0, -24 },
  { 5901, 11, 30, 12, 2, -30 },
  { 5943, 19, 24, 22, 2, -24 },
  { 6000, 17, 24, 17, 2, -24 },
  { 6051, 25, 24, 27, 3, -24 },
  { 6126, 21, 24, 18, -2, -24 },
  { 6189, 24, 35, 17, -5, -24 },
  { 6294, 18, 24, 16, -1, -24 },
  { 6348, 16, 39, 15, 1, -32 },
  { 6426, 2, 45, 21, 10, -34 },
  { 6438, 16, 39, 15, -2, -32 },
  { 6516, 19, 4, 23, 3, -18 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC45PT7B_H_
