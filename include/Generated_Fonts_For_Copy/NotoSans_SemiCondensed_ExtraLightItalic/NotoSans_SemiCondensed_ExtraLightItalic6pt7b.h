#ifndef _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-ExtraLightItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_ExtraLightItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x80, 0x6B, 0xE0, 0x39, 0x2C, 0xDF, 0x37, 0x6B, 0xF0, 0x80,
  0x6A, 0x80, 0xF8, 0xB4, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A, 0xF6, 0xE0,
  0xF0, 0x65, 0x60, 0x6C, 0xF0, 0x2A, 0xA0, 0x68, 0xF0, 0x6A, 0xF0, 0x69,
  0x40, 0xEA, 0xF0, 0xF5, 0xE0, 0x20, 0x30, 0xEC, 0xFC, 0xF8, 0x5A, 0x7F,
  0xBC, 0x60, 0x4A, 0xD0, 0x7E, 0xF0, 0x72, 0x60, 0x76, 0xF0, 0x7A, 0x60,
  0x7A, 0x40, 0x7A, 0x9E, 0x5D, 0xAA, 0x6A, 0x55, 0xC0, 0x6B, 0x50, 0x6B,
  0x55, 0xFD, 0x5D, 0xAA, 0x79, 0x9E, 0x77, 0x40, 0x79, 0x9E, 0x20, 0x77,
  0x50, 0xE8, 0xE0, 0xEA, 0x59, 0xAE, 0xEA, 0xDD, 0xAC, 0x6B, 0x60, 0xEA,
  0x6A, 0x60, 0xEA, 0x80, 0xF0, 0x56, 0x80, 0x54, 0xE0, 0x80, 0xF7, 0x00,
  0x5A, 0xDE, 0xEC, 0x2E, 0xDC, 0xEC, 0x25, 0x25, 0x80, 0xF7, 0x60, 0x5A,
  0xDA, 0x70, 0x15, 0xC0, 0x57, 0x4C, 0xF8, 0xFB, 0xD0, 0xF6, 0x80, 0xF7,
  0x80, 0xF7, 0xC0, 0xF7, 0x20, 0xE8, 0xDC, 0xEA, 0xB7, 0x00, 0xBA, 0x00,
  0xDA, 0xA0, 0xEB, 0x00, 0x52, 0x4C, 0x6C, 0x5A, 0x80, 0xFC, 0x56, 0x80,
  0xE0,
};

const GFXglyph NotoSans_SemiCondensed_ExtraLightItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 1, 5, 2, 0, -4 },
  { 15, 2, 3, 3, 1, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 4, 3, 1, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 1, 3, 1, 0, -3 },
  { 42, 1, 4, 1, 0, -3 },
  { 43, 3, 2, 3, 0, -3 },
  { 44, 3, 2, 3, 0, -3 },
  { 45, 3, 2, 3, 0, -3 },
  { 46, 2, 4, 2, 0, -4 },
  { 47, 4, 5, 4, 0, -4 },
  { 50, 3, 4, 3, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 2, 4, 2, 0, -4 },
  { 67, 2, 5, 1, -1, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 2, 4, 3, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 4, 4, 4, 0, -4 },
  { 78, 3, 4, 3, 0, -4 },
  { 80, 4, 5, 4, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 2, 4, 3, 1, -4 },
  { 88, 4, 4, 4, 0, -4 },
  { 90, 2, 4, 3, 1, -4 },
  { 91, 4, 4, 5, 1, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 2, 4, 3, 1, -4 },
  { 96, 3, 4, 3, 0, -4 },
  { 98, 2, 5, 2, 0, -4 },
  { 100, 1, 4, 2, 1, -4 },
  { 101, 2, 5, 2, 0, -4 },
  { 103, 3, 2, 3, 0, -4 },
  { 104, 3, 1, 2, -1, 0 },
  { 105, 1, 1, 1, 1, -5 },
  { 106, 3, 3, 3, 0, -3 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 2, 3, 2, 0, -3 },
  { 111, 3, 5, 3, 0, -5 },
  { 113, 2, 3, 3, 0, -3 },
  { 114, 3, 6, 1, -1, -5 },
  { 117, 3, 4, 3, 0, -3 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 1, 4, 1, 0, -4 },
  { 122, 2, 5, 1, -1, -4 },
  { 124, 3, 5, 2, 0, -5 },
  { 126, 1, 5, 1, 0, -5 },
  { 127, 4, 3, 4, 0, -3 },
  { 129, 3, 3, 3, 0, -3 },
  { 131, 3, 3, 3, 0, -3 },
  { 133, 3, 4, 3, 0, -3 },
  { 135, 3, 4, 3, 0, -3 },
  { 137, 2, 3, 2, 0, -3 },
  { 138, 2, 3, 2, 0, -3 },
  { 139, 2, 4, 2, 0, -4 },
  { 140, 3, 3, 3, 0, -3 },
  { 142, 3, 3, 2, 0, -3 },
  { 144, 4, 3, 4, 0, -3 },
  { 146, 3, 3, 2, 0, -3 },
  { 148, 4, 4, 2, -1, -3 },
  { 150, 2, 3, 2, 0, -3 },
  { 151, 2, 5, 2, 0, -4 },
  { 153, 1, 6, 3, 1, -5 },
  { 154, 2, 5, 2, 0, -4 },
  { 156, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_ExtraLightItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_ExtraLightItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_ExtraLightItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_EXTRALIGHTITALIC6PT7B_H_
